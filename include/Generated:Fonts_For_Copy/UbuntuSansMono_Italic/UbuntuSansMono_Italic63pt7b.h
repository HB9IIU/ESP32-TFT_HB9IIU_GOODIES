#ifndef _UBUNTUSANSMONO_ITALIC63PT7B_H_
#define _UBUNTUSANSMONO_ITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x1E, 0x03, 0xCF, 0x81, 0xF3,
  0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9F, 0x03, 0xE7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x03, 0xE0,
  0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x00, 0x1E,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x3C,
  0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x83, 0xE0,
  0x00, 0x0F, 0x81, 0xE1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0xF8, 0x00, 0x00,
  0x78, 0x3C, 0x7C, 0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0x8F, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x8F, 0xDF, 0x00, 0x00, 0x03, 0xE3,
  0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x1E,
  0x00, 0x00, 0x7C, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x03, 0xE0,
  0x78, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80,
  0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0,
  0x00, 0xF9, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x40, 0x03, 0xFC, 0x01, 0xE0, 0x7F, 0xF0, 0x1F, 0x07,
  0xFF, 0x80, 0xF0, 0x7E, 0x3E, 0x07, 0x87, 0xE1, 0xF8, 0x7C, 0x3E, 0x07,
  0xC3, 0xC3, 0xE0, 0x3F, 0x3E, 0x3E, 0x00, 0xF9, 0xF1, 0xF0, 0x03, 0xEF,
  0x1F, 0x80, 0x1F, 0xF8, 0xF8, 0x00, 0x7F, 0x87, 0xC0, 0x03, 0xFC, 0x3E,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x83, 0xF0, 0x03, 0xFE, 0x1F, 0x80, 0x3F, 0xF0, 0x7E, 0x07, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3E, 0x0F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0,
  0xFF, 0xC0, 0x3E, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0x00, 0x78, 0x06, 0x3C, 0x0F, 0x03, 0xCF, 0xE1, 0xE3,
  0xF9, 0xFF, 0x39, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0xFC,
  0x0F, 0xCF, 0x87, 0xF8, 0x3F, 0x7E, 0x1F, 0xE0, 0xF9, 0xF0, 0x7F, 0x83,
  0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0xFC, 0x1F, 0xE1, 0xFB,
  0xE0, 0x7F, 0x07, 0xCF, 0x80, 0x78, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xDF, 0x00, 0x7F, 0x8F, 0x80, 0x3F, 0x07, 0xC0, 0x0E, 0x03, 0xE0,
  0x08, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x1E, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x3F, 0x00, 0x40, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x00, 0x1F, 0xC0,
  0x38, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x04, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x07,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0x03,
  0xC1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81,
  0xFE, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x9F, 0xF0, 0x10, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0xFE, 0x1F,
  0x80, 0x1F, 0xFF, 0x87, 0xC0, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xF8,
  0xFC, 0x0F, 0xE0, 0x7C, 0x3E, 0x07, 0xF0, 0x1F, 0x1F, 0x81, 0xF0, 0x07,
  0xC7, 0xE0, 0xFC, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0x3E, 0x3F, 0x07, 0xC0, 0x0F, 0x8F, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xF8,
  0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xF8, 0x7C, 0x0F, 0x80, 0xFF, 0xFF,
  0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x04, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x30, 0x03, 0xF8, 0x00, 0x04,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7C, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x04,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC1,
  0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x0F,
  0x70, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x0F, 0x78, 0x07, 0xBC, 0x00, 0x7B,
  0xC0, 0x79, 0xE0, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x3C, 0x78,
  0x01, 0xE3, 0xC1, 0xE7, 0xC0, 0x1E, 0x1E, 0x1E, 0x3C, 0x00, 0xF0, 0xF0,
  0xE1, 0xE0, 0x07, 0x87, 0x8F, 0x0F, 0x00, 0x7C, 0x3C, 0xF0, 0x78, 0x03,
  0xC1, 0xE7, 0x87, 0xC0, 0x1E, 0x0F, 0x78, 0x3E, 0x01, 0xF0, 0x7B, 0xC1,
  0xE0, 0x0F, 0x83, 0xFC, 0x0F, 0x00, 0x78, 0x1F, 0xC0, 0x78, 0x03, 0xC0,
  0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x7B, 0xE0,
  0x00, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x01,
  0xF0, 0xF8, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x1F, 0x00, 0x1E, 0x07, 0x80,
  0x7C, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x0F,
  0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x01, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xC0,
  0x03, 0xCF, 0x80, 0x1F, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0x00, 0x3E, 0xF0,
  0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xE0,
  0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xE0,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x10, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x1F, 0x03,
  0xF8, 0x1E, 0x00, 0x78, 0x1F, 0xE0, 0x78, 0x01, 0xE0, 0x7F, 0x81, 0xE0,
  0x07, 0x83, 0xDE, 0x0F, 0x80, 0x1E, 0x1F, 0x78, 0x3C, 0x00, 0xF8, 0x79,
  0xE0, 0xF0, 0x03, 0xC3, 0xC7, 0x87, 0xC0, 0x0F, 0x0F, 0x0E, 0x1E, 0x00,
  0x3C, 0x78, 0x38, 0x78, 0x00, 0xF1, 0xE0, 0xE1, 0xE0, 0x03, 0xCF, 0x03,
  0x8F, 0x00, 0x1E, 0x7C, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x1D, 0xE0, 0x0F,
  0x78, 0x00, 0x77, 0x80, 0x3D, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0xC3, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x08, 0x01, 0x80, 0x7C, 0x0F, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1E,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x01,
  0xE0, 0x3F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0xFF, 0x81, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0xF8, 0x07, 0xFF,
  0xF3, 0xE0, 0x07, 0xFF, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF9, 0xFF, 0x80, 0x01, 0xEF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3F, 0x07, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x07, 0xF8,
  0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04,
  0x03, 0xFC, 0x00, 0x38, 0x03, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x78, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x07, 0xFF, 0xFD,
  0xF0, 0x00, 0x7F, 0xFF, 0x3E, 0x00, 0x07, 0xFF, 0x83, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x0F, 0xF0,
  0x01, 0xF0, 0x7F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFF, 0x1F,
  0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20,
  0x3F, 0xC0, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF3,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x73, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFB, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x81, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x08, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x01, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x7F,
  0x00, 0x01, 0xF0, 0xFE, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0xFE,
  0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xDF,
  0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x01, 0xF0,
  0x7F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x1B, 0xFC, 0x7C, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x7F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7F,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x7C,
  0x0F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1E, 0x02, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3F, 0xC0,
  0x0F, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xDF, 0x40,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x0F,
  0x80, 0xFE, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBE, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x0E, 0x00, 0xF8, 0x00, 0x10, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x80, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xE0, 0x7F, 0xCF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF,
  0xE3, 0xC0, 0x07, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3C,
  0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0xF0, 0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x1F, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x78, 0x1F, 0x03, 0xF8, 0x1F, 0x03,
  0xE0, 0xFF, 0x03, 0xE0, 0x7C, 0x1E, 0xF0, 0x78, 0x0F, 0x87, 0x9E, 0x1F,
  0x01, 0xF0, 0xF3, 0xC3, 0xC0, 0x3E, 0x3C, 0x78, 0xF8, 0x07, 0x8F, 0x8F,
  0x1F, 0x00, 0xF1, 0xE1, 0xE7, 0xC0, 0x1E, 0x78, 0x3C, 0xF8, 0x03, 0xCF,
  0x07, 0x9E, 0x00, 0x7B, 0xC0, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x07, 0xF0, 0x00, 0x00, 0x7B, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x18, 0x0F, 0xFC,
  0x00, 0x7C, 0x7F, 0xFC, 0x00, 0xF0, 0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0xFE,
  0x0F, 0x8F, 0x80, 0xFF, 0xFE, 0x1E, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x7F,
  0xE0, 0x30, 0x00, 0x3F, 0x80,
};

const GFXglyph UbuntuSansMono_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 45, 35, 10, -44 },
  { 91, 18, 17, 35, 14, -48 },
  { 130, 37, 44, 35, 0, -44 },
  { 334, 32, 56, 35, 3, -49 },
  { 558, 42, 46, 35, -2, -45 },
  { 800, 29, 46, 35, 2, -45 },
  { 967, 8, 18, 35, 19, -48 },
  { 985, 26, 61, 35, 8, -49 },
  { 1184, 26, 61, 35, 2, -49 },
  { 1383, 27, 26, 35, 7, -44 },
  { 1471, 29, 31, 35, 4, -34 },
  { 1584, 15, 19, 35, 5, -9 },
  { 1620, 15, 4, 35, 11, -20 },
  { 1628, 10, 10, 35, 10, -9 },
  { 1641, 40, 61, 35, -4, -49 },
  { 1946, 30, 46, 35, 4, -45 },
  { 2119, 25, 44, 35, 4, -44 },
  { 2257, 31, 45, 35, 3, -45 },
  { 2432, 32, 46, 35, 2, -45 },
  { 2616, 32, 44, 35, 1, -44 },
  { 2792, 34, 45, 35, 2, -44 },
  { 2984, 31, 45, 35, 5, -44 },
  { 3159, 31, 44, 35, 8, -44 },
  { 3330, 32, 46, 35, 3, -45 },
  { 3514, 32, 45, 35, 3, -45 },
  { 3694, 15, 33, 35, 10, -32 },
  { 3756, 20, 42, 35, 5, -32 },
  { 3861, 31, 28, 35, 3, -32 },
  { 3970, 32, 17, 35, 2, -27 },
  { 4038, 30, 28, 35, 2, -32 },
  { 4143, 25, 46, 35, 9, -45 },
  { 4287, 34, 54, 35, 3, -45 },
  { 4517, 34, 44, 35, -4, -44 },
  { 4704, 33, 44, 35, 1, -44 },
  { 4886, 34, 46, 35, 4, -45 },
  { 5082, 34, 44, 35, 0, -44 },
  { 5269, 34, 44, 35, 3, -44 },
  { 5456, 34, 44, 35, 3, -44 },
  { 5643, 33, 46, 35, 3, -45 },
  { 5833, 38, 44, 35, 0, -44 },
  { 6042, 32, 44, 35, 3, -44 },
  { 6218, 33, 45, 35, 3, -44 },
  { 6404, 38, 44, 35, 1, -44 },
  { 6613, 25, 44, 35, 1, -44 },
  { 6751, 37, 44, 35, -1, -44 },
  { 6955, 38, 44, 35, 0, -44 },
  { 7164, 33, 46, 35, 3, -45 },
  { 7354, 34, 44, 35, 1, -44 },
  { 7541, 33, 57, 35, 3, -45 },
  { 7777, 33, 44, 35, 1, -44 },
  { 7959, 34, 46, 35, 2, -45 },
  { 8155, 30, 44, 35, 9, -44 },
  { 8320, 35, 45, 35, 3, -44 },
  { 8517, 33, 44, 35, 7, -44 },
  { 8699, 38, 44, 35, 2, -44 },
  { 8908, 42, 44, 35, -2, -44 },
  { 9139, 33, 44, 35, 8, -44 },
  { 9321, 38, 44, 35, 0, -44 },
  { 9530, 31, 61, 35, 4, -49 },
  { 9767, 10, 61, 35, 13, -49 },
  { 9844, 31, 61, 35, -1, -49 },
  { 10081, 27, 24, 35, 6, -44 },
  { 10162, 32, 5, 35, -4, 7 },
  { 10182, 12, 13, 35, 16, -49 },
  { 10202, 30, 34, 35, 3, -33 },
  { 10330, 31, 50, 35, 2, -49 },
  { 10524, 31, 34, 35, 2, -33 },
  { 10656, 35, 50, 35, 3, -49 },
  { 10875, 30, 34, 35, 2, -33 },
  { 11003, 41, 61, 35, -1, -49 },
  { 11316, 36, 45, 35, -1, -33 },
  { 11519, 30, 49, 35, 0, -49 },
  { 11703, 20, 48, 35, 7, -48 },
  { 11823, 34, 60, 35, -1, -48 },
  { 12078, 33, 49, 35, 2, -49 },
  { 12281, 17, 50, 35, 11, -49 },
  { 12388, 34, 33, 35, 0, -33 },
  { 12529, 30, 33, 35, 2, -33 },
  { 12653, 30, 34, 35, 3, -33 },
  { 12781, 34, 45, 35, -1, -33 },
  { 12973, 31, 45, 35, 3, -33 },
  { 13148, 30, 33, 35, 4, -33 },
  { 13272, 29, 34, 35, 4, -33 },
  { 13396, 25, 44, 35, 8, -43 },
  { 13534, 31, 34, 35, 3, -33 },
  { 13666, 28, 33, 35, 7, -33 },
  { 13782, 35, 33, 35, 3, -33 },
  { 13927, 36, 33, 35, -1, -33 },
  { 14076, 38, 45, 35, -3, -33 },
  { 14290, 31, 33, 35, 2, -33 },
  { 14418, 35, 61, 35, 3, -49 },
  { 14685, 19, 61, 35, 9, -49 },
  { 14830, 34, 61, 35, -3, -49 },
  { 15090, 31, 9, 35, 3, -23 },
};

const GFXfont UbuntuSansMono_Italic63pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic63pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic63pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _UBUNTUSANSMONO_ITALIC63PT7B_H_
