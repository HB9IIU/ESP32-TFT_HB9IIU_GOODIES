#ifndef _UBUNTUSANSMONO_ITALIC12PT7B_H_
#define _UBUNTUSANSMONO_ITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x24, 0xB6, 0x80, 0x1A, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x48, 0x10, 0xF4, 0x10, 0x60, 0x60, 0xA4, 0xE1, 0x00, 0x21, 0x52, 0x54,
  0x58, 0x70, 0x1C, 0x34, 0x54, 0x9C, 0x08, 0xD2, 0x4A, 0x31, 0x58, 0xA2,
  0x7C, 0xE0, 0x12, 0x48, 0x88, 0x88, 0x88, 0x40, 0x10, 0x42, 0x10, 0x84,
  0x22, 0x11, 0x30, 0x27, 0x4C, 0xF5, 0x00, 0x31, 0x3E, 0x46, 0x00, 0x6D,
  0x40, 0xE0, 0xF0, 0x03, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0xC0, 0x13, 0x53, 0x1A, 0xD6, 0x32, 0xE0, 0x1B, 0x84, 0x22, 0x10,
  0x9E, 0x11, 0xA0, 0x42, 0x18, 0x84, 0x20, 0xF0, 0x08, 0xD0, 0x41, 0x18,
  0x10, 0x43, 0xF8, 0x0C, 0x52, 0x52, 0x4B, 0xF0, 0x84, 0x1E, 0x20, 0x81,
  0xC0, 0x40, 0x83, 0x7C, 0x1C, 0x84, 0x3E, 0x8A, 0x28, 0xBC, 0x7C, 0x21,
  0x04, 0x21, 0x84, 0x30, 0x11, 0xB4, 0x52, 0x7B, 0x68, 0xA2, 0xF0, 0x11,
  0xA4, 0x61, 0x49, 0xE1, 0x8C, 0xC0, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66,
  0x48, 0x0B, 0xA0, 0xC1, 0x80, 0x7E, 0x03, 0xF0, 0x60, 0x60, 0x4E, 0xC0,
  0x69, 0x11, 0x24, 0x08, 0x80, 0x0C, 0x24, 0x8A, 0x75, 0x2A, 0xA9, 0x4A,
  0x48, 0x80, 0xC0, 0x0C, 0x18, 0x48, 0x92, 0x27, 0xD0, 0xE1, 0x3C, 0x94,
  0x5E, 0x45, 0x18, 0x7E, 0x18, 0x94, 0x20, 0x82, 0x08, 0x20, 0x70, 0x3C,
  0x89, 0x0A, 0x24, 0x48, 0xA2, 0x78, 0x7D, 0x04, 0x1E, 0x82, 0x08, 0x3E,
  0x7D, 0x04, 0x1E, 0x82, 0x08, 0x20, 0x18, 0x94, 0x20, 0x82, 0x28, 0xA2,
  0xF0, 0x22, 0x45, 0x0B, 0xE4, 0x48, 0xA1, 0x44, 0x7C, 0x42, 0x08, 0x20,
  0x84, 0x3C, 0x3C, 0x10, 0x82, 0x08, 0x21, 0x3C, 0x26, 0x51, 0x43, 0x05,
  0x0A, 0x22, 0x46, 0x21, 0x08, 0x84, 0x21, 0x1F, 0x22, 0x4D, 0x6A, 0xE5,
  0x50, 0xA1, 0x42, 0x22, 0x65, 0x4A, 0xA5, 0x49, 0xA3, 0x44, 0x11, 0xA4,
  0x61, 0x86, 0x28, 0xA2, 0xF0, 0x3C, 0x44, 0x8A, 0x27, 0x88, 0x10, 0x40,
  0x11, 0xA4, 0x61, 0x86, 0x28, 0xA2, 0xF1, 0x03, 0x00, 0x3C, 0x45, 0x12,
  0x27, 0x89, 0x22, 0x44, 0x0C, 0x64, 0x81, 0x01, 0x01, 0x01, 0x02, 0xF8,
  0xF9, 0x10, 0x84, 0x22, 0x10, 0x45, 0x18, 0x62, 0x8A, 0x29, 0xBC, 0x87,
  0x0A, 0x24, 0x45, 0x0A, 0x18, 0x20, 0x23, 0x42, 0x42, 0x54, 0x6C, 0x6C,
  0x48, 0xC8, 0x23, 0x14, 0x18, 0x18, 0x18, 0x28, 0x48, 0x84, 0xC6, 0x89,
  0x22, 0x82, 0x04, 0x08, 0x20, 0x3E, 0x08, 0x20, 0x82, 0x04, 0x10, 0x7E,
  0x3C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x0E, 0x00, 0xD5, 0x55, 0x54,
  0x3C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x11, 0x53, 0x10,
  0xFC, 0x90, 0x3D, 0x14, 0x61, 0x49, 0xE0, 0x30, 0x82, 0x0F, 0x45, 0x14,
  0x52, 0xF0, 0x3D, 0x04, 0x20, 0x41, 0xE0, 0x04, 0x10, 0x5E, 0x8A, 0x28,
  0xA4, 0xE8, 0x3D, 0x14, 0xFC, 0x41, 0xE0, 0x0F, 0x08, 0x10, 0x3E, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x3E, 0xC9, 0x12, 0x24, 0x8F, 0x02,
  0x78, 0x20, 0x82, 0x1F, 0x45, 0x14, 0xA2, 0x88, 0x32, 0x0E, 0x22, 0x44,
  0x30, 0x04, 0x10, 0x0F, 0x04, 0x20, 0x82, 0x08, 0x4F, 0x00, 0x30, 0x40,
  0x89, 0x25, 0x8C, 0x14, 0x24, 0x8C, 0xE5, 0x24, 0xA4, 0xE0, 0x7D, 0x55,
  0x65, 0x86, 0x20, 0x3D, 0x14, 0x51, 0x47, 0x20, 0x7C, 0x63, 0x19, 0xF8,
  0x3D, 0x14, 0x51, 0x4B, 0xC8, 0x20, 0x7E, 0x28, 0xA2, 0x93, 0xC1, 0x04,
  0x7A, 0x11, 0x08, 0x40, 0x7A, 0x18, 0x21, 0x78, 0x21, 0x3E, 0x44, 0x21,
  0x0E, 0xCC, 0x63, 0x19, 0x78, 0x8E, 0x25, 0x14, 0x61, 0x00, 0x86, 0x9A,
  0xBA, 0x92, 0x40, 0x66, 0x50, 0x41, 0x84, 0x91, 0x00, 0x23, 0x12, 0x12,
  0x14, 0x14, 0x18, 0x10, 0xE0, 0x3C, 0x21, 0x08, 0x43, 0xE0, 0x1C, 0x82,
  0x08, 0x43, 0x04, 0x10, 0x42, 0x0F, 0x00, 0x24, 0xA4, 0x94, 0x92, 0x00,
  0x1C, 0x08, 0x10, 0x20, 0x40, 0xC2, 0x04, 0x08, 0x23, 0xC0, 0xF8,
};

const GFXglyph UbuntuSansMono_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 3, 3, 7, 3, -9 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 10, 7, 1, -9 },
  { 21, 8, 9, 7, 0, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 7, 4, -9 },
  { 38, 4, 11, 7, 2, -9 },
  { 44, 5, 11, 7, 0, -9 },
  { 51, 5, 5, 7, 1, -8 },
  { 55, 5, 5, 7, 1, -6 },
  { 59, 3, 4, 7, 1, -2 },
  { 61, 3, 1, 7, 2, -4 },
  { 62, 2, 2, 7, 2, -2 },
  { 63, 8, 11, 7, -1, -9 },
  { 74, 5, 9, 7, 1, -9 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 6, 9, 7, 1, -9 },
  { 92, 6, 9, 7, 0, -9 },
  { 99, 6, 8, 7, 0, -8 },
  { 105, 7, 8, 7, 0, -8 },
  { 112, 6, 8, 7, 1, -8 },
  { 118, 6, 8, 7, 1, -8 },
  { 124, 6, 9, 7, 1, -9 },
  { 131, 6, 9, 7, 1, -9 },
  { 138, 3, 6, 7, 2, -6 },
  { 141, 4, 8, 7, 1, -6 },
  { 145, 5, 5, 7, 1, -6 },
  { 149, 7, 3, 7, 0, -5 },
  { 152, 6, 5, 7, 0, -6 },
  { 156, 4, 9, 7, 2, -9 },
  { 161, 7, 11, 7, 0, -9 },
  { 171, 7, 8, 7, -1, -8 },
  { 178, 6, 8, 7, 0, -8 },
  { 184, 6, 9, 7, 1, -9 },
  { 191, 7, 8, 7, 0, -8 },
  { 198, 6, 8, 7, 1, -8 },
  { 204, 6, 8, 7, 1, -8 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 7, 8, 7, 0, -8 },
  { 224, 6, 8, 7, 1, -8 },
  { 230, 6, 8, 7, 1, -8 },
  { 236, 7, 8, 7, 0, -8 },
  { 243, 5, 8, 7, 0, -8 },
  { 248, 7, 8, 7, 0, -8 },
  { 255, 7, 8, 7, 0, -8 },
  { 262, 6, 9, 7, 1, -9 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 6, 11, 7, 1, -9 },
  { 285, 7, 8, 7, 0, -8 },
  { 292, 7, 9, 7, 0, -9 },
  { 300, 5, 8, 7, 2, -8 },
  { 305, 6, 8, 7, 1, -8 },
  { 311, 7, 8, 7, 1, -8 },
  { 318, 8, 8, 7, 0, -8 },
  { 326, 8, 8, 7, 0, -8 },
  { 334, 7, 8, 7, 1, -8 },
  { 341, 7, 8, 7, 0, -8 },
  { 348, 6, 11, 7, 1, -9 },
  { 357, 2, 11, 7, 2, -9 },
  { 360, 6, 11, 7, 0, -9 },
  { 369, 5, 4, 7, 1, -8 },
  { 372, 6, 1, 7, -1, 1 },
  { 373, 2, 2, 7, 3, -9 },
  { 374, 6, 6, 7, 0, -6 },
  { 379, 6, 9, 7, 0, -9 },
  { 386, 6, 6, 7, 0, -6 },
  { 391, 6, 9, 7, 1, -9 },
  { 398, 6, 6, 7, 0, -6 },
  { 403, 8, 11, 7, 0, -9 },
  { 414, 7, 8, 7, 0, -6 },
  { 421, 6, 9, 7, 0, -9 },
  { 428, 4, 9, 7, 1, -9 },
  { 433, 6, 11, 7, 0, -9 },
  { 442, 7, 9, 7, 0, -9 },
  { 450, 3, 9, 7, 2, -9 },
  { 454, 6, 6, 7, 0, -6 },
  { 459, 6, 6, 7, 0, -6 },
  { 464, 5, 6, 7, 1, -6 },
  { 468, 6, 8, 7, 0, -6 },
  { 474, 6, 8, 7, 1, -6 },
  { 480, 5, 6, 7, 1, -6 },
  { 484, 5, 6, 7, 1, -6 },
  { 488, 5, 8, 7, 1, -8 },
  { 493, 5, 6, 7, 1, -6 },
  { 497, 6, 6, 7, 1, -6 },
  { 502, 6, 6, 7, 1, -6 },
  { 507, 7, 6, 7, 0, -6 },
  { 513, 8, 8, 7, -1, -6 },
  { 521, 6, 6, 7, 0, -6 },
  { 526, 6, 11, 7, 1, -9 },
  { 535, 3, 11, 7, 2, -9 },
  { 540, 7, 11, 7, -1, -9 },
  { 550, 5, 1, 7, 1, -4 },
};

const GFXfont UbuntuSansMono_Italic12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_ITALIC12PT7B_H_
