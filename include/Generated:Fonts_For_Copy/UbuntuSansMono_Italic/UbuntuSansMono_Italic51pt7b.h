#ifndef _UBUNTUSANSMONO_ITALIC51PT7B_H_
#define _UBUNTUSANSMONO_ITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x60, 0x00,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9C,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8C, 0x06,
  0x18, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xC0, 0x18, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x08, 0x00, 0x1E, 0x03, 0x80, 0x1F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x78, 0x03, 0x87,
  0x00, 0x3C, 0x01, 0xC1, 0xC0, 0x1E, 0x00, 0x70, 0x70, 0x0F, 0x00, 0x3C,
  0x1C, 0x07, 0x80, 0x0E, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0xF0, 0x00,
  0xE0, 0x70, 0x78, 0x00, 0x38, 0x1C, 0x3C, 0x00, 0x0E, 0x0F, 0x1E, 0x00,
  0x03, 0x83, 0x8F, 0x00, 0x00, 0xE1, 0xE7, 0x80, 0x00, 0x3C, 0x71, 0xC0,
  0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x0C, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07,
  0x8F, 0xF0, 0x00, 0x01, 0xC7, 0xFC, 0x00, 0x00, 0xF3, 0xC7, 0x80, 0x00,
  0x78, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x78, 0x00, 0x1E, 0x1C, 0x1E, 0x00,
  0x0F, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x78,
  0x00, 0xF0, 0x38, 0x1C, 0x00, 0x78, 0x0E, 0x07, 0x00, 0x3C, 0x03, 0x83,
  0xC0, 0x1E, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x3C, 0x78, 0x07, 0x80, 0x07,
  0xFC, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x07, 0x03, 0xFC, 0x0F, 0x07, 0xFE, 0x0F, 0x0F,
  0x1E, 0x0E, 0x1E, 0x0F, 0x1E, 0x3C, 0x0F, 0x9E, 0x3C, 0x07, 0xBC, 0x78,
  0x07, 0xFC, 0x78, 0x03, 0xF8, 0x78, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x7E,
  0x1F, 0xF8, 0x3F, 0xFE, 0x7C, 0x1F, 0xFC, 0x3C, 0x0F, 0xF0, 0x3E, 0x1E,
  0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0x81, 0xE0, 0x47, 0x87, 0x07, 0x9F, 0x9C, 0xFE, 0xFF,
  0xBF, 0xF9, 0xFF, 0xFF, 0xD0, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0x78, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x7C, 0x1F, 0x80, 0xF0, 0x3C, 0x01, 0x80, 0x40, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x7E, 0x07, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0xF8, 0x7F,
  0x8F, 0xE0, 0xFC, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x7E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF0, 0xF0, 0x3C, 0x78, 0xFC,
  0x1E, 0x7C, 0x7F, 0x0F, 0x3C, 0x3F, 0x87, 0x9E, 0x1F, 0xC7, 0xCF, 0x0F,
  0xC3, 0xCF, 0x83, 0xC1, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x01,
  0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0x3C, 0x07, 0xC3, 0xC0, 0x70, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x02, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xF9, 0xFE,
  0x01, 0xE0, 0x0F, 0x80, 0x30, 0x01, 0xE0, 0x08, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x0E, 0x00, 0xF8,
  0x04, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x80, 0x03, 0xF0,
  0x70, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07,
  0x81, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x20, 0x01, 0xF8, 0x03, 0x80, 0x7F, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x10, 0x00, 0x79,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x3F, 0xC0, 0x1F, 0x83, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xFC, 0x03,
  0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xE7, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x4F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x80, 0x3E, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x80, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0xFE, 0x00,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x70, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x7F, 0xE1, 0xE0, 0x3F, 0xFE,
  0x1E, 0x07, 0xFF, 0xE3, 0xE0, 0xFC, 0x1E, 0x3C, 0x1F, 0x03, 0xC7, 0xC3,
  0xE0, 0x3C, 0x7C, 0x3C, 0x03, 0xC7, 0x87, 0xC0, 0x3C, 0x78, 0x78, 0x07,
  0x87, 0x87, 0x80, 0x78, 0xF8, 0x78, 0x07, 0x8F, 0x07, 0x80, 0x78, 0xF0,
  0xF8, 0x0F, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0x80,
  0xF0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xE1, 0xE0, 0xF0, 0x3F, 0xFE, 0x0F,
  0x81, 0xFF, 0xE0, 0x78, 0x07, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x01,
  0xC0, 0x07, 0xC0, 0x78, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0x00, 0x7F, 0x01, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xE0,
  0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x1F, 0x00, 0x04, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x3F, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0xC0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0xF8,
  0x07, 0x80, 0x3F, 0x00, 0x78, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFC, 0x7E, 0x00, 0xFC, 0x00, 0xC0, 0x1F, 0x80, 0x04, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x78, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x03, 0xE0, 0x0C, 0x00, 0xF8,
  0x03, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x03, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x0F,
  0x80, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1D,
  0xC0, 0x1B, 0xC0, 0xEE, 0x00, 0xE7, 0x03, 0xB8, 0x03, 0x9C, 0x1C, 0xE0,
  0x0E, 0x70, 0x73, 0x80, 0x71, 0xC3, 0x8E, 0x01, 0xC7, 0x1E, 0x78, 0x0F,
  0x1C, 0x71, 0xE0, 0x3C, 0x73, 0x87, 0x00, 0xE1, 0xCE, 0x1C, 0x03, 0x87,
  0x70, 0x70, 0x1E, 0x1F, 0xC3, 0xC0, 0x78, 0x3E, 0x0F, 0x01, 0xC0, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x38, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xE0,
  0x01, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0xF7, 0x00, 0x3C, 0x01, 0xCF, 0x00, 0x78, 0x03, 0x9E, 0x00,
  0xE0, 0x0F, 0x1C, 0x01, 0xC0, 0x1E, 0x3C, 0x07, 0x80, 0x38, 0x78, 0x0F,
  0x00, 0x70, 0x70, 0x1E, 0x01, 0xE0, 0xE0, 0x38, 0x03, 0xC1, 0xE0, 0xF0,
  0x07, 0x03, 0xC1, 0xE0, 0x0E, 0x03, 0x83, 0xC0, 0x3C, 0x07, 0x07, 0x00,
  0x78, 0x0F, 0x1E, 0x00, 0xF0, 0x1E, 0x3C, 0x01, 0xC0, 0x3C, 0x78, 0x07,
  0x80, 0x38, 0xE0, 0x0F, 0x00, 0x73, 0xC0, 0x1E, 0x00, 0xE7, 0x80, 0x38,
  0x01, 0xEF, 0x00, 0xF0, 0x01, 0xDC, 0x01, 0xE0, 0x03, 0xB8, 0x03, 0xC0,
  0x07, 0xF0, 0x07, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x3C, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xF9, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF8,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x07,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFE, 0xFE, 0x00, 0x7C, 0x00, 0x40, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x02, 0x00, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC0, 0xE0, 0x3C, 0x3F, 0x07, 0x80, 0xE0, 0xFC, 0x1E, 0x03, 0x87, 0xB0,
  0x70, 0x0E, 0x1C, 0xE1, 0xC0, 0x38, 0xE3, 0x8F, 0x01, 0xE3, 0x8E, 0x38,
  0x07, 0x1C, 0x38, 0xE0, 0x1C, 0xF0, 0xE7, 0x80, 0x73, 0x83, 0x9C, 0x01,
  0xDE, 0x0E, 0x70, 0x07, 0x70, 0x39, 0xC0, 0x3B, 0xC0, 0xEE, 0x00, 0xEE,
  0x03, 0xB8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xE7, 0x00, 0x0F, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xC0, 0xE0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0,
  0x1C, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x03, 0xBE, 0x00, 0x0F,
  0xF0, 0x00, 0x3D, 0x80, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8,
  0x3C, 0x0F, 0x03, 0x81, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xF1, 0xE0, 0x3F, 0x80, 0xF0, 0x3F, 0x00, 0x78,
  0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x3C, 0x03, 0xFF, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xF8, 0xFE, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01,
  0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0xFC, 0x0F, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0x83, 0xE0, 0x7E, 0x00, 0x10, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x7E, 0x00, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x1F, 0x00, 0x3F, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xE0, 0x1F, 0x00, 0x1E, 0x03,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x70, 0x00, 0xFF, 0x87, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x7E, 0x78, 0x03,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x3F, 0x00, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x02, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xF3, 0xF0, 0x03, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0x78, 0x03,
  0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x87, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x7F, 0x80,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xE1, 0x07, 0xFF, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x20, 0x03, 0xC0, 0x07, 0x01, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x40, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x03, 0x81, 0xF8, 0x00, 0xF0, 0x7C, 0x00,
  0x1E, 0x3F, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x03, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0x80, 0x60, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0xFB, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x7E, 0xFF, 0xFE, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF8, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00,
  0xF0, 0x03, 0xF0, 0x0F, 0x00, 0x7E, 0x01, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xE3, 0xE0, 0x3F, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0x78, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xE0, 0x07, 0x80, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x0E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x3E, 0x00, 0x40, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x78,
  0x38, 0x03, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x30, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFC, 0xF0, 0x1F, 0xF8, 0xF0, 0x01, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x0E, 0x03, 0x87,
  0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x03, 0xE0, 0xF0, 0x70, 0x3E,
  0x0F, 0x0F, 0x07, 0xE0, 0xE0, 0xF0, 0xFE, 0x1E, 0x0F, 0x0E, 0xE1, 0xE0,
  0xF1, 0xEF, 0x1C, 0x0F, 0x1C, 0xF3, 0xC0, 0xF3, 0x8F, 0x38, 0x0F, 0x78,
  0x77, 0x80, 0xF7, 0x07, 0x78, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x3C,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x04, 0x1F, 0xE0, 0x07, 0x3F, 0xF8, 0x0F,
  0x7F, 0xFC, 0x1E, 0x78, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xE0, 0x0F, 0xF8,
  0x20, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 36, 29, 8, -35 },
  { 60, 15, 14, 29, 11, -39 },
  { 87, 30, 35, 29, 0, -35 },
  { 219, 26, 46, 29, 2, -40 },
  { 369, 34, 37, 29, -2, -36 },
  { 527, 24, 36, 29, 1, -36 },
  { 635, 7, 15, 29, 15, -39 },
  { 649, 22, 49, 29, 6, -40 },
  { 784, 21, 49, 29, 1, -40 },
  { 913, 22, 20, 29, 6, -35 },
  { 968, 23, 24, 29, 3, -27 },
  { 1037, 12, 16, 29, 4, -8 },
  { 1061, 12, 3, 29, 9, -16 },
  { 1066, 8, 9, 29, 8, -8 },
  { 1075, 32, 49, 29, -3, -40 },
  { 1271, 25, 37, 29, 3, -36 },
  { 1387, 20, 35, 29, 4, -35 },
  { 1475, 26, 36, 29, 2, -36 },
  { 1592, 25, 37, 29, 2, -36 },
  { 1708, 25, 35, 29, 1, -35 },
  { 1818, 28, 36, 29, 1, -35 },
  { 1944, 25, 37, 29, 4, -36 },
  { 2060, 26, 35, 29, 6, -35 },
  { 2174, 26, 37, 29, 3, -36 },
  { 2295, 26, 36, 29, 2, -36 },
  { 2412, 12, 28, 29, 8, -27 },
  { 2454, 16, 35, 29, 4, -27 },
  { 2524, 25, 23, 29, 2, -26 },
  { 2596, 26, 14, 29, 2, -22 },
  { 2642, 25, 23, 29, 1, -26 },
  { 2714, 20, 37, 29, 7, -36 },
  { 2807, 28, 44, 29, 2, -36 },
  { 2961, 28, 35, 29, -3, -35 },
  { 3084, 27, 36, 29, 1, -36 },
  { 3206, 28, 37, 29, 3, -36 },
  { 3336, 28, 36, 29, 0, -36 },
  { 3462, 28, 35, 29, 2, -35 },
  { 3585, 28, 35, 29, 2, -35 },
  { 3708, 28, 37, 29, 2, -36 },
  { 3838, 31, 35, 29, 0, -35 },
  { 3974, 25, 35, 29, 3, -35 },
  { 4084, 27, 36, 29, 2, -35 },
  { 4206, 30, 35, 29, 1, -35 },
  { 4338, 20, 35, 29, 1, -35 },
  { 4426, 30, 35, 29, -1, -35 },
  { 4558, 31, 35, 29, 0, -35 },
  { 4694, 26, 37, 29, 3, -36 },
  { 4815, 28, 36, 29, 1, -36 },
  { 4941, 26, 45, 29, 3, -36 },
  { 5088, 27, 36, 29, 1, -36 },
  { 5210, 28, 37, 29, 1, -36 },
  { 5340, 24, 35, 29, 7, -35 },
  { 5445, 28, 36, 29, 3, -35 },
  { 5571, 27, 35, 29, 6, -35 },
  { 5690, 30, 35, 29, 2, -35 },
  { 5822, 35, 35, 29, -2, -35 },
  { 5976, 28, 35, 29, 6, -35 },
  { 6099, 31, 35, 29, 0, -35 },
  { 6235, 25, 49, 29, 4, -40 },
  { 6389, 8, 49, 29, 11, -40 },
  { 6438, 25, 49, 29, -1, -40 },
  { 6592, 22, 18, 29, 5, -35 },
  { 6642, 27, 3, 29, -4, 6 },
  { 6653, 9, 10, 29, 13, -39 },
  { 6665, 25, 28, 29, 2, -27 },
  { 6753, 25, 41, 29, 2, -40 },
  { 6882, 25, 28, 29, 2, -27 },
  { 6970, 28, 41, 29, 3, -40 },
  { 7114, 24, 28, 29, 2, -27 },
  { 7198, 33, 50, 29, -1, -40 },
  { 7405, 29, 37, 29, -1, -27 },
  { 7540, 25, 40, 29, 0, -40 },
  { 7665, 16, 39, 29, 6, -39 },
  { 7743, 27, 49, 29, 0, -39 },
  { 7909, 27, 40, 29, 2, -40 },
  { 8044, 14, 40, 29, 9, -39 },
  { 8114, 28, 27, 29, 0, -27 },
  { 8209, 24, 27, 29, 2, -27 },
  { 8290, 24, 28, 29, 3, -27 },
  { 8374, 28, 36, 29, -1, -27 },
  { 8500, 25, 36, 29, 3, -27 },
  { 8613, 24, 27, 29, 3, -27 },
  { 8694, 23, 28, 29, 3, -27 },
  { 8775, 21, 36, 29, 6, -35 },
  { 8870, 24, 27, 29, 3, -26 },
  { 8951, 22, 26, 29, 6, -26 },
  { 9023, 28, 26, 29, 3, -26 },
  { 9114, 30, 26, 29, -1, -26 },
  { 9212, 31, 36, 29, -3, -26 },
  { 9352, 26, 26, 29, 1, -26 },
  { 9437, 27, 49, 29, 3, -40 },
  { 9603, 16, 49, 29, 7, -40 },
  { 9701, 27, 49, 29, -2, -40 },
  { 9867, 24, 8, 29, 3, -19 },
};

const GFXfont UbuntuSansMono_Italic51pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic51pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic51pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UBUNTUSANSMONO_ITALIC51PT7B_H_
