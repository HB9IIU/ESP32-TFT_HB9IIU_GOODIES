#ifndef _UBUNTUSANSMONO_ITALIC38PT7B_H_
#define _UBUNTUSANSMONO_ITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x02, 0x00, 0x38,
  0x66, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xC3, 0x98, 0x73, 0x0C, 0xC1, 0x98,
  0x30, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x60, 0x60, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xE0, 0xE0, 0x01, 0x81,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x02, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x40, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x81, 0xFC, 0x03, 0x81, 0xCE, 0x01, 0x80, 0xC3, 0x01, 0xC0,
  0xE1, 0x81, 0xC0, 0x60, 0xC1, 0xC0, 0x30, 0x61, 0xC0, 0x18, 0x71, 0xC0,
  0x0C, 0x39, 0xC0, 0x06, 0x18, 0xC0, 0x03, 0x1C, 0xE0, 0x01, 0xFC, 0xE0,
  0x00, 0x7C, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE7,
  0xE0, 0x00, 0x67, 0x38, 0x00, 0x73, 0x1C, 0x00, 0x73, 0x8E, 0x00, 0x71,
  0x87, 0x00, 0x70, 0xC3, 0x80, 0x70, 0xE1, 0xC0, 0x70, 0x70, 0xE0, 0x30,
  0x38, 0x60, 0x38, 0x1C, 0x70, 0x38, 0x07, 0x70, 0x38, 0x03, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0E, 0x0E,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x0F, 0x01,
  0xC7, 0x80, 0x73, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x71, 0xFE,
  0x18, 0xF3, 0x8E, 0x38, 0x73, 0x9C, 0x1C, 0xC7, 0x03, 0xF3, 0x80, 0xF8,
  0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0xC0, 0xF8, 0x78, 0xF7, 0x1F,
  0xF9, 0xC3, 0xF8, 0x78, 0x3C, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x61, 0x8E,
  0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x07, 0x1C, 0x73, 0xEE, 0xFB, 0xFF, 0xFE, 0x3F, 0xF0, 0x01, 0xC0,
  0x01, 0xB0, 0x01, 0xDC, 0x01, 0xC7, 0x01, 0xE3, 0xC1, 0xE0, 0xF0, 0x30,
  0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x02, 0x07, 0x87, 0xE3, 0xF1, 0xF8,
  0x7C, 0x1C, 0x0E, 0x1E, 0x7E, 0x3E, 0x1C, 0x00, 0x7F, 0xDF, 0xEF, 0xF8,
  0x31, 0xEF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xE1, 0xE0, 0x78, 0x1C, 0x1E, 0x03, 0x83,
  0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x3C,
  0xF8, 0xE7, 0x1F, 0x1C, 0xE3, 0xE3, 0x9C, 0x7C, 0xF7, 0x87, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0,
  0x3C, 0x3C, 0x07, 0x03, 0x81, 0xE0, 0x78, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xF7, 0x03, 0x8E, 0x04, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x03, 0x81, 0xE0, 0x40, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE2, 0x00, 0x78, 0x70, 0x7E, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x0F, 0x1C,
  0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70,
  0x78, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x0E, 0x0F, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xEF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07,
  0x03, 0x83, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xC0, 0xF0, 0x70, 0x0E, 0x1E, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0F,
  0x07, 0x83, 0xC0, 0x7C, 0xF0, 0x07, 0xF8, 0x03, 0xDF, 0x80, 0xF0, 0xF8,
  0x38, 0x0F, 0x0E, 0x00, 0xF1, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x80, 0x78, 0x78, 0x3E, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xC0, 0xE0, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E,
  0x3C, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x43, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x02, 0x07,
  0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x02, 0x00, 0x00, 0x40,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x1E, 0x0F, 0xC0, 0xF8, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x38, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x0F, 0x07, 0x80, 0x70, 0xF0, 0x07,
  0x0E, 0x00, 0x71, 0xE0, 0x07, 0x3C, 0x00, 0x73, 0x80, 0xFF, 0x38, 0x3F,
  0xF7, 0x07, 0x8E, 0x70, 0xE0, 0xE7, 0x1C, 0x0E, 0xF1, 0xC0, 0xEE, 0x38,
  0x1C, 0xE3, 0x81, 0xCE, 0x38, 0x1C, 0xE3, 0x81, 0xCE, 0x38, 0x38, 0xE3,
  0x83, 0x8E, 0x3C, 0x38, 0xE1, 0xE7, 0x8E, 0x0F, 0xF0, 0xE0, 0x7F, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x60,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xC0, 0x07, 0x18, 0x00,
  0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0x03, 0xE0,
  0x38, 0x07, 0x03, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x0F, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x70, 0x7F, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0F, 0x0E, 0x00, 0xF0, 0x70, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xC0, 0x60, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x40, 0x3E, 0x0E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x0E, 0x07,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x0E,
  0x00, 0x78, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03, 0xC1,
  0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0xF1, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3C, 0x06, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x38, 0x01,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01,
  0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x40, 0x3C, 0x0F, 0x07, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x01,
  0xC3, 0xC0, 0x03, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x78, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xE0,
  0x38, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x07,
  0xC0, 0x36, 0x0D, 0x80, 0xEC, 0x3B, 0x01, 0x98, 0x6E, 0x03, 0x31, 0x9C,
  0x0E, 0x63, 0x38, 0x18, 0xCC, 0x60, 0x31, 0xB8, 0xC0, 0xE3, 0xE3, 0x81,
  0xC7, 0xC7, 0x03, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x00, 0x30, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00,
  0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x80, 0x70, 0x1F, 0x00,
  0xE0, 0x7E, 0x01, 0xC0, 0xEE, 0x03, 0x81, 0xDC, 0x06, 0x03, 0x38, 0x1C,
  0x06, 0x30, 0x38, 0x1C, 0x70, 0x70, 0x38, 0xE0, 0xC0, 0x61, 0xC3, 0x80,
  0xC1, 0x87, 0x03, 0x83, 0x8E, 0x07, 0x07, 0x18, 0x0E, 0x0E, 0x70, 0x18,
  0x0C, 0xE0, 0x70, 0x19, 0xC0, 0xE0, 0x3B, 0x01, 0xC0, 0x76, 0x03, 0x00,
  0xFC, 0x0E, 0x00, 0xF8, 0x1C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x60, 0x07,
  0x81, 0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03,
  0xC0, 0xF0, 0x70, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x03, 0x83, 0x80,
  0xF0, 0x78, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0xF0,
  0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0x03, 0xC0, 0xF0, 0x70, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x3C,
  0x03, 0x83, 0x80, 0xF0, 0x78, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0,
  0xE0, 0x1E, 0x07, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x3C, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0x80, 0x40, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x08, 0x01, 0xE0, 0x78, 0x3F, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x07, 0x01, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x70, 0x70,
  0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x03, 0x38, 0x00, 0x37, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x30, 0x00,
  0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0xC3, 0x03, 0x8F, 0x8E, 0x06, 0x1B, 0x1C,
  0x0C, 0x66, 0x30, 0x19, 0xCC, 0x60, 0x73, 0x19, 0xC0, 0xEE, 0x33, 0x01,
  0x98, 0x66, 0x03, 0x70, 0xDC, 0x06, 0xC1, 0xB0, 0x0F, 0x83, 0xE0, 0x1E,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x07, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x78,
  0x01, 0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x70,
  0x70, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x01, 0x8E, 0x00, 0x1C, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3D, 0x80, 0x1C, 0xE0, 0x1C, 0x70, 0x1C, 0x18,
  0x1E, 0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x8E, 0x00, 0xCE, 0x00, 0x7F, 0x00,
  0x39, 0x00, 0x10, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x61,
  0xE1, 0xC1, 0xC3, 0xC3, 0xC3, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7F,
  0x3C, 0x3C, 0x06, 0x1E, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0C,
  0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x1F, 0x87, 0xFF,
  0xE0, 0xFF, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xEF, 0xE0, 0x1F, 0xFE, 0x07, 0xF3, 0xE0, 0xF0, 0x1C, 0x1C, 0x03,
  0xC3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0x80, 0x3C,
  0x70, 0x0F, 0x0E, 0x07, 0xC1, 0xC3, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x1F, 0x87, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x01, 0x07, 0xC0, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xE3, 0x80, 0xF8, 0x1C,
  0x0F, 0x00, 0xE0, 0xF0, 0x06, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x1E, 0x0F,
  0x80, 0x7F, 0xFC, 0x01, 0xFE, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0x9F, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x73,
  0xC0, 0x1E, 0x70, 0x07, 0x8E, 0x1F, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x01, 0x07,
  0xC1, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x40, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x27, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xBE, 0x07, 0xC0,
  0xE0, 0x78, 0x07, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x07, 0x80, 0x70, 0x1E, 0x1F, 0x80, 0xFF,
  0xFC, 0x01, 0xFE, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x10, 0x03, 0xC0, 0xF9, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFF, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x8F,
  0xF8, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x80,
  0x78, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x07, 0x01,
  0xE0, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xE1, 0xE0, 0x0E, 0x3C, 0x01, 0xC7,
  0x80, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xBC, 0x00, 0x39,
  0xE0, 0x03, 0x8F, 0x00, 0x38, 0x78, 0x03, 0x83, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x80, 0x7F, 0xCF,
  0xF2, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE1, 0x9F,
  0xF1, 0xFE, 0x07, 0xF3, 0xE0, 0x7F, 0xFF, 0x83, 0xDF, 0xFC, 0x1C, 0x78,
  0xF0, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18,
  0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x0E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00,
  0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x3C, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C,
  0x0E, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0xF3, 0x80, 0x38, 0xF0, 0x1E, 0x1F, 0x3F, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFC, 0xFC, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xE1, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x1F, 0xCF, 0x07, 0xC0, 0xE1, 0xE0, 0x1C,
  0x78, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x07, 0xC1, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x21, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0x1C,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7E, 0xF8, 0x3C, 0x02, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x40, 0x0E, 0x1C, 0x0F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x18, 0x3F, 0xF0, 0x3F, 0xE0,
  0x1C, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xF0, 0x1E, 0x1E, 0x1F, 0x87, 0xFE, 0xE0, 0xFF, 0x38, 0xE0, 0x03, 0xF8,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x0E,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x30, 0x71, 0xC3, 0x83, 0x8E, 0x1C,
  0x18, 0x61, 0xE1, 0xC3, 0x0F, 0x8E, 0x38, 0xFC, 0xE1, 0xC6, 0xE7, 0x0E,
  0x67, 0x30, 0x77, 0x1B, 0x83, 0xB0, 0xDC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x1C,
  0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03,
  0xCF, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xBC, 0x00,
  0x3C, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x1C, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x6F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x8F, 0xF0, 0x77, 0xBE, 0x19, 0x83, 0xFE, 0xE0, 0x7F, 0x10, 0x07, 0x00,
};

const GFXglyph UbuntuSansMono_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 10, 27, 21, 6, -26 },
  { 35, 11, 10, 21, 8, -29 },
  { 49, 23, 26, 21, 0, -26 },
  { 124, 19, 33, 21, 2, -29 },
  { 203, 25, 28, 21, -1, -27 },
  { 291, 18, 27, 21, 1, -27 },
  { 352, 6, 11, 21, 11, -29 },
  { 361, 16, 37, 21, 5, -30 },
  { 435, 16, 37, 21, 1, -30 },
  { 509, 17, 15, 21, 4, -26 },
  { 541, 18, 18, 21, 2, -20 },
  { 582, 9, 12, 21, 3, -6 },
  { 596, 10, 3, 21, 6, -12 },
  { 600, 6, 7, 21, 6, -6 },
  { 606, 24, 37, 21, -2, -30 },
  { 717, 19, 28, 21, 2, -27 },
  { 784, 15, 26, 21, 3, -26 },
  { 833, 19, 27, 21, 2, -27 },
  { 898, 19, 28, 21, 1, -27 },
  { 965, 19, 26, 21, 1, -26 },
  { 1027, 21, 27, 21, 1, -26 },
  { 1098, 19, 27, 21, 3, -26 },
  { 1163, 18, 26, 21, 5, -26 },
  { 1222, 19, 28, 21, 2, -27 },
  { 1289, 19, 27, 21, 2, -27 },
  { 1354, 9, 21, 21, 6, -20 },
  { 1378, 12, 26, 21, 3, -20 },
  { 1417, 18, 16, 21, 2, -19 },
  { 1453, 20, 10, 21, 1, -16 },
  { 1478, 19, 16, 21, 1, -19 },
  { 1516, 15, 28, 21, 5, -27 },
  { 1569, 20, 33, 21, 2, -27 },
  { 1652, 20, 26, 21, -2, -26 },
  { 1717, 21, 27, 21, 0, -27 },
  { 1788, 21, 28, 21, 2, -27 },
  { 1862, 21, 27, 21, 0, -27 },
  { 1933, 21, 26, 21, 2, -26 },
  { 2002, 21, 26, 21, 2, -26 },
  { 2071, 20, 28, 21, 2, -27 },
  { 2141, 23, 26, 21, 0, -26 },
  { 2216, 19, 26, 21, 2, -26 },
  { 2278, 20, 27, 21, 2, -26 },
  { 2346, 23, 26, 21, 0, -26 },
  { 2421, 15, 26, 21, 1, -26 },
  { 2470, 23, 26, 21, -1, -26 },
  { 2545, 23, 26, 21, 0, -26 },
  { 2620, 19, 28, 21, 2, -27 },
  { 2687, 20, 27, 21, 1, -27 },
  { 2755, 19, 34, 21, 2, -27 },
  { 2836, 21, 27, 21, 0, -27 },
  { 2907, 21, 28, 21, 1, -27 },
  { 2981, 18, 26, 21, 5, -26 },
  { 3040, 21, 27, 21, 2, -26 },
  { 3111, 20, 26, 21, 4, -26 },
  { 3176, 23, 26, 21, 1, -26 },
  { 3251, 25, 26, 21, -1, -26 },
  { 3333, 20, 26, 21, 5, -26 },
  { 3398, 23, 26, 21, 0, -26 },
  { 3473, 18, 37, 21, 3, -30 },
  { 3557, 6, 37, 21, 8, -30 },
  { 3585, 18, 37, 21, 0, -30 },
  { 3669, 17, 14, 21, 3, -26 },
  { 3699, 20, 3, 21, -3, 4 },
  { 3707, 7, 7, 21, 10, -29 },
  { 3714, 18, 20, 21, 2, -20 },
  { 3759, 19, 29, 21, 1, -29 },
  { 3828, 19, 21, 21, 1, -20 },
  { 3878, 21, 29, 21, 2, -29 },
  { 3955, 19, 21, 21, 1, -20 },
  { 4005, 25, 36, 21, -1, -29 },
  { 4118, 21, 27, 21, 0, -20 },
  { 4189, 18, 29, 21, 0, -29 },
  { 4255, 12, 29, 21, 4, -29 },
  { 4299, 20, 36, 21, 0, -29 },
  { 4389, 20, 29, 21, 1, -29 },
  { 4462, 11, 29, 21, 6, -29 },
  { 4502, 21, 20, 21, 0, -20 },
  { 4555, 18, 20, 21, 1, -20 },
  { 4600, 18, 20, 21, 2, -20 },
  { 4645, 21, 27, 21, -1, -20 },
  { 4716, 19, 27, 21, 2, -20 },
  { 4781, 18, 20, 21, 2, -20 },
  { 4826, 18, 20, 21, 2, -20 },
  { 4871, 15, 26, 21, 5, -26 },
  { 4920, 18, 20, 21, 2, -20 },
  { 4965, 17, 20, 21, 4, -20 },
  { 5008, 21, 20, 21, 2, -20 },
  { 5061, 22, 20, 21, -1, -20 },
  { 5116, 23, 27, 21, -2, -20 },
  { 5194, 19, 20, 21, 1, -20 },
  { 5242, 21, 37, 21, 2, -30 },
  { 5340, 12, 37, 21, 5, -30 },
  { 5396, 21, 37, 21, -2, -30 },
  { 5494, 18, 6, 21, 2, -14 },
};

const GFXfont UbuntuSansMono_Italic38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_ITALIC38PT7B_H_
