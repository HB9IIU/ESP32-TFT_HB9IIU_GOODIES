#ifndef _UBUNTUSANSMONO_ITALIC24PT7B_H_
#define _UBUNTUSANSMONO_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x0C, 0x30, 0x82, 0x00, 0x00, 0x0E,
  0x38, 0xE0, 0x66, 0xCD, 0x12, 0x2C, 0x51, 0x80, 0x01, 0x8C, 0x06, 0x30,
  0x10, 0x80, 0xC6, 0x03, 0x18, 0xFF, 0xF0, 0x63, 0x03, 0x18, 0x0C, 0x60,
  0x63, 0x01, 0x8C, 0x1F, 0xFE, 0xFF, 0xF0, 0x84, 0x06, 0x30, 0x18, 0xC0,
  0xC6, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x3E, 0x0F, 0xF1, 0xC1, 0x18,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x0C, 0x61, 0xCF, 0xF8, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x07,
  0x03, 0x0D, 0x86, 0x19, 0x84, 0x11, 0x8C, 0x11, 0x98, 0x11, 0x30, 0x13,
  0x60, 0x1E, 0xC0, 0x01, 0x80, 0x01, 0x38, 0x02, 0x48, 0x06, 0xCC, 0x0C,
  0x8C, 0x18, 0x88, 0x30, 0x88, 0x60, 0x98, 0xC0, 0xF0, 0x07, 0x81, 0xF8,
  0x63, 0x0C, 0x61, 0x8C, 0x33, 0x06, 0xE0, 0xF0, 0x1C, 0x6E, 0xCD, 0x9B,
  0x61, 0xEC, 0x39, 0x83, 0x30, 0xE7, 0x76, 0x7C, 0xC0, 0x6D, 0xA5, 0xA0,
  0x00, 0x40, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x04, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0xC3, 0x33, 0xFF, 0xCF, 0x81, 0xE0, 0xDC, 0x73, 0x88, 0x40, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0xFF, 0xFF, 0xF8, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x10, 0xE3, 0xCE, 0x18, 0xCE, 0x30, 0xFF, 0xF0,
  0x5F, 0xF0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0xFE, 0x0C, 0x31, 0x83, 0x30, 0x33, 0x03, 0x60, 0x36, 0x73,
  0x67, 0x36, 0x66, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0x61, 0x87, 0x70,
  0x3E, 0x00, 0x00, 0x80, 0xC1, 0xE3, 0xA3, 0xB0, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x31, 0xFF, 0xFF, 0x00, 0x07, 0xC1,
  0xFE, 0x08, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xC0, 0xFE, 0x08, 0x70, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x7C,
  0x0F, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xCE, 0x78,
  0xFF, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1B, 0x03, 0x20, 0x66, 0x0C,
  0x61, 0x86, 0x18, 0x43, 0x0C, 0x60, 0xC7, 0xFF, 0xFF, 0xF0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x07, 0xF8, 0x3F, 0xC1, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x1D, 0xF0, 0xFF, 0x00, 0x00, 0x70, 0x3F, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x07, 0xF8, 0xFF, 0xCC, 0x0C, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8E, 0x38, 0x7E, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0xE0, 0xFF, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x83, 0x18, 0x71, 0xCE,
  0x0F, 0x83, 0x9C, 0x70, 0xE6, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xC6, 0x3C,
  0x7F, 0x00, 0x07, 0xC0, 0xFF, 0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x30,
  0x33, 0x03, 0x38, 0xF1, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x07,
  0x07, 0xE0, 0xF0, 0x00, 0x10, 0xE3, 0xCE, 0x00, 0x00, 0x00, 0x01, 0x0E,
  0x38, 0xE0, 0x04, 0x0E, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x38, 0x3C, 0x38, 0x18, 0x30, 0xE0, 0xC0, 0x00, 0x30, 0x0F, 0x07, 0xC1,
  0xE0, 0xF8, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x20, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x01, 0xC1, 0xF0, 0xF0, 0xF8, 0x18, 0x00, 0x1F, 0x07, 0xE0,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0x06,
  0x30, 0x33, 0x81, 0x98, 0x0D, 0x87, 0xEC, 0xE2, 0x66, 0x36, 0x61, 0xB3,
  0x0D, 0x98, 0x4C, 0xC6, 0x66, 0x33, 0x1F, 0x98, 0x38, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x40, 0x00, 0x00, 0x60, 0x07, 0x00, 0x2C, 0x03,
  0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x41, 0x86, 0x0C,
  0x7F, 0xE3, 0xFF, 0x30, 0x09, 0x80, 0x58, 0x02, 0xC0, 0x18, 0x0F, 0xC0,
  0x7F, 0x83, 0x0E, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xC6, 0x7C, 0x3F,
  0xC1, 0x83, 0x0C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x39, 0x81, 0x8C, 0xF8,
  0xFF, 0x00, 0x01, 0xF0, 0x3F, 0xC3, 0x02, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x07, 0x38, 0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x06, 0x1C, 0x30,
  0x71, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xD8, 0x0C,
  0xC0, 0x66, 0x06, 0x30, 0x71, 0x07, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC2, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x07, 0xFC, 0x3F,
  0xC1, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xF8,
  0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC2, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x04, 0x3F, 0xC1, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0xC3, 0x04, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x04, 0x60, 0x61, 0x83, 0x0F, 0x38, 0x3F, 0xC0, 0x0C, 0x0C,
  0x30, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x60, 0x61, 0x01, 0x8C, 0x06,
  0x3F, 0xF0, 0xC0, 0xC2, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81, 0x84, 0x06,
  0x30, 0x18, 0xC0, 0x60, 0x0F, 0xF0, 0xFF, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x61, 0x06, 0x1C, 0x70, 0x7F, 0x00, 0x0C, 0x0E,
  0x18, 0x38, 0x30, 0xE0, 0x43, 0x01, 0x8C, 0x03, 0x30, 0x06, 0xC0, 0x0B,
  0x00, 0x3C, 0x00, 0x6C, 0x00, 0xCC, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x30, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0xFF, 0xFF, 0xC0, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1E,
  0x28, 0x69, 0xA1, 0x25, 0x8C, 0xB6, 0x33, 0x98, 0x8C, 0x66, 0x31, 0x18,
  0x0C, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x30, 0x08, 0xC0, 0x60, 0x0C, 0x06,
  0x1C, 0x18, 0x38, 0x30, 0xF0, 0x61, 0xA0, 0xC3, 0x61, 0x04, 0xC6, 0x18,
  0x8C, 0x31, 0x18, 0x63, 0x20, 0x86, 0xC1, 0x0D, 0x86, 0x0B, 0x0C, 0x14,
  0x18, 0x38, 0x20, 0x70, 0xC0, 0xE0, 0x03, 0xC0, 0x7F, 0x87, 0x0C, 0x30,
  0x63, 0x01, 0x18, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x0D,
  0x80, 0xCC, 0x06, 0x60, 0x61, 0x87, 0x0E, 0x70, 0x3F, 0x00, 0x0F, 0x81,
  0xFE, 0x18, 0x31, 0x83, 0x10, 0x13, 0x03, 0x30, 0x33, 0x07, 0x20, 0xE7,
  0xFC, 0x7C, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0x7F, 0x87, 0x0C, 0x30, 0x63, 0x01, 0x98, 0x0D, 0x80, 0x6C,
  0x06, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x60, 0x61, 0x87,
  0x0E, 0x70, 0x3F, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x7F, 0x83, 0x0E, 0x10, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x62, 0x06,
  0x30, 0xE1, 0xFE, 0x0C, 0x60, 0x43, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x0C,
  0x0C, 0xC0, 0x60, 0x03, 0xF0, 0x7F, 0xC7, 0x04, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x1C, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0x18, 0x08, 0xC0,
  0xC4, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x03, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x61, 0x83, 0x0E, 0x70, 0x3F,
  0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C,
  0x18, 0xC3, 0x0C, 0x30, 0xC6, 0x0C, 0x40, 0xCC, 0x0D, 0x80, 0x58, 0x07,
  0x00, 0x70, 0x00, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x20, 0x19,
  0x80, 0x66, 0x01, 0x19, 0xCC, 0x67, 0x31, 0x3C, 0x84, 0xB6, 0x36, 0xD8,
  0xF1, 0x43, 0x85, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x80, 0x06, 0x03, 0x06,
  0x07, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x01, 0xB0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x1C,
  0x30, 0x38, 0x30, 0x30, 0x30, 0xE0, 0x18, 0xC0, 0x1E, 0x01, 0xB0, 0x18,
  0x80, 0xC6, 0x0C, 0x30, 0xC1, 0x8C, 0x04, 0x60, 0x36, 0x01, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xE0, 0xFC, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x3F,
  0x00, 0xCC, 0xCC, 0xCC, 0xC4, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x63,
  0x30, 0x07, 0xF0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFC, 0x00,
  0x03, 0x00, 0x60, 0x1E, 0x06, 0xC1, 0x88, 0x61, 0x8C, 0x33, 0x02, 0xC0,
  0x60, 0xFF, 0xF8, 0x47, 0x18, 0x61, 0x80, 0x01, 0xE0, 0xFF, 0x1C, 0x63,
  0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x86,
  0x7C, 0x7E, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1B, 0x81, 0xFE, 0x38, 0x63, 0x06, 0x30, 0x32, 0x03, 0x60, 0x66, 0x06,
  0x60, 0x64, 0x0C, 0xC1, 0x8C, 0xF0, 0xFE, 0x00, 0x03, 0xD0, 0xFE, 0x38,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x07, 0x98, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x1F, 0x03, 0xFC, 0x1C, 0x30, 0xE0, 0x87, 0x06, 0x18,
  0x18, 0x60, 0x63, 0x01, 0x0C, 0x0C, 0x30, 0x30, 0xE0, 0xC1, 0xCF, 0x03,
  0xEC, 0x00, 0x03, 0x83, 0xFC, 0xE1, 0xB8, 0x36, 0x07, 0x81, 0xFF, 0xF7,
  0xF8, 0xC0, 0x18, 0x03, 0x00, 0x3C, 0xC3, 0xFC, 0x00, 0x1C, 0x00, 0xFC,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x07, 0xFE, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x3C, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x3F, 0xC3, 0x86, 0x38, 0x31,
  0x83, 0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x0C, 0x38, 0x7F,
  0xC0, 0x64, 0x00, 0x60, 0x03, 0x18, 0x70, 0xFF, 0x00, 0x80, 0x00, 0x02,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x1B, 0x81, 0xFE, 0x18,
  0x63, 0x03, 0x30, 0x33, 0x03, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0xC4, 0x0C, 0xC0, 0xC0, 0x0E, 0x3C, 0x30, 0x00, 0x00, 0xBE, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x3E, 0x3C, 0x00, 0x38, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x0C, 0x70, 0x7F, 0x00, 0x04, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x07, 0x30, 0xC3, 0x38, 0x37,
  0x02, 0xC0, 0x7C, 0x06, 0xE0, 0x66, 0x04, 0x30, 0xC1, 0x8C, 0x18, 0xC0,
  0xC0, 0xFD, 0xF8, 0x20, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x0C, 0x18, 0x20, 0x40, 0xCD, 0xF8, 0x0E, 0x70, 0xFF, 0xCC, 0x66, 0x62,
  0x33, 0x31, 0x99, 0x89, 0x8C, 0xCC, 0x46, 0x64, 0x33, 0x01, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x00, 0x07, 0x83, 0xF8, 0xC1, 0x98, 0x33, 0x06, 0x60,
  0xD8, 0x1B, 0x03, 0x60, 0x4C, 0x1B, 0x03, 0x60, 0x6C, 0x1C, 0x03, 0x80,
  0xFE, 0x38, 0x63, 0x02, 0x60, 0x36, 0x03, 0x60, 0x6C, 0x06, 0xC0, 0x6C,
  0x0C, 0xE1, 0xC7, 0x78, 0x3F, 0x00, 0x03, 0xC0, 0xFF, 0x06, 0x0C, 0x30,
  0x61, 0x81, 0x98, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x03, 0x18, 0x38,
  0xEF, 0x87, 0xF0, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0xFF, 0x1C, 0x33, 0x06, 0x60, 0x66, 0x06, 0x40, 0x6C, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC0, 0xC7, 0x38, 0x3F, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x07, 0xE7, 0xFC, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x03, 0xC1, 0xFC, 0x60, 0x8C, 0x01,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x03, 0x31, 0xCF, 0xF0,
  0x0C, 0x06, 0x01, 0x80, 0x61, 0xFF, 0x84, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x30, 0xFC, 0x30, 0x33, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0x77,
  0xC7, 0xEC, 0xC0, 0xF0, 0x2C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x30,
  0x6C, 0x1E, 0x07, 0x01, 0xC0, 0x60, 0x1D, 0x80, 0x66, 0x01, 0x18, 0x8C,
  0x46, 0x31, 0x3C, 0x84, 0xB6, 0x36, 0xD8, 0xD3, 0xC3, 0xC7, 0x0E, 0x18,
  0x30, 0x60, 0x18, 0x18, 0x61, 0x83, 0x18, 0x0D, 0x80, 0x78, 0x01, 0x80,
  0x1C, 0x01, 0xB0, 0x19, 0x81, 0x86, 0x18, 0x31, 0x80, 0xC0, 0x0C, 0x0C,
  0x30, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x98,
  0x06, 0x60, 0x0B, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x08, 0xE0,
  0x3E, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x78,
  0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFC, 0x00,
  0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x07,
  0xC0, 0x3F, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xF0, 0x0F, 0x80, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x03, 0xF0,
  0x00, 0x38, 0x37, 0xE2, 0xC7, 0xE4, 0x18,
};

const GFXglyph UbuntuSansMono_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 17, 13, 4, -17 },
  { 14, 7, 6, 13, 5, -18 },
  { 20, 14, 17, 13, 0, -17 },
  { 50, 12, 22, 13, 1, -19 },
  { 83, 16, 17, 13, -1, -17 },
  { 117, 11, 17, 13, 1, -17 },
  { 141, 3, 7, 13, 7, -18 },
  { 144, 10, 23, 13, 3, -19 },
  { 173, 10, 23, 13, 1, -19 },
  { 202, 10, 10, 13, 3, -17 },
  { 215, 11, 12, 13, 1, -13 },
  { 232, 6, 8, 13, 2, -4 },
  { 238, 6, 2, 13, 4, -8 },
  { 240, 3, 4, 13, 4, -4 },
  { 242, 16, 23, 13, -2, -19 },
  { 288, 12, 17, 13, 1, -17 },
  { 314, 9, 17, 13, 2, -17 },
  { 334, 12, 17, 13, 1, -17 },
  { 360, 12, 17, 13, 1, -17 },
  { 386, 12, 17, 13, 0, -17 },
  { 412, 13, 17, 13, 1, -17 },
  { 440, 12, 17, 13, 2, -17 },
  { 466, 12, 17, 13, 3, -17 },
  { 492, 12, 17, 13, 1, -17 },
  { 518, 12, 17, 13, 1, -17 },
  { 544, 6, 13, 13, 4, -13 },
  { 554, 8, 17, 13, 2, -13 },
  { 571, 12, 10, 13, 1, -12 },
  { 586, 12, 6, 13, 1, -10 },
  { 595, 11, 10, 13, 1, -12 },
  { 609, 10, 17, 13, 3, -17 },
  { 631, 13, 21, 13, 1, -17 },
  { 666, 13, 17, 13, -1, -17 },
  { 694, 13, 17, 13, 0, -17 },
  { 722, 13, 17, 13, 1, -17 },
  { 750, 13, 17, 13, 0, -17 },
  { 778, 13, 17, 13, 1, -17 },
  { 806, 13, 17, 13, 1, -17 },
  { 834, 13, 17, 13, 1, -17 },
  { 862, 14, 17, 13, 0, -17 },
  { 892, 12, 17, 13, 1, -17 },
  { 918, 13, 17, 13, 1, -17 },
  { 946, 15, 17, 13, 0, -17 },
  { 978, 10, 17, 13, 0, -17 },
  { 1000, 14, 17, 13, 0, -17 },
  { 1030, 15, 17, 13, 0, -17 },
  { 1062, 13, 17, 13, 1, -17 },
  { 1090, 12, 17, 13, 1, -17 },
  { 1116, 13, 21, 13, 1, -17 },
  { 1151, 13, 17, 13, 0, -17 },
  { 1179, 13, 17, 13, 1, -17 },
  { 1207, 12, 17, 13, 3, -17 },
  { 1233, 13, 17, 13, 1, -17 },
  { 1261, 12, 17, 13, 3, -17 },
  { 1287, 14, 17, 13, 1, -17 },
  { 1317, 16, 17, 13, -1, -17 },
  { 1351, 13, 17, 13, 3, -17 },
  { 1379, 14, 17, 13, 0, -17 },
  { 1409, 11, 23, 13, 2, -19 },
  { 1441, 4, 23, 13, 5, -19 },
  { 1453, 12, 23, 13, 0, -19 },
  { 1488, 11, 9, 13, 2, -17 },
  { 1501, 13, 1, 13, -2, 3 },
  { 1503, 5, 5, 13, 6, -19 },
  { 1507, 12, 13, 13, 1, -13 },
  { 1527, 12, 19, 13, 1, -19 },
  { 1556, 12, 13, 13, 1, -13 },
  { 1576, 14, 19, 13, 1, -19 },
  { 1610, 11, 13, 13, 1, -13 },
  { 1628, 15, 24, 13, 0, -19 },
  { 1673, 13, 18, 13, 0, -13 },
  { 1703, 12, 19, 13, 0, -19 },
  { 1732, 7, 18, 13, 3, -18 },
  { 1748, 13, 22, 13, 0, -18 },
  { 1784, 12, 19, 13, 1, -19 },
  { 1813, 7, 19, 13, 4, -19 },
  { 1830, 13, 13, 13, 0, -13 },
  { 1852, 11, 13, 13, 1, -13 },
  { 1870, 12, 13, 13, 1, -13 },
  { 1890, 13, 17, 13, 0, -13 },
  { 1918, 12, 17, 13, 1, -13 },
  { 1944, 11, 13, 13, 2, -13 },
  { 1962, 11, 13, 13, 1, -13 },
  { 1980, 10, 16, 13, 3, -16 },
  { 2000, 12, 12, 13, 1, -12 },
  { 2018, 10, 12, 13, 3, -12 },
  { 2033, 14, 12, 13, 1, -12 },
  { 2054, 13, 12, 13, 0, -12 },
  { 2074, 14, 17, 13, -1, -12 },
  { 2104, 12, 12, 13, 1, -12 },
  { 2122, 13, 23, 13, 1, -19 },
  { 2160, 8, 23, 13, 3, -19 },
  { 2183, 13, 23, 13, -1, -19 },
  { 2221, 12, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Italic24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_ITALIC24PT7B_H_
