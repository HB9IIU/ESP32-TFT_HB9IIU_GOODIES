#ifndef _UBUNTUSANSMONO_ITALIC48PT7B_H_
#define _UBUNTUSANSMONO_ITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x1C, 0x1C, 0xF0,
  0x73, 0x83, 0xCE, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0x1C, 0x1C, 0x70,
  0x71, 0x81, 0xC6, 0x06, 0x30, 0x18, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1E, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x03, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8,
  0x01, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0x7F, 0x3F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0xF7, 0x80, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x01, 0xC3,
  0x80, 0x78, 0x03, 0x83, 0x80, 0x70, 0x03, 0x83, 0x80, 0xE0, 0x03, 0x83,
  0x81, 0xE0, 0x03, 0x83, 0x83, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x07, 0x03,
  0x8F, 0x00, 0x07, 0x87, 0x8E, 0x00, 0x07, 0x87, 0x1C, 0x00, 0x03, 0x8F,
  0x38, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x07,
  0x1F, 0xC0, 0x00, 0x0E, 0x3F, 0xE0, 0x00, 0x1E, 0x70, 0xE0, 0x00, 0x3C,
  0xF0, 0xE0, 0x00, 0x78, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0xE0, 0x00, 0xE1,
  0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x07, 0x81,
  0xC1, 0xE0, 0x0F, 0x01, 0xC1, 0xC0, 0x1E, 0x01, 0xC1, 0xC0, 0x3C, 0x01,
  0xE3, 0x80, 0x38, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xC3, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x0E, 0x0F,
  0x00, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x3E, 0xF0, 0x70, 0xF9, 0xE1, 0xE1,
  0xE1, 0xE3, 0x87, 0x81, 0xE7, 0x1E, 0x03, 0xDE, 0x3C, 0x03, 0xF8, 0x78,
  0x07, 0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x80,
  0x7E, 0x0F, 0x01, 0xFE, 0x1F, 0x07, 0xFC, 0x3F, 0xFF, 0x78, 0x3F, 0xF8,
  0x78, 0x3F, 0xC0, 0xF0, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x70,
  0xE1, 0xC3, 0x8E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x06, 0x0E, 0x06, 0xF8, 0xE1, 0xEF, 0xE6, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xBC, 0x00, 0x79, 0xE0, 0x0F,
  0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x70, 0x04, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x7C, 0x7F, 0x0F, 0xC1,
  0xE0, 0x20, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0,
  0x3F, 0x03, 0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xC0,
  0x01, 0xE7, 0x87, 0x03, 0xDE, 0x1F, 0x07, 0xBC, 0x7F, 0x1E, 0x78, 0xFE,
  0x3C, 0xF1, 0xFC, 0x7B, 0xC3, 0xF0, 0xF7, 0x83, 0xC3, 0xEF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1F,
  0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x81, 0xFE, 0xF0, 0x1F, 0x1E,
  0x03, 0x83, 0x80, 0x40, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xC0, 0x1F, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x40, 0x03, 0xF0,
  0x60, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x9C,
  0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xE0,
  0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x0F, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7A, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x81, 0xF8, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x83, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xF1, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF3, 0xF8, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0x7F,
  0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFB, 0xC0, 0x07, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x06, 0x00, 0x00,
  0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x06, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0xFC, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x7C, 0x01, 0xFF, 0x1E, 0x03, 0xFF, 0x8F, 0x83, 0xFF, 0xE3, 0xC1,
  0xF8, 0x78, 0xF0, 0xF8, 0x1E, 0x78, 0x3C, 0x07, 0x1E, 0x1E, 0x03, 0xC7,
  0x87, 0x80, 0xF1, 0xE3, 0xC0, 0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x3C, 0x07,
  0x8F, 0x0F, 0x01, 0xE3, 0xC3, 0xC0, 0x78, 0xF0, 0xF0, 0x1E, 0x3C, 0x3C,
  0x07, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x7F, 0xFC, 0x3C,
  0x0F, 0xFE, 0x0F, 0x00, 0xFF, 0x81, 0xE0, 0x04, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xF0, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01,
  0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0xC0, 0x78, 0x01, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07,
  0xC0, 0x78, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0xF8, 0x0E, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x3F, 0x07, 0x80, 0x3F, 0x81, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x7E, 0x01, 0xF8, 0x03, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x03, 0xE0, 0x0C, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x83, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x07, 0x01, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x03, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x20, 0x03, 0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x1C,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x3E, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x37, 0x01,
  0xF8, 0x03, 0xB8, 0x1D, 0xC0, 0x1D, 0xC0, 0xEE, 0x00, 0xEE, 0x0E, 0x70,
  0x0E, 0x70, 0x77, 0x00, 0x73, 0x87, 0x38, 0x03, 0x9C, 0x71, 0xC0, 0x38,
  0xE3, 0x8E, 0x01, 0xC7, 0x38, 0x70, 0x0E, 0x19, 0xC7, 0x80, 0xF0, 0xFC,
  0x3C, 0x07, 0x07, 0xE1, 0xC0, 0x38, 0x3E, 0x0E, 0x03, 0xC1, 0xE0, 0x70,
  0x1E, 0x0F, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x1C, 0x03, 0xF0, 0x00, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0xEE, 0x00,
  0x78, 0x07, 0x70, 0x03, 0x80, 0x3B, 0xC0, 0x1C, 0x03, 0xDE, 0x01, 0xE0,
  0x1C, 0x70, 0x0F, 0x00, 0xE3, 0xC0, 0x70, 0x07, 0x1E, 0x03, 0x80, 0x78,
  0x70, 0x3C, 0x03, 0x83, 0x81, 0xE0, 0x1C, 0x1E, 0x0E, 0x00, 0xE0, 0xF0,
  0x70, 0x0F, 0x03, 0x83, 0x80, 0x78, 0x1C, 0x3C, 0x03, 0x80, 0xE1, 0xE0,
  0x1C, 0x07, 0x8E, 0x01, 0xE0, 0x1C, 0x70, 0x0F, 0x00, 0xE7, 0x80, 0x70,
  0x07, 0x3C, 0x03, 0x80, 0x39, 0xC0, 0x3C, 0x01, 0xEE, 0x01, 0xE0, 0x07,
  0xF0, 0x0E, 0x00, 0x3F, 0x80, 0x70, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0xC0,
  0x3C, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x1C, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F,
  0x00, 0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1C, 0x01, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x83, 0xC0,
  0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78,
  0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x07,
  0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x7E, 0x00, 0xF8, 0x00, 0x80, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x08, 0x00, 0x3E, 0x07, 0x80, 0x3F, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x38, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x07, 0x81, 0xC0,
  0x70, 0x7C, 0x1E, 0x03, 0x83, 0xE0, 0xE0, 0x1C, 0x3B, 0x07, 0x00, 0xE1,
  0xD8, 0x38, 0x0F, 0x1C, 0xC3, 0x80, 0x71, 0xE7, 0x1C, 0x03, 0x8E, 0x38,
  0xE0, 0x1C, 0xE1, 0xCE, 0x00, 0xE7, 0x0E, 0x70, 0x07, 0x70, 0x73, 0x80,
  0x73, 0x83, 0x98, 0x03, 0xB8, 0x1D, 0xC0, 0x1F, 0xC0, 0xEE, 0x00, 0xFC,
  0x07, 0x60, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x04, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xBC, 0x00, 0x7C,
  0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x03,
  0xE0, 0x3C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x3D, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0x30, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x10, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0x01, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xC0, 0xF0, 0x7C, 0x01, 0xC1, 0xF0, 0x03, 0x87, 0xC0, 0x0F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0xC0,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x0F,
  0x0F, 0x80, 0x3E, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0x70,
  0x0F, 0xF8, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7B, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xC0, 0x01, 0xE3, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x7C, 0x38,
  0x01, 0xF0, 0x70, 0x07, 0xC1, 0xE0, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0x00, 0x20, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x0C, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x70,
  0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x03, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xF7, 0x80, 0x1F, 0xF8, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0x01, 0xE0,
  0xF8, 0x01, 0xE3, 0xE0, 0x03, 0xCF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE7, 0x80, 0x7F, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x02,
  0x0F, 0xC0, 0x1C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x1F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xF8, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF3, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x3E, 0x00, 0x7C,
  0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x3E, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x70, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x20, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0xF0, 0x1E, 0x01, 0xF0, 0x0E, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x83,
  0xF0, 0x03, 0xC3, 0xE0, 0x01, 0xC3, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xF7,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0xC0,
  0x78, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x0E, 0x00, 0x0F,
  0x00, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x23, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0x04, 0x00, 0x03, 0xFE, 0x7F, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1E, 0x1F, 0x1F, 0x07, 0x07, 0x83,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0E, 0x07,
  0x03, 0x83, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C,
  0x0E, 0x07, 0x07, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x00, 0x3C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xE0, 0x3F, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x38, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83,
  0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0,
  0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF0, 0x07,
  0xC3, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xE0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x07,
  0x80, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xF8, 0x1E, 0x07, 0xE0, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x07, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xE3, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xF8, 0x06, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x40, 0x03, 0xC1, 0x80, 0x1F,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x04, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x03, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFC, 0xE0, 0x1F, 0xF1, 0xE0, 0x04, 0x00, 0x00,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00,
  0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x03, 0xC0, 0x78,
  0x3C, 0x07, 0x87, 0x80, 0x78, 0x70, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x03,
  0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x39, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xF1, 0xC0, 0xF0, 0x38, 0xF0, 0x3C, 0x1E, 0x3C, 0x1F, 0x07, 0x8F,
  0x07, 0xC1, 0xC3, 0xC3, 0xF0, 0xF0, 0xF0, 0xFC, 0x38, 0x3C, 0x77, 0x0E,
  0x0F, 0x39, 0xC7, 0x83, 0x8E, 0x79, 0xC0, 0xE7, 0x0E, 0xF0, 0x39, 0xC3,
  0xB8, 0x0E, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E,
  0x03, 0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x1F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x83,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x08,
  0x0F, 0xF0, 0x0F, 0x1F, 0xF8, 0x0E, 0x3E, 0xFC, 0x1E, 0x78, 0x3F, 0xFC,
  0x70, 0x1F, 0xF8, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x80,
};

const GFXglyph UbuntuSansMono_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 13, 34, 27, 7, -33 },
  { 57, 14, 12, 27, 10, -36 },
  { 78, 29, 33, 27, 0, -33 },
  { 198, 25, 42, 27, 2, -37 },
  { 330, 32, 35, 27, -2, -34 },
  { 470, 23, 34, 27, 1, -34 },
  { 568, 7, 13, 27, 14, -36 },
  { 580, 20, 47, 27, 6, -38 },
  { 698, 20, 47, 27, 1, -38 },
  { 816, 20, 19, 27, 6, -33 },
  { 864, 22, 24, 27, 3, -26 },
  { 930, 11, 15, 27, 4, -7 },
  { 951, 12, 3, 27, 8, -15 },
  { 956, 7, 8, 27, 8, -7 },
  { 963, 30, 47, 27, -3, -38 },
  { 1140, 23, 35, 27, 3, -34 },
  { 1241, 19, 33, 27, 3, -33 },
  { 1320, 24, 34, 27, 2, -34 },
  { 1422, 24, 35, 27, 2, -34 },
  { 1527, 24, 33, 27, 1, -33 },
  { 1626, 27, 34, 27, 1, -33 },
  { 1741, 24, 34, 27, 3, -33 },
  { 1843, 24, 33, 27, 6, -33 },
  { 1942, 25, 35, 27, 2, -34 },
  { 2052, 25, 34, 27, 2, -34 },
  { 2159, 11, 26, 27, 8, -25 },
  { 2195, 15, 33, 27, 4, -25 },
  { 2257, 24, 21, 27, 2, -24 },
  { 2320, 24, 14, 27, 2, -21 },
  { 2362, 24, 21, 27, 1, -24 },
  { 2425, 19, 35, 27, 7, -34 },
  { 2509, 26, 41, 27, 2, -34 },
  { 2643, 26, 33, 27, -3, -33 },
  { 2751, 26, 34, 27, 0, -34 },
  { 2862, 26, 35, 27, 3, -34 },
  { 2976, 26, 34, 27, 0, -34 },
  { 3087, 26, 33, 27, 2, -33 },
  { 3195, 27, 33, 27, 2, -33 },
  { 3307, 26, 35, 27, 2, -34 },
  { 3421, 29, 33, 27, 0, -33 },
  { 3541, 25, 33, 27, 2, -33 },
  { 3645, 26, 34, 27, 2, -33 },
  { 3756, 28, 33, 27, 1, -33 },
  { 3872, 19, 33, 27, 1, -33 },
  { 3951, 29, 33, 27, -1, -33 },
  { 4071, 29, 33, 27, 0, -33 },
  { 4191, 24, 35, 27, 3, -34 },
  { 4296, 26, 34, 27, 1, -34 },
  { 4407, 25, 43, 27, 2, -34 },
  { 4542, 25, 34, 27, 1, -34 },
  { 4649, 26, 35, 27, 1, -34 },
  { 4763, 22, 33, 27, 7, -33 },
  { 4854, 26, 34, 27, 3, -33 },
  { 4965, 26, 33, 27, 5, -33 },
  { 5073, 29, 33, 27, 1, -33 },
  { 5193, 32, 33, 27, -1, -33 },
  { 5325, 26, 33, 27, 6, -33 },
  { 5433, 29, 33, 27, 0, -33 },
  { 5553, 24, 47, 27, 3, -38 },
  { 5694, 7, 47, 27, 10, -38 },
  { 5736, 24, 47, 27, -1, -38 },
  { 5877, 21, 17, 27, 4, -33 },
  { 5922, 24, 3, 27, -3, 6 },
  { 5931, 9, 10, 27, 12, -37 },
  { 5943, 23, 26, 27, 2, -25 },
  { 6018, 23, 37, 27, 2, -37 },
  { 6125, 23, 26, 27, 2, -25 },
  { 6200, 26, 38, 27, 3, -37 },
  { 6324, 23, 26, 27, 2, -25 },
  { 6399, 31, 46, 27, -1, -37 },
  { 6578, 28, 34, 27, -1, -25 },
  { 6697, 23, 37, 27, 0, -37 },
  { 6804, 14, 37, 27, 6, -37 },
  { 6869, 25, 46, 27, 0, -37 },
  { 7013, 25, 37, 27, 2, -37 },
  { 7129, 14, 38, 27, 8, -37 },
  { 7196, 26, 25, 27, 0, -25 },
  { 7278, 22, 25, 27, 2, -25 },
  { 7347, 22, 26, 27, 3, -25 },
  { 7419, 26, 34, 27, -1, -25 },
  { 7530, 24, 34, 27, 2, -25 },
  { 7632, 23, 25, 27, 3, -25 },
  { 7704, 22, 26, 27, 3, -25 },
  { 7776, 19, 34, 27, 6, -33 },
  { 7857, 23, 26, 27, 3, -25 },
  { 7932, 20, 25, 27, 6, -25 },
  { 7995, 26, 25, 27, 3, -25 },
  { 8077, 28, 25, 27, -1, -25 },
  { 8165, 30, 34, 27, -3, -25 },
  { 8293, 24, 25, 27, 1, -25 },
  { 8368, 26, 47, 27, 3, -38 },
  { 8521, 14, 47, 27, 7, -38 },
  { 8604, 26, 47, 27, -2, -38 },
  { 8757, 24, 8, 27, 2, -18 },
};

const GFXfont UbuntuSansMono_Italic48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_ITALIC48PT7B_H_
