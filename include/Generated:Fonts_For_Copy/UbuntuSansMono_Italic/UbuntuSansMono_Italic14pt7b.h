#ifndef _UBUNTUSANSMONO_ITALIC14PT7B_H_
#define _UBUNTUSANSMONO_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x24, 0x40, 0xCC, 0x59, 0x9A, 0x09, 0x09, 0x12, 0x7F,
  0x34, 0x24, 0xFE, 0x48, 0x48, 0x90, 0x08, 0x10, 0xFB, 0x04, 0x04, 0x06,
  0x02, 0x05, 0x11, 0xC1, 0x04, 0x00, 0x30, 0xA4, 0x92, 0x8A, 0x87, 0x80,
  0xB0, 0x68, 0x54, 0x4A, 0x47, 0x00, 0x1C, 0x64, 0x91, 0x21, 0x86, 0x53,
  0x66, 0xCC, 0xE8, 0x56, 0x0C, 0x63, 0x18, 0x42, 0x08, 0x20, 0x82, 0x08,
  0x30, 0x61, 0x00, 0x18, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x08, 0x21, 0x08,
  0x42, 0x00, 0x20, 0x8F, 0xC8, 0x53, 0x60, 0x10, 0x41, 0x3F, 0x20, 0x82,
  0x00, 0x6C, 0xE0, 0xF0, 0xF0, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x00, 0x1C, 0x49, 0x1A,
  0x3B, 0x56, 0xA1, 0x44, 0x89, 0xE0, 0x04, 0x66, 0x82, 0x18, 0x41, 0x04,
  0x33, 0xE0, 0x3C, 0xC8, 0x18, 0x20, 0xC3, 0x08, 0x20, 0x81, 0xF0, 0x1E,
  0x24, 0x08, 0x11, 0xC0, 0x80, 0x81, 0x05, 0xF8, 0x02, 0x0C, 0x28, 0xA2,
  0x48, 0x91, 0x5F, 0x08, 0x10, 0x0F, 0x10, 0x10, 0x10, 0x38, 0x04, 0x02,
  0x02, 0x04, 0xF8, 0x06, 0x30, 0x82, 0x07, 0x90, 0xA1, 0x42, 0x8C, 0xF0,
  0x7E, 0x08, 0x20, 0x83, 0x04, 0x10, 0x20, 0x81, 0x00, 0x1C, 0x4D, 0x0A,
  0x36, 0xCF, 0x21, 0x42, 0x8D, 0xF0, 0x1C, 0xCD, 0x0A, 0x14, 0x6F, 0x81,
  0x04, 0x11, 0xC0, 0x36, 0x00, 0x0C, 0xC0, 0x19, 0x80, 0x00, 0x31, 0x84,
  0xC0, 0x04, 0x6E, 0x30, 0x30, 0x20, 0x7F, 0x00, 0x00, 0xFE, 0x60, 0x30,
  0x18, 0x73, 0x18, 0x00, 0x78, 0x42, 0x11, 0x11, 0x00, 0xC6, 0x00, 0x1C,
  0x45, 0x0E, 0x79, 0x34, 0xE9, 0x52, 0xBD, 0x03, 0x03, 0x80, 0x06, 0x06,
  0x0A, 0x0A, 0x12, 0x13, 0x3F, 0x41, 0x41, 0xC1, 0x3C, 0x22, 0x23, 0x22,
  0x7C, 0x46, 0x42, 0x42, 0xC4, 0xF8, 0x1E, 0x45, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x80, 0xF0, 0x3C, 0x26, 0x22, 0x63, 0x43, 0x42, 0x42, 0x46, 0x8C,
  0xF8, 0x3E, 0x41, 0x82, 0x07, 0xC8, 0x30, 0x40, 0x81, 0xF8, 0x3E, 0x41,
  0x02, 0x07, 0xC8, 0x30, 0x40, 0x81, 0x00, 0x1E, 0x45, 0x04, 0x08, 0x10,
  0xA1, 0x42, 0x88, 0xF0, 0x21, 0x21, 0x21, 0x21, 0x7E, 0x42, 0x42, 0x42,
  0x84, 0x84, 0x3E, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x21, 0xF0, 0x1E,
  0x44, 0x18, 0x20, 0x40, 0x81, 0x04, 0x89, 0xE0, 0x31, 0x91, 0x09, 0x05,
  0x07, 0x02, 0x81, 0x20, 0x90, 0x44, 0x43, 0x00, 0x10, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x43, 0xF0, 0x11, 0x33, 0x33, 0x35, 0x55, 0x5A, 0x42, 0xC2,
  0x82, 0x86, 0x31, 0x31, 0x31, 0x29, 0x4A, 0x4A, 0x4A, 0x4A, 0x84, 0x84,
  0x1C, 0x4D, 0x0E, 0x18, 0x30, 0x61, 0x42, 0x89, 0xE0, 0x1E, 0x23, 0x21,
  0x21, 0x22, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x1C, 0x4D, 0x0E, 0x18, 0x30,
  0x61, 0x42, 0x89, 0xE1, 0x81, 0x80, 0x80, 0x3C, 0x22, 0x21, 0x23, 0x62,
  0x7C, 0x48, 0x44, 0x44, 0x84, 0x0F, 0x11, 0x20, 0x20, 0x18, 0x0C, 0x06,
  0x02, 0x04, 0xFC, 0xFE, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x41, 0x80,
  0x42, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x42, 0x89, 0xF0, 0x83, 0x0A, 0x14,
  0x48, 0x92, 0x24, 0x50, 0xE1, 0x80, 0x20, 0x90, 0x88, 0x48, 0x24, 0x92,
  0xD1, 0xA8, 0xD4, 0x4C, 0x62, 0x00, 0x31, 0x88, 0x84, 0x83, 0x80, 0xC0,
  0xC0, 0x50, 0x48, 0x44, 0x41, 0x00, 0x83, 0x0A, 0x36, 0x45, 0x0C, 0x18,
  0x20, 0x40, 0x80, 0x3F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40,
  0xFC, 0x1E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x1E, 0x00, 0xAA, 0xAF, 0x55, 0x50, 0x1E, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x1C, 0x00, 0x08, 0x62, 0x59, 0xC4, 0xFE,
  0xA4, 0x3D, 0x18, 0x63, 0x8A, 0x2F, 0x80, 0x20, 0x86, 0x10, 0x7D, 0x14,
  0x61, 0x86, 0x2F, 0x00, 0x3E, 0xC1, 0x02, 0x0C, 0x08, 0x1F, 0x00, 0x03,
  0x02, 0x02, 0x02, 0x3C, 0x44, 0x84, 0x84, 0x88, 0x88, 0xFC, 0x7F, 0x18,
  0x7E, 0x82, 0x0F, 0x80, 0x03, 0x82, 0x02, 0x01, 0x03, 0xF0, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x0A, 0x06, 0x00, 0x1F, 0x22, 0x42, 0x42,
  0x42, 0x44, 0x3C, 0x04, 0x98, 0x60, 0x10, 0x40, 0x81, 0x03, 0xCC, 0x50,
  0xA3, 0x45, 0x8A, 0x10, 0x23, 0x00, 0xE2, 0x44, 0x44, 0x70, 0x02, 0x0C,
  0x00, 0x01, 0xE0, 0x81, 0x02, 0x04, 0x18, 0x20, 0x49, 0x0C, 0x00, 0x10,
  0x10, 0x30, 0x21, 0x22, 0x2C, 0x30, 0x50, 0x48, 0x4C, 0xC4, 0xF3, 0x22,
  0x26, 0x44, 0x44, 0x70, 0x3F, 0x4A, 0x4A, 0x52, 0x42, 0x86, 0x84, 0x3E,
  0x44, 0x8A, 0x14, 0x28, 0xB1, 0x00, 0x7D, 0x18, 0x61, 0x86, 0x2F, 0x00,
  0x3E, 0x45, 0x8A, 0x14, 0x28, 0x9E, 0x40, 0x81, 0x00, 0x3E, 0x8A, 0x14,
  0x28, 0x91, 0x3E, 0x04, 0x10, 0x20, 0x7E, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x00, 0x3D, 0x06, 0x06, 0x08, 0x2F, 0x80, 0x11, 0x09, 0xF4, 0x21, 0x10,
  0x83, 0x80, 0x47, 0x18, 0x63, 0x8A, 0x2F, 0x80, 0x8E, 0x29, 0xA4, 0xA2,
  0x8C, 0x00, 0x83, 0x06, 0x55, 0xAD, 0x5B, 0x22, 0x00, 0x23, 0x14, 0x18,
  0x18, 0x38, 0x64, 0xC4, 0x11, 0x88, 0x84, 0x42, 0x41, 0x20, 0x60, 0x30,
  0x10, 0x90, 0x30, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x00, 0x0E,
  0x20, 0x40, 0x82, 0x04, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x06, 0x00,
  0x11, 0x12, 0x22, 0x24, 0x44, 0x48, 0x88, 0x1E, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x03, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0xE0, 0xE6, 0x70,
};

const GFXglyph UbuntuSansMono_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 4, 4, 8, 3, -11 },
  { 8, 8, 10, 8, 0, -10 },
  { 18, 7, 13, 8, 1, -11 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 7, 10, 8, 0, -10 },
  { 51, 2, 4, 8, 4, -11 },
  { 52, 6, 14, 8, 2, -11 },
  { 63, 6, 14, 8, 0, -11 },
  { 74, 6, 6, 8, 2, -10 },
  { 79, 6, 7, 8, 1, -8 },
  { 85, 3, 4, 8, 1, -2 },
  { 87, 4, 1, 8, 2, -4 },
  { 88, 2, 2, 8, 2, -2 },
  { 89, 9, 14, 8, -1, -11 },
  { 105, 7, 10, 8, 1, -10 },
  { 114, 6, 10, 8, 1, -10 },
  { 122, 7, 10, 8, 1, -10 },
  { 131, 7, 10, 8, 0, -10 },
  { 140, 7, 10, 8, 0, -10 },
  { 149, 8, 10, 8, 0, -10 },
  { 159, 7, 10, 8, 1, -10 },
  { 168, 7, 10, 8, 2, -10 },
  { 177, 7, 10, 8, 1, -10 },
  { 186, 7, 10, 8, 1, -10 },
  { 195, 4, 7, 8, 2, -7 },
  { 199, 5, 9, 8, 1, -7 },
  { 205, 6, 6, 8, 1, -7 },
  { 210, 8, 4, 8, 0, -6 },
  { 214, 7, 6, 8, 0, -7 },
  { 220, 5, 10, 8, 2, -10 },
  { 227, 7, 12, 8, 1, -10 },
  { 238, 8, 10, 8, -1, -10 },
  { 248, 8, 10, 8, 0, -10 },
  { 258, 7, 10, 8, 1, -10 },
  { 267, 8, 10, 8, 0, -10 },
  { 277, 7, 10, 8, 1, -10 },
  { 286, 7, 10, 8, 1, -10 },
  { 295, 7, 10, 8, 1, -10 },
  { 304, 8, 10, 8, 0, -10 },
  { 314, 7, 10, 8, 1, -10 },
  { 323, 7, 10, 8, 1, -10 },
  { 332, 9, 10, 8, 0, -10 },
  { 344, 6, 10, 8, 0, -10 },
  { 352, 8, 10, 8, 0, -10 },
  { 362, 8, 10, 8, 0, -10 },
  { 372, 7, 10, 8, 1, -10 },
  { 381, 8, 10, 8, 0, -10 },
  { 391, 7, 13, 8, 1, -10 },
  { 403, 8, 10, 8, 0, -10 },
  { 413, 8, 10, 8, 0, -10 },
  { 423, 7, 10, 8, 2, -10 },
  { 432, 7, 10, 8, 1, -10 },
  { 441, 7, 10, 8, 2, -10 },
  { 450, 9, 10, 8, 0, -10 },
  { 462, 9, 10, 8, 0, -10 },
  { 474, 7, 10, 8, 2, -10 },
  { 483, 8, 10, 8, 0, -10 },
  { 493, 7, 14, 8, 1, -11 },
  { 506, 2, 14, 8, 3, -11 },
  { 510, 7, 14, 8, 0, -11 },
  { 523, 6, 5, 8, 1, -10 },
  { 527, 7, 1, 8, -1, 2 },
  { 528, 2, 3, 8, 4, -11 },
  { 529, 6, 7, 8, 1, -7 },
  { 535, 6, 11, 8, 1, -11 },
  { 544, 7, 7, 8, 0, -7 },
  { 551, 8, 11, 8, 1, -11 },
  { 562, 6, 7, 8, 1, -7 },
  { 568, 9, 14, 8, 0, -11 },
  { 584, 8, 10, 8, 0, -7 },
  { 594, 7, 11, 8, 0, -11 },
  { 604, 4, 11, 8, 2, -11 },
  { 610, 7, 14, 8, 0, -11 },
  { 623, 8, 11, 8, 0, -11 },
  { 634, 4, 11, 8, 2, -11 },
  { 640, 8, 7, 8, 0, -7 },
  { 647, 7, 7, 8, 0, -7 },
  { 654, 6, 7, 8, 1, -7 },
  { 660, 7, 10, 8, 0, -7 },
  { 669, 7, 10, 8, 1, -7 },
  { 678, 7, 7, 8, 1, -7 },
  { 685, 6, 7, 8, 1, -7 },
  { 691, 5, 10, 8, 2, -10 },
  { 698, 6, 7, 8, 1, -7 },
  { 704, 6, 7, 8, 2, -7 },
  { 710, 7, 7, 8, 1, -7 },
  { 717, 8, 7, 8, 0, -7 },
  { 724, 9, 10, 8, -1, -7 },
  { 736, 7, 7, 8, 0, -7 },
  { 743, 7, 14, 8, 1, -11 },
  { 756, 4, 14, 8, 2, -11 },
  { 763, 8, 14, 8, -1, -11 },
  { 777, 6, 2, 8, 1, -5 },
};

const GFXfont UbuntuSansMono_Italic14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_ITALIC14PT7B_H_
