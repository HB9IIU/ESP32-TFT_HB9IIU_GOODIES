#ifndef _UBUNTUSANSMONO_ITALIC67PT7B_H_
#define _UBUNTUSANSMONO_ITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x03, 0xE1,
  0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78,
  0x3C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x70, 0x70, 0x07,
  0x07, 0x00, 0xF0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00,
  0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xC1, 0xF0,
  0x00, 0x01, 0xE0, 0x7C, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x87, 0xC0, 0x00,
  0x01, 0xF0, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0x00, 0x00, 0x00,
  0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0x8F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0xF8,
  0x00, 0x00, 0x1F, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x78, 0x00,
  0x00, 0x7C, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x78, 0x00, 0x01,
  0xF0, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E,
  0x00, 0x07, 0xEF, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0xFE, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0xC0, 0x3E, 0x07, 0xFF,
  0x80, 0x7C, 0x1F, 0xDF, 0x80, 0xF0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x3F,
  0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x0F, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0x7E,
  0x78, 0x7E, 0x00, 0x7D, 0xF0, 0xF8, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0xFF,
  0x87, 0xE0, 0x01, 0xFF, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xC1,
  0xF8, 0x00, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0x83, 0xFC, 0x3F, 0xDF, 0x87,
  0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x7C, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF8, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0xF0,
  0x0E, 0x7C, 0x0F, 0x03, 0xE7, 0xF8, 0xF0, 0xFE, 0xFF, 0xEF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x40, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x1E, 0x1F, 0xEF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0xC3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x3F, 0x3F, 0x03, 0xC0, 0x3F, 0x3F, 0x07, 0xF0, 0x3F, 0x3E, 0x0F, 0xF0,
  0x3F, 0x3E, 0x0F, 0xF8, 0x3E, 0x7E, 0x0F, 0xF8, 0x3E, 0x7E, 0x0F, 0xF8,
  0x7E, 0x7C, 0x0F, 0xF8, 0x7E, 0x7C, 0x0F, 0xF0, 0x7E, 0xFC, 0x07, 0xE0,
  0x7C, 0xFC, 0x01, 0x80, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xDF, 0x00, 0x7F, 0xE7, 0xC0, 0x1F, 0xE3,
  0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xC0, 0x3E, 0x00, 0x40, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xCF,
  0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x00,
  0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x0F,
  0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF9, 0xF8, 0x00, 0x00, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xE0, 0x0F, 0xE0, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x3F,
  0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0x80, 0xFF, 0x8F, 0xE3, 0xF0,
  0x1F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0x07, 0xC3, 0xE0, 0x7E, 0x00, 0x7C,
  0x7E, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0xF8, 0x00, 0xF8, 0xFC, 0x1F, 0x80, 0x1F, 0x8F, 0xC1,
  0xF8, 0x01, 0xF8, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0x81,
  0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xFE, 0x07, 0xC0,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x04, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x07, 0xF8,
  0x00, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x3F,
  0x80, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x03, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07,
  0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xFE,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00,
  0x01, 0xF1, 0xFC, 0x00, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x07,
  0xBC, 0x00, 0x3C, 0xF8, 0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x1F, 0x3C, 0x00,
  0x3C, 0xF8, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x3C, 0x7C, 0x00, 0x78, 0x78,
  0x3C, 0x7C, 0x00, 0x78, 0x78, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0xF0, 0x79, 0xF0, 0xF8, 0x01, 0xF0,
  0x79, 0xE0, 0xF8, 0x01, 0xF0, 0x7B, 0xC0, 0xF8, 0x01, 0xE0, 0x7B, 0xC0,
  0xF0, 0x03, 0xE0, 0x7F, 0x80, 0xF0, 0x03, 0xE0, 0x7F, 0x81, 0xF0, 0x03,
  0xE0, 0x7F, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0x00,
  0x7B, 0xE0, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x01, 0xF0, 0x03, 0xE7, 0x80,
  0x03, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0xC0, 0x0F, 0x1F, 0x00, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x07,
  0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0xC0,
  0x03, 0xC7, 0xC0, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x00, 0x0F, 0x9F,
  0x00, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0x00, 0x1E, 0xF8, 0x01, 0xF0,
  0x00, 0x3D, 0xF0, 0x03, 0xE0, 0x00, 0x7B, 0xE0, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x7C,
  0x00, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xC0, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x02,
  0x00, 0x00, 0x3F, 0x80, 0x30, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xFC,
  0x03, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x0F, 0x01, 0xFC, 0x07, 0xC0,
  0x0F, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0x07,
  0xFC, 0x0F, 0x80, 0x1E, 0x07, 0xBC, 0x0F, 0x80, 0x1E, 0x0F, 0x9C, 0x0F,
  0x00, 0x1E, 0x0F, 0x1C, 0x1F, 0x00, 0x1E, 0x1E, 0x1E, 0x1F, 0x00, 0x3E,
  0x3E, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x1E,
  0x3E, 0x00, 0x3C, 0x78, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x1E, 0x3C, 0x00,
  0x3C, 0xF0, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x00, 0x7B, 0xE0,
  0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x1E, 0x70, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8,
  0x3C, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x3C, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7E, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xE2, 0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x01,
  0xC0, 0x7C, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x07,
  0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0xE3, 0xE0, 0x07,
  0xFF, 0x83, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x7E, 0x7F, 0xF0, 0x00, 0x3E, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFE,
  0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFF,
  0x01, 0xF0, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x07,
  0xF8, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0x9F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F,
  0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x9F, 0x00, 0x07, 0xFF,
  0xF8, 0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x1F, 0x07, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0xC0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x07, 0xFC, 0x7E, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x60, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xFE, 0x30, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x7F, 0x80, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0x00,
  0x3E, 0x7F, 0x80, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x00,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x09, 0xF8,
  0x07, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F,
  0xC0, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x03, 0xFF, 0x87, 0xF8, 0x00, 0xFF,
  0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x87, 0xFC, 0x7F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFE, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0xC7,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x7F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0x80, 0x3F, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0x0F, 0xE0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0C, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x3F,
  0x00, 0x02, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x04, 0x03, 0xF8, 0x03, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7F, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF7, 0xC0, 0x1F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3E, 0x03, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3E, 0x07, 0xC0, 0xF7, 0x83, 0xE0, 0x3E, 0x0F, 0xBC, 0x1F,
  0x01, 0xF0, 0x79, 0xE1, 0xF0, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0x7C, 0x7C,
  0x7C, 0x78, 0x03, 0xE3, 0xC3, 0xE7, 0xC0, 0x1F, 0x3E, 0x1F, 0x3E, 0x00,
  0xF9, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x00, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0xE0,
  0x03, 0xE1, 0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xFF, 0x03, 0xE1, 0xF0, 0x3F,
  0xC3, 0xF1, 0xF0, 0x0F, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xF0, 0xF8, 0x00,
  0x7F, 0xF0, 0x18, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 18, 47, 38, 10, -46 },
  { 107, 20, 18, 38, 14, -51 },
  { 152, 40, 46, 38, 0, -46 },
  { 382, 34, 59, 38, 3, -52 },
  { 633, 44, 48, 38, -2, -47 },
  { 897, 31, 49, 38, 2, -48 },
  { 1087, 9, 19, 38, 20, -51 },
  { 1109, 28, 64, 38, 8, -52 },
  { 1333, 28, 64, 38, 2, -52 },
  { 1557, 28, 27, 38, 8, -46 },
  { 1652, 31, 33, 38, 4, -36 },
  { 1780, 16, 21, 38, 5, -10 },
  { 1822, 17, 4, 38, 11, -21 },
  { 1831, 10, 11, 38, 11, -10 },
  { 1845, 42, 64, 38, -4, -52 },
  { 2181, 32, 49, 38, 4, -48 },
  { 2377, 26, 46, 38, 5, -46 },
  { 2527, 33, 48, 38, 3, -48 },
  { 2725, 34, 49, 38, 2, -48 },
  { 2934, 34, 46, 38, 1, -46 },
  { 3130, 36, 47, 38, 2, -46 },
  { 3342, 33, 48, 38, 5, -47 },
  { 3540, 33, 46, 38, 8, -46 },
  { 3730, 35, 49, 38, 3, -48 },
  { 3945, 34, 47, 38, 3, -47 },
  { 4145, 16, 36, 38, 11, -35 },
  { 4217, 22, 46, 38, 5, -35 },
  { 4344, 33, 30, 38, 3, -34 },
  { 4468, 35, 19, 38, 2, -29 },
  { 4552, 33, 30, 38, 2, -34 },
  { 4676, 26, 49, 38, 10, -48 },
  { 4836, 36, 58, 38, 3, -48 },
  { 5097, 36, 46, 38, -4, -46 },
  { 5304, 35, 47, 38, 1, -47 },
  { 5510, 36, 49, 38, 4, -48 },
  { 5731, 36, 47, 38, 0, -47 },
  { 5943, 37, 46, 38, 3, -46 },
  { 6156, 37, 46, 38, 3, -46 },
  { 6369, 36, 49, 38, 3, -48 },
  { 6590, 40, 46, 38, 0, -46 },
  { 6820, 34, 46, 38, 3, -46 },
  { 7016, 36, 47, 38, 3, -46 },
  { 7228, 40, 46, 38, 1, -46 },
  { 7458, 27, 46, 38, 1, -46 },
  { 7614, 40, 46, 38, -1, -46 },
  { 7844, 39, 46, 38, 1, -46 },
  { 8069, 34, 49, 38, 4, -48 },
  { 8278, 35, 47, 38, 2, -47 },
  { 8484, 35, 60, 38, 3, -48 },
  { 8747, 36, 47, 38, 1, -47 },
  { 8959, 36, 49, 38, 2, -48 },
  { 9180, 32, 46, 38, 9, -46 },
  { 9364, 36, 47, 38, 4, -46 },
  { 9576, 36, 46, 38, 7, -46 },
  { 9783, 40, 46, 38, 2, -46 },
  { 10013, 45, 46, 38, -2, -46 },
  { 10272, 36, 46, 38, 8, -46 },
  { 10479, 40, 46, 38, 0, -46 },
  { 10709, 33, 64, 38, 5, -52 },
  { 10973, 10, 64, 38, 14, -52 },
  { 11053, 33, 64, 38, -1, -52 },
  { 11317, 29, 24, 38, 6, -46 },
  { 11404, 35, 4, 38, -5, 8 },
  { 11422, 12, 14, 38, 17, -52 },
  { 11443, 32, 36, 38, 3, -35 },
  { 11587, 33, 53, 38, 2, -52 },
  { 11806, 33, 37, 38, 2, -36 },
  { 11959, 37, 53, 38, 4, -52 },
  { 12205, 32, 37, 38, 2, -36 },
  { 12353, 43, 65, 38, -1, -52 },
  { 12703, 38, 48, 38, -1, -35 },
  { 12931, 31, 52, 38, 1, -52 },
  { 13133, 20, 51, 38, 8, -51 },
  { 13261, 36, 64, 38, -1, -51 },
  { 13549, 36, 52, 38, 2, -52 },
  { 13783, 19, 53, 38, 11, -52 },
  { 13909, 36, 36, 38, 0, -36 },
  { 14071, 32, 35, 38, 2, -35 },
  { 14211, 31, 37, 38, 4, -36 },
  { 14355, 36, 48, 38, -1, -36 },
  { 14571, 34, 47, 38, 3, -35 },
  { 14771, 32, 36, 38, 4, -36 },
  { 14915, 31, 37, 38, 4, -36 },
  { 15059, 27, 47, 38, 8, -46 },
  { 15218, 32, 36, 38, 4, -35 },
  { 15362, 29, 35, 38, 8, -35 },
  { 15489, 37, 35, 38, 4, -35 },
  { 15651, 39, 35, 38, -1, -35 },
  { 15822, 41, 48, 38, -4, -35 },
  { 16068, 33, 35, 38, 2, -35 },
  { 16213, 36, 64, 38, 4, -52 },
  { 16501, 21, 64, 38, 9, -52 },
  { 16669, 36, 64, 38, -3, -52 },
  { 16957, 33, 10, 38, 3, -25 },
};

const GFXfont UbuntuSansMono_Italic67pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic67pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic67pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _UBUNTUSANSMONO_ITALIC67PT7B_H_
