#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &UbuntuSansMono_Italic6pt7b, 6, "UbuntuSansMono_Italic6pt7b" },
  { &UbuntuSansMono_Italic7pt7b, 7, "UbuntuSansMono_Italic7pt7b" },
  { &UbuntuSansMono_Italic8pt7b, 8, "UbuntuSansMono_Italic8pt7b" },
  { &UbuntuSansMono_Italic9pt7b, 9, "UbuntuSansMono_Italic9pt7b" },
  { &UbuntuSansMono_Italic10pt7b, 10, "UbuntuSansMono_Italic10pt7b" },
  { &UbuntuSansMono_Italic11pt7b, 11, "UbuntuSansMono_Italic11pt7b" },
  { &UbuntuSansMono_Italic12pt7b, 12, "UbuntuSansMono_Italic12pt7b" },
  { &UbuntuSansMono_Italic13pt7b, 13, "UbuntuSansMono_Italic13pt7b" },
  { &UbuntuSansMono_Italic14pt7b, 14, "UbuntuSansMono_Italic14pt7b" },
  { &UbuntuSansMono_Italic15pt7b, 15, "UbuntuSansMono_Italic15pt7b" },
  { &UbuntuSansMono_Italic16pt7b, 16, "UbuntuSansMono_Italic16pt7b" },
  { &UbuntuSansMono_Italic17pt7b, 17, "UbuntuSansMono_Italic17pt7b" },
  { &UbuntuSansMono_Italic18pt7b, 18, "UbuntuSansMono_Italic18pt7b" },
  { &UbuntuSansMono_Italic19pt7b, 19, "UbuntuSansMono_Italic19pt7b" },
  { &UbuntuSansMono_Italic20pt7b, 20, "UbuntuSansMono_Italic20pt7b" },
  { &UbuntuSansMono_Italic21pt7b, 21, "UbuntuSansMono_Italic21pt7b" },
  { &UbuntuSansMono_Italic22pt7b, 22, "UbuntuSansMono_Italic22pt7b" },
  { &UbuntuSansMono_Italic23pt7b, 23, "UbuntuSansMono_Italic23pt7b" },
  { &UbuntuSansMono_Italic24pt7b, 24, "UbuntuSansMono_Italic24pt7b" },
  { &UbuntuSansMono_Italic25pt7b, 25, "UbuntuSansMono_Italic25pt7b" },
  { &UbuntuSansMono_Italic26pt7b, 26, "UbuntuSansMono_Italic26pt7b" },
  { &UbuntuSansMono_Italic27pt7b, 27, "UbuntuSansMono_Italic27pt7b" },
  { &UbuntuSansMono_Italic28pt7b, 28, "UbuntuSansMono_Italic28pt7b" },
  { &UbuntuSansMono_Italic29pt7b, 29, "UbuntuSansMono_Italic29pt7b" },
  { &UbuntuSansMono_Italic30pt7b, 30, "UbuntuSansMono_Italic30pt7b" },
  { &UbuntuSansMono_Italic31pt7b, 31, "UbuntuSansMono_Italic31pt7b" },
  { &UbuntuSansMono_Italic32pt7b, 32, "UbuntuSansMono_Italic32pt7b" },
  { &UbuntuSansMono_Italic33pt7b, 33, "UbuntuSansMono_Italic33pt7b" },
  { &UbuntuSansMono_Italic34pt7b, 34, "UbuntuSansMono_Italic34pt7b" },
  { &UbuntuSansMono_Italic35pt7b, 35, "UbuntuSansMono_Italic35pt7b" },
  { &UbuntuSansMono_Italic36pt7b, 36, "UbuntuSansMono_Italic36pt7b" },
  { &UbuntuSansMono_Italic37pt7b, 37, "UbuntuSansMono_Italic37pt7b" },
  { &UbuntuSansMono_Italic38pt7b, 38, "UbuntuSansMono_Italic38pt7b" },
  { &UbuntuSansMono_Italic39pt7b, 39, "UbuntuSansMono_Italic39pt7b" },
  { &UbuntuSansMono_Italic40pt7b, 40, "UbuntuSansMono_Italic40pt7b" },
  { &UbuntuSansMono_Italic41pt7b, 41, "UbuntuSansMono_Italic41pt7b" },
  { &UbuntuSansMono_Italic42pt7b, 42, "UbuntuSansMono_Italic42pt7b" },
  { &UbuntuSansMono_Italic43pt7b, 43, "UbuntuSansMono_Italic43pt7b" },
  { &UbuntuSansMono_Italic44pt7b, 44, "UbuntuSansMono_Italic44pt7b" },
  { &UbuntuSansMono_Italic45pt7b, 45, "UbuntuSansMono_Italic45pt7b" },
  { &UbuntuSansMono_Italic46pt7b, 46, "UbuntuSansMono_Italic46pt7b" },
  { &UbuntuSansMono_Italic47pt7b, 47, "UbuntuSansMono_Italic47pt7b" },
  { &UbuntuSansMono_Italic48pt7b, 48, "UbuntuSansMono_Italic48pt7b" },
  { &UbuntuSansMono_Italic49pt7b, 49, "UbuntuSansMono_Italic49pt7b" },
  { &UbuntuSansMono_Italic50pt7b, 50, "UbuntuSansMono_Italic50pt7b" },
  { &UbuntuSansMono_Italic51pt7b, 51, "UbuntuSansMono_Italic51pt7b" },
  { &UbuntuSansMono_Italic52pt7b, 52, "UbuntuSansMono_Italic52pt7b" },
  { &UbuntuSansMono_Italic53pt7b, 53, "UbuntuSansMono_Italic53pt7b" },
  { &UbuntuSansMono_Italic54pt7b, 54, "UbuntuSansMono_Italic54pt7b" },
  { &UbuntuSansMono_Italic55pt7b, 55, "UbuntuSansMono_Italic55pt7b" },
  { &UbuntuSansMono_Italic56pt7b, 56, "UbuntuSansMono_Italic56pt7b" },
  { &UbuntuSansMono_Italic57pt7b, 57, "UbuntuSansMono_Italic57pt7b" },
  { &UbuntuSansMono_Italic58pt7b, 58, "UbuntuSansMono_Italic58pt7b" },
  { &UbuntuSansMono_Italic59pt7b, 59, "UbuntuSansMono_Italic59pt7b" },
  { &UbuntuSansMono_Italic60pt7b, 60, "UbuntuSansMono_Italic60pt7b" },
  { &UbuntuSansMono_Italic61pt7b, 61, "UbuntuSansMono_Italic61pt7b" },
  { &UbuntuSansMono_Italic62pt7b, 62, "UbuntuSansMono_Italic62pt7b" },
  { &UbuntuSansMono_Italic63pt7b, 63, "UbuntuSansMono_Italic63pt7b" },
  { &UbuntuSansMono_Italic64pt7b, 64, "UbuntuSansMono_Italic64pt7b" },
  { &UbuntuSansMono_Italic65pt7b, 65, "UbuntuSansMono_Italic65pt7b" },
  { &UbuntuSansMono_Italic66pt7b, 66, "UbuntuSansMono_Italic66pt7b" },
  { &UbuntuSansMono_Italic67pt7b, 67, "UbuntuSansMono_Italic67pt7b" },
  { &UbuntuSansMono_Italic68pt7b, 68, "UbuntuSansMono_Italic68pt7b" },
  { &UbuntuSansMono_Italic69pt7b, 69, "UbuntuSansMono_Italic69pt7b" },
  { &UbuntuSansMono_Italic70pt7b, 70, "UbuntuSansMono_Italic70pt7b" },
  { &UbuntuSansMono_Italic71pt7b, 71, "UbuntuSansMono_Italic71pt7b" },
  { &UbuntuSansMono_Italic72pt7b, 72, "UbuntuSansMono_Italic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
