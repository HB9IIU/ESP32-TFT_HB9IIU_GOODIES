#ifndef _UBUNTUSANSMONO_SEMIBOLD21PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x00, 0xEF, 0xE0, 0xE7, 0xCF, 0x9F,
  0x36, 0x6C, 0xC0, 0x0C, 0xE1, 0x98, 0x33, 0x0E, 0x6F, 0xFF, 0xFF, 0xC6,
  0x60, 0xCC, 0x39, 0x9F, 0xFF, 0xFF, 0x99, 0x83, 0x30, 0x66, 0x1C, 0xC0,
  0x0C, 0x03, 0x03, 0xF9, 0xFE, 0x70, 0xB8, 0x0E, 0x01, 0xE0, 0x3F, 0x03,
  0xE0, 0x3C, 0x07, 0x01, 0xFC, 0xFF, 0xF8, 0xF8, 0x0C, 0x03, 0x00, 0x30,
  0x37, 0x86, 0xC8, 0xCC, 0xCC, 0xC9, 0x85, 0xB0, 0x7B, 0x00, 0x60, 0x0D,
  0xC0, 0xDE, 0x1B, 0x23, 0x32, 0x33, 0x26, 0x36, 0xC1, 0xE0, 0x1C, 0x1F,
  0x86, 0x71, 0x9C, 0x67, 0x1B, 0x87, 0xC0, 0xE7, 0x7D, 0xF3, 0xEC, 0x7B,
  0x0E, 0xC3, 0xBF, 0xF7, 0xCC, 0xFF, 0xFC, 0x02, 0x06, 0x0F, 0x1C, 0x38,
  0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x38,
  0x38, 0x1C, 0x0F, 0x02, 0x41, 0xC1, 0xC1, 0xC1, 0xC1, 0x83, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x1C, 0x71, 0xE7, 0x84, 0x00, 0x0C,
  0x03, 0x04, 0xC9, 0xB6, 0xFF, 0xC3, 0x01, 0xE1, 0xDE, 0x33, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x33, 0xDE, 0x71, 0xBB, 0x90, 0xFF, 0xF0, 0x6F, 0xFE, 0x01, 0xC0, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x1E, 0x0F,
  0xC7, 0x3B, 0x86, 0xE1, 0xF0, 0x7C, 0xDF, 0x37, 0xCD, 0xF0, 0x7E, 0x1F,
  0x86, 0x73, 0x9F, 0xE3, 0xF0, 0x06, 0x03, 0x83, 0xE3, 0xF8, 0x7E, 0x13,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x1F, 0xF7, 0xFC,
  0x3E, 0x1F, 0xCF, 0x79, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x1E, 0x0F,
  0x03, 0x81, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x3E, 0x3F, 0xC6, 0x78, 0x0E,
  0x03, 0x80, 0xE1, 0xF0, 0x7C, 0x07, 0x80, 0x60, 0x1C, 0x06, 0x83, 0xBF,
  0xEF, 0xF0, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x0E, 0xC7, 0x31, 0x8C,
  0xE3, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x3F, 0x9F, 0xCF,
  0xE6, 0x07, 0x03, 0x81, 0xF8, 0xFE, 0x07, 0x80, 0xC0, 0x60, 0x38, 0x3F,
  0xFF, 0xF8, 0x01, 0x83, 0xE1, 0xF8, 0xE0, 0x70, 0x18, 0x0F, 0xF3, 0xFE,
  0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0x1E, 0x1F, 0xE7, 0x3B, 0x86, 0xE1, 0x98, 0x67,
  0xB8, 0xF8, 0x7F, 0xB8, 0xEE, 0x1F, 0x07, 0xE1, 0xDF, 0xE3, 0xF0, 0x1E,
  0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1D, 0xFF, 0x7F, 0xC2, 0x60,
  0x38, 0x1C, 0x1F, 0x1F, 0x87, 0x80, 0x6F, 0xFE, 0x00, 0x06, 0xFF, 0xE0,
  0x33, 0xDE, 0xE0, 0x00, 0x06, 0x7B, 0xDE, 0x37, 0x72, 0x00, 0x00, 0x80,
  0xF1, 0xF9, 0xF8, 0xF0, 0x3C, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x20, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x40, 0x3C, 0x07, 0xE0,
  0x7E, 0x03, 0xC0, 0xF1, 0xF9, 0xF8, 0xF0, 0x10, 0x00, 0x7C, 0xFE, 0xCF,
  0x07, 0x07, 0x0F, 0x1E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x38, 0x38, 0x38,
  0x1E, 0x0F, 0xE7, 0x19, 0x83, 0xC0, 0xF3, 0xFC, 0xFF, 0x73, 0xD8, 0xF6,
  0x3D, 0x8F, 0x73, 0xCF, 0xF1, 0xF6, 0x01, 0xC0, 0x3F, 0x87, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1B, 0x81, 0x98, 0x19, 0x83, 0x9C, 0x31,
  0xC3, 0xFC, 0x7F, 0xC7, 0xFE, 0x60, 0xE6, 0x0E, 0xE0, 0x70, 0x7C, 0x3F,
  0xCF, 0xFB, 0x86, 0xE1, 0xB8, 0xEF, 0xF3, 0xFC, 0xE7, 0xB8, 0x7E, 0x1F,
  0x87, 0xE3, 0xFF, 0xEF, 0xF0, 0x0F, 0x8F, 0xF7, 0x99, 0xC0, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x4F, 0xF1, 0xFC,
  0x7C, 0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x86, 0xE7, 0xBF, 0xCF, 0xE0, 0xFF, 0x7F, 0xBF, 0xD8, 0x0C,
  0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x0F, 0x0F, 0xF7, 0x99, 0xC0, 0xE0, 0x38, 0x0C, 0x03,
  0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF1, 0xFC, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0x9F, 0xCF, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x74, 0x3F, 0xF9,
  0xF8, 0xE1, 0xDC, 0x73, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x07, 0xE0,
  0xFE, 0x1D, 0xC3, 0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x78, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0xFF, 0xFE, 0x61, 0xB8, 0x6E, 0x3B, 0xCF, 0xF2, 0xF5, 0xBD, 0xEF,
  0x7B, 0xCC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xC1, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF9, 0xFE, 0x7F, 0xDF, 0xB7, 0xEF, 0xF9, 0xFE, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7E, 0x1C, 0x1E, 0x1F, 0xC7, 0x3B, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0x63, 0x9F, 0xE3, 0xF0,
  0x7C, 0x3F, 0xEF, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xFF, 0xBF,
  0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1E, 0x0F, 0xC7, 0x7B, 0x86,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE3, 0x9F,
  0xE3, 0xF0, 0x30, 0x0F, 0x01, 0xF0, 0x18, 0x7C, 0x3F, 0xCF, 0xFB, 0x8E,
  0xE1, 0xB8, 0x6E, 0x3B, 0xFE, 0xFF, 0x3F, 0x8E, 0x73, 0x8E, 0xE3, 0xB8,
  0x7E, 0x1C, 0x1F, 0x1F, 0xE7, 0x1B, 0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xFC,
  0x0F, 0x80, 0xE0, 0x1C, 0x07, 0x41, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0x9F, 0xE3, 0xF0, 0xE0,
  0x6C, 0x0D, 0x83, 0xB8, 0x77, 0x0E, 0x61, 0x8C, 0x71, 0xCE, 0x39, 0x83,
  0x30, 0x6E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0xCF, 0x73, 0xDE, 0xF7, 0xBF, 0x2F, 0xCF, 0xF3,
  0xF8, 0x6E, 0x18, 0x60, 0xEE, 0x1C, 0xC7, 0x1C, 0xC1, 0xB8, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xF0, 0x66, 0x1C, 0xE3, 0x0C, 0xE1, 0xF8, 0x38,
  0xE0, 0x6C, 0x1D, 0xC3, 0x98, 0x63, 0x9C, 0x73, 0x07, 0xE0, 0xF8, 0x0F,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF, 0xBF, 0xEF,
  0xF8, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0x1C, 0x07, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x0C,
  0x07, 0x81, 0xE0, 0xFC, 0x73, 0x1C, 0xEE, 0x1F, 0x87, 0x40, 0x80, 0xFF,
  0xFF, 0xFF, 0xCE, 0x71, 0x7F, 0x3F, 0xC0, 0xE0, 0x31, 0xFB, 0xFF, 0x87,
  0xC3, 0xE1, 0xBF, 0xDF, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xF3,
  0xFD, 0x8E, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3B, 0xFD, 0xFC, 0x1F,
  0xDF, 0xE7, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1F, 0xF1,
  0xFC, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x39, 0xFD, 0xFF, 0xC7, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1D, 0xFE, 0x7F, 0x3F, 0x1F, 0xEE, 0x1B, 0x87,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xF0, 0x9F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8,
  0x70, 0x9C, 0x03, 0x81, 0xFF, 0xBF, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xBF, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x87, 0xC3, 0x7F, 0x9F, 0xC0, 0x60, 0x74, 0x7F, 0xF9, 0xF8,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x18, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x10, 0xFC, 0x3F,
  0x07, 0x07, 0x07, 0x00, 0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x67, 0xFF, 0x7C, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x1F, 0x1D, 0x9C, 0xDC, 0x7C, 0x3E, 0x1B, 0x8C, 0xE6, 0x3B,
  0x1D, 0x87, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x10, 0xFC, 0x3F, 0xFF, 0xBF,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0xFE, 0xFF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3F,
  0x1F, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE3, 0x9F, 0xE3,
  0xF0, 0xFE, 0x7F, 0xB1, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0x7F,
  0xBF, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0xBF, 0xFC, 0x7C, 0x3E, 0x1E,
  0x0F, 0x87, 0xC3, 0xE1, 0xBF, 0xCF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x7F,
  0xFF, 0xB8, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00,
  0x3F, 0xBF, 0xD8, 0x2C, 0x07, 0xC1, 0xF8, 0x3E, 0x03, 0x41, 0xBF, 0xFF,
  0xC0, 0x38, 0x0E, 0x03, 0x83, 0xFF, 0xFF, 0xCE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0x80, 0x71, 0x1F, 0xC3, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x86, 0xC3, 0x71, 0xBF, 0xCF, 0xE0, 0xE0, 0x6E, 0x1D, 0xC3,
  0x98, 0x63, 0x9C, 0x73, 0x06, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x38, 0x00,
  0xE0, 0x7C, 0x0D, 0x99, 0xB3, 0x36, 0xE6, 0xDE, 0xDB, 0xDB, 0x5A, 0x79,
  0xC7, 0x38, 0xC3, 0x00, 0xE1, 0xD8, 0xE7, 0x30, 0xFC, 0x1E, 0x07, 0x81,
  0xE0, 0xDC, 0x73, 0xB8, 0x6C, 0x1C, 0xE1, 0xF8, 0x76, 0x19, 0xC6, 0x73,
  0x8C, 0xC3, 0xB0, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0x30, 0x9C, 0x3E, 0x0F,
  0x00, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF,
  0x1F, 0x3F, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0xE0, 0xF0, 0x30,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x07, 0x0F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0xF8, 0xF0, 0x78, 0xFF, 0xFC,
  0xF9, 0x0C,
};

const GFXglyph UbuntuSansMono_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 7, 6, 12, 2, -16 },
  { 15, 11, 15, 12, 0, -15 },
  { 36, 10, 18, 12, 1, -16 },
  { 59, 12, 15, 12, 0, -15 },
  { 82, 10, 15, 12, 1, -15 },
  { 101, 2, 7, 12, 5, -16 },
  { 103, 8, 21, 12, 2, -17 },
  { 124, 7, 21, 12, 2, -17 },
  { 143, 10, 9, 12, 1, -15 },
  { 155, 10, 10, 12, 1, -11 },
  { 168, 5, 8, 12, 3, -4 },
  { 173, 6, 2, 12, 3, -7 },
  { 175, 4, 4, 12, 4, -4 },
  { 177, 10, 20, 12, 1, -16 },
  { 202, 10, 15, 12, 1, -15 },
  { 221, 10, 15, 12, 1, -15 },
  { 240, 10, 15, 12, 1, -15 },
  { 259, 10, 15, 12, 1, -15 },
  { 278, 10, 15, 12, 1, -15 },
  { 297, 9, 15, 12, 1, -15 },
  { 314, 10, 15, 12, 1, -15 },
  { 333, 10, 15, 12, 1, -15 },
  { 352, 10, 15, 12, 1, -15 },
  { 371, 10, 15, 12, 1, -15 },
  { 390, 4, 11, 12, 4, -11 },
  { 396, 5, 15, 12, 3, -11 },
  { 406, 10, 10, 12, 1, -11 },
  { 419, 10, 7, 12, 1, -10 },
  { 428, 10, 10, 12, 1, -11 },
  { 441, 8, 15, 12, 2, -15 },
  { 456, 10, 18, 12, 1, -15 },
  { 479, 12, 15, 12, 0, -15 },
  { 502, 10, 15, 12, 1, -15 },
  { 521, 10, 15, 12, 1, -15 },
  { 540, 10, 15, 12, 1, -15 },
  { 559, 9, 15, 12, 2, -15 },
  { 576, 8, 15, 12, 2, -15 },
  { 591, 10, 15, 12, 1, -15 },
  { 610, 10, 15, 12, 1, -15 },
  { 629, 8, 15, 12, 2, -15 },
  { 644, 9, 15, 12, 1, -15 },
  { 661, 11, 15, 12, 1, -15 },
  { 682, 9, 15, 12, 2, -15 },
  { 699, 10, 15, 12, 1, -15 },
  { 718, 10, 15, 12, 1, -15 },
  { 737, 10, 15, 12, 1, -15 },
  { 756, 10, 15, 12, 1, -15 },
  { 775, 10, 19, 12, 1, -15 },
  { 799, 10, 15, 12, 1, -15 },
  { 818, 10, 15, 12, 1, -15 },
  { 837, 10, 15, 12, 1, -15 },
  { 856, 10, 15, 12, 1, -15 },
  { 875, 11, 15, 12, 0, -15 },
  { 896, 10, 15, 12, 1, -15 },
  { 915, 11, 15, 12, 0, -15 },
  { 936, 11, 15, 12, 0, -15 },
  { 957, 10, 15, 12, 1, -15 },
  { 976, 6, 20, 12, 3, -16 },
  { 991, 10, 20, 12, 1, -16 },
  { 1016, 6, 20, 12, 3, -16 },
  { 1031, 10, 9, 12, 1, -15 },
  { 1043, 12, 2, 12, 0, 2 },
  { 1046, 4, 4, 12, 4, -16 },
  { 1048, 9, 11, 12, 1, -11 },
  { 1061, 9, 16, 12, 2, -16 },
  { 1079, 10, 11, 12, 1, -11 },
  { 1093, 9, 16, 12, 1, -16 },
  { 1111, 10, 11, 12, 1, -11 },
  { 1125, 11, 16, 12, 1, -16 },
  { 1147, 9, 15, 12, 1, -11 },
  { 1164, 8, 16, 12, 2, -16 },
  { 1180, 10, 16, 12, 1, -16 },
  { 1200, 8, 20, 12, 1, -16 },
  { 1220, 9, 16, 12, 2, -16 },
  { 1238, 10, 16, 12, 1, -16 },
  { 1258, 10, 11, 12, 1, -11 },
  { 1272, 8, 11, 12, 2, -11 },
  { 1283, 10, 11, 12, 1, -11 },
  { 1297, 9, 15, 12, 2, -11 },
  { 1314, 9, 15, 12, 1, -11 },
  { 1331, 9, 11, 12, 2, -11 },
  { 1344, 9, 11, 12, 1, -11 },
  { 1357, 10, 14, 12, 1, -14 },
  { 1375, 9, 11, 12, 1, -11 },
  { 1388, 11, 11, 12, 0, -11 },
  { 1404, 11, 11, 12, 0, -11 },
  { 1420, 10, 11, 12, 1, -11 },
  { 1434, 10, 15, 12, 1, -11 },
  { 1453, 8, 11, 12, 2, -11 },
  { 1464, 8, 20, 12, 2, -16 },
  { 1484, 2, 20, 12, 5, -16 },
  { 1489, 8, 20, 12, 2, -16 },
  { 1509, 10, 4, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_SEMIBOLD21PT7B_H_
