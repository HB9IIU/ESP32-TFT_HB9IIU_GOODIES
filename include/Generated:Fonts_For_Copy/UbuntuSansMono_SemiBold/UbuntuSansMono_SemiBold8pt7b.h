#ifndef _UBUNTUSANSMONO_SEMIBOLD8PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x55, 0xF6, 0xFA, 0x25, 0x43, 0x1F, 0x20, 0x5D, 0xE3,
  0x7B, 0x66, 0x67, 0xB7, 0xE0, 0x72, 0x49, 0x11, 0x89, 0x12, 0xB4, 0x27,
  0xA5, 0x2F, 0x22, 0x70, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0xC0, 0x65, 0x9B,
  0x97, 0x2E, 0x22, 0x27, 0x69, 0x12, 0x47, 0x69, 0x37, 0x1F, 0x13, 0x59,
  0xF1, 0x74, 0x43, 0x1F, 0x16, 0x49, 0x97, 0xF1, 0x22, 0x24, 0x6D, 0x57,
  0x97, 0x65, 0x97, 0x16, 0xC3, 0xC3, 0xC0, 0x3C, 0x71, 0xF0, 0xF0, 0xC3,
  0x68, 0xC5, 0xA1, 0x80, 0x25, 0xBD, 0xBB, 0x70, 0x26, 0x55, 0xF9, 0x69,
  0x9F, 0x9F, 0x35, 0x88, 0xC7, 0x69, 0x99, 0x9E, 0xF2, 0x79, 0xC0, 0xF2,
  0x79, 0x00, 0x35, 0x89, 0xD7, 0x99, 0x9F, 0x99, 0xE9, 0x25, 0xC0, 0x71,
  0x11, 0x1E, 0x9B, 0xAE, 0xB9, 0x92, 0x49, 0xC0, 0x9D, 0xFB, 0x99, 0x9D,
  0xDB, 0x99, 0x65, 0x99, 0x97, 0xD6, 0xF9, 0x00, 0x65, 0x99, 0x97, 0x21,
  0x69, 0x9E, 0x99, 0x6D, 0x43, 0x1F, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x97,
  0x99, 0x55, 0x62, 0x99, 0xBB, 0xD5, 0x95, 0x66, 0x59, 0x95, 0x52, 0x22,
  0x71, 0x26, 0x4F, 0xEA, 0xAC, 0xC4, 0x42, 0x22, 0x10, 0xD5, 0x5C, 0x26,
  0x59, 0xF0, 0xC0, 0x77, 0x97, 0x93, 0xDB, 0xC0, 0x78, 0xC7, 0x11, 0x79,
  0x97, 0x7F, 0x87, 0x34, 0xF4, 0x44, 0x79, 0x97, 0x96, 0x93, 0xDB, 0x40,
  0x60, 0xE2, 0x23, 0x20, 0x71, 0x11, 0xA4, 0x93, 0xED, 0x40, 0xE2, 0x22,
  0x23, 0xFB, 0x99, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF8, 0x79, 0x97, 0x10,
  0xF2, 0x40, 0xF8, 0xF0, 0x4F, 0x44, 0x30, 0xB6, 0xF0, 0x95, 0x62, 0x9B,
  0xF5, 0xD6, 0x6D, 0xD5, 0x62, 0x2C, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE,
  0xC9, 0x34, 0xB0, 0xF0,
};

const GFXglyph UbuntuSansMono_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 6, 4, 2, -6 },
  { 2, 3, 2, 4, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 6, 4, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 3, 4, 2, -6 },
  { 17, 3, 8, 4, 1, -6 },
  { 20, 3, 8, 4, 1, -6 },
  { 23, 4, 4, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 2, 2, 4, 1, -1 },
  { 28, 2, 1, 4, 1, -3 },
  { 29, 2, 1, 4, 1, -1 },
  { 30, 4, 7, 4, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 5, 4, 1, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 3, 6, 4, 1, -6 },
  { 76, 4, 7, 4, 0, -6 },
  { 80, 4, 6, 4, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 3, 6, 4, 1, -6 },
  { 95, 3, 6, 4, 1, -6 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 3, 6, 4, 1, -6 },
  { 107, 4, 6, 4, 0, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 4, 6, 4, 0, -6 },
  { 119, 4, 6, 4, 0, -6 },
  { 122, 4, 6, 4, 0, -6 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 4, 8, 4, 0, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 2, 7, 4, 1, -6 },
  { 161, 4, 7, 4, 0, -6 },
  { 165, 2, 7, 4, 1, -6 },
  { 167, 4, 4, 4, 0, -6 },
  { 169, 4, 1, 4, 0, 1 },
  { 170, 2, 1, 4, 1, -6 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 3, 6, 4, 1, -6 },
  { 176, 4, 4, 4, 0, -4 },
  { 178, 4, 6, 4, 0, -6 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 6, 4, 0, -6 },
  { 186, 4, 6, 4, 0, -4 },
  { 189, 3, 6, 4, 1, -6 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 4, 8, 4, 0, -6 },
  { 199, 3, 6, 4, 1, -6 },
  { 202, 4, 6, 4, 0, -6 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 3, 4, 4, 1, -4 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 3, 5, 4, 1, -4 },
  { 213, 4, 5, 4, 0, -4 },
  { 216, 3, 4, 4, 1, -4 },
  { 218, 3, 4, 4, 1, -4 },
  { 220, 4, 5, 4, 0, -5 },
  { 223, 3, 4, 4, 1, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 4, 6, 4, 0, -4 },
  { 234, 3, 4, 4, 1, -4 },
  { 236, 3, 7, 4, 1, -6 },
  { 239, 1, 7, 4, 2, -6 },
  { 240, 3, 7, 4, 1, -6 },
  { 243, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_SEMIBOLD8PT7B_H_
