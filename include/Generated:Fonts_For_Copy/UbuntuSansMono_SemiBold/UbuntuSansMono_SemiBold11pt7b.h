#ifndef _UBUNTUSANSMONO_SEMIBOLD11PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCF, 0xDD, 0x90, 0x2C, 0xAF, 0xDA, 0x4B, 0xF5, 0x14, 0x30,
  0xC7, 0x90, 0x60, 0xE0, 0xD3, 0xF8, 0xC0, 0x46, 0xAA, 0xBC, 0x28, 0xD5,
  0x63, 0x31, 0x65, 0x1C, 0x6F, 0x6C, 0x9F, 0xF4, 0x13, 0x64, 0xCC, 0xCC,
  0x42, 0x10, 0x84, 0x23, 0x11, 0x13, 0x26, 0xC0, 0x65, 0x7E, 0xCD, 0x00,
  0x63, 0x3E, 0xC6, 0x30, 0xF6, 0xFF, 0xF0, 0x18, 0x8C, 0x62, 0x31, 0x88,
  0xC6, 0x20, 0x31, 0xA4, 0xF7, 0xFD, 0x34, 0x9E, 0x23, 0x28, 0x42, 0x10,
  0x9F, 0x65, 0x84, 0x66, 0x62, 0x1F, 0xE5, 0x84, 0xE7, 0x0C, 0x5E, 0x08,
  0x62, 0x9A, 0x4B, 0xF0, 0x82, 0xFF, 0x8E, 0x31, 0x1F, 0x13, 0xB1, 0xE9,
  0x4E, 0x5E, 0xFF, 0xCC, 0x42, 0x31, 0x08, 0x64, 0xA5, 0xAF, 0x4E, 0x7E,
  0x64, 0xA7, 0x3F, 0x88, 0xD8, 0xF0, 0xF0, 0x6C, 0x06, 0xEA, 0x0B, 0xB1,
  0xC3, 0x80, 0xF8, 0x3F, 0xF0, 0x87, 0x0E, 0xFC, 0x00, 0xEB, 0x13, 0x60,
  0x66, 0x39, 0x24, 0x6F, 0xA6, 0x9F, 0xD2, 0x64, 0x60, 0x30, 0xC3, 0x9A,
  0x49, 0xEC, 0xF3, 0xE5, 0xA5, 0xEF, 0x4E, 0x7E, 0x39, 0xB4, 0x30, 0xC1,
  0x06, 0x0F, 0xE5, 0xA7, 0x39, 0xCE, 0x5C, 0xF7, 0xA1, 0xEF, 0x42, 0x1F,
  0xFF, 0x88, 0xF8, 0x88, 0x3D, 0xA4, 0x30, 0xCD, 0x34, 0xCF, 0x9C, 0xE7,
  0xFF, 0xCE, 0x73, 0xFF, 0x66, 0x66, 0x6F, 0xFF, 0x11, 0x11, 0x9F, 0x9C,
  0xA9, 0xCE, 0x5A, 0x53, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x49, 0x27, 0x5D,
  0xF7, 0x1C, 0x71, 0x9C, 0xF7, 0xBB, 0xDE, 0x73, 0x31, 0xA4, 0xF3, 0xCF,
  0x34, 0x9E, 0xE5, 0xA7, 0x3F, 0x42, 0x10, 0x31, 0xA4, 0xF3, 0xCF, 0x34,
  0x9E, 0x10, 0x70, 0xE5, 0xA5, 0x2F, 0x5A, 0x53, 0x76, 0xA1, 0x87, 0x0E,
  0x7E, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x9C, 0xE7, 0x39, 0xCE, 0x7E,
  0xC7, 0x34, 0xD2, 0x48, 0xE3, 0x0C, 0xC7, 0x1C, 0x7D, 0xF5, 0xD4, 0xD2,
  0xCD, 0x27, 0x8C, 0x31, 0xE4, 0xB3, 0xC5, 0x34, 0x8E, 0x30, 0xC3, 0x0C,
  0xF7, 0x8C, 0x46, 0x62, 0x1F, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x84,
  0x30, 0x84, 0x30, 0x84, 0x30, 0x86, 0xF3, 0x33, 0x33, 0x33, 0x33, 0xF0,
  0x30, 0xC7, 0x93, 0xC8, 0xFC, 0xB4, 0xF1, 0x7D, 0x9F, 0x44, 0x21, 0xE9,
  0x4E, 0x73, 0xF0, 0x7E, 0x61, 0x0C, 0x3C, 0x08, 0x42, 0xF4, 0xE7, 0x29,
  0x78, 0x39, 0x2C, 0xFF, 0x41, 0xE0, 0x13, 0xD1, 0xF4, 0x21, 0x08, 0x40,
  0x3A, 0x73, 0x97, 0x9C, 0x2F, 0x48, 0x8F, 0x99, 0x99, 0x90, 0x30, 0x0E,
  0x08, 0x20, 0x83, 0x07, 0x30, 0xF3, 0x33, 0x33, 0xBE, 0x44, 0x21, 0x3B,
  0x73, 0x96, 0x98, 0xE0, 0x82, 0x08, 0x20, 0x83, 0x07, 0xFB, 0xFD, 0x75,
  0xC7, 0x10, 0xF9, 0x99, 0x99, 0x39, 0x2C, 0xF3, 0x4D, 0xE0, 0xF4, 0xA7,
  0x39, 0xFA, 0x10, 0x3A, 0x73, 0x94, 0xBC, 0x21, 0xFE, 0x71, 0x8C, 0x60,
  0x79, 0xC7, 0x1F, 0x47, 0xD0, 0x84, 0x21, 0xE0, 0x99, 0x99, 0x9F, 0xCD,
  0x34, 0x9E, 0x30, 0xC0, 0x86, 0x5F, 0x5D, 0x79, 0x20, 0xCD, 0xA3, 0x0C,
  0x6B, 0x30, 0xCD, 0x26, 0x8A, 0x30, 0xC3, 0x38, 0xF3, 0x24, 0xCF, 0x36,
  0x44, 0x4C, 0x44, 0x46, 0x30, 0xFF, 0xFF, 0xFC, 0xC6, 0x22, 0x23, 0x22,
  0x22, 0xE0, 0x7E, 0x60,
};

const GFXglyph UbuntuSansMono_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 6, 8, 6, 0, -8 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 6, 8, 6, 0, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 2, 3, 6, 2, -8 },
  { 32, 4, 11, 6, 1, -9 },
  { 38, 4, 11, 6, 1, -9 },
  { 44, 5, 5, 6, 1, -8 },
  { 48, 5, 6, 6, 1, -6 },
  { 52, 2, 4, 6, 2, -2 },
  { 53, 4, 2, 6, 1, -4 },
  { 54, 2, 2, 6, 2, -2 },
  { 55, 5, 11, 6, 1, -9 },
  { 62, 6, 8, 6, 0, -8 },
  { 68, 5, 8, 6, 1, -8 },
  { 73, 5, 8, 6, 1, -8 },
  { 78, 5, 8, 6, 1, -8 },
  { 83, 6, 8, 6, 0, -8 },
  { 89, 4, 8, 6, 1, -8 },
  { 93, 5, 8, 6, 1, -8 },
  { 98, 5, 8, 6, 1, -8 },
  { 103, 5, 8, 6, 1, -8 },
  { 108, 5, 8, 6, 1, -8 },
  { 113, 2, 6, 6, 2, -6 },
  { 115, 3, 8, 6, 1, -6 },
  { 118, 5, 5, 6, 1, -6 },
  { 122, 5, 4, 6, 1, -5 },
  { 125, 5, 5, 6, 1, -6 },
  { 129, 4, 8, 6, 1, -8 },
  { 133, 6, 10, 6, 0, -8 },
  { 141, 6, 8, 6, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 6, 8, 6, 0, -8 },
  { 158, 5, 8, 6, 1, -8 },
  { 163, 5, 8, 6, 1, -8 },
  { 168, 4, 8, 6, 1, -8 },
  { 172, 6, 8, 6, 0, -8 },
  { 178, 5, 8, 6, 1, -8 },
  { 183, 4, 8, 6, 1, -8 },
  { 187, 4, 8, 6, 1, -8 },
  { 191, 5, 8, 6, 1, -8 },
  { 196, 5, 8, 6, 1, -8 },
  { 201, 6, 8, 6, 0, -8 },
  { 207, 5, 8, 6, 1, -8 },
  { 212, 6, 8, 6, 0, -8 },
  { 218, 5, 8, 6, 1, -8 },
  { 223, 6, 10, 6, 0, -8 },
  { 231, 5, 8, 6, 1, -8 },
  { 236, 5, 8, 6, 1, -8 },
  { 241, 6, 8, 6, 0, -8 },
  { 247, 5, 8, 6, 1, -8 },
  { 252, 6, 8, 6, 0, -8 },
  { 258, 6, 8, 6, 0, -8 },
  { 264, 6, 8, 6, 0, -8 },
  { 270, 6, 8, 6, 0, -8 },
  { 276, 5, 8, 6, 1, -8 },
  { 281, 4, 11, 6, 1, -9 },
  { 287, 5, 11, 6, 1, -9 },
  { 294, 4, 11, 6, 1, -9 },
  { 300, 6, 5, 6, 0, -8 },
  { 304, 6, 1, 6, 0, 1 },
  { 305, 2, 3, 6, 2, -9 },
  { 306, 4, 6, 6, 1, -6 },
  { 309, 5, 9, 6, 1, -9 },
  { 315, 5, 6, 6, 1, -6 },
  { 319, 5, 9, 6, 0, -9 },
  { 325, 6, 6, 6, 0, -6 },
  { 330, 5, 9, 6, 1, -9 },
  { 336, 5, 8, 6, 0, -6 },
  { 341, 4, 9, 6, 1, -9 },
  { 346, 6, 8, 6, 0, -8 },
  { 352, 4, 10, 6, 1, -8 },
  { 357, 5, 9, 6, 1, -9 },
  { 363, 6, 8, 6, 0, -8 },
  { 369, 6, 6, 6, 0, -6 },
  { 374, 4, 6, 6, 1, -6 },
  { 377, 6, 6, 6, 0, -6 },
  { 382, 5, 8, 6, 1, -6 },
  { 387, 5, 8, 6, 0, -6 },
  { 392, 5, 6, 6, 1, -6 },
  { 396, 4, 6, 6, 1, -6 },
  { 399, 5, 7, 6, 1, -7 },
  { 404, 4, 6, 6, 1, -6 },
  { 407, 6, 6, 6, 0, -6 },
  { 412, 6, 6, 6, 0, -6 },
  { 417, 6, 6, 6, 0, -6 },
  { 422, 6, 8, 6, 0, -6 },
  { 428, 4, 6, 6, 1, -6 },
  { 431, 4, 11, 6, 1, -9 },
  { 437, 2, 11, 6, 2, -9 },
  { 440, 4, 11, 6, 1, -9 },
  { 446, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_SEMIBOLD11PT7B_H_
