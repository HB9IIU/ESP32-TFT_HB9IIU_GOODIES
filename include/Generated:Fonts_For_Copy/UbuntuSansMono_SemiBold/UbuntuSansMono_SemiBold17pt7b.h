#ifndef _UBUNTUSANSMONO_SEMIBOLD17PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x0F, 0xF0, 0xDF, 0x7C, 0xF2, 0xC8, 0x19, 0x8D,
  0x86, 0xDF, 0xFF, 0xF9, 0x90, 0xC9, 0xFF, 0xFF, 0xB3, 0x19, 0x8D, 0x80,
  0x18, 0x18, 0x7E, 0xE6, 0xC0, 0xE0, 0x78, 0x3E, 0x07, 0x03, 0x87, 0xFE,
  0x7C, 0x18, 0x18, 0x70, 0xE8, 0xF4, 0xDA, 0x4F, 0x63, 0xE0, 0x2C, 0x3F,
  0x36, 0x92, 0x59, 0xB8, 0x70, 0x3C, 0x1F, 0x19, 0x8C, 0xC3, 0xC1, 0xC1,
  0xE6, 0xDA, 0xC7, 0x61, 0x9F, 0xC7, 0xB0, 0xFF, 0xE0, 0x1C, 0xE3, 0x18,
  0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x60, 0xC3, 0xC2, 0xC1, 0x83, 0x0E,
  0x18, 0x60, 0xC3, 0x0C, 0x31, 0x86, 0x38, 0xCE, 0x30, 0x18, 0x18, 0xDE,
  0xFF, 0x18, 0x7C, 0x6E, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x6F, 0x72, 0xE8, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0,
  0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C,
  0x08, 0x38, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7F, 0x7F,
  0x7C, 0xFE, 0x46, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF,
  0x7C, 0xFE, 0x86, 0x06, 0x0E, 0x3C, 0x3E, 0x06, 0x07, 0x06, 0xFE, 0xFC,
  0x0E, 0x0E, 0x1E, 0x36, 0x66, 0x66, 0xC6, 0xFF, 0xFF, 0x06, 0x06, 0x06,
  0x7E, 0xFD, 0x83, 0x06, 0x0F, 0x83, 0x83, 0x06, 0x0F, 0xFF, 0xE0, 0x0E,
  0x3E, 0x70, 0x60, 0xC0, 0xFE, 0xC6, 0xC7, 0xC3, 0xC6, 0x7E, 0x7C, 0xFF,
  0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x3C,
  0x7E, 0xC6, 0xC6, 0xE6, 0x7C, 0x7E, 0xC6, 0xC3, 0xC3, 0xFE, 0x7C, 0x3C,
  0x7E, 0xC6, 0xC7, 0xC3, 0xE3, 0x7F, 0x16, 0x06, 0x0C, 0x78, 0x70, 0x7F,
  0x80, 0x1F, 0xE0, 0x37, 0x70, 0x00, 0x37, 0x73, 0xE4, 0x02, 0x0F, 0x7C,
  0xF0, 0xE0, 0x7C, 0x1F, 0x02, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xF0, 0x7C, 0x0F, 0x0F, 0x3E, 0xF0, 0xC0, 0xFC, 0xFC, 0x18, 0x30, 0xE3,
  0x8E, 0x18, 0x00, 0x20, 0xE1, 0xC0, 0x1E, 0x1F, 0x98, 0x6C, 0x34, 0xFA,
  0x6F, 0x67, 0xB3, 0xD9, 0xA6, 0xDB, 0xEC, 0x03, 0x00, 0xF8, 0x18, 0x0C,
  0x0E, 0x07, 0x82, 0xC3, 0x61, 0x98, 0xCC, 0xFE, 0x7F, 0x30, 0xD8, 0x78,
  0x30, 0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE,
  0xFC, 0x3E, 0x7F, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F,
  0x3F, 0xF8, 0xFC, 0xC6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE,
  0xF8, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x06, 0x00,
  0x3E, 0x7F, 0xE1, 0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x7E,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xE0, 0xC7, 0xC6,
  0xCC, 0xDC, 0xD8, 0xF0, 0xF8, 0xDC, 0xCC, 0xC6, 0xC7, 0xC3, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0x63, 0x31,
  0x9C, 0xEA, 0xF5, 0x7A, 0xED, 0x36, 0x9B, 0x41, 0xA0, 0xD0, 0x78, 0x30,
  0xC3, 0xC3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCB, 0xCF, 0xC7, 0xC7, 0xC3,
  0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0,
  0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C,
  0x18, 0x1E, 0x07, 0xF8, 0xFE, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0xFC, 0xCC,
  0xC6, 0xC7, 0xC3, 0x3E, 0x7E, 0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x06, 0x03,
  0x07, 0xFE, 0xFC, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC7, 0xFE, 0x7C, 0xE1, 0xB0, 0xD8, 0x6C, 0x76, 0x31, 0x98, 0xCC, 0x6C,
  0x36, 0x0F, 0x07, 0x03, 0x80, 0xC1, 0xA0, 0xD0, 0x68, 0x34, 0xDA, 0x6D,
  0x76, 0xAB, 0x57, 0xB9, 0xDC, 0xCC, 0x60, 0xE1, 0xB1, 0x8C, 0xC6, 0xC1,
  0xE0, 0xE0, 0x70, 0x3C, 0x37, 0x39, 0x98, 0xFC, 0x30, 0xE1, 0xB0, 0xD8,
  0xC6, 0x63, 0x60, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFE,
  0xFE, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFE,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0E, 0x06,
  0x07, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x0C,
  0x0E, 0x07, 0x86, 0xE7, 0x33, 0x1F, 0x84, 0xFF, 0xFF, 0xC0, 0x4E, 0x30,
  0x7C, 0xFC, 0x18, 0x37, 0xF8, 0xF1, 0xFF, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0x3F, 0x7E, 0xE0,
  0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0x06, 0x0C, 0x18, 0x37, 0xFF, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0xF7, 0xE0, 0x3C, 0x7E, 0xC7, 0xC3, 0xFF, 0xC0,
  0xC0, 0xFE, 0x3E, 0x1F, 0x3F, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x3F, 0xFF, 0x1E, 0x3C, 0x78, 0xF9, 0xBF, 0x06,
  0x0F, 0xFF, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0xDF, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x60, 0x30, 0x30, 0x30, 0x00, 0xF0, 0xF0, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x1F, 0x1F, 0x0C, 0x38, 0x30, 0x07, 0xEF, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xBF, 0x7C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xCE,
  0xDC, 0xD8, 0xF8, 0xDC, 0xCC, 0xC6, 0xC3, 0xF0, 0xF0, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x1F, 0xFE, 0xFF, 0x9B, 0x9B,
  0x9B, 0x9B, 0x83, 0x83, 0x83, 0xFD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC6, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xFC, 0xFE,
  0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0x3E, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C, 0x18, 0x30, 0xFF, 0xFB, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x7E, 0xFF, 0x07, 0x87, 0xC1, 0xC1, 0xFF,
  0xFC, 0x10, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F,
  0x1F, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF9, 0xBF, 0x7E, 0xE1, 0xB0, 0xD8,
  0xCE, 0x63, 0x31, 0xB0, 0x78, 0x38, 0x0C, 0x00, 0xC1, 0xE0, 0xF3, 0x69,
  0xB5, 0xDB, 0xBD, 0xDC, 0xE6, 0x23, 0x00, 0xE3, 0x99, 0x8D, 0x83, 0xC0,
  0xC0, 0xF0, 0xDC, 0xC6, 0xE1, 0x80, 0x61, 0xB1, 0xDC, 0xC6, 0x63, 0x30,
  0xF0, 0x78, 0x3C, 0x0C, 0x06, 0x1E, 0x1E, 0x00, 0x7E, 0xFC, 0x30, 0xE3,
  0x86, 0x18, 0x7F, 0xFE, 0x1E, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x78, 0xF0,
  0x60, 0xC1, 0x83, 0x06, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x07, 0x0E, 0x30, 0x60, 0xC1, 0x83, 0x3E, 0x78,
  0x31, 0x3E, 0xDB, 0xF8, 0x40,
};

const GFXglyph UbuntuSansMono_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 6, 5, 10, 2, -13 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 15, 10, 1, -13 },
  { 39, 9, 12, 10, 0, -12 },
  { 53, 9, 12, 10, 0, -12 },
  { 67, 2, 6, 10, 4, -13 },
  { 69, 6, 16, 10, 2, -13 },
  { 81, 6, 16, 10, 2, -13 },
  { 93, 8, 8, 10, 1, -12 },
  { 101, 8, 8, 10, 1, -9 },
  { 109, 4, 6, 10, 3, -3 },
  { 112, 5, 2, 10, 2, -6 },
  { 114, 3, 3, 10, 3, -3 },
  { 116, 8, 16, 10, 1, -13 },
  { 132, 8, 12, 10, 1, -12 },
  { 144, 8, 12, 10, 1, -12 },
  { 156, 8, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 8, 12, 10, 1, -12 },
  { 192, 7, 12, 10, 1, -12 },
  { 203, 8, 12, 10, 1, -12 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 8, 12, 10, 1, -12 },
  { 239, 8, 12, 10, 1, -12 },
  { 251, 3, 9, 10, 3, -9 },
  { 255, 4, 12, 10, 2, -9 },
  { 261, 8, 8, 10, 1, -9 },
  { 269, 8, 6, 10, 1, -8 },
  { 275, 8, 8, 10, 1, -9 },
  { 283, 7, 12, 10, 1, -12 },
  { 294, 9, 15, 10, 0, -12 },
  { 311, 9, 12, 10, 0, -12 },
  { 325, 8, 12, 10, 1, -12 },
  { 337, 8, 12, 10, 1, -12 },
  { 349, 8, 12, 10, 1, -12 },
  { 361, 8, 12, 10, 1, -12 },
  { 373, 7, 12, 10, 1, -12 },
  { 384, 8, 12, 10, 1, -12 },
  { 396, 8, 12, 10, 1, -12 },
  { 408, 7, 12, 10, 1, -12 },
  { 419, 7, 12, 10, 1, -12 },
  { 430, 8, 12, 10, 1, -12 },
  { 442, 8, 12, 10, 1, -12 },
  { 454, 9, 12, 10, 0, -12 },
  { 468, 8, 12, 10, 1, -12 },
  { 480, 8, 12, 10, 1, -12 },
  { 492, 8, 12, 10, 1, -12 },
  { 504, 8, 15, 10, 1, -12 },
  { 519, 8, 12, 10, 1, -12 },
  { 531, 8, 12, 10, 1, -12 },
  { 543, 8, 12, 10, 1, -12 },
  { 555, 8, 12, 10, 1, -12 },
  { 567, 9, 12, 10, 0, -12 },
  { 581, 9, 12, 10, 0, -12 },
  { 595, 9, 12, 10, 0, -12 },
  { 609, 9, 12, 10, 0, -12 },
  { 623, 8, 12, 10, 1, -12 },
  { 635, 5, 16, 10, 2, -13 },
  { 645, 8, 16, 10, 1, -13 },
  { 661, 5, 16, 10, 2, -13 },
  { 671, 9, 7, 10, 0, -12 },
  { 679, 9, 2, 10, 0, 1 },
  { 682, 4, 3, 10, 3, -13 },
  { 684, 7, 9, 10, 1, -9 },
  { 692, 8, 13, 10, 1, -13 },
  { 705, 8, 9, 10, 1, -9 },
  { 714, 7, 13, 10, 1, -13 },
  { 726, 8, 9, 10, 1, -9 },
  { 735, 8, 13, 10, 1, -13 },
  { 748, 7, 12, 10, 1, -9 },
  { 759, 7, 13, 10, 1, -13 },
  { 771, 8, 13, 10, 1, -13 },
  { 784, 7, 16, 10, 1, -13 },
  { 798, 8, 13, 10, 1, -13 },
  { 811, 8, 13, 10, 1, -13 },
  { 824, 8, 9, 10, 1, -9 },
  { 833, 7, 9, 10, 1, -9 },
  { 841, 8, 9, 10, 1, -9 },
  { 850, 8, 12, 10, 1, -9 },
  { 862, 7, 12, 10, 1, -9 },
  { 873, 7, 9, 10, 2, -9 },
  { 881, 7, 9, 10, 1, -9 },
  { 889, 8, 12, 10, 1, -12 },
  { 901, 7, 9, 10, 1, -9 },
  { 909, 9, 9, 10, 0, -9 },
  { 920, 9, 9, 10, 0, -9 },
  { 931, 9, 9, 10, 0, -9 },
  { 942, 9, 12, 10, 0, -9 },
  { 956, 7, 9, 10, 1, -9 },
  { 964, 7, 16, 10, 1, -13 },
  { 978, 2, 16, 10, 4, -13 },
  { 982, 7, 16, 10, 1, -13 },
  { 996, 9, 4, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_SEMIBOLD17PT7B_H_
