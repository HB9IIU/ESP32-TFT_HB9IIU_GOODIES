#ifndef _UBUNTUSANSMONO_SEMIBOLD27PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x0E, 0xFF,
  0xDC, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC7, 0x63, 0x00,
  0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x1C, 0x1C, 0x73, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0xE0, 0xE3, 0x83, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1F, 0xC3, 0xFF, 0x3F, 0xF9, 0xE0, 0x4E, 0x00, 0x70,
  0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x0F,
  0x00, 0x7B, 0x07, 0xDF, 0xFD, 0xFF, 0xC1, 0xF8, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x3C, 0x0E, 0xF8, 0x19, 0xB8, 0x67, 0x31, 0xCE, 0x63, 0x1C, 0xCC,
  0x1B, 0xB8, 0x3F, 0x60, 0x3D, 0xC0, 0x07, 0x00, 0x0C, 0xE0, 0x3B, 0xE0,
  0xEE, 0xC1, 0x99, 0xC7, 0x33, 0x8C, 0x67, 0x30, 0xEE, 0xE1, 0xFB, 0x81,
  0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xBC, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07,
  0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0xE7, 0xF3, 0xBD, 0xCC, 0xE3, 0xF3,
  0x87, 0xCE, 0x1E, 0x38, 0x3C, 0xF3, 0xF1, 0xFF, 0xE3, 0xF3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x03, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0x80, 0x60, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x20, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE, 0x67, 0xBF, 0x7F,
  0xFC, 0x3F, 0x01, 0xF0, 0x1D, 0xC1, 0xEF, 0x06, 0x38, 0x11, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x79,
  0xF3, 0xF3, 0xC1, 0x87, 0x7C, 0xF1, 0x00, 0xFF, 0xFF, 0xF8, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0xF1, 0xE7,
  0x07, 0x38, 0x3F, 0xC0, 0xFC, 0x47, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xC0,
  0x7E, 0x03, 0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x3F, 0xF1, 0xFF, 0x07, 0xF0,
  0x07, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFF, 0x0F, 0x70, 0x47, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1F, 0x83, 0xFF, 0x3F, 0xF8, 0xE1, 0xE2,
  0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x1F, 0x83, 0xFF, 0x1F, 0xF8, 0x41, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xC0, 0x1E, 0x7F, 0xF3, 0xFF, 0x3F, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0x70, 0x73, 0x87, 0x9C, 0x38, 0xE3, 0x87, 0x1C,
  0x39, 0xC1, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x7F, 0xF7, 0xFE, 0x7F, 0xC0, 0x00, 0xF0, 0x1F, 0x83, 0xFC,
  0x3F, 0x03, 0xE0, 0x1C, 0x01, 0xE0, 0x0E, 0xF0, 0x7F, 0xE3, 0xFF, 0xBC,
  0x3D, 0xE0, 0xFF, 0x07, 0xB8, 0x3D, 0xC1, 0xEF, 0x0E, 0x7F, 0xF1, 0xFF,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x1E, 0x3F, 0xE0, 0xFE, 0x0F,
  0xF8, 0xE1, 0xE7, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0x7D, 0xF3, 0xFF,
  0x87, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3F,
  0xC1, 0xEE, 0x0F, 0x78, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x03, 0xBF, 0xFF, 0xB8, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0xE7, 0xDF, 0x7C, 0xF1, 0xCE, 0xF3, 0x88, 0x00, 0x00, 0x30, 0x07,
  0xC0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xE0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x60, 0x03, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x7F, 0x1F, 0xE3, 0xFC,
  0x3F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x3F, 0x1F, 0xF9, 0xFF, 0x20, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x0F, 0x81, 0xE0, 0x78, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0x3C, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x8F, 0xFC, 0xFF, 0xE7, 0xBE,
  0x79, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x9C, 0xFC, 0xFF, 0xE3,
  0xFB, 0x0F, 0xDC, 0x00, 0x70, 0x03, 0xF1, 0x07, 0xF8, 0x1F, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xE1, 0xC1, 0xC3, 0xFF, 0x87,
  0xFF, 0x1F, 0xFF, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0x78, 0xFF,
  0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x3C, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x78, 0x27, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x01, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0xFE,
  0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF,
  0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF8, 0x27, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0,
  0xEF, 0x07, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF4, 0x0F, 0x7F, 0xEF, 0xFE, 0x7F, 0x80, 0xE0, 0xF7,
  0x07, 0x38, 0x79, 0xC7, 0x8E, 0x3C, 0x73, 0xC3, 0xBC, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0xC1, 0xDE, 0x0E, 0x78, 0x71, 0xE3, 0x87, 0x9C, 0x3C,
  0xE0, 0xF7, 0x07, 0xB8, 0x1E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x73,
  0x83, 0x9E, 0x1C, 0xF1, 0xE7, 0x8F, 0xFC, 0x7F, 0xB7, 0xFD, 0xB7, 0xED,
  0xBF, 0x7D, 0xF9, 0xCF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xF7, 0x3F, 0xB9, 0xFC, 0xEF, 0xE7,
  0x7F, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0E,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0xC1,
  0xEE, 0x0E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE,
  0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x7E, 0xFF, 0xEF,
  0xF8, 0xF8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC1,
  0xEE, 0x0E, 0x7D, 0xF1, 0xFF, 0x07, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xE0, 0x0E, 0xFE, 0x07, 0xFC, 0x3F, 0xF1, 0xC3, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0E, 0x38,
  0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1E, 0x0F, 0xE1,
  0xFF, 0x9F, 0xF8, 0xF0, 0x47, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE8, 0x0F,
  0x7F, 0xF7, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xEE, 0x0E, 0x7F, 0xF1, 0xFF, 0x87, 0xF0, 0xF0, 0x1E, 0xE0, 0x39, 0xC0,
  0x73, 0xC0, 0xE7, 0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0xE7, 0xE7, 0x3F, 0x3D, 0xFB,
  0xEF, 0xDB, 0x7E, 0xDB, 0xFE, 0x7F, 0xE3, 0xEF, 0x1F, 0x78, 0x73, 0x83,
  0x9C, 0x1C, 0x78, 0x1C, 0xF0, 0x78, 0xF0, 0xE0, 0xE3, 0xC1, 0xE7, 0x01,
  0xDC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F,
  0x00, 0xEF, 0x03, 0xCE, 0x07, 0x1E, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x7B,
  0xC0, 0x78, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0x83,
  0x8F, 0x07, 0x1C, 0x07, 0x78, 0x0E, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x1D,
  0xE0, 0xF7, 0x83, 0x8F, 0x1E, 0x1C, 0xF0, 0x7B, 0xC0, 0xF2, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x43, 0x8F, 0x1F, 0x18, 0x06, 0x03,
  0xFC, 0x3F, 0xE3, 0x1F, 0x00, 0x70, 0x07, 0x07, 0xF3, 0xFF, 0x7F, 0xF7,
  0x07, 0xF0, 0x7F, 0x07, 0x7C, 0x77, 0xFF, 0x3F, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xEF, 0xBE,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E,
  0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0xC0, 0x7F, 0xCF, 0xFC, 0x7E, 0x67,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x71, 0xFF, 0x7F, 0xF7, 0xDF, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x7F, 0xF3, 0xFF,
  0x1F, 0xF0, 0x03, 0x00, 0xFE, 0x0F, 0xFC, 0xFB, 0xE7, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xFF, 0x1F,
  0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xC2, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x1F, 0xF3, 0xFF, 0x7C, 0x77, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0,
  0x07, 0x00, 0x74, 0x0F, 0x7F, 0xE7, 0xFC, 0xFF, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFC, 0xFF, 0xDF, 0x7F, 0x87,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0E, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x7F,
  0xDF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF4, 0x3F, 0xFE, 0xFF, 0x9F, 0x80, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1E, 0xE1,
  0xE7, 0x1E, 0x39, 0xE1, 0xDE, 0x0F, 0xE0, 0x7F, 0x03, 0xBC, 0x1C, 0xF0,
  0xE3, 0x87, 0x1E, 0x38, 0x79, 0xC1, 0xEE, 0x0F, 0x80, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xF7, 0xFF, 0xFB,
  0xDF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C, 0xFF, 0x9F, 0xFB, 0xFF, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xC0, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFB, 0xE7, 0x07, 0xF8,
  0x3F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1E, 0xE0, 0xE7, 0xFF,
  0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x8F, 0xFC, 0xF3, 0xEE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFF, 0xFE, 0xFF, 0xCF,
  0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xF3, 0xFF,
  0x7E, 0xF7, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0x77, 0xFF, 0x3F, 0xF1, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xFF, 0xFF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x07,
  0xFD, 0xFF, 0x7C, 0x6E, 0x01, 0xE0, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0x7C,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xC3, 0xFF, 0xF7, 0xFE, 0x7F, 0xC0, 0xE0, 0x3F, 0xC0,
  0xEF, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x1D,
  0xC0, 0x77, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0xC0, 0x1D, 0x80, 0x33, 0x9C, 0x67, 0x38, 0xCE, 0x7B, 0x9D, 0xF7, 0x3B,
  0x6E, 0x76, 0xDC, 0x7D, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x07,
  0x00, 0xF0, 0x7B, 0xC3, 0x8E, 0x38, 0x7B, 0xC1, 0xFC, 0x07, 0xC0, 0x1E,
  0x01, 0xF0, 0x1F, 0xC0, 0xEF, 0x0E, 0x38, 0xF1, 0xE7, 0x07, 0xF0, 0x1C,
  0xF0, 0x3B, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x87, 0x1C, 0x78, 0xF3, 0x83,
  0x9C, 0x1C, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0xFE, 0x07, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x3F, 0x8F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x0F, 0x81, 0xF0, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F,
  0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x1F, 0xC3, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3E, 0x07, 0xC1, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC7, 0xF0, 0xFE, 0x1F,
  0x80, 0x10, 0x01, 0xF8, 0x77, 0xFF, 0xBF, 0xFE, 0xE3, 0xF0, 0x81, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 19, 15, 5, -19 },
  { 13, 9, 9, 15, 3, -21 },
  { 24, 14, 19, 15, 1, -19 },
  { 58, 13, 24, 15, 1, -21 },
  { 97, 15, 19, 15, 0, -19 },
  { 133, 14, 19, 15, 1, -19 },
  { 167, 3, 9, 15, 6, -21 },
  { 171, 9, 26, 15, 3, -21 },
  { 201, 9, 26, 15, 3, -21 },
  { 231, 13, 12, 15, 1, -19 },
  { 251, 13, 14, 15, 1, -15 },
  { 274, 7, 10, 15, 4, -5 },
  { 283, 7, 3, 15, 4, -9 },
  { 286, 5, 5, 15, 5, -5 },
  { 290, 12, 26, 15, 2, -21 },
  { 329, 13, 19, 15, 1, -19 },
  { 360, 12, 19, 15, 2, -19 },
  { 389, 13, 19, 15, 1, -19 },
  { 420, 13, 19, 15, 1, -19 },
  { 451, 13, 19, 15, 1, -19 },
  { 482, 12, 19, 15, 1, -19 },
  { 511, 13, 19, 15, 1, -19 },
  { 542, 12, 19, 15, 2, -19 },
  { 571, 13, 19, 15, 1, -19 },
  { 602, 13, 19, 15, 1, -19 },
  { 633, 5, 14, 15, 5, -14 },
  { 642, 6, 19, 15, 4, -14 },
  { 657, 13, 13, 15, 1, -14 },
  { 679, 13, 8, 15, 1, -12 },
  { 692, 13, 13, 15, 1, -14 },
  { 714, 11, 19, 15, 2, -19 },
  { 741, 13, 23, 15, 1, -19 },
  { 779, 15, 19, 15, 0, -19 },
  { 815, 12, 19, 15, 2, -19 },
  { 844, 13, 19, 15, 1, -19 },
  { 875, 12, 19, 15, 2, -19 },
  { 904, 12, 19, 15, 2, -19 },
  { 933, 11, 19, 15, 2, -19 },
  { 960, 13, 19, 15, 1, -19 },
  { 991, 13, 19, 15, 1, -19 },
  { 1022, 11, 19, 15, 2, -19 },
  { 1049, 12, 19, 15, 1, -19 },
  { 1078, 13, 19, 15, 2, -19 },
  { 1109, 12, 19, 15, 2, -19 },
  { 1138, 13, 19, 15, 1, -19 },
  { 1169, 13, 19, 15, 1, -19 },
  { 1200, 13, 19, 15, 1, -19 },
  { 1231, 12, 19, 15, 2, -19 },
  { 1260, 13, 24, 15, 1, -19 },
  { 1299, 13, 19, 15, 2, -19 },
  { 1330, 13, 19, 15, 1, -19 },
  { 1361, 13, 19, 15, 1, -19 },
  { 1392, 13, 19, 15, 1, -19 },
  { 1423, 15, 19, 15, 0, -19 },
  { 1459, 13, 19, 15, 1, -19 },
  { 1490, 15, 19, 15, 0, -19 },
  { 1526, 15, 19, 15, 0, -19 },
  { 1562, 13, 19, 15, 1, -19 },
  { 1593, 8, 26, 15, 4, -21 },
  { 1619, 12, 26, 15, 2, -21 },
  { 1658, 8, 26, 15, 3, -21 },
  { 1684, 14, 11, 15, 1, -19 },
  { 1704, 15, 3, 15, 0, 2 },
  { 1710, 6, 5, 15, 5, -21 },
  { 1714, 12, 15, 15, 1, -15 },
  { 1737, 12, 21, 15, 2, -21 },
  { 1769, 13, 15, 15, 1, -15 },
  { 1794, 12, 21, 15, 1, -21 },
  { 1826, 13, 15, 15, 1, -15 },
  { 1851, 14, 21, 15, 1, -21 },
  { 1888, 12, 19, 15, 1, -14 },
  { 1917, 11, 21, 15, 2, -21 },
  { 1946, 13, 21, 15, 1, -21 },
  { 1981, 10, 26, 15, 2, -21 },
  { 2014, 13, 21, 15, 2, -21 },
  { 2049, 13, 21, 15, 1, -21 },
  { 2084, 13, 14, 15, 1, -14 },
  { 2107, 11, 14, 15, 2, -14 },
  { 2127, 13, 15, 15, 1, -15 },
  { 2152, 12, 19, 15, 2, -14 },
  { 2181, 12, 19, 15, 1, -14 },
  { 2210, 11, 14, 15, 3, -14 },
  { 2230, 11, 15, 15, 2, -15 },
  { 2251, 13, 18, 15, 1, -18 },
  { 2281, 11, 14, 15, 2, -14 },
  { 2301, 14, 14, 15, 1, -14 },
  { 2326, 15, 14, 15, 0, -14 },
  { 2353, 13, 14, 15, 1, -14 },
  { 2376, 13, 19, 15, 1, -14 },
  { 2407, 11, 14, 15, 2, -14 },
  { 2427, 11, 26, 15, 2, -21 },
  { 2463, 3, 26, 15, 6, -21 },
  { 2473, 11, 26, 15, 2, -21 },
  { 2509, 14, 6, 15, 1, -11 },
};

const GFXfont UbuntuSansMono_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_SEMIBOLD27PT7B_H_
