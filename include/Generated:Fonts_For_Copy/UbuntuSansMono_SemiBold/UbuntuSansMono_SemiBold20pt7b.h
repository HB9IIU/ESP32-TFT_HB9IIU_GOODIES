#ifndef _UBUNTUSANSMONO_SEMIBOLD20PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x60, 0x7F, 0xC0, 0xEF, 0xDF, 0x9F, 0x34, 0x68,
  0x80, 0x0C, 0xC1, 0x98, 0x67, 0x0C, 0xCF, 0xFF, 0xFF, 0xC6, 0x61, 0x9C,
  0xFF, 0xFF, 0xFF, 0xFF, 0x99, 0x87, 0x30, 0xCC, 0x00, 0x1C, 0x0E, 0x07,
  0x07, 0xF7, 0xF7, 0x03, 0x81, 0xE0, 0x7E, 0x0F, 0x81, 0xE0, 0x30, 0x1F,
  0x1F, 0xFC, 0x7C, 0x1C, 0x0E, 0x00, 0x70, 0x6B, 0x1B, 0x22, 0x64, 0xCD,
  0xB0, 0xF6, 0x0D, 0x80, 0x64, 0x0F, 0xC3, 0x6C, 0xCD, 0x99, 0xB6, 0x37,
  0x83, 0x80, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x66, 0x1F, 0x03, 0x91, 0xE6,
  0xDD, 0xB3, 0xEC, 0x73, 0x1C, 0xFF, 0x9F, 0x70, 0xFF, 0xF6, 0x80, 0x04,
  0x1C, 0x71, 0xC3, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x20, 0x41, 0xC1, 0xC1, 0xC1, 0xC1, 0x83, 0x07,
  0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x38, 0xE3, 0x82, 0x00, 0x1C,
  0x06, 0x13, 0x7F, 0x77, 0xF8, 0xE0, 0xDC, 0xEE, 0x22, 0x00, 0x0C, 0x06,
  0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x23, 0xDE,
  0xF1, 0x3B, 0x80, 0xFF, 0xC0, 0x4E, 0xFE, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x1C, 0x00, 0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E,
  0x4F, 0x77, 0xBB, 0xC1, 0xE0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0x0C, 0x0E,
  0x1F, 0x1F, 0x84, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87,
  0xFB, 0xFC, 0x3E, 0x7F, 0x90, 0xC0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0x7E, 0x7F, 0x90, 0xC0, 0x60, 0x30,
  0x38, 0xF8, 0x7E, 0x03, 0x81, 0xC0, 0xF0, 0x7F, 0xF7, 0xF0, 0x07, 0x01,
  0xC0, 0xF0, 0x6C, 0x3B, 0x0C, 0xC6, 0x33, 0x8C, 0xC3, 0x3F, 0xFF, 0xFC,
  0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xBF, 0xDC, 0x0E, 0x06, 0x03, 0xC1, 0xF8,
  0x1E, 0x03, 0x81, 0xC0, 0xF0, 0x7F, 0xF7, 0xF0, 0x07, 0x0F, 0x8F, 0x0E,
  0x06, 0x07, 0xF3, 0xFD, 0xC7, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0,
  0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x3E, 0x3B, 0x99, 0xF8,
  0xFE, 0x63, 0xE0, 0xF0, 0x7C, 0x3F, 0xFB, 0xF8, 0x3E, 0x3F, 0xB8, 0xFC,
  0x7E, 0x1F, 0x0F, 0x8E, 0xFF, 0x3F, 0x81, 0xC1, 0xC3, 0xC7, 0xC3, 0x80,
  0x4E, 0xFE, 0x00, 0x04, 0xEF, 0xE0, 0x23, 0x9E, 0xE0, 0x00, 0x04, 0x73,
  0xDC, 0x67, 0x70, 0x03, 0x87, 0xCF, 0x9F, 0x0E, 0x07, 0xE0, 0x7C, 0x0F,
  0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF0, 0x38, 0xFD, 0xF9, 0xE0, 0xC0, 0x00, 0xFC, 0xFE, 0x86, 0x07,
  0x06, 0x0E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x38, 0x78, 0x38, 0x1F, 0x3F,
  0xD8, 0x78, 0x3C, 0x7E, 0x7F, 0x77, 0xB3, 0xD9, 0xEC, 0xF6, 0x7B, 0xFC,
  0xFF, 0x01, 0xC0, 0x7F, 0x0F, 0x80, 0x0E, 0x01, 0xC0, 0x7C, 0x0D, 0x81,
  0xB0, 0x37, 0x0C, 0x61, 0x8C, 0x31, 0xCF, 0xF9, 0xFF, 0x30, 0x66, 0x0F,
  0xC1, 0xC0, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x3B, 0xF9, 0xFE, 0xE3,
  0xF0, 0xF8, 0x7C, 0x7F, 0xFF, 0xF0, 0x1F, 0x9F, 0xDC, 0x3C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0E, 0x17, 0xF8, 0xFC, 0xFC, 0x3F,
  0xCE, 0x73, 0x8E, 0xE1, 0xB8, 0x6E, 0x1F, 0x87, 0xE1, 0xB8, 0x6E, 0x3B,
  0x9E, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x9F, 0xDC, 0x3C,
  0x0E, 0x06, 0x03, 0x01, 0x83, 0xC1, 0xF0, 0xF8, 0x6E, 0x37, 0xF9, 0xFC,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x3F, 0x9F, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE8, 0x6F, 0xF3, 0xF0,
  0xE3, 0xF8, 0xEE, 0x73, 0x98, 0xEE, 0x3F, 0x0F, 0x83, 0xF0, 0xEE, 0x3B,
  0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE1, 0xB8, 0xEE, 0x3B,
  0xCE, 0xF7, 0xB5, 0xED, 0xDB, 0x76, 0xDD, 0xB0, 0x6C, 0x1F, 0x07, 0xC1,
  0xF0, 0x70, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9E, 0xCF, 0x37, 0x9B, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x0C, 0x3E, 0x1F, 0xCE, 0x3B, 0x86, 0xC1,
  0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x6E, 0x1B, 0x8E, 0x7F, 0x0F, 0x80,
  0xFE, 0x7F, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x8F, 0xFF, 0xFE, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x3E, 0x1F, 0xCE, 0x3B, 0x86, 0xC1, 0xB0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x6E, 0x1B, 0x8E, 0x7F, 0x0F, 0x81, 0xC0, 0x38,
  0x07, 0x80, 0x60, 0xFE, 0x3F, 0xCE, 0x7B, 0x8E, 0xE3, 0xB8, 0xEE, 0x73,
  0xFC, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE1, 0xB8, 0x70, 0x3F, 0xBF, 0xB8,
  0x5C, 0x0E, 0x03, 0x81, 0xF8, 0x3E, 0x07, 0x80, 0xC0, 0x70, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x77, 0xF9, 0xF8, 0xE0,
  0xEC, 0x1D, 0x83, 0x38, 0x67, 0x1C, 0x63, 0x8C, 0x61, 0x8C, 0x3B, 0x83,
  0x60, 0x6C, 0x0F, 0x80, 0xE0, 0x1C, 0x00, 0xC1, 0xF0, 0x7C, 0x1F, 0x06,
  0xC1, 0xB3, 0x6D, 0xDB, 0x76, 0xD7, 0xBD, 0xEF, 0x3B, 0x8E, 0xE3, 0xB8,
  0xE0, 0x60, 0xEE, 0x38, 0xC6, 0x1D, 0xC1, 0xB0, 0x1E, 0x03, 0x80, 0x78,
  0x1F, 0x03, 0x70, 0xE6, 0x18, 0xE7, 0x0D, 0xC1, 0xC0, 0xE0, 0xEC, 0x19,
  0xC7, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x60, 0x70,
  0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x3F, 0xFF, 0x1C, 0x07, 0x83, 0xE0, 0xDC, 0x73, 0x38, 0xEE, 0x1F, 0x06,
  0xFF, 0xFF, 0xFC, 0x43, 0x3C, 0x70, 0x3C, 0x3F, 0x91, 0xE0, 0x70, 0x3B,
  0xFF, 0xCF, 0xC7, 0xE3, 0xFF, 0xDF, 0xE0, 0x20, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x73, 0xFD, 0xEF, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0xFD,
  0xFC, 0x0F, 0x1F, 0xDE, 0x7C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x3F,
  0xC7, 0xE0, 0x00, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xDD, 0xFF, 0xEF, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1D, 0xFE, 0x7F, 0x1C, 0x3F, 0x9C, 0xFC,
  0x3C, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0, 0x3F, 0xCF, 0xE0, 0x02, 0x07, 0xF1,
  0xFC, 0xE0, 0x38, 0x0E, 0x0F, 0xFB, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1E, 0x3F, 0xFC, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0xC7, 0xFF, 0xBF, 0xC0, 0xE0, 0x7C, 0x77, 0xF9, 0xF0, 0x20, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xFD, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0x38, 0x1C, 0x06, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xFC, 0x3E, 0x0E, 0x0F, 0x06,
  0x00, 0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x6F, 0xFE, 0x3C, 0x20, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x3B, 0x9C, 0xEE, 0x3F, 0x0F, 0x83, 0xB0, 0xEE, 0x39, 0xCE, 0x3B, 0x87,
  0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0xFC, 0x3E, 0x73, 0x3F, 0xED, 0xDB, 0x36, 0xCD, 0xF3,
  0x7C, 0xDF, 0x07, 0xC1, 0xF0, 0x7C, 0x1C, 0x3C, 0x7F, 0xBD, 0xDC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x1C, 0x1F, 0xC7, 0x7B,
  0x8E, 0xC1, 0xB0, 0x7C, 0x1B, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0x3C, 0x7F,
  0xB9, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xFF, 0xFF, 0xDC, 0x0E,
  0x07, 0x03, 0x80, 0x1E, 0x3F, 0xDC, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7,
  0xE3, 0xBF, 0xCF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x1E, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x3F, 0x9C, 0xCC, 0x07,
  0x03, 0xF0, 0x3C, 0x07, 0x83, 0xFF, 0xFF, 0xC0, 0x08, 0x1C, 0x0E, 0x07,
  0x0F, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xF8, 0xFC,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC7, 0x7F, 0x9F, 0xC0,
  0xE0, 0xEE, 0x19, 0xC7, 0x18, 0xC3, 0x98, 0x77, 0x06, 0xC0, 0xF8, 0x0E,
  0x01, 0xC0, 0xE0, 0x7C, 0x0D, 0x99, 0xB7, 0x26, 0xEC, 0xD7, 0x9E, 0xF3,
  0xDE, 0x31, 0xC6, 0x30, 0x71, 0xE7, 0x30, 0x6C, 0x07, 0x80, 0xE0, 0x1E,
  0x06, 0xE1, 0xCC, 0x71, 0xDC, 0x1C, 0xE1, 0xF8, 0xE6, 0x39, 0xCC, 0x73,
  0x0D, 0xC3, 0xE0, 0x78, 0x1E, 0x03, 0x01, 0xC2, 0xE0, 0xF8, 0x38, 0x00,
  0xFF, 0xFE, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0x0F, 0x1F,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0xE0, 0xE0, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x38, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x7E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x03, 0xC1, 0xE1, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x3F, 0x1E,
  0x00, 0x70, 0xBF, 0x7D, 0xFB, 0x1C,
};

const GFXglyph UbuntuSansMono_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 7, 6, 11, 2, -15 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 9, 18, 11, 1, -16 },
  { 54, 11, 14, 11, 0, -14 },
  { 74, 10, 14, 11, 1, -14 },
  { 92, 3, 6, 11, 4, -15 },
  { 95, 7, 20, 11, 2, -16 },
  { 113, 7, 20, 11, 2, -16 },
  { 131, 9, 9, 11, 1, -14 },
  { 142, 9, 10, 11, 1, -11 },
  { 154, 5, 7, 11, 3, -4 },
  { 159, 5, 2, 11, 3, -7 },
  { 161, 4, 4, 11, 4, -4 },
  { 163, 9, 20, 11, 1, -16 },
  { 186, 9, 14, 11, 1, -14 },
  { 202, 9, 14, 11, 1, -14 },
  { 218, 9, 14, 11, 1, -14 },
  { 234, 9, 14, 11, 1, -14 },
  { 250, 10, 14, 11, 1, -14 },
  { 268, 9, 14, 11, 1, -14 },
  { 284, 9, 14, 11, 1, -14 },
  { 300, 9, 14, 11, 1, -14 },
  { 316, 9, 14, 11, 1, -14 },
  { 332, 9, 14, 11, 1, -14 },
  { 348, 4, 11, 11, 4, -11 },
  { 354, 5, 14, 11, 3, -11 },
  { 363, 9, 9, 11, 1, -10 },
  { 374, 9, 6, 11, 1, -9 },
  { 381, 9, 9, 11, 1, -10 },
  { 392, 8, 14, 11, 2, -14 },
  { 406, 9, 17, 11, 1, -14 },
  { 426, 11, 14, 11, 0, -14 },
  { 446, 9, 14, 11, 1, -14 },
  { 462, 9, 14, 11, 1, -14 },
  { 478, 10, 14, 11, 1, -14 },
  { 496, 8, 14, 11, 2, -14 },
  { 510, 8, 14, 11, 2, -14 },
  { 524, 9, 14, 11, 1, -14 },
  { 540, 9, 14, 11, 1, -14 },
  { 556, 9, 14, 11, 1, -14 },
  { 572, 9, 14, 11, 1, -14 },
  { 588, 10, 14, 11, 1, -14 },
  { 606, 8, 14, 11, 2, -14 },
  { 620, 10, 14, 11, 1, -14 },
  { 638, 9, 14, 11, 1, -14 },
  { 654, 10, 14, 11, 1, -14 },
  { 672, 9, 14, 11, 1, -14 },
  { 688, 10, 18, 11, 1, -14 },
  { 711, 10, 14, 11, 1, -14 },
  { 729, 9, 14, 11, 1, -14 },
  { 745, 10, 14, 11, 1, -14 },
  { 763, 9, 14, 11, 1, -14 },
  { 779, 11, 14, 11, 0, -14 },
  { 799, 10, 14, 11, 1, -14 },
  { 817, 11, 14, 11, 0, -14 },
  { 837, 11, 14, 11, 0, -14 },
  { 857, 9, 14, 11, 1, -14 },
  { 873, 6, 20, 11, 3, -16 },
  { 888, 9, 20, 11, 1, -16 },
  { 911, 6, 20, 11, 2, -16 },
  { 926, 10, 8, 11, 1, -14 },
  { 936, 11, 2, 11, 0, 2 },
  { 939, 5, 4, 11, 3, -16 },
  { 942, 9, 11, 11, 1, -11 },
  { 955, 9, 16, 11, 1, -16 },
  { 973, 9, 11, 11, 1, -11 },
  { 986, 9, 16, 11, 1, -16 },
  { 1004, 9, 11, 11, 1, -11 },
  { 1017, 10, 16, 11, 1, -16 },
  { 1037, 9, 15, 11, 1, -11 },
  { 1054, 9, 16, 11, 1, -16 },
  { 1072, 9, 15, 11, 1, -15 },
  { 1089, 8, 19, 11, 1, -15 },
  { 1108, 10, 16, 11, 1, -16 },
  { 1128, 9, 15, 11, 1, -15 },
  { 1145, 10, 11, 11, 1, -11 },
  { 1159, 9, 11, 11, 1, -11 },
  { 1172, 10, 11, 11, 1, -11 },
  { 1186, 9, 15, 11, 1, -11 },
  { 1203, 9, 15, 11, 1, -11 },
  { 1220, 8, 11, 11, 2, -11 },
  { 1231, 9, 11, 11, 1, -11 },
  { 1244, 9, 14, 11, 1, -14 },
  { 1260, 9, 10, 11, 1, -10 },
  { 1272, 11, 10, 11, 0, -10 },
  { 1286, 11, 10, 11, 0, -10 },
  { 1300, 11, 10, 11, 0, -10 },
  { 1314, 10, 14, 11, 1, -10 },
  { 1332, 8, 10, 11, 2, -10 },
  { 1342, 8, 20, 11, 2, -16 },
  { 1362, 3, 20, 11, 4, -16 },
  { 1370, 9, 20, 11, 1, -16 },
  { 1393, 10, 4, 11, 1, -8 },
};

const GFXfont UbuntuSansMono_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_SEMIBOLD20PT7B_H_
