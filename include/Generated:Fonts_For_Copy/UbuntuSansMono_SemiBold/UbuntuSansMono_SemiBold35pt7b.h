#ifndef _UBUNTUSANSMONO_SEMIBOLD35PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x80, 0x00, 0x03, 0x3E, 0xFF, 0xFF, 0xDE, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xEF, 0x0E, 0xF0, 0xE7, 0x0E, 0x60, 0xE0,
  0x03, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x01,
  0xC3, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x87, 0x80, 0xE1,
  0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x78, 0x0E,
  0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1C, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0xE0,
  0x3D, 0xFC, 0x07, 0x39, 0xC1, 0xC7, 0x38, 0x39, 0xC7, 0x0E, 0x38, 0xE3,
  0xC3, 0x1C, 0x70, 0x73, 0x9C, 0x0F, 0xF7, 0x81, 0xFC, 0xE0, 0x1F, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC4, 0x00, 0x73, 0xF0, 0x1E, 0xFE, 0x03, 0x9D,
  0xE0, 0xE3, 0x1C, 0x1C, 0xE3, 0x87, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0x39,
  0xCE, 0x07, 0x7B, 0xC0, 0xFE, 0xF0, 0x0F, 0x80, 0x00, 0x40, 0x03, 0xC0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3C, 0x38, 0x0E, 0x0F, 0x03,
  0x83, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0xBC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x87, 0x8F, 0xF1, 0xE7, 0xFE, 0x71, 0xE7, 0x9C, 0xF0, 0xFF,
  0x3C, 0x3F, 0xCF, 0x07, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3E, 0x1F, 0xC7,
  0xFF, 0xF8, 0xFF, 0xDE, 0x1F, 0xC7, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE6, 0x00, 0x40, 0x0E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x40, 0x07, 0x00, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x40, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6, 0x7B, 0x9E, 0xFD, 0xBE, 0xFF,
  0xFF, 0x3F, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x78, 0x3E,
  0x7C, 0x1C, 0x30, 0x08, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x1C, 0x1E,
  0x3E, 0x7E, 0x1E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFF,
  0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0,
  0x3C, 0xF0, 0x1F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x71, 0xEF, 0x3C, 0xFF,
  0x9E, 0x7F, 0xCF, 0x3D, 0xE3, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xF9, 0xF0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7D, 0xE0, 0x71, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8,
  0xFF, 0xFC, 0x78, 0x7C, 0x60, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x70, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x02, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0x80, 0xFF, 0xC1, 0xFF, 0xC4, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xF0, 0x02, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0x7C, 0x3E, 0x7E, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C,
  0xFC, 0x78, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0x00, 0x07,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x0F, 0xDE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7C,
  0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xCF, 0xFF, 0xFF, 0x7E, 0xF8, 0x1E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x3F, 0x7F, 0x3F, 0x3F, 0x0F,
  0x0E, 0x3E, 0xFC, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x3E, 0x00, 0xFF, 0x03,
  0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1E, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x0F, 0x81, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x60, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xE3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xE0, 0x07, 0x70, 0x7F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x7F, 0x3C, 0x3F, 0x1E, 0x1F, 0x8F, 0x0F, 0xC7,
  0x87, 0xE3, 0xC3, 0xF1, 0xE1, 0xFC, 0xF0, 0xFE, 0x7C, 0x7F, 0x1F, 0xFB,
  0x8F, 0xFD, 0xE1, 0xFE, 0xF0, 0x18, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0x81,
  0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0xF0, 0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xDE,
  0x00, 0xFF, 0xC0, 0x1F, 0x07, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFD, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF1, 0xF8, 0x31, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x09, 0xFE, 0x3C, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0xFC,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x31, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDF, 0x01, 0xEF,
  0x80, 0xF3, 0xE0, 0x79, 0xFC, 0x7C, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x18, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFA, 0x01, 0xE7, 0x8F,
  0xDF, 0xFF, 0x3F, 0xFE, 0x3F, 0xF0, 0x03, 0x00, 0xF0, 0x1F, 0x78, 0x1F,
  0x3C, 0x0F, 0x9E, 0x0F, 0x8F, 0x0F, 0x87, 0x87, 0xC3, 0xC7, 0xC1, 0xE7,
  0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xBF, 0x03, 0xCF, 0xC1, 0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x3E, 0x3C, 0x1F,
  0x9E, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x0F, 0x1F, 0x03,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x9F, 0x8E, 0xE7, 0x63, 0xB9,
  0xDC, 0xEE, 0x77, 0x33, 0x9D, 0xDC, 0xE7, 0x3F, 0x39, 0xCF, 0xCE, 0xF3,
  0xE3, 0xBC, 0x78, 0xEF, 0x1E, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00,
  0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F,
  0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E,
  0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01,
  0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B,
  0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x7C,
  0x1F, 0x0F, 0xCF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x20,
  0x00, 0x06, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E,
  0x7C, 0x0F, 0x0F, 0x8F, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x04, 0x06, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0x0F, 0xE7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x9E, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xE7,
  0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0x7C, 0x0C, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x1F, 0x40, 0x1F, 0x70, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF0, 0x03, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0x77,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC,
  0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF1, 0xC3, 0xBC, 0x78, 0xEF, 0x1E,
  0x3B, 0xCF, 0x8E, 0x73, 0xF3, 0x9C, 0xFC, 0xE7, 0x77, 0x39, 0xDC, 0xEE,
  0x77, 0x3B, 0x9F, 0x8E, 0xE7, 0xE1, 0xB9, 0xF8, 0x7E, 0x7C, 0x1F, 0x1F,
  0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x07, 0xDF, 0x03, 0xE3, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE1,
  0xF0, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x0F,
  0x07, 0xC3, 0xE1, 0xE0, 0x78, 0x78, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x03, 0xDF, 0x01, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x1F,
  0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x1F, 0x70, 0x07, 0x84, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x70, 0xFC, 0x7E,
  0x3F, 0x0E, 0x02, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE2, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFF,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x7F, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0x7C, 0xFE,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x7E, 0x02, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0x8F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x03, 0xDF, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C, 0x1F,
  0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x3F, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xFF, 0x01, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE1,
  0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x9E,
  0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0x08, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x7E, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xEF, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x30,
  0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x03, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF7,
  0x83, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x07, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE7, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x40, 0x79, 0xE3, 0xE7, 0xFF, 0xBF, 0xFC, 0x7F,
  0xE0, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x7E, 0xF0,
  0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF7, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE7, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x0C, 0x0C, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x3C, 0x7F, 0x8F, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1,
  0xFC, 0x78, 0xFE, 0x3C, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xE0, 0x1F, 0x83, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFE, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D,
  0xF0, 0x7C, 0x7E, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xFE, 0x7E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x0F, 0x7C, 0x0F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x7C, 0x0F, 0x7F, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFC, 0x3B, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0xCF, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x03,
  0xD0, 0x07, 0xBC, 0x3F, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0xE7, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x83,
  0xDF, 0x8F, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0xF8, 0x07, 0xFE, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0,
  0xF8, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF1, 0xE3,
  0xFC, 0x78, 0xEF, 0x1E, 0x3B, 0xCF, 0x8E, 0x73, 0xF3, 0x9C, 0xFC, 0xE7,
  0x77, 0x79, 0xDD, 0xFE, 0x77, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3C, 0x1F, 0x0F, 0x03, 0x80, 0xF8, 0x0F, 0x9F, 0x03, 0xC3, 0xE1,
  0xE0, 0x78, 0xF8, 0x0F, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x83, 0xC1, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0xBE, 0x01, 0xF0, 0x78,
  0x07, 0xBE, 0x07, 0xDF, 0x03, 0xE7, 0x81, 0xE3, 0xE0, 0xF1, 0xF0, 0x78,
  0x78, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x07, 0x9F, 0x03, 0xEF, 0x00, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x04, 0x7C, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x07, 0xF0,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x00, 0x0C, 0x02, 0x0F, 0xE0, 0xF7, 0xFE, 0x3D, 0xFF, 0xFE, 0xFB,
  0xFF, 0xBC, 0x3F, 0xC2, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 12, 11, 20, 4, -27 },
  { 36, 18, 24, 20, 1, -24 },
  { 90, 16, 31, 20, 2, -27 },
  { 152, 19, 26, 20, 0, -25 },
  { 214, 18, 25, 20, 1, -25 },
  { 271, 4, 12, 20, 8, -27 },
  { 277, 12, 35, 20, 4, -28 },
  { 330, 12, 35, 20, 4, -28 },
  { 383, 16, 15, 20, 2, -24 },
  { 413, 16, 17, 20, 2, -19 },
  { 447, 9, 12, 20, 5, -6 },
  { 461, 10, 4, 20, 5, -12 },
  { 466, 7, 6, 20, 6, -6 },
  { 472, 16, 33, 20, 2, -27 },
  { 538, 17, 26, 20, 1, -25 },
  { 594, 16, 24, 20, 2, -24 },
  { 642, 16, 25, 20, 2, -25 },
  { 692, 16, 26, 20, 2, -25 },
  { 744, 18, 24, 20, 1, -24 },
  { 798, 15, 25, 20, 2, -24 },
  { 845, 16, 25, 20, 2, -24 },
  { 895, 16, 24, 20, 2, -24 },
  { 943, 16, 26, 20, 2, -25 },
  { 995, 16, 25, 20, 2, -25 },
  { 1045, 7, 18, 20, 6, -18 },
  { 1061, 8, 24, 20, 5, -18 },
  { 1085, 16, 16, 20, 2, -18 },
  { 1117, 16, 11, 20, 2, -16 },
  { 1139, 16, 16, 20, 2, -18 },
  { 1171, 14, 25, 20, 3, -25 },
  { 1215, 17, 30, 20, 1, -25 },
  { 1279, 19, 24, 20, 0, -24 },
  { 1336, 16, 25, 20, 2, -25 },
  { 1386, 17, 26, 20, 1, -25 },
  { 1442, 16, 25, 20, 2, -25 },
  { 1492, 15, 24, 20, 3, -24 },
  { 1537, 14, 24, 20, 3, -24 },
  { 1579, 17, 26, 20, 1, -25 },
  { 1635, 16, 24, 20, 2, -24 },
  { 1683, 14, 24, 20, 3, -24 },
  { 1725, 15, 25, 20, 2, -24 },
  { 1772, 17, 24, 20, 2, -24 },
  { 1823, 15, 24, 20, 3, -24 },
  { 1868, 18, 24, 20, 1, -24 },
  { 1922, 16, 24, 20, 2, -24 },
  { 1970, 18, 26, 20, 1, -25 },
  { 2029, 16, 25, 20, 2, -25 },
  { 2079, 18, 32, 20, 1, -25 },
  { 2151, 17, 25, 20, 2, -25 },
  { 2205, 16, 26, 20, 2, -25 },
  { 2257, 17, 24, 20, 1, -24 },
  { 2308, 16, 25, 20, 2, -24 },
  { 2358, 18, 24, 20, 1, -24 },
  { 2412, 18, 24, 20, 1, -24 },
  { 2466, 18, 24, 20, 1, -24 },
  { 2520, 18, 24, 20, 1, -24 },
  { 2574, 16, 24, 20, 2, -24 },
  { 2622, 10, 33, 20, 5, -27 },
  { 2664, 16, 33, 20, 2, -27 },
  { 2730, 11, 33, 20, 4, -27 },
  { 2776, 18, 14, 20, 1, -24 },
  { 2808, 19, 3, 20, 0, 3 },
  { 2816, 8, 7, 20, 6, -27 },
  { 2823, 15, 19, 20, 2, -19 },
  { 2859, 15, 27, 20, 3, -27 },
  { 2910, 16, 19, 20, 2, -19 },
  { 2948, 16, 27, 20, 1, -27 },
  { 3002, 17, 19, 20, 1, -19 },
  { 3043, 17, 27, 20, 2, -27 },
  { 3101, 16, 26, 20, 1, -19 },
  { 3153, 14, 27, 20, 3, -27 },
  { 3201, 16, 27, 20, 2, -27 },
  { 3255, 14, 34, 20, 2, -27 },
  { 3315, 16, 27, 20, 3, -27 },
  { 3369, 16, 27, 20, 2, -27 },
  { 3423, 17, 19, 20, 1, -19 },
  { 3464, 14, 19, 20, 3, -19 },
  { 3498, 17, 19, 20, 1, -19 },
  { 3539, 15, 25, 20, 3, -19 },
  { 3586, 16, 25, 20, 1, -19 },
  { 3636, 14, 19, 20, 4, -19 },
  { 3670, 15, 19, 20, 2, -19 },
  { 3706, 16, 24, 20, 2, -24 },
  { 3754, 15, 18, 20, 2, -18 },
  { 3788, 18, 18, 20, 1, -18 },
  { 3829, 18, 18, 20, 1, -18 },
  { 3870, 18, 18, 20, 1, -18 },
  { 3911, 17, 25, 20, 1, -18 },
  { 3965, 14, 18, 20, 3, -18 },
  { 3997, 14, 33, 20, 3, -27 },
  { 4055, 4, 33, 20, 8, -27 },
  { 4072, 14, 33, 20, 3, -27 },
  { 4130, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_SEMIBOLD35PT7B_H_
