#ifndef _UBUNTUSANSMONO_SEMIBOLD49PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0x7F, 0x1F, 0x86, 0x00, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F,
  0xBE, 0x0F, 0x9F, 0x03, 0xCF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0,
  0x3C, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x83, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0x07, 0xE1, 0xFC, 0x00, 0xC7, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC8, 0x00, 0x3F, 0x9E, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0xFF,
  0x80, 0x1F, 0x1F, 0xF8, 0x03, 0xC7, 0xCF, 0x00, 0xF8, 0xF1, 0xF0, 0x3E,
  0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC1, 0xF0, 0x78, 0x78, 0x3C, 0x0F, 0x0F,
  0x0F, 0x81, 0xE1, 0xE3, 0xE0, 0x3C, 0x7C, 0x78, 0x07, 0x8F, 0x1F, 0x00,
  0xFF, 0xE7, 0xC0, 0x0F, 0xFC, 0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xCF, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x1E, 0x7F, 0xF0, 0x07, 0x8F,
  0x1E, 0x01, 0xF1, 0xE3, 0xE0, 0x3C, 0x3C, 0x3C, 0x0F, 0x87, 0x87, 0x83,
  0xE0, 0xF0, 0xF0, 0x78, 0x1E, 0x1E, 0x1F, 0x03, 0xC7, 0xC7, 0xC0, 0x78,
  0xF0, 0xF0, 0x0F, 0xBE, 0x3E, 0x00, 0xFF, 0xCF, 0x80, 0x1F, 0xF3, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x10, 0x03,
  0xFC, 0x0F, 0x83, 0xFF, 0x07, 0xC3, 0xFF, 0xC3, 0xE3, 0xF7, 0xE3, 0xE3,
  0xF3, 0xF9, 0xF1, 0xF8, 0xFE, 0xF8, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xFC,
  0x7E, 0x03, 0xFE, 0x3F, 0x00, 0xFF, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x1F,
  0xC3, 0xF0, 0x1F, 0xF1, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xBF, 0x07, 0xFF, 0x8F, 0xC1, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xF9, 0xE7, 0x9E, 0x00, 0x02, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x0C, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xC3, 0xE0,
  0xC7, 0xC7, 0x8F, 0x9F, 0xDE, 0xFE, 0xFF, 0xF7, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7D,
  0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x7C,
  0x01, 0xC0, 0xE0, 0x02, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xE1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x1E, 0x03, 0xE0, 0x7E,
  0x1F, 0xCF, 0xF8, 0x7F, 0x07, 0xE0, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFE, 0x1F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01,
  0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0x1F,
  0xFE, 0x3E, 0x1F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFC, 0x7F, 0xF1, 0xF8, 0xFF,
  0xE3, 0xE1, 0xFF, 0xC3, 0x83, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xC7, 0xE0, 0x08, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xC0, 0x7F, 0x0C, 0x00, 0xFC, 0x20, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0x80, 0x7F, 0x08, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF9, 0x80, 0x1F, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x60, 0x03, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x10, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xF8, 0xFF, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x3F, 0x0F, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0x87, 0xE0, 0x7F,
  0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0xC7, 0xE0, 0x3F,
  0x3F, 0x80, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x0C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x3F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0x82,
  0x00, 0x03, 0x03, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF,
  0x0F, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x3F, 0x0F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1F, 0xE1,
  0xFC, 0x0F, 0x81, 0xE0, 0x7C, 0x7F, 0x3F, 0xC7, 0xF0, 0xFC, 0x1E, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x20, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE,
  0xFF, 0xCC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xEF,
  0x80, 0xFF, 0xF7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFD, 0xF0, 0xFF, 0xFE,
  0xF8, 0x7F, 0xFF, 0x78, 0x7F, 0x1F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F, 0x07,
  0xFF, 0x1F, 0x83, 0xFF, 0x8F, 0xC1, 0xFF, 0xC7, 0xE0, 0xFF, 0xE3, 0xF0,
  0x7F, 0xF1, 0xF8, 0x3F, 0xF8, 0x7C, 0x1F, 0xBC, 0x3E, 0x0F, 0xDE, 0x1F,
  0x87, 0xEF, 0x8F, 0xE3, 0xF7, 0xC3, 0xFF, 0xFB, 0xE1, 0xFF, 0xFD, 0xF0,
  0x7F, 0xFE, 0x7C, 0x1F, 0xFF, 0x3E, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x10,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x7F, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE0, 0x0C, 0x3F, 0xC0, 0x04, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x0C,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x83, 0xFE, 0x3F,
  0x01, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x3F, 0xCF, 0xC1, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0x1F,
  0xE0, 0x02, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF3,
  0xF8, 0x07, 0xE7, 0xF8, 0x0F, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x84, 0x00, 0xFE, 0x3C, 0x07, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00,
  0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFD, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0xFC, 0x3F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x1E, 0xF0, 0xFF, 0x8F, 0x78,
  0xF7, 0xCF, 0xBC, 0x7B, 0xE7, 0xCF, 0x3D, 0xF3, 0xE7, 0xBC, 0xF9, 0xF3,
  0xDE, 0x7C, 0xF8, 0xFF, 0x3E, 0x7C, 0x7F, 0x9F, 0x3E, 0x3F, 0x8F, 0x9F,
  0x1F, 0xC7, 0xCF, 0x87, 0xE3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xFD,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x3F, 0xFB,
  0xF0, 0xFF, 0xE7, 0xC3, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0x7C,
  0xFF, 0xE1, 0xF3, 0xFF, 0x83, 0xCF, 0xFE, 0x0F, 0xBF, 0xF8, 0x1E, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x0F,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xEF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3C, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x81, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x01,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x07, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFE, 0x7E, 0x0F, 0xE0, 0x0C,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF2, 0x00, 0x0F, 0xE7, 0x00, 0x3F, 0x9F, 0xF3, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xF7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xFC,
  0x7C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E, 0x3F, 0xCF, 0x9F, 0x1F,
  0xE7, 0xCF, 0x9E, 0xF3, 0xE7, 0xCF, 0x79, 0xF3, 0xE7, 0x9E, 0xF9, 0xF7,
  0x8F, 0x7C, 0x7B, 0xC7, 0xBE, 0x3D, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F,
  0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x00, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE,
  0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xF3, 0xF0, 0x03,
  0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE1,
  0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0x87, 0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x20, 0x07, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7E, 0x03, 0x80, 0x10, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x08, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x7E, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFE, 0x01, 0x8F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x23, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x2E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFD, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xF7,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x81, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0x87, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x58, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF0, 0x78, 0x0F,
  0xE0, 0x04, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0x00, 0x20, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x40, 0x03, 0xF8, 0xE0,
  0x1F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x06, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x20, 0x0F, 0xCF, 0x83, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFE, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0xDF, 0x80, 0xFF, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8,
  0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80,
  0x3F, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x06, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0xFC,
  0x3E, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x3F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC,
  0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00,
  0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x07,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xC7, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x03, 0xF7, 0xF0, 0x0F, 0xDF,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F,
  0x81, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFB, 0xF0, 0x02, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0x80, 0x31, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x80, 0x03, 0xF7, 0x00, 0x1F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x06, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0x80, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x0D, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x83, 0xE0, 0xFB, 0xE0,
  0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE7, 0xC7, 0xF0, 0xF9,
  0xF1, 0xFE, 0x3C, 0x7C, 0x7F, 0x8F, 0x1F, 0x1F, 0xE7, 0xC7, 0xCF, 0x79,
  0xF0, 0xF3, 0xDF, 0x7C, 0x3C, 0xF3, 0xDF, 0x0F, 0x78, 0xF7, 0x83, 0xFE,
  0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1F,
  0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xF8, 0xFE,
  0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0xFE, 0x01,
  0xF8, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x02, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x06, 0x0F, 0xFC, 0x07, 0xC7, 0xFF, 0x83, 0xE7,
  0xFF, 0xF7, 0xF7, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xF9, 0xF0, 0x7F, 0xF9,
  0xF0, 0x0F, 0xF8, 0x18, 0x01, 0xF8, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 35, 27, 9, -34 },
  { 41, 17, 15, 27, 5, -37 },
  { 73, 25, 34, 27, 1, -34 },
  { 180, 23, 43, 27, 2, -38 },
  { 304, 27, 36, 27, 0, -35 },
  { 426, 25, 35, 27, 1, -35 },
  { 536, 6, 16, 27, 11, -37 },
  { 548, 17, 48, 27, 5, -39 },
  { 650, 17, 48, 27, 5, -39 },
  { 752, 22, 21, 27, 3, -34 },
  { 810, 23, 25, 27, 2, -27 },
  { 882, 12, 17, 27, 7, -9 },
  { 908, 14, 6, 27, 7, -17 },
  { 919, 9, 10, 27, 9, -9 },
  { 931, 22, 47, 27, 3, -38 },
  { 1061, 23, 36, 27, 2, -35 },
  { 1165, 22, 34, 27, 3, -34 },
  { 1259, 22, 35, 27, 3, -35 },
  { 1356, 22, 36, 27, 3, -35 },
  { 1455, 24, 34, 27, 2, -34 },
  { 1557, 22, 35, 27, 2, -34 },
  { 1654, 22, 35, 27, 3, -34 },
  { 1751, 22, 34, 27, 3, -34 },
  { 1845, 23, 36, 27, 2, -35 },
  { 1949, 22, 35, 27, 3, -35 },
  { 2046, 9, 27, 27, 9, -26 },
  { 2077, 11, 34, 27, 7, -26 },
  { 2124, 22, 24, 27, 3, -26 },
  { 2190, 23, 15, 27, 2, -22 },
  { 2234, 23, 24, 27, 2, -26 },
  { 2303, 19, 36, 27, 4, -35 },
  { 2389, 25, 42, 27, 1, -35 },
  { 2521, 27, 34, 27, 0, -34 },
  { 2636, 22, 34, 27, 3, -34 },
  { 2730, 24, 36, 27, 2, -35 },
  { 2838, 23, 34, 27, 3, -34 },
  { 2936, 21, 34, 27, 4, -34 },
  { 3026, 20, 34, 27, 4, -34 },
  { 3111, 23, 36, 27, 2, -35 },
  { 3215, 23, 34, 27, 2, -34 },
  { 3313, 20, 34, 27, 4, -34 },
  { 3398, 22, 35, 27, 2, -34 },
  { 3495, 24, 34, 27, 3, -34 },
  { 3597, 21, 34, 27, 4, -34 },
  { 3687, 25, 34, 27, 1, -34 },
  { 3794, 22, 34, 27, 3, -34 },
  { 3888, 24, 36, 27, 2, -35 },
  { 3996, 23, 34, 27, 3, -34 },
  { 4094, 24, 44, 27, 2, -35 },
  { 4226, 23, 34, 27, 3, -34 },
  { 4324, 23, 36, 27, 2, -35 },
  { 4428, 24, 34, 27, 2, -34 },
  { 4530, 23, 35, 27, 2, -34 },
  { 4631, 26, 34, 27, 1, -34 },
  { 4742, 25, 34, 27, 1, -34 },
  { 4849, 26, 34, 27, 1, -34 },
  { 4960, 26, 34, 27, 1, -34 },
  { 5071, 22, 34, 27, 3, -34 },
  { 5165, 14, 47, 27, 7, -38 },
  { 5248, 22, 47, 27, 3, -38 },
  { 5378, 15, 47, 27, 6, -38 },
  { 5467, 25, 20, 27, 1, -34 },
  { 5530, 27, 5, 27, 0, 4 },
  { 5547, 11, 10, 27, 9, -38 },
  { 5561, 21, 27, 27, 3, -26 },
  { 5632, 22, 39, 27, 4, -38 },
  { 5740, 23, 27, 27, 2, -26 },
  { 5818, 22, 39, 27, 2, -38 },
  { 5926, 23, 27, 27, 2, -26 },
  { 6004, 25, 38, 27, 2, -38 },
  { 6123, 22, 35, 27, 2, -26 },
  { 6220, 20, 38, 27, 4, -38 },
  { 6315, 23, 39, 27, 2, -38 },
  { 6428, 19, 47, 27, 3, -38 },
  { 6540, 23, 38, 27, 4, -38 },
  { 6650, 23, 39, 27, 2, -38 },
  { 6763, 24, 26, 27, 2, -26 },
  { 6841, 20, 26, 27, 4, -26 },
  { 6906, 24, 27, 27, 2, -26 },
  { 6987, 22, 35, 27, 4, -26 },
  { 7084, 22, 35, 27, 2, -26 },
  { 7181, 20, 26, 27, 5, -26 },
  { 7246, 21, 27, 27, 3, -26 },
  { 7317, 24, 34, 27, 2, -33 },
  { 7419, 21, 27, 27, 3, -26 },
  { 7490, 25, 26, 27, 1, -26 },
  { 7572, 26, 26, 27, 1, -26 },
  { 7657, 25, 26, 27, 1, -26 },
  { 7739, 25, 35, 27, 1, -26 },
  { 7849, 20, 26, 27, 4, -26 },
  { 7914, 20, 47, 27, 4, -38 },
  { 8032, 6, 47, 27, 11, -38 },
  { 8068, 20, 47, 27, 4, -38 },
  { 8186, 25, 9, 27, 1, -19 },
};

const GFXfont UbuntuSansMono_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold49pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUSANSMONO_SEMIBOLD49PT7B_H_
