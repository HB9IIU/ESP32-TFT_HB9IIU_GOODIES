#ifndef _UBUNTUSANSMONO_SEMIBOLD24PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFF, 0xE0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x18,
  0xCF, 0xFF, 0xFF, 0xF3, 0x9C, 0x39, 0x83, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0x30, 0x63, 0x06, 0x30, 0xE7, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0xE3, 0xFE, 0xF3, 0x9C, 0x03, 0x80, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x1E, 0x01, 0xC0, 0x3A, 0x07, 0xFF, 0xFF, 0xF8, 0x7C, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x1B, 0xE1, 0xBB, 0x0D, 0x98, 0xCC, 0xCE, 0x66, 0x61,
  0xF6, 0x0F, 0x70, 0x03, 0x00, 0x37, 0x83, 0xBE, 0x1B, 0x31, 0x99, 0x9C,
  0xCC, 0xC6, 0x6C, 0x3F, 0xE0, 0xF0, 0x1E, 0x03, 0xF0, 0x73, 0x86, 0x38,
  0x63, 0x87, 0x38, 0x77, 0x03, 0xE0, 0x3C, 0x67, 0xE6, 0xEF, 0xEC, 0x7E,
  0xC3, 0xCC, 0x1C, 0xE3, 0xE7, 0xFE, 0x3E, 0x70, 0xFF, 0xFE, 0xDB, 0x02,
  0x0F, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0F, 0x06, 0x02, 0x40,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0x0E,
  0x01, 0xC0, 0x38, 0x33, 0x77, 0xFF, 0xFF, 0xC3, 0xC0, 0xFC, 0x3B, 0xC7,
  0x30, 0x44, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF,
  0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7B, 0xDE, 0xF1, 0xBB,
  0xD8, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xF0, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x3C, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x73, 0xEE, 0x7C, 0xCF, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x71,
  0xFE, 0x1F, 0x80, 0x06, 0x03, 0x83, 0xE3, 0xF8, 0xFE, 0x33, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF,
  0xC0, 0x1F, 0x0F, 0xF3, 0xFF, 0x30, 0xE0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0xFF, 0x7F,
  0xE0, 0x3F, 0x0F, 0xF1, 0xFF, 0x20, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0xFC,
  0x1F, 0x81, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xD0, 0xFF, 0xFE, 0xFF,
  0x80, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xDC, 0x39, 0xC3,
  0x1C, 0x71, 0xCE, 0x1C, 0xE1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3F, 0xC7, 0xF8, 0xFF, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xF8, 0x7F, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xD0, 0xF7,
  0xFE, 0xFF, 0x00, 0x00, 0xC0, 0xF8, 0x7F, 0x1F, 0x03, 0x80, 0xE0, 0x1D,
  0x03, 0xFC, 0xFF, 0xDC, 0x3F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x79,
  0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x1F, 0x07, 0xF9, 0xEF, 0xB8, 0x76, 0x0E, 0xE1, 0xDC,
  0x73, 0xFE, 0x1F, 0x8F, 0xF9, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x7B,
  0xFE, 0x3F, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3B, 0x87, 0x7F, 0xE7, 0xFC, 0x7B, 0x80, 0xE0, 0x1C, 0x0F, 0x1F, 0xE3,
  0xF0, 0x78, 0x00, 0x77, 0xFE, 0xF0, 0x00, 0x00, 0x77, 0xFE, 0xF0, 0x39,
  0xF7, 0xCF, 0x00, 0x00, 0x00, 0x39, 0xF7, 0xCF, 0x1C, 0xEF, 0x18, 0x00,
  0x20, 0x1C, 0x0F, 0x8F, 0xE7, 0xF1, 0xF0, 0x3E, 0x07, 0xF0, 0x1F, 0xC0,
  0xFC, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x40, 0x0E, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xC0,
  0x78, 0x7F, 0x3F, 0x9F, 0xC1, 0xC0, 0x20, 0x00, 0x7E, 0x7F, 0xDF, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xFC, 0x38, 0xE7, 0x06, 0xE0, 0x6E,
  0x3F, 0xC7, 0xFC, 0xFF, 0xCE, 0x7C, 0xC7, 0xCC, 0x7C, 0xC7, 0xCE, 0x7C,
  0xF7, 0xE7, 0xFE, 0x3E, 0x60, 0x07, 0x00, 0x3F, 0xE1, 0xFE, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xDC, 0x0E, 0xE0, 0x73, 0x03,
  0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x1C, 0x7F, 0xE7, 0xFF, 0x38, 0x39, 0xC1,
  0xEE, 0x07, 0xE0, 0x38, 0x7F, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1,
  0xF8, 0x77, 0xFC, 0xFF, 0x9F, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xC1, 0xFE, 0x3F, 0xE7, 0x82, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x7C, 0x63, 0xFE, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E,
  0xE0, 0xEE, 0x1E, 0xE7, 0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0xBC, 0x17, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0E, 0xE1, 0xDF,
  0x39, 0xFF, 0x1F, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC3, 0xFF,
  0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x98, 0xF7, 0xFC,
  0x7F, 0x00, 0xE0, 0xFE, 0x0E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x70, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0E, 0xF0, 0xE7, 0x0E, 0x78, 0xE3, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0F, 0xE0, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xC0, 0x60, 0xE7, 0x0E, 0xF1, 0xEF, 0x1E, 0xD9, 0xED, 0xB6, 0xDB,
  0x6C, 0xF6, 0xCF, 0x6C, 0xE6, 0xCE, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x70, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9,
  0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xE0, 0xE0, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF,
  0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xEE,
  0x1D, 0xC3, 0xF8, 0x7F, 0x0E, 0xE7, 0xDF, 0xF3, 0xFC, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xEF, 0x0E, 0x71, 0xE3, 0xFC, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0x7E,
  0x01, 0xE0, 0x02, 0x7E, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x8E, 0x38, 0xE1, 0xCE, 0x1C,
  0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0x1F, 0x87, 0xFD, 0xFF, 0x38, 0x0E, 0x00,
  0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xD8, 0x7F, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xDE, 0x7B, 0xFE, 0x3F, 0x80, 0xF0, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0xE7, 0x07, 0x1C, 0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xE0, 0xC7, 0x07,
  0x30, 0x3B, 0x80, 0xDC, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC6, 0x6C, 0xE6, 0xCE,
  0x6C, 0xF6, 0xDB, 0x6D, 0xB6, 0xD9, 0xEF, 0x1E, 0xF1, 0xE7, 0x0E, 0x60,
  0xE0, 0x70, 0x3B, 0x83, 0x8E, 0x1C, 0x71, 0xC1, 0xCE, 0x07, 0xE0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3B, 0x81, 0xCE, 0x1C, 0x70,
  0xE1, 0xCE, 0x0E, 0xF0, 0x38, 0xF0, 0x3B, 0x81, 0xDC, 0x1C, 0x70, 0xE3,
  0x8E, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x0F, 0xC0, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xEF, 0xFD,
  0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3B, 0xC7, 0x9C, 0x71, 0xEF, 0x0E, 0xE0,
  0x76, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x41, 0x8F, 0x0F, 0x18, 0x3F, 0x07,
  0xF8, 0xFF, 0x00, 0xF0, 0x0E, 0x1F, 0xDF, 0xFB, 0xCF, 0xE0, 0xFC, 0x1F,
  0xC3, 0xBF, 0xF3, 0xFE, 0x20, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0x87, 0xFC, 0xFF, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1F, 0xC3, 0xF8,
  0x77, 0x0E, 0xE3, 0xDF, 0xF3, 0xFC, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xBC,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xF8, 0x9F, 0xF1,
  0xFE, 0x00, 0x20, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xB9, 0xFF,
  0x7F, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0x78,
  0xEF, 0xFC, 0x7F, 0x80, 0x0F, 0x07, 0xF9, 0xFF, 0xB8, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xF3, 0x1F, 0xE1, 0xFE, 0x01, 0x80,
  0xFF, 0x0F, 0xF1, 0xE1, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x0F, 0x87, 0xFD, 0xFF, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xEE, 0x3D, 0xFF, 0x9F, 0xF0, 0x0E, 0x03, 0xD0, 0x73,
  0xFE, 0xFF, 0x81, 0x00, 0x20, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xE3, 0xFE, 0xFF, 0xB8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1C, 0x08, 0x03, 0x80, 0x78, 0x0E, 0x00, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x21, 0xFC, 0x1F, 0x80, 0x01, 0x00, 0xE0, 0x78, 0x0E,
  0x01, 0x00, 0x03, 0xFC, 0xFF, 0x3F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x63, 0x9F, 0xEF, 0xF0,
  0x20, 0x20, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0x1E,
  0xE7, 0x9C, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xFC, 0x3B, 0xC7, 0x3C, 0xE3,
  0x9C, 0x3B, 0x87, 0x80, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x21, 0xFC, 0x1F, 0x80, 0x79, 0xCF, 0xFE, 0xFF, 0xEC,
  0xE7, 0xCE, 0x7C, 0xE7, 0xCE, 0x7C, 0xE7, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x70, 0x7E, 0x3F, 0xEF, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x0F, 0x03, 0xFC, 0x7F,
  0xCF, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0x0E, 0x79,
  0xE7, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xF3, 0xFE, 0x71, 0xEE, 0x1D, 0xC3,
  0xB8, 0x7F, 0x0F, 0xE1, 0xDC, 0x3B, 0xDF, 0x7F, 0xCF, 0xF1, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x0F, 0x87, 0xFD, 0xFF, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xE7, 0xBF, 0xF3, 0xFE, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x1F, 0x1F, 0xEF, 0xFB, 0x80,
  0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x7C, 0x3F, 0xFE, 0xFF, 0x00,
  0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE2, 0x0F, 0xE0, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0x1D, 0xFF, 0x3F, 0xC0, 0xF0, 0x3B, 0x81, 0xDC, 0x1C, 0xF0, 0xE3,
  0x87, 0x1C, 0x70, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0x7E, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xC6, 0x76, 0x73, 0xB3,
  0x9D, 0x9E, 0xCD, 0xF6, 0x7D, 0xB1, 0xE7, 0x8F, 0x3C, 0x71, 0xC3, 0x86,
  0x00, 0xE0, 0xF7, 0x0E, 0x71, 0xC3, 0xBC, 0x1F, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x83, 0x9C, 0x71, 0xCF, 0x0E, 0xE0, 0xF0, 0xE0, 0x7E, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x06, 0x00,
  0xFF, 0xBF, 0xEF, 0xF8, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x1C,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC7, 0xF1, 0xFC, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xC0, 0xF0, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF0, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3F, 0x0F, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x0F, 0x07, 0xC3,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0x0F, 0xC0,
  0x7C, 0x7F, 0xFF, 0xEF, 0xEC, 0x3C,
};

const GFXglyph UbuntuSansMono_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 17, 13, 5, -17 },
  { 10, 8, 7, 13, 3, -18 },
  { 17, 12, 17, 13, 1, -17 },
  { 43, 11, 22, 13, 1, -19 },
  { 74, 13, 17, 13, 0, -17 },
  { 102, 12, 17, 13, 1, -17 },
  { 128, 3, 8, 13, 5, -18 },
  { 131, 8, 24, 13, 3, -19 },
  { 155, 8, 24, 13, 3, -19 },
  { 179, 11, 11, 13, 1, -17 },
  { 195, 11, 12, 13, 1, -13 },
  { 212, 5, 8, 13, 4, -4 },
  { 217, 7, 3, 13, 3, -8 },
  { 220, 5, 4, 13, 4, -4 },
  { 223, 11, 23, 13, 1, -19 },
  { 255, 11, 17, 13, 1, -17 },
  { 279, 10, 17, 13, 2, -17 },
  { 301, 11, 17, 13, 1, -17 },
  { 325, 11, 17, 13, 1, -17 },
  { 349, 12, 17, 13, 1, -17 },
  { 375, 11, 17, 13, 1, -17 },
  { 399, 11, 17, 13, 1, -17 },
  { 423, 11, 17, 13, 1, -17 },
  { 447, 11, 17, 13, 1, -17 },
  { 471, 11, 17, 13, 1, -17 },
  { 495, 5, 12, 13, 4, -12 },
  { 503, 6, 16, 13, 3, -12 },
  { 515, 11, 12, 13, 1, -13 },
  { 532, 11, 8, 13, 1, -11 },
  { 543, 11, 12, 13, 1, -13 },
  { 560, 9, 17, 13, 2, -17 },
  { 580, 12, 21, 13, 1, -17 },
  { 612, 13, 17, 13, 0, -17 },
  { 640, 11, 17, 13, 1, -17 },
  { 664, 12, 17, 13, 1, -17 },
  { 690, 12, 17, 13, 1, -17 },
  { 716, 10, 17, 13, 2, -17 },
  { 738, 10, 17, 13, 2, -17 },
  { 760, 11, 17, 13, 1, -17 },
  { 784, 11, 17, 13, 1, -17 },
  { 808, 10, 17, 13, 2, -17 },
  { 830, 11, 17, 13, 1, -17 },
  { 854, 12, 17, 13, 1, -17 },
  { 880, 10, 17, 13, 2, -17 },
  { 902, 12, 17, 13, 1, -17 },
  { 928, 11, 17, 13, 1, -17 },
  { 952, 12, 17, 13, 1, -17 },
  { 978, 11, 17, 13, 2, -17 },
  { 1002, 12, 22, 13, 1, -17 },
  { 1035, 12, 17, 13, 1, -17 },
  { 1061, 11, 17, 13, 1, -17 },
  { 1085, 12, 17, 13, 1, -17 },
  { 1111, 11, 17, 13, 1, -17 },
  { 1135, 13, 17, 13, 0, -17 },
  { 1163, 12, 17, 13, 1, -17 },
  { 1189, 13, 17, 13, 0, -17 },
  { 1217, 13, 17, 13, 0, -17 },
  { 1245, 11, 17, 13, 1, -17 },
  { 1269, 7, 23, 13, 3, -19 },
  { 1290, 11, 23, 13, 1, -19 },
  { 1322, 7, 23, 13, 3, -19 },
  { 1343, 12, 10, 13, 1, -17 },
  { 1358, 13, 2, 13, 0, 2 },
  { 1362, 6, 5, 13, 4, -19 },
  { 1366, 11, 13, 13, 1, -13 },
  { 1384, 11, 19, 13, 2, -19 },
  { 1411, 11, 13, 13, 1, -13 },
  { 1429, 11, 19, 13, 1, -19 },
  { 1456, 11, 13, 13, 1, -13 },
  { 1474, 12, 19, 13, 1, -19 },
  { 1503, 11, 18, 13, 1, -13 },
  { 1528, 10, 19, 13, 2, -19 },
  { 1552, 11, 19, 13, 1, -19 },
  { 1579, 10, 24, 13, 1, -19 },
  { 1609, 11, 19, 13, 2, -19 },
  { 1636, 11, 19, 13, 1, -19 },
  { 1663, 12, 13, 13, 1, -13 },
  { 1683, 10, 13, 13, 2, -13 },
  { 1700, 12, 13, 13, 1, -13 },
  { 1720, 11, 17, 13, 2, -13 },
  { 1744, 11, 17, 13, 1, -13 },
  { 1768, 9, 13, 13, 3, -13 },
  { 1783, 10, 13, 13, 2, -13 },
  { 1800, 12, 16, 13, 1, -16 },
  { 1824, 10, 13, 13, 2, -13 },
  { 1841, 13, 13, 13, 0, -13 },
  { 1863, 13, 13, 13, 0, -13 },
  { 1885, 12, 13, 13, 1, -13 },
  { 1905, 12, 18, 13, 1, -13 },
  { 1932, 10, 13, 13, 2, -13 },
  { 1949, 10, 23, 13, 2, -19 },
  { 1978, 3, 23, 13, 5, -19 },
  { 1987, 10, 23, 13, 2, -19 },
  { 2016, 12, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_SEMIBOLD24PT7B_H_
