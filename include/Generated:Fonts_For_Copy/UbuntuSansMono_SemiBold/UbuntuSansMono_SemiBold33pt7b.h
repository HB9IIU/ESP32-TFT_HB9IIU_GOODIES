#ifndef _UBUNTUSANSMONO_SEMIBOLD33PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE3,
  0x80, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x77, 0x0E, 0xE1, 0xCC, 0x38, 0x07, 0x8F, 0x03,
  0xC7, 0x01, 0xC3, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xC3,
  0x80, 0xE3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0x38, 0x0E,
  0x1C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3E, 0x3C, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x70, 0x1F, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xF8,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x01,
  0xDF, 0xC0, 0xE7, 0x70, 0x39, 0x8E, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x86,
  0x39, 0xC1, 0x8C, 0xE0, 0x7F, 0x38, 0x1F, 0xDC, 0x03, 0xEE, 0x00, 0x03,
  0x80, 0x01, 0xCF, 0x00, 0xF7, 0xE0, 0x3B, 0xF8, 0x1C, 0xE7, 0x07, 0x39,
  0xC3, 0x8E, 0x71, 0xC3, 0x9C, 0x70, 0xE7, 0x38, 0x39, 0xDC, 0x07, 0xEF,
  0x01, 0xF8, 0x00, 0x10, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0x8F,
  0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0F,
  0xF0, 0x07, 0xE2, 0x03, 0xF1, 0xE3, 0xF8, 0xF3, 0xDE, 0x73, 0xC7, 0xB9,
  0xE1, 0xFC, 0xF0, 0xFE, 0x78, 0x3E, 0x3C, 0x0F, 0x1F, 0x0F, 0xC7, 0xFF,
  0xF1, 0xFF, 0x78, 0x7F, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x00,
  0xC0, 0x38, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF0, 0x06, 0x20, 0x07, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x03, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x02, 0x1C, 0x27, 0x39, 0xDF, 0xEF, 0xBF, 0xFF, 0x9F, 0xFC, 0x07, 0xC0,
  0x1F, 0xC0, 0x7B, 0xC3, 0xE7, 0xC3, 0xC7, 0x01, 0x0C, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F,
  0x0E, 0x0E, 0x7C, 0xF8, 0xF0, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF1, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF0, 0x8F, 0x70, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x1E, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x1E, 0xF0, 0x31, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xC6, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xE1,
  0xFF, 0xE3, 0x87, 0xC4, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF6, 0x07, 0xEF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xF8, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFE,
  0x01, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xF0, 0x3F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x01, 0x00, 0x00, 0x78, 0x07,
  0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xF3, 0xE3, 0xE7, 0xFF,
  0x87, 0xFF, 0x07, 0xF8, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC3, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x3C, 0xFC, 0xF0, 0xFF, 0xC0, 0xFF,
  0x83, 0xFF, 0x8F, 0x1F, 0xBC, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x01, 0x80, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFB, 0xFF, 0xF3, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFD, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0x7C, 0x0E, 0x1F, 0x3F, 0x3F,
  0x3F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F,
  0x1F, 0x07, 0x0E, 0xBE, 0x7C, 0x78, 0x40, 0x00, 0x0C, 0x00, 0x78, 0x07,
  0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0x80, 0x78, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x01, 0xF0,
  0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F,
  0x00, 0xFE, 0x0F, 0xFC, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xC7, 0xFF, 0x3F, 0xFC, 0xC3, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x0E,
  0x38, 0x0F, 0x78, 0x07, 0x70, 0x07, 0x70, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xE3, 0xC7, 0xE3, 0x87, 0xE7, 0x87, 0xE7, 0x87, 0xE7, 0x87, 0xE7, 0x87,
  0xE3, 0x87, 0xE3, 0xC7, 0xF3, 0xFF, 0x71, 0xFF, 0x70, 0xFF, 0x78, 0x3C,
  0x38, 0x00, 0x3C, 0x00, 0x1F, 0x02, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFE,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xEE, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xDE,
  0x01, 0xFF, 0x80, 0x3C, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xCF, 0xEF,
  0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0xCF, 0xFF, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x8E, 0x3E, 0x01, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x06, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x60,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x9F, 0xCF, 0x07, 0xDE, 0x07, 0xBC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7,
  0x8F, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x0E, 0x3E,
  0x02, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x0F, 0x3C, 0x0F, 0x3F, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0x40, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF4,
  0x07, 0xDC, 0x3E, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x01, 0x80, 0xF0, 0x3E,
  0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xE0,
  0xF3, 0xC0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xF7, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xF3,
  0xF1, 0xF9, 0xF8, 0xDC, 0xEC, 0xEE, 0x77, 0x77, 0x3B, 0xB3, 0xBD, 0xF9,
  0xDE, 0x7C, 0xEF, 0x3C, 0x77, 0x9E, 0x3B, 0xC7, 0x1D, 0xE0, 0x0E, 0xF0,
  0x07, 0x78, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3B,
  0xC0, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C,
  0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x07, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x1E,
  0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xCF, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x7E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0E, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF3, 0xFC,
  0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1F, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xE3, 0xE0, 0xCF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0xFF, 0x03, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC3, 0xE7, 0xFF,
  0xCF, 0xFF, 0x07, 0xFC, 0x00, 0x80, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0x80,
  0x7D, 0xE0, 0x1E, 0x7C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C,
  0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x0E, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x07,
  0xF8, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xF1, 0xC7, 0x79, 0xE3, 0xBC, 0xF1, 0xDE, 0x7C, 0xEF,
  0x7E, 0x73, 0xBB, 0x39, 0xDD, 0xDC, 0xEC, 0xEE, 0x7E, 0x37, 0x3F, 0x1F,
  0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF8,
  0x0F, 0xBC, 0x07, 0x9F, 0x07, 0x87, 0x83, 0xC3, 0xE3, 0xC0, 0xF3, 0xE0,
  0x7D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3E,
  0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x3E,
  0x0F, 0xBE, 0x03, 0xDF, 0x01, 0xF3, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x40, 0xC3, 0xC7, 0xE7, 0xE3, 0xC1, 0x00, 0x0F, 0xC1,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC1, 0xEF,
  0x3F, 0xFD, 0xFF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83,
  0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0x08, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE,
  0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xE7, 0xC0, 0x5F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC1, 0x9F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0x9E, 0x3F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x83, 0xDF, 0x87,
  0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x06,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x70, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0x82, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0xC1, 0xEF, 0xCF,
  0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF7,
  0x8F, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x08, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB, 0x83, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xC1, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xD0, 0x3C,
  0xF3, 0xE7, 0xFF, 0x7F, 0xF0, 0xFF, 0x00, 0x08, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x0C, 0x10,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x07, 0x83,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7E, 0x3E,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0x81, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x1F, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFC, 0x0B, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0xE3,
  0xFF, 0x9F, 0xFE, 0x78, 0x09, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0xF7, 0x07, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x18, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3D, 0xF0, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xE7, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x0F,
  0x3C, 0x07, 0xDE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D,
  0xC3, 0x8F, 0x70, 0xE3, 0xDC, 0x78, 0xE7, 0x9F, 0x39, 0xE7, 0xCE, 0x7B,
  0xF3, 0x8E, 0xFC, 0xE3, 0xBB, 0xB8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xC7,
  0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0xF8, 0x0F, 0x3E, 0x0F,
  0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xE3, 0xC1,
  0xE1, 0xF1, 0xF0, 0x78, 0xF0, 0x1E, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x4F,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0x80, 0x1E, 0x02, 0x1F, 0xC3, 0xDF, 0xFB, 0xCF, 0xFF, 0xEF,
  0x1F, 0xE7, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 23, 18, 6, -23 },
  { 19, 11, 10, 18, 4, -25 },
  { 33, 17, 23, 18, 1, -23 },
  { 82, 16, 30, 18, 1, -26 },
  { 142, 18, 24, 18, 0, -23 },
  { 196, 17, 23, 18, 1, -23 },
  { 245, 4, 11, 18, 7, -25 },
  { 251, 11, 32, 18, 4, -26 },
  { 295, 12, 32, 18, 3, -26 },
  { 343, 15, 14, 18, 2, -23 },
  { 370, 15, 17, 18, 2, -18 },
  { 402, 8, 12, 18, 5, -6 },
  { 414, 10, 4, 18, 4, -11 },
  { 419, 6, 6, 18, 6, -6 },
  { 424, 15, 32, 18, 2, -26 },
  { 484, 16, 24, 18, 1, -23 },
  { 532, 15, 23, 18, 2, -23 },
  { 576, 15, 23, 18, 2, -23 },
  { 620, 15, 24, 18, 2, -23 },
  { 665, 16, 23, 18, 1, -23 },
  { 711, 14, 24, 18, 2, -23 },
  { 753, 15, 24, 18, 2, -23 },
  { 798, 15, 23, 18, 2, -23 },
  { 842, 15, 24, 18, 2, -23 },
  { 887, 15, 23, 18, 2, -23 },
  { 931, 6, 17, 18, 6, -17 },
  { 944, 8, 23, 18, 4, -17 },
  { 967, 15, 15, 18, 2, -17 },
  { 996, 15, 11, 18, 2, -15 },
  { 1017, 15, 15, 18, 2, -17 },
  { 1046, 13, 23, 18, 3, -23 },
  { 1084, 16, 28, 18, 1, -23 },
  { 1140, 18, 23, 18, 0, -23 },
  { 1192, 15, 23, 18, 2, -23 },
  { 1236, 16, 24, 18, 1, -23 },
  { 1284, 15, 23, 18, 2, -23 },
  { 1328, 14, 23, 18, 3, -23 },
  { 1369, 13, 23, 18, 3, -23 },
  { 1407, 16, 24, 18, 1, -23 },
  { 1455, 15, 23, 18, 2, -23 },
  { 1499, 14, 23, 18, 2, -23 },
  { 1540, 14, 24, 18, 2, -23 },
  { 1582, 16, 23, 18, 2, -23 },
  { 1628, 14, 23, 18, 3, -23 },
  { 1669, 17, 23, 18, 1, -23 },
  { 1718, 15, 23, 18, 2, -23 },
  { 1762, 16, 24, 18, 1, -23 },
  { 1810, 15, 23, 18, 2, -23 },
  { 1854, 16, 29, 18, 1, -23 },
  { 1912, 16, 23, 18, 2, -23 },
  { 1958, 15, 24, 18, 2, -23 },
  { 2003, 16, 23, 18, 1, -23 },
  { 2049, 15, 24, 18, 2, -23 },
  { 2094, 18, 23, 18, 0, -23 },
  { 2146, 17, 23, 18, 1, -23 },
  { 2195, 17, 23, 18, 1, -23 },
  { 2244, 18, 23, 18, 0, -23 },
  { 2296, 15, 23, 18, 2, -23 },
  { 2340, 9, 32, 18, 5, -26 },
  { 2376, 15, 32, 18, 2, -26 },
  { 2436, 10, 32, 18, 4, -26 },
  { 2476, 17, 13, 18, 1, -23 },
  { 2504, 18, 3, 18, 0, 3 },
  { 2511, 7, 7, 18, 6, -26 },
  { 2518, 14, 18, 18, 2, -18 },
  { 2550, 15, 26, 18, 2, -26 },
  { 2599, 15, 18, 18, 2, -18 },
  { 2633, 15, 26, 18, 1, -26 },
  { 2682, 16, 18, 18, 1, -18 },
  { 2718, 16, 26, 18, 2, -26 },
  { 2770, 15, 24, 18, 1, -18 },
  { 2815, 14, 26, 18, 2, -26 },
  { 2861, 15, 25, 18, 2, -25 },
  { 2908, 13, 31, 18, 2, -25 },
  { 2959, 16, 26, 18, 2, -26 },
  { 3011, 15, 25, 18, 2, -25 },
  { 3058, 16, 18, 18, 1, -18 },
  { 3094, 14, 18, 18, 2, -18 },
  { 3126, 16, 18, 18, 1, -18 },
  { 3162, 15, 24, 18, 2, -18 },
  { 3207, 15, 24, 18, 1, -18 },
  { 3252, 14, 18, 18, 3, -18 },
  { 3284, 14, 18, 18, 2, -18 },
  { 3316, 15, 22, 18, 2, -22 },
  { 3358, 14, 17, 18, 2, -17 },
  { 3388, 17, 17, 18, 1, -17 },
  { 3425, 18, 17, 18, 0, -17 },
  { 3464, 17, 17, 18, 1, -17 },
  { 3501, 16, 23, 18, 1, -17 },
  { 3547, 13, 17, 18, 3, -17 },
  { 3575, 13, 32, 18, 3, -26 },
  { 3627, 4, 32, 18, 7, -26 },
  { 3643, 14, 32, 18, 2, -26 },
  { 3699, 17, 6, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_SEMIBOLD33PT7B_H_
