#ifndef _UBUNTUSANSMONO_SEMIBOLD18PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x06, 0xF6, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x19, 0x86, 0x61, 0x93, 0xFF, 0xFF, 0xCC, 0xC3, 0x33, 0xFF, 0xFF, 0xC9,
  0x86, 0x61, 0x98, 0x18, 0x18, 0x3F, 0x7F, 0xE0, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0x03, 0x83, 0xFF, 0x7C, 0x18, 0x18, 0x70, 0x5C, 0x2D, 0x9B, 0x6C,
  0xDA, 0x1D, 0x82, 0xC0, 0x2E, 0x1A, 0xCD, 0xB2, 0x6D, 0x9B, 0xC3, 0x80,
  0x1C, 0x0F, 0x86, 0x61, 0x98, 0x36, 0x0F, 0x03, 0x99, 0xF6, 0x6F, 0xB1,
  0xC6, 0x31, 0xFE, 0x3D, 0xC0, 0xFF, 0xF0, 0x0C, 0x73, 0x9C, 0x63, 0x8C,
  0x30, 0xC3, 0x0C, 0x38, 0x61, 0xC3, 0x07, 0x0C, 0xC3, 0x83, 0x0E, 0x18,
  0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x63, 0x18, 0xC0, 0x18, 0x59, 0xFF,
  0x7E, 0x3C, 0x7E, 0x26, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x77, 0x73, 0xEC, 0xFF, 0xF0, 0x6F, 0x60, 0x03, 0x06, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60,
  0xE0, 0x1C, 0x7E, 0x67, 0xC3, 0xC3, 0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xE7,
  0x7E, 0x3C, 0x1C, 0x7C, 0xFC, 0x5C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x7F, 0x7F, 0x38, 0xFE, 0xC6, 0x07, 0x07, 0x06, 0x0E, 0x1C, 0x38, 0x70,
  0x60, 0xFF, 0xFF, 0x38, 0xFE, 0x46, 0x07, 0x06, 0x3E, 0x3C, 0x0F, 0x03,
  0x03, 0x07, 0xFE, 0xFC, 0x0E, 0x0F, 0x07, 0x86, 0xC6, 0x63, 0x33, 0x19,
  0xFF, 0xFF, 0x83, 0x01, 0x80, 0xC0, 0x7F, 0x60, 0x60, 0x60, 0x78, 0x7E,
  0x07, 0x03, 0x03, 0x07, 0xFE, 0xFC, 0x02, 0x1E, 0x3D, 0x70, 0x60, 0xFC,
  0xFE, 0xC7, 0xC3, 0xC3, 0xE3, 0x7E, 0x3E, 0xFF, 0x07, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3,
  0x76, 0x3C, 0x6E, 0xC3, 0xC3, 0xC3, 0xFF, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3,
  0xC3, 0xC3, 0xFF, 0x7F, 0x07, 0x06, 0x0E, 0x7C, 0x70, 0x6F, 0x60, 0x00,
  0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00, 0xCF, 0x38, 0xBC, 0xC0, 0x07, 0x1F,
  0x7C, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0xF8, 0x3E, 0x07, 0x0F, 0x3E, 0xF0, 0xC0, 0x79, 0xFA, 0x30, 0x70,
  0xC3, 0x8E, 0x18, 0x60, 0x00, 0xC3, 0x87, 0x00, 0x0E, 0x1F, 0x8C, 0x6C,
  0x36, 0x7A, 0x7D, 0x37, 0xB3, 0xD9, 0xA6, 0xD3, 0xEC, 0xF6, 0x01, 0x80,
  0x7E, 0x0F, 0x1E, 0x07, 0x81, 0xE0, 0x4C, 0x33, 0x0C, 0xC3, 0x31, 0xFE,
  0x7F, 0x98, 0x66, 0x1F, 0x87, 0x78, 0xFE, 0xC7, 0xC3, 0xC7, 0xCE, 0xFE,
  0xC7, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0x1E, 0x3F, 0x71, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0x70, 0xFE, 0xCE, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xE0, 0xE0, 0xE0,
  0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x3F, 0x71, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x7F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0xC7, 0x63, 0x33,
  0x9B, 0x8D, 0x87, 0xC3, 0x71, 0x98, 0xCE, 0x63, 0xB0, 0xD8, 0x70, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE3, 0x73,
  0xB9, 0xDC, 0xEF, 0xF6, 0xDB, 0x6D, 0xB6, 0xC3, 0x61, 0xB0, 0xF8, 0x70,
  0xC3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0xC3,
  0x1C, 0x3F, 0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0xC3, 0x61, 0xB8,
  0xCF, 0xC3, 0xC0, 0x78, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xF8,
  0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x3F, 0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0F,
  0x87, 0xC3, 0x61, 0xB0, 0xCF, 0xC3, 0xE0, 0xC0, 0x78, 0x0E, 0x78, 0x7F,
  0x33, 0xD8, 0x6C, 0x36, 0x3B, 0xF9, 0xF8, 0xCC, 0x63, 0x31, 0xD8, 0x6C,
  0x38, 0x3C, 0x7F, 0xE2, 0xC0, 0xE0, 0x70, 0x7C, 0x0F, 0x07, 0x03, 0x03,
  0xFF, 0xFE, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0x7E, 0xE1, 0xD8, 0x66, 0x19, 0x86, 0x33, 0x8C, 0xC3, 0x30, 0xCC,
  0x1E, 0x07, 0x81, 0xE0, 0x30, 0xC3, 0xE1, 0xB0, 0xD8, 0x6D, 0xB6, 0xDB,
  0xFD, 0xFE, 0xE7, 0x73, 0xB9, 0xD8, 0x60, 0x61, 0xCC, 0xC3, 0x30, 0x78,
  0x1E, 0x03, 0x01, 0xE0, 0x7C, 0x33, 0x0C, 0xE6, 0x1B, 0x87, 0xE1, 0xD8,
  0x67, 0x38, 0xCC, 0x3B, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0x60, 0xFF,
  0xFF, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xFC, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C,
  0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0xFF, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFC, 0x0E, 0x07, 0x83, 0xF0,
  0xCC, 0x73, 0xB8, 0x72, 0x10, 0xFF, 0xFF, 0xF0, 0x4E, 0x71, 0x3C, 0x7E,
  0x47, 0x03, 0x3F, 0xFF, 0xC3, 0xC3, 0xFF, 0x7F, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFC, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFC, 0x0E, 0x3F,
  0x71, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0x07, 0x07, 0x07, 0x07,
  0x3F, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x1C, 0x7E,
  0xE7, 0xC3, 0xFF, 0xFF, 0xC0, 0xE0, 0x7F, 0x3F, 0x0F, 0x8F, 0xCE, 0x06,
  0x03, 0x07, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x1C, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x03, 0x07, 0xFE,
  0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xF8, 0xFE, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0x30, 0x38, 0x30, 0x00, 0x00, 0xF8, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x18, 0x1F, 0x1F, 0x0C, 0x1C, 0x30, 0x00, 0x0F, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xBF, 0xFC, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x3B, 0xB9, 0xF8, 0xF8, 0x7C, 0x3B, 0x1D, 0xCE, 0x77, 0x1C,
  0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x1F, 0x1F, 0x66, 0xFF, 0xDB, 0xD9, 0xD9, 0xD9, 0xC1, 0xC1, 0xC1, 0xC1,
  0x38, 0xFE, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x18, 0x7E,
  0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3E, 0x38, 0xFE, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0x1C, 0x7F, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7F, 0x03, 0x03, 0x03, 0x3D, 0xFF,
  0xDE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1C, 0x7E, 0xE2, 0xE0, 0x78,
  0x3E, 0x07, 0x03, 0xFF, 0xFE, 0x30, 0x30, 0x30, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3,
  0x7F, 0x3F, 0xE1, 0xD8, 0x67, 0x38, 0xCC, 0x33, 0x0F, 0xC1, 0xE0, 0x78,
  0x0C, 0x00, 0xC0, 0xF0, 0x34, 0xCD, 0x32, 0x7E, 0x9F, 0xE7, 0x39, 0xCE,
  0x33, 0x00, 0x71, 0x8C, 0xC1, 0xE0, 0x78, 0x0E, 0x07, 0x83, 0x31, 0xCE,
  0xE1, 0xC0, 0x61, 0xB8, 0xCC, 0xE6, 0x63, 0xB0, 0xD8, 0x78, 0x1C, 0x0E,
  0x06, 0x1F, 0x1F, 0x00, 0x7F, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xFF,
  0xFF, 0x1F, 0x1F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0xF0, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x07, 0x0F, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xF8, 0x71, 0xFF, 0xA3, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 6, 10, 2, -14 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 8, 16, 10, 1, -14 },
  { 43, 10, 13, 10, 0, -13 },
  { 60, 10, 13, 10, 0, -13 },
  { 77, 2, 6, 10, 4, -14 },
  { 79, 6, 17, 10, 2, -14 },
  { 92, 6, 17, 10, 2, -14 },
  { 105, 8, 7, 10, 1, -12 },
  { 112, 8, 9, 10, 1, -10 },
  { 121, 4, 6, 10, 3, -3 },
  { 124, 6, 2, 10, 2, -6 },
  { 126, 4, 3, 10, 3, -3 },
  { 128, 8, 17, 10, 1, -14 },
  { 145, 8, 13, 10, 1, -13 },
  { 158, 8, 12, 10, 1, -12 },
  { 170, 8, 13, 10, 1, -13 },
  { 183, 8, 13, 10, 1, -13 },
  { 196, 9, 12, 10, 1, -12 },
  { 210, 8, 12, 10, 1, -12 },
  { 222, 8, 13, 10, 1, -13 },
  { 235, 8, 12, 10, 1, -12 },
  { 247, 8, 13, 10, 1, -13 },
  { 260, 8, 13, 10, 1, -13 },
  { 273, 4, 9, 10, 3, -9 },
  { 278, 5, 12, 10, 2, -9 },
  { 286, 8, 8, 10, 1, -9 },
  { 294, 8, 6, 10, 1, -8 },
  { 300, 8, 8, 10, 1, -9 },
  { 308, 7, 13, 10, 2, -13 },
  { 320, 9, 16, 10, 0, -13 },
  { 338, 10, 12, 10, 0, -12 },
  { 353, 8, 13, 10, 1, -13 },
  { 366, 8, 13, 10, 1, -13 },
  { 379, 8, 13, 10, 1, -13 },
  { 392, 8, 12, 10, 1, -12 },
  { 404, 8, 12, 10, 1, -12 },
  { 416, 8, 13, 10, 1, -13 },
  { 429, 8, 12, 10, 1, -12 },
  { 441, 8, 12, 10, 1, -12 },
  { 453, 8, 12, 10, 1, -12 },
  { 465, 9, 12, 10, 1, -12 },
  { 479, 7, 12, 10, 2, -12 },
  { 490, 9, 12, 10, 1, -12 },
  { 504, 8, 12, 10, 1, -12 },
  { 516, 9, 13, 10, 1, -13 },
  { 531, 8, 13, 10, 1, -13 },
  { 544, 9, 16, 10, 1, -13 },
  { 562, 9, 13, 10, 1, -13 },
  { 577, 8, 13, 10, 1, -13 },
  { 590, 8, 12, 10, 1, -12 },
  { 602, 8, 12, 10, 1, -12 },
  { 614, 10, 12, 10, 0, -12 },
  { 629, 9, 12, 10, 1, -12 },
  { 643, 10, 12, 10, 0, -12 },
  { 658, 10, 12, 10, 0, -12 },
  { 673, 8, 12, 10, 1, -12 },
  { 685, 6, 17, 10, 2, -14 },
  { 698, 8, 17, 10, 1, -14 },
  { 715, 6, 17, 10, 2, -14 },
  { 728, 10, 7, 10, 0, -12 },
  { 737, 10, 2, 10, 0, 1 },
  { 740, 4, 4, 10, 3, -14 },
  { 742, 8, 10, 10, 1, -10 },
  { 752, 8, 14, 10, 1, -14 },
  { 766, 8, 10, 10, 1, -10 },
  { 776, 8, 14, 10, 1, -14 },
  { 790, 8, 10, 10, 1, -10 },
  { 800, 9, 14, 10, 1, -14 },
  { 816, 8, 13, 10, 1, -10 },
  { 829, 8, 14, 10, 1, -14 },
  { 843, 8, 14, 10, 1, -14 },
  { 857, 7, 17, 10, 1, -14 },
  { 872, 9, 14, 10, 1, -14 },
  { 888, 8, 14, 10, 1, -14 },
  { 902, 8, 10, 10, 1, -10 },
  { 912, 8, 10, 10, 1, -10 },
  { 922, 8, 10, 10, 1, -10 },
  { 932, 8, 13, 10, 1, -10 },
  { 945, 8, 13, 10, 1, -10 },
  { 958, 7, 10, 10, 2, -10 },
  { 967, 8, 10, 10, 1, -10 },
  { 977, 8, 12, 10, 1, -12 },
  { 989, 8, 9, 10, 1, -9 },
  { 998, 10, 9, 10, 0, -9 },
  { 1010, 10, 9, 10, 0, -9 },
  { 1022, 10, 9, 10, 0, -9 },
  { 1034, 9, 12, 10, 0, -9 },
  { 1048, 8, 9, 10, 1, -9 },
  { 1057, 8, 17, 10, 1, -14 },
  { 1074, 2, 17, 10, 4, -14 },
  { 1079, 8, 17, 10, 1, -14 },
  { 1096, 9, 3, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_SEMIBOLD18PT7B_H_
