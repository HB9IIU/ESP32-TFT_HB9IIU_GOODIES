#ifndef _UBUNTUSANSMONO_SEMIBOLD22PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x66, 0x02, 0xFF, 0x70, 0xE7, 0xE7, 0xE7,
  0x67, 0x67, 0x67, 0x62, 0x0E, 0x60, 0xCE, 0x0C, 0xC1, 0xCC, 0xFF, 0xFF,
  0xFF, 0x19, 0xC1, 0x9C, 0x19, 0x8F, 0xFF, 0xFF, 0xF3, 0x38, 0x33, 0x83,
  0x30, 0x73, 0x00, 0x0C, 0x03, 0x01, 0xF0, 0xFF, 0x7F, 0xB8, 0x0E, 0x01,
  0xC0, 0x7E, 0x0F, 0xE0, 0x7C, 0x07, 0x01, 0xE0, 0x7F, 0xFF, 0xFE, 0x3E,
  0x03, 0x00, 0xC0, 0x30, 0x07, 0x83, 0x4C, 0x6C, 0xCC, 0xCC, 0xCC, 0xD8,
  0x7B, 0x07, 0xB0, 0x06, 0x00, 0xDE, 0x0D, 0xB1, 0x93, 0x39, 0x33, 0x13,
  0x61, 0xFE, 0x1E, 0x08, 0x07, 0xC1, 0xDC, 0x31, 0x86, 0x30, 0xCE, 0x1F,
  0x81, 0xE0, 0x7C, 0xDF, 0x9B, 0x3B, 0x63, 0xCC, 0x39, 0xC7, 0xBF, 0xF3,
  0xE7, 0xFF, 0xFD, 0xB0, 0x06, 0x0F, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x38, 0x1C, 0x1E, 0x0F,
  0x02, 0x60, 0xF0, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0xF0, 0x60, 0x0E, 0x03,
  0x06, 0xCF, 0xDF, 0x7F, 0xC7, 0x83, 0xB1, 0xEE, 0x33, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x39, 0xE7, 0xCE, 0x18, 0xEF, 0x10, 0xFF, 0xFF, 0xC0, 0x6F, 0xF7, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x00, 0x0C, 0x0F, 0xC7, 0xF9, 0xC7, 0xE1, 0xF8, 0x3E, 0x4F, 0xB3,
  0xEE, 0xFB, 0x3E, 0x0F, 0x83, 0xE1, 0xDC, 0xE7, 0xF8, 0xFC, 0x06, 0x07,
  0x87, 0xE3, 0xF8, 0x6E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x1F, 0xF7, 0xFC, 0x0C, 0x1F, 0xCF, 0xF9, 0x0E, 0x01, 0xC0,
  0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x0F, 0xFF,
  0xFF, 0x1C, 0x3F, 0xC7, 0xF9, 0x0E, 0x01, 0x80, 0x60, 0x38, 0x7C, 0x1F,
  0x80, 0xF0, 0x1C, 0x07, 0x01, 0xD0, 0xFF, 0xFB, 0xFC, 0x03, 0x80, 0xF0,
  0x3E, 0x0F, 0xC1, 0xB8, 0x67, 0x1C, 0xE3, 0x1C, 0xE3, 0x9F, 0xFF, 0xFF,
  0x81, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0x8F, 0xE3, 0x00, 0xC0, 0x30,
  0x1E, 0x07, 0xF1, 0xFE, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x83, 0xFF, 0xEF,
  0xF0, 0x07, 0x87, 0xE3, 0xC1, 0xE0, 0x70, 0x1B, 0x8F, 0xFB, 0xFF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xF0, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0x0E, 0x0F, 0xE7, 0xF9, 0x87, 0xE1, 0xF8, 0x77, 0x19,
  0xFE, 0x3F, 0x1D, 0xEE, 0x1F, 0x83, 0xE0, 0xF8, 0x77, 0xFC, 0xFC, 0x0C,
  0x0F, 0xC7, 0xF9, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0xCF, 0xF0,
  0x1C, 0x0E, 0x07, 0x87, 0xC7, 0xE1, 0xE0, 0x6F, 0xF7, 0x00, 0x00, 0x6F,
  0xF7, 0x33, 0xDE, 0x70, 0x00, 0x00, 0x33, 0xDE, 0x71, 0xBB, 0x90, 0x00,
  0x40, 0x70, 0x7C, 0xFE, 0xFC, 0x3C, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xF0,
  0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x18,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x70, 0x7C, 0x7E, 0xFE, 0x3C, 0x04, 0x00,
  0x18, 0x7F, 0x3F, 0xD0, 0xE0, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E,
  0x00, 0x01, 0x01, 0xC0, 0xF0, 0x70, 0x06, 0x07, 0xF1, 0xEF, 0x30, 0x6E,
  0x0D, 0x8F, 0xF3, 0xFE, 0x77, 0xDC, 0xFB, 0x9F, 0x73, 0xEE, 0x7C, 0xCF,
  0x9F, 0xF9, 0xFB, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0x00, 0xF0,
  0x0F, 0x81, 0xF8, 0x1D, 0x81, 0x9C, 0x19, 0xC3, 0x8C, 0x30, 0xC3, 0xFE,
  0x7F, 0xE7, 0x0E, 0x70, 0x66, 0x07, 0xE0, 0x70, 0xFF, 0x3F, 0xEE, 0x1F,
  0x87, 0xE1, 0xF8, 0xEF, 0xF3, 0xFE, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xFF, 0xEF, 0xF0, 0x07, 0x07, 0xF3, 0xFD, 0xC1, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x13, 0xFC, 0x7F, 0xFF,
  0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC1, 0xB8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1B, 0x87, 0x70, 0xEE, 0x79, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x07, 0x07, 0xF3, 0xFD, 0xC1, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xDE, 0x33,
  0xFC, 0x7F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xFF, 0xC7,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7,
  0xFF, 0xFE, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x43, 0xBF, 0xE7, 0xF0, 0xE1, 0xFC, 0x73,
  0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x07, 0xE0, 0xEE, 0x1C, 0xE3, 0x9E,
  0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x38, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xE1,
  0xDC, 0x3B, 0xCF, 0x79, 0xED, 0x3D, 0xB5, 0xB7, 0xB6, 0x76, 0xCC, 0xD9,
  0x9B, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x38, 0xE0, 0xFC, 0x3F, 0x0F,
  0xE3, 0xF8, 0xFF, 0x3E, 0xCF, 0xBB, 0xE6, 0xF9, 0xFE, 0x3F, 0x8F, 0xE1,
  0xF8, 0x7E, 0x0C, 0x0C, 0x07, 0xE1, 0xFE, 0x38, 0xEE, 0x1D, 0xC1, 0xB8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x6E, 0x1C, 0xE3, 0x9F, 0xE1,
  0xF8, 0xFF, 0x9F, 0xFB, 0x87, 0x70, 0x6E, 0x0F, 0xC1, 0xB8, 0x77, 0xFE,
  0xFF, 0x9F, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07,
  0xE1, 0xFE, 0x38, 0xEE, 0x1D, 0xC1, 0xB8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x83, 0xF0, 0x6E, 0x1C, 0xE3, 0x9F, 0xE1, 0xF8, 0x0C, 0x01, 0xE0, 0x1F,
  0x00, 0xE0, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7,
  0xFC, 0xFF, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x38, 0x0E,
  0x0F, 0xF7, 0xF9, 0x82, 0xE0, 0x38, 0x07, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x1C, 0x07, 0x01, 0xD0, 0x7F, 0xF9, 0xFC, 0xFF, 0xFF, 0xFC, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xF1, 0xDF, 0xE3, 0xF0, 0xE0,
  0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE3, 0x0E, 0x38, 0xC3, 0x8C, 0x19,
  0xC1, 0x98, 0x1D, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x99, 0xB3, 0xB6, 0xF6, 0xDE, 0xDB, 0x5B,
  0x4F, 0x79, 0xEF, 0x1D, 0xC3, 0x98, 0x70, 0x70, 0x73, 0x0E, 0x39, 0xC1,
  0x9C, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x19, 0xC3,
  0x9C, 0x30, 0xE7, 0x0E, 0xF0, 0x70, 0xF0, 0x77, 0x06, 0x70, 0xE3, 0x8E,
  0x39, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xDF, 0xF0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xE0, 0x1C, 0x07, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xFF, 0xFC, 0x0E, 0x03, 0xC0, 0xFC, 0x1D, 0xC7, 0x38, 0xE3, 0xB8, 0x77,
  0x07, 0x40, 0x80, 0xFF, 0xFF, 0xFF, 0x47, 0x1E, 0x60, 0x3E, 0x1F, 0xE3,
  0x78, 0x07, 0x01, 0xCF, 0xF7, 0xFF, 0x87, 0xE1, 0xF8, 0x77, 0xFC, 0xFF,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8F, 0xF3, 0xFE, 0xC3, 0xB0,
  0x6C, 0x1B, 0x07, 0xC1, 0xB0, 0xEC, 0x7B, 0xFC, 0xFE, 0x00, 0x0F, 0x8F,
  0xF7, 0xFD, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1E, 0x13, 0xFC,
  0x7F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC7, 0x77, 0xFD, 0xFF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1D, 0xFF, 0x3F, 0xC0, 0x1E,
  0x0F, 0xE7, 0xBF, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x17,
  0xFC, 0x7F, 0x07, 0xE3, 0xFC, 0x71, 0x8E, 0x01, 0x81, 0xFF, 0xBF, 0xF7,
  0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x1F, 0x0F, 0xF7, 0xBF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xDF, 0xF3, 0xFC, 0x07, 0x01, 0xD0, 0xEF, 0xFB, 0xF8, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0xE3, 0xFD, 0xFE, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x80, 0x18, 0x0F, 0x03, 0xC0, 0x60, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xE4, 0x3F, 0x07, 0xC0, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x03, 0xFD, 0xFE,
  0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xD9, 0xCF, 0xEF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xEC,
  0x7B, 0x1C, 0xCE, 0x37, 0x0F, 0x83, 0xF0, 0xDE, 0x33, 0x8C, 0x73, 0x0E,
  0xC1, 0xC0, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE4, 0x3F, 0x07, 0xC0,
  0x73, 0x9F, 0xFB, 0xFF, 0x66, 0x7C, 0xCF, 0x99, 0xF3, 0x3E, 0x67, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x70, 0x7C, 0x7F, 0xBF, 0xD8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x1E, 0x07, 0xF1, 0xFF, 0x70,
  0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x06, 0xE1, 0xCE, 0x79, 0xFE, 0x1F, 0x80,
  0x7C, 0x7F, 0xBF, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC3, 0xF1, 0xFF,
  0xDF, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x1F, 0x0F, 0xF7, 0xFF, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x77, 0xFC, 0xFF, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x1F, 0x7F, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x00, 0x1F, 0x0F, 0xE7, 0xB9, 0x80, 0x70, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xD0, 0x77, 0xFB, 0xFC, 0x18, 0x06, 0x01, 0x83, 0xFF,
  0xFF, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x47,
  0xF0, 0xFC, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xF1, 0xFF, 0xEF, 0xF0, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x38, 0xE3,
  0x9C, 0x39, 0xC1, 0xD8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x60, 0xE0, 0x3E,
  0x03, 0x60, 0x36, 0x67, 0x67, 0x76, 0x76, 0x6F, 0x66, 0xF6, 0x69, 0xE3,
  0x9E, 0x38, 0xE3, 0x0C, 0xE0, 0xFC, 0x39, 0xCE, 0x1D, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF8, 0x3B, 0x8E, 0x73, 0x87, 0x70, 0x70, 0xE0, 0xFC, 0x19,
  0x87, 0x38, 0xE7, 0x18, 0x63, 0x0E, 0xE1, 0xDC, 0x1B, 0x03, 0xE0, 0x38,
  0x07, 0x00, 0xE1, 0x38, 0x3E, 0x07, 0x80, 0xFF, 0x7F, 0xBF, 0xC1, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x1F, 0x8F, 0xCE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x78, 0x38, 0x1E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0C, 0x07, 0xC1, 0xE1, 0xF0, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x1F, 0x0F, 0x80, 0x30, 0x8F, 0x9F, 0xFF, 0x63, 0xE4, 0x10,
};

const GFXglyph UbuntuSansMono_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 8, 7, 12, 2, -17 },
  { 16, 12, 15, 12, 0, -15 },
  { 39, 10, 19, 12, 1, -17 },
  { 63, 12, 16, 12, 0, -16 },
  { 87, 11, 16, 12, 1, -16 },
  { 109, 3, 7, 12, 5, -17 },
  { 112, 8, 21, 12, 2, -17 },
  { 133, 8, 21, 12, 2, -17 },
  { 154, 10, 9, 12, 1, -15 },
  { 166, 10, 11, 12, 1, -12 },
  { 180, 6, 8, 12, 3, -4 },
  { 186, 6, 3, 12, 3, -8 },
  { 189, 4, 4, 12, 4, -4 },
  { 191, 10, 21, 12, 1, -17 },
  { 218, 10, 16, 12, 1, -16 },
  { 238, 10, 15, 12, 1, -15 },
  { 257, 10, 16, 12, 1, -16 },
  { 277, 10, 16, 12, 1, -16 },
  { 297, 11, 15, 12, 1, -15 },
  { 318, 10, 15, 12, 1, -15 },
  { 337, 10, 15, 12, 1, -15 },
  { 356, 10, 15, 12, 1, -15 },
  { 375, 10, 16, 12, 1, -16 },
  { 395, 10, 16, 12, 1, -16 },
  { 415, 4, 12, 12, 4, -12 },
  { 421, 5, 16, 12, 3, -12 },
  { 431, 10, 11, 12, 1, -12 },
  { 445, 10, 7, 12, 1, -10 },
  { 454, 10, 11, 12, 1, -12 },
  { 468, 9, 16, 12, 2, -16 },
  { 486, 11, 19, 12, 1, -16 },
  { 513, 12, 15, 12, 0, -15 },
  { 536, 10, 15, 12, 1, -15 },
  { 555, 10, 16, 12, 1, -16 },
  { 575, 11, 15, 12, 1, -15 },
  { 596, 9, 15, 12, 2, -15 },
  { 613, 9, 15, 12, 2, -15 },
  { 630, 10, 16, 12, 1, -16 },
  { 650, 10, 15, 12, 1, -15 },
  { 669, 9, 15, 12, 2, -15 },
  { 686, 10, 15, 12, 1, -15 },
  { 705, 11, 15, 12, 1, -15 },
  { 726, 9, 15, 12, 2, -15 },
  { 743, 11, 15, 12, 1, -15 },
  { 764, 10, 15, 12, 1, -15 },
  { 783, 11, 16, 12, 1, -16 },
  { 805, 11, 15, 12, 1, -15 },
  { 826, 11, 20, 12, 1, -16 },
  { 854, 11, 15, 12, 1, -15 },
  { 875, 10, 16, 12, 1, -16 },
  { 895, 11, 15, 12, 1, -15 },
  { 916, 10, 15, 12, 1, -15 },
  { 935, 12, 15, 12, 0, -15 },
  { 958, 11, 15, 12, 1, -15 },
  { 979, 12, 15, 12, 0, -15 },
  { 1002, 12, 15, 12, 0, -15 },
  { 1025, 10, 15, 12, 1, -15 },
  { 1044, 7, 21, 12, 3, -17 },
  { 1063, 10, 21, 12, 1, -17 },
  { 1090, 6, 21, 12, 3, -17 },
  { 1106, 11, 9, 12, 1, -15 },
  { 1119, 12, 2, 12, 0, 2 },
  { 1122, 5, 4, 12, 4, -17 },
  { 1125, 10, 12, 12, 1, -12 },
  { 1140, 10, 17, 12, 2, -17 },
  { 1162, 10, 12, 12, 1, -12 },
  { 1177, 10, 17, 12, 1, -17 },
  { 1199, 10, 12, 12, 1, -12 },
  { 1214, 11, 17, 12, 1, -17 },
  { 1238, 10, 16, 12, 1, -12 },
  { 1258, 9, 17, 12, 2, -17 },
  { 1278, 10, 17, 12, 1, -17 },
  { 1300, 9, 21, 12, 1, -17 },
  { 1324, 10, 17, 12, 2, -17 },
  { 1346, 10, 17, 12, 1, -17 },
  { 1368, 11, 12, 12, 1, -12 },
  { 1385, 9, 12, 12, 2, -12 },
  { 1399, 11, 12, 12, 1, -12 },
  { 1416, 9, 16, 12, 2, -12 },
  { 1434, 10, 16, 12, 1, -12 },
  { 1454, 9, 12, 12, 2, -12 },
  { 1468, 10, 12, 12, 1, -12 },
  { 1483, 10, 15, 12, 1, -15 },
  { 1502, 9, 12, 12, 2, -12 },
  { 1516, 12, 12, 12, 0, -12 },
  { 1534, 12, 12, 12, 0, -12 },
  { 1552, 11, 12, 12, 1, -12 },
  { 1569, 11, 16, 12, 1, -12 },
  { 1591, 9, 12, 12, 2, -12 },
  { 1605, 9, 21, 12, 2, -17 },
  { 1629, 3, 21, 12, 5, -17 },
  { 1637, 9, 21, 12, 2, -17 },
  { 1661, 11, 5, 12, 1, -9 },
};

const GFXfont UbuntuSansMono_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_SEMIBOLD22PT7B_H_
