#ifndef _UBUNTUSANSMONO_SEMIBOLD42PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC2, 0x00, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xC1, 0xE7, 0x07, 0x9C,
  0x0E, 0x70, 0x38, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00,
  0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE1, 0xF0,
  0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00,
  0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7C,
  0x7E, 0x00, 0x47, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x40, 0x03, 0xF7, 0x80, 0x7E, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0x00, 0x3C, 0xFF, 0x00, 0xF3, 0xFE, 0x03, 0xC7, 0x9E, 0x07,
  0x8E, 0x3C, 0x1E, 0x1C, 0x78, 0x38, 0x38, 0x70, 0xF0, 0x71, 0xE3, 0xC0,
  0xE3, 0xC7, 0x81, 0xE7, 0x9E, 0x03, 0xFE, 0x78, 0x03, 0xFC, 0xF0, 0x07,
  0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x79, 0xF0, 0x01,
  0xE7, 0xF0, 0x03, 0xDF, 0xF0, 0x0F, 0x3D, 0xE0, 0x1C, 0x71, 0xE0, 0x78,
  0xE3, 0xC1, 0xE3, 0xC7, 0x83, 0xC7, 0x8F, 0x0F, 0x0F, 0x1E, 0x3C, 0x0E,
  0x3C, 0x78, 0x1E, 0x79, 0xE0, 0x3F, 0xE7, 0x80, 0x3F, 0xDF, 0x00, 0x3F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x0F,
  0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xDF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x0F, 0x07, 0xF8, 0x3C,
  0x3F, 0xF0, 0xF0, 0xFF, 0xE3, 0xC7, 0xCF, 0xDF, 0x1E, 0x1F, 0xFC, 0xF8,
  0x3F, 0xE3, 0xE0, 0x7F, 0x8F, 0x80, 0xFE, 0x3E, 0x03, 0xF0, 0xF8, 0x07,
  0xE1, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0xF8,
  0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E,
  0x79, 0xC0, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x1E,
  0x00, 0x10, 0x30, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x03, 0x0F, 0x0C, 0xF9, 0xE7, 0x9F, 0xBB, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0xFB, 0xE0, 0x1F, 0x3E, 0x0F, 0xE7, 0xE0, 0xF8, 0x7C, 0x0F, 0x0E, 0x00,
  0x40, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xFF,
  0x3F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07, 0x83, 0xEF, 0xF3, 0xF8, 0x7C, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0xF1, 0xFF,
  0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8E, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x79, 0xF8, 0x18, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF8, 0xF8, 0x3F, 0x8C, 0x03, 0xF1, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x70, 0x3F, 0x08, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xEE, 0x03, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C,
  0x07, 0xC3, 0xC0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x60, 0x1F, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x3F, 0x3F, 0x0F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x3F, 0x8F,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE3,
  0xFC, 0x7C, 0x0F, 0xE7, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xEF, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x1F,
  0x9F, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0xC3, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x1F, 0x0F, 0xE3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7,
  0xE0, 0x78, 0x1E, 0x1F, 0x3F, 0x8F, 0xE3, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x60, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x03,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xC0, 0x3F, 0xDE, 0x0F, 0xFE, 0xF0, 0xFF, 0xF7, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC3, 0xE3, 0xFE, 0x3E, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87,
  0xFC, 0x7C, 0x3F, 0xE3, 0xE1, 0xFF, 0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xE7,
  0xC3, 0xFF, 0x1F, 0x1F, 0x78, 0xFF, 0xFB, 0xC3, 0xFF, 0xDE, 0x0F, 0xFE,
  0xF8, 0x3F, 0xE3, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFD, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x83, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x7E, 0x7C, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xF8, 0x1F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7E, 0xF8, 0x3F, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0x0E,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x23,
  0xFC, 0x0E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x1C, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0x87, 0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07,
  0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0xFC,
  0xF8, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0x0E, 0x7F, 0x00, 0x27, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x80, 0x3F, 0x78, 0x1F, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x7E,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0xFE,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x83, 0xF9, 0xFE,
  0x1F, 0xCF, 0x70, 0xFE, 0x7B, 0x8F, 0xF3, 0xDE, 0x77, 0x9E, 0xF3, 0xBC,
  0xF3, 0xBD, 0xE7, 0x9D, 0xEF, 0xBC, 0xFE, 0x7D, 0xE3, 0xF3, 0xEF, 0x1F,
  0x9F, 0x78, 0xF8, 0xFB, 0xC7, 0xC7, 0xDE, 0x1E, 0x3E, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0x78, 0x7F,
  0xEF, 0x8F, 0xFC, 0xF1, 0xFF, 0x9E, 0x3F, 0xF1, 0xE7, 0xFE, 0x3C, 0xFF,
  0xC3, 0xDF, 0xF8, 0x7B, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x83,
  0xF0, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0xC0, 0x3E,
  0x3E, 0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x81, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0x83, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0xFD, 0xF0, 0x07, 0xCF, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF8, 0x3F,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x38, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF8, 0x7F, 0x8F, 0x81, 0xF8, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x87, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFC, 0x03, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x40, 0x03, 0xEF, 0x01, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC,
  0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7,
  0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0x78, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x1E, 0x3E, 0xF1, 0xF1, 0xF7, 0x8F,
  0x8F, 0xBC, 0x7E, 0x7D, 0xE3, 0xF3, 0xEF, 0x3F, 0x9F, 0x79, 0xFE, 0xFB,
  0xCE, 0xF7, 0x9E, 0xF3, 0xBC, 0xF7, 0x9D, 0xE7, 0xB8, 0xFF, 0x3F, 0xC3,
  0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0xF9, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF8,
  0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x3E, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xCE, 0x00, 0x38, 0x08,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x0C, 0x03, 0xC1, 0xF8, 0xFF, 0x0F,
  0xE0, 0xFC, 0x0E, 0x01, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x20, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x0C, 0x7C, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x03, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE1, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xF0, 0xFE, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x81, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFC, 0x04, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x63, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0x0F, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8,
  0x3F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7D, 0xF8, 0x0F, 0xBF, 0x01, 0xF3, 0xF8, 0x3E, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x81, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x18,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x07, 0x8F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC8, 0x01,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x84, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0,
  0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x86, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x04, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x60,
  0x7E, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x08,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x3F,
  0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0xF9,
  0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F,
  0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x86, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0x9F, 0x8F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBE, 0x0F, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x60, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7C,
  0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x3F, 0x3E, 0x03,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xDF, 0x01, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3E, 0xFF, 0x07, 0xC3, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x0F,
  0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xFC, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x04, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x00,
  0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC3, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x60, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x0C, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0x7C, 0x1F, 0x01, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x3F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7B, 0xE1, 0xE1, 0xEF, 0x8F, 0x87, 0xBE, 0x3F, 0x1E, 0x78,
  0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x9F, 0xC7, 0x9E, 0x7F, 0x9E, 0x79, 0xDE,
  0xF1, 0xE7, 0x7B, 0xC7, 0xBC, 0xEF, 0x0E, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x80, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xC3, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x87,
  0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xFB,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFB, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x78, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x3C, 0xFF, 0xC1,
  0xE3, 0xFF, 0xCF, 0x9F, 0xFF, 0xFE, 0x7C, 0xFF, 0xF3, 0xE0, 0xFF, 0xCF,
  0x01, 0xFE, 0x04, 0x00, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 7, 30, 24, 8, -29 },
  { 28, 14, 13, 24, 5, -32 },
  { 51, 22, 29, 24, 1, -29 },
  { 131, 20, 38, 24, 2, -33 },
  { 226, 23, 31, 24, 0, -30 },
  { 316, 22, 30, 24, 1, -30 },
  { 399, 6, 14, 24, 9, -32 },
  { 410, 14, 41, 24, 5, -33 },
  { 482, 15, 41, 24, 4, -33 },
  { 559, 19, 18, 24, 2, -29 },
  { 602, 20, 21, 24, 2, -23 },
  { 655, 10, 14, 24, 6, -7 },
  { 673, 12, 6, 24, 6, -15 },
  { 682, 8, 8, 24, 8, -7 },
  { 690, 18, 41, 24, 3, -33 },
  { 783, 20, 31, 24, 2, -30 },
  { 861, 18, 29, 24, 3, -29 },
  { 927, 19, 30, 24, 2, -30 },
  { 999, 19, 31, 24, 2, -30 },
  { 1073, 21, 29, 24, 1, -29 },
  { 1150, 19, 30, 24, 2, -29 },
  { 1222, 19, 30, 24, 2, -29 },
  { 1294, 18, 29, 24, 3, -29 },
  { 1360, 20, 31, 24, 2, -30 },
  { 1438, 19, 30, 24, 2, -30 },
  { 1510, 8, 23, 24, 8, -22 },
  { 1533, 10, 29, 24, 6, -22 },
  { 1570, 20, 20, 24, 2, -22 },
  { 1620, 20, 13, 24, 2, -19 },
  { 1653, 20, 20, 24, 2, -22 },
  { 1703, 16, 31, 24, 4, -30 },
  { 1765, 21, 36, 24, 1, -30 },
  { 1860, 23, 29, 24, 0, -29 },
  { 1944, 19, 29, 24, 3, -29 },
  { 2013, 20, 31, 24, 2, -30 },
  { 2091, 19, 29, 24, 3, -29 },
  { 2160, 19, 29, 24, 3, -29 },
  { 2229, 18, 29, 24, 3, -29 },
  { 2295, 20, 31, 24, 2, -30 },
  { 2373, 19, 29, 24, 2, -29 },
  { 2442, 18, 29, 24, 3, -29 },
  { 2508, 18, 30, 24, 2, -29 },
  { 2576, 21, 29, 24, 2, -29 },
  { 2653, 18, 29, 24, 4, -29 },
  { 2719, 21, 29, 24, 1, -29 },
  { 2796, 19, 29, 24, 2, -29 },
  { 2865, 21, 31, 24, 1, -30 },
  { 2947, 19, 29, 24, 3, -29 },
  { 3016, 21, 38, 24, 1, -30 },
  { 3116, 20, 29, 24, 3, -29 },
  { 3189, 19, 31, 24, 2, -30 },
  { 3263, 21, 29, 24, 1, -29 },
  { 3340, 20, 30, 24, 2, -29 },
  { 3415, 22, 29, 24, 1, -29 },
  { 3495, 21, 29, 24, 1, -29 },
  { 3572, 22, 29, 24, 1, -29 },
  { 3652, 22, 29, 24, 1, -29 },
  { 3732, 19, 29, 24, 2, -29 },
  { 3801, 12, 41, 24, 6, -33 },
  { 3863, 18, 41, 24, 3, -33 },
  { 3956, 13, 41, 24, 5, -33 },
  { 4023, 22, 17, 24, 1, -29 },
  { 4070, 23, 5, 24, 0, 3 },
  { 4085, 10, 9, 24, 7, -33 },
  { 4097, 19, 24, 24, 2, -23 },
  { 4154, 19, 34, 24, 3, -33 },
  { 4235, 20, 24, 24, 2, -23 },
  { 4295, 19, 34, 24, 1, -33 },
  { 4376, 20, 24, 24, 2, -23 },
  { 4436, 21, 33, 24, 2, -33 },
  { 4523, 19, 31, 24, 2, -23 },
  { 4597, 18, 33, 24, 3, -33 },
  { 4672, 20, 33, 24, 2, -32 },
  { 4755, 16, 40, 24, 3, -32 },
  { 4835, 20, 33, 24, 3, -33 },
  { 4918, 20, 33, 24, 2, -32 },
  { 5001, 20, 22, 24, 2, -22 },
  { 5056, 18, 23, 24, 3, -23 },
  { 5108, 20, 24, 24, 2, -23 },
  { 5168, 19, 31, 24, 3, -23 },
  { 5242, 19, 31, 24, 2, -23 },
  { 5316, 17, 22, 24, 4, -22 },
  { 5363, 18, 24, 24, 3, -23 },
  { 5417, 20, 30, 24, 2, -29 },
  { 5492, 18, 23, 24, 3, -22 },
  { 5544, 22, 22, 24, 1, -22 },
  { 5605, 22, 22, 24, 1, -22 },
  { 5666, 22, 22, 24, 1, -22 },
  { 5727, 21, 30, 24, 1, -22 },
  { 5806, 17, 22, 24, 3, -22 },
  { 5853, 17, 41, 24, 3, -33 },
  { 5941, 5, 41, 24, 9, -33 },
  { 5967, 17, 41, 24, 3, -33 },
  { 6055, 22, 8, 24, 1, -16 },
};

const GFXfont UbuntuSansMono_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_SEMIBOLD42PT7B_H_
