#ifndef _UBUNTUSANSMONO_SEMIBOLD6PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x7F, 0xE0, 0x4F, 0x1E, 0x80, 0xF9, 0xD0, 0xEB, 0xF0,
  0xC0, 0x6A, 0x90, 0xA5, 0x60, 0xEC, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x25,
  0x25, 0x00, 0xFE, 0xB0, 0xC9, 0x30, 0xE5, 0x70, 0xEC, 0xF0, 0x6F, 0x90,
  0x68, 0xF0, 0x7A, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0,
  0x78, 0x80, 0xFC, 0xCE, 0x00, 0xDA, 0xFF, 0xD6, 0x4F, 0xD0, 0xFE, 0xF0,
  0x72, 0x30, 0xF6, 0xF0, 0xFE, 0x70, 0xFE, 0x40, 0x72, 0xB0, 0xBE, 0xD0,
  0xE9, 0x70, 0x64, 0xF0, 0xBB, 0x50, 0xAB, 0xBF, 0xD0, 0xBE, 0xD0, 0xF6,
  0xB0, 0xF7, 0x40, 0xF6, 0xB6, 0xF7, 0xD0, 0xE8, 0xF0, 0xE9, 0x20, 0xB6,
  0xF0, 0xB5, 0xA0, 0xBF, 0xD0, 0xA9, 0xD0, 0xAD, 0x20, 0xE9, 0x70, 0xEA,
  0xB0, 0x89, 0x22, 0x40, 0xD5, 0x70, 0x54, 0xE0, 0xC0, 0xFF, 0x80, 0x93,
  0xDE, 0x71, 0x80, 0x27, 0xDE, 0xFD, 0x80, 0x2B, 0xA4, 0xF5, 0xF0, 0x93,
  0xDA, 0x43, 0x26, 0x21, 0x93, 0xC0, 0x92, 0xEA, 0xC9, 0x26, 0xFE, 0x80,
  0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xEF, 0x80, 0x5D,
  0x30, 0xB5, 0x80, 0xAD, 0x00, 0xBE, 0x80, 0xEA, 0x80, 0xAD, 0x60, 0x6B,
  0x80, 0x69, 0x64, 0xC0, 0xFC, 0xC9, 0x15, 0x80, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 4, 3, 1, -4 },
  { 2, 2, 2, 3, 1, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 3, 4, 3, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 3, 1, -5 },
  { 13, 2, 6, 3, 1, -5 },
  { 15, 2, 6, 3, 1, -5 },
  { 17, 3, 2, 3, 0, -4 },
  { 18, 3, 3, 3, 0, -3 },
  { 20, 1, 2, 3, 1, -1 },
  { 21, 2, 1, 3, 1, -2 },
  { 22, 1, 1, 3, 1, -1 },
  { 23, 3, 6, 3, 0, -5 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 1, 3, 3, 1, -3 },
  { 47, 1, 4, 3, 1, -3 },
  { 48, 3, 3, 3, 0, -3 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -3 },
  { 53, 2, 4, 3, 1, -4 },
  { 54, 3, 5, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 2, 4, 3, 1, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 5, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 2, 6, 3, 1, -5 },
  { 109, 3, 6, 3, 0, -5 },
  { 112, 2, 6, 3, 1, -5 },
  { 114, 3, 2, 3, 0, -4 },
  { 115, 3, 1, 3, 0, 0 },
  { 116, 1, 2, 3, 1, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 3, 4, 3, 0, -3 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 3, 5, 3, 0, -5 },
  { 135, 3, 6, 3, 0, -5 },
  { 138, 3, 5, 3, 0, -5 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 4, 3, 0, -3 },
  { 150, 3, 4, 3, 0, -3 },
  { 152, 2, 3, 3, 1, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -4 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 3, 3, 3, 0, -3 },
  { 165, 3, 4, 3, 0, -3 },
  { 167, 3, 3, 3, 0, -3 },
  { 169, 3, 6, 3, 0, -5 },
  { 172, 1, 6, 3, 1, -5 },
  { 173, 3, 6, 3, 0, -5 },
  { 176, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuSansMono_SemiBold6pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold6pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUSANSMONO_SEMIBOLD6PT7B_H_
