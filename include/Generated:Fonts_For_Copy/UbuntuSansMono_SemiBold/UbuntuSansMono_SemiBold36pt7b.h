#ifndef _UBUNTUSANSMONO_SEMIBOLD36PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x78, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x70, 0xF7, 0x0E, 0x70,
  0x60, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F,
  0x01, 0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7C, 0x02, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7D, 0x00, 0x3D, 0xF0,
  0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x03, 0xF0, 0x0F, 0x7F,
  0x81, 0xE7, 0x78, 0x1C, 0x73, 0x83, 0xC7, 0x38, 0x38, 0xE3, 0x87, 0x06,
  0x38, 0xF0, 0x73, 0x8E, 0x07, 0x39, 0xC0, 0x7F, 0xBC, 0x03, 0xF3, 0x80,
  0x1E, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x80, 0x1C, 0xFC, 0x03, 0xDF,
  0xE0, 0x39, 0xCE, 0x07, 0x9C, 0xF0, 0x71, 0xC7, 0x0E, 0x1C, 0x71, 0xE1,
  0xC7, 0x1C, 0x1C, 0xE3, 0x81, 0xEE, 0x78, 0x0F, 0xEF, 0x00, 0xFC, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC2, 0x07, 0xE1, 0xE3, 0xFC, 0x79,
  0xFF, 0x9E, 0x79, 0xF7, 0xBC, 0x3F, 0xCF, 0x07, 0xF3, 0xC0, 0xFC, 0xF0,
  0x1E, 0x3E, 0x0F, 0xC7, 0xC7, 0xF9, 0xFF, 0xFE, 0x3F, 0xF7, 0xC7, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x70, 0x00, 0x20, 0x06, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xE0,
  0x02, 0x40, 0x06, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x43, 0xC2, 0x71, 0xCE, 0x7D, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x3E, 0x0C,
  0x30, 0x04, 0x10, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8,
  0xFC, 0x1E, 0x1E, 0x1E, 0x7F, 0x1E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x79, 0xFB, 0xF7, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xE7, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F,
  0x78, 0x07, 0xBC, 0x23, 0xDE, 0x79, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F, 0xCF,
  0x3F, 0xE3, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x81, 0xF3, 0xE0, 0xF1, 0xF9, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x79, 0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x01, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFC, 0xFE, 0xFE, 0x70, 0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x3F,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C, 0xFE, 0x20, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF0, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03,
  0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x02, 0x00, 0x00, 0x3E, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x79, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x3E,
  0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xC0, 0xFB, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0x3C, 0x0F, 0x1F, 0x0F, 0x87, 0xEF, 0x83,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xF8, 0xFC, 0xF8, 0x1F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xFB, 0xF8, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x03, 0x9F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x03, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00,
  0x79, 0xFB, 0xF7, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F,
  0xBF, 0x7F, 0xFC, 0xF8, 0x1E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F,
  0x81, 0xC1, 0xE3, 0xE7, 0xE3, 0xE1, 0xC0, 0x00, 0x02, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x38, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x02, 0x01, 0xFF,
  0x8F, 0xFF, 0x9F, 0xFE, 0x78, 0xFD, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1E, 0x0F, 0x8F, 0x01, 0xE3, 0x80, 0x3D, 0xE0,
  0x0F, 0x70, 0x3F, 0xDC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE3,
  0xFC, 0xF0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0xF0, 0xFF,
  0x3C, 0x3F, 0xCF, 0x8F, 0xF1, 0xE3, 0xFC, 0x7F, 0xF7, 0x0F, 0xFD, 0xE1,
  0xFF, 0x78, 0x0C, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0x9E, 0x00, 0x79,
  0xE0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xF0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xE7, 0xC0, 0xF3, 0xE0, 0x7D, 0xF0,
  0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xEF, 0x8F, 0xC0, 0x23, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x21, 0xFE, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0x87, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x87, 0xE7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xCF, 0x8F, 0xC0, 0x23,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0x81, 0xF1,
  0xFC, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x02, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF6, 0x03, 0xEF, 0x3F, 0xBF, 0xFF, 0x7F, 0xFC, 0x3F, 0xF0, 0x04,
  0x00, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xE7,
  0xC0, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3F,
  0x3E, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F,
  0x87, 0xE7, 0x61, 0xF9, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xE7, 0x3F,
  0x39, 0xCF, 0xCF, 0x73, 0xF3, 0xDC, 0x7C, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1,
  0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x3F, 0x1F, 0x03,
  0xE7, 0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE3, 0xF3, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0x80,
  0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0xCF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x06, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x07,
  0xCF, 0x81, 0xE7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0x00, 0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x1C, 0xF8, 0x04,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x40, 0x1F, 0x78, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF8, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7E, 0x7F, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x80, 0xF0, 0x03, 0xFE, 0x00, 0x7B,
  0xE0, 0x0F, 0x7C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81,
  0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0xCF, 0x73, 0xF3,
  0xDC, 0xFC, 0xE7, 0x3F, 0x39, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xE7,
  0x71, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x3C, 0x07, 0x80, 0xF8, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x1F,
  0x07, 0x83, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x7D, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x78,
  0x7C, 0x1F, 0x0F, 0x83, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x3E,
  0x03, 0xC7, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x83, 0xC0, 0xF0, 0xF8, 0x1F,
  0x1E, 0x01, 0xE7, 0xC0, 0x3E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C,
  0x3E, 0x1F, 0x0F, 0x83, 0xE7, 0xC0, 0xFB, 0xF0, 0x1F, 0xF8, 0x07, 0xCC,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x20, 0x30, 0x7C, 0xFE, 0x3F, 0x0F, 0x06, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3C, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xDF, 0x1F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3E, 0xF9, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE7, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x7C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x3F, 0xBF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFE, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0,
  0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xF3,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xF0, 0x7C, 0xFF, 0xFE,
  0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xF7, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF1, 0x81, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xE0, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xF0, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFF, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7D, 0x01, 0xF7, 0x0F, 0x9F,
  0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0xF8, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x1F, 0x3C, 0x1F, 0x9E, 0x0F, 0x8F, 0x0F, 0x87, 0x8F,
  0x83, 0xCF, 0x81, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1E,
  0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x83, 0xC7, 0xE1, 0xE1, 0xF8, 0xF0, 0x7C,
  0x78, 0x1F, 0x3C, 0x0F, 0xDE, 0x03, 0xF0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xBF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3C, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE,
  0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E,
  0x0F, 0x9F, 0x03, 0xE7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF8,
  0xFE, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFE, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x7F,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7F, 0x3C, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x40, 0x1F, 0x7C, 0x7E, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8, 0x00,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x78, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7F,
  0x7F, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xC0, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x00, 0xEF,
  0x1E, 0x1D, 0xE3, 0xC7, 0xBC, 0x78, 0xF7, 0x8F, 0x9E, 0xF3, 0xF3, 0xCE,
  0x7E, 0x79, 0xCF, 0xCE, 0x39, 0xDD, 0xC7, 0x73, 0xB8, 0xFE, 0x77, 0x1F,
  0xC7, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x00,
  0xF8, 0x07, 0xDF, 0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x1F, 0x3E, 0x03,
  0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x81, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x0F, 0x9E, 0x01, 0xFF, 0x80, 0x7C, 0x78, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF9, 0xE0, 0x3E, 0xF8, 0x07, 0xBC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x21, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7E, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0x8F, 0xF0, 0x77, 0xFF,
  0x3D, 0xFF, 0xFF, 0xF1, 0xFF, 0xBC, 0x1F, 0xC2, 0x01, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 12, 11, 20, 4, -27 },
  { 37, 18, 25, 20, 1, -25 },
  { 94, 17, 32, 20, 2, -28 },
  { 162, 20, 27, 20, 0, -26 },
  { 230, 18, 26, 20, 1, -26 },
  { 289, 4, 11, 20, 8, -27 },
  { 295, 12, 36, 20, 4, -29 },
  { 349, 12, 36, 20, 4, -29 },
  { 403, 16, 16, 20, 2, -25 },
  { 435, 17, 18, 20, 2, -20 },
  { 474, 9, 12, 20, 5, -6 },
  { 488, 10, 4, 20, 5, -12 },
  { 493, 7, 6, 20, 7, -6 },
  { 499, 16, 35, 20, 2, -28 },
  { 569, 17, 27, 20, 2, -26 },
  { 627, 16, 25, 20, 2, -25 },
  { 677, 16, 26, 20, 2, -26 },
  { 729, 16, 27, 20, 2, -26 },
  { 783, 18, 25, 20, 1, -25 },
  { 840, 16, 26, 20, 2, -25 },
  { 892, 16, 26, 20, 2, -25 },
  { 944, 16, 25, 20, 2, -25 },
  { 994, 17, 27, 20, 2, -26 },
  { 1052, 16, 26, 20, 2, -26 },
  { 1104, 7, 18, 20, 7, -18 },
  { 1120, 9, 24, 20, 5, -18 },
  { 1147, 17, 17, 20, 2, -19 },
  { 1184, 17, 11, 20, 2, -16 },
  { 1208, 17, 17, 20, 2, -19 },
  { 1245, 14, 26, 20, 3, -26 },
  { 1291, 18, 31, 20, 1, -26 },
  { 1361, 20, 25, 20, 0, -25 },
  { 1424, 17, 25, 20, 2, -25 },
  { 1478, 18, 27, 20, 1, -26 },
  { 1539, 17, 25, 20, 2, -25 },
  { 1593, 16, 25, 20, 3, -25 },
  { 1643, 15, 25, 20, 3, -25 },
  { 1690, 18, 27, 20, 1, -26 },
  { 1751, 16, 25, 20, 2, -25 },
  { 1801, 15, 25, 20, 3, -25 },
  { 1848, 15, 26, 20, 2, -25 },
  { 1897, 18, 25, 20, 2, -25 },
  { 1954, 16, 25, 20, 3, -25 },
  { 2004, 18, 25, 20, 1, -25 },
  { 2061, 16, 25, 20, 2, -25 },
  { 2111, 18, 27, 20, 1, -26 },
  { 2172, 17, 25, 20, 2, -25 },
  { 2226, 18, 32, 20, 1, -25 },
  { 2298, 17, 25, 20, 2, -25 },
  { 2352, 16, 27, 20, 2, -26 },
  { 2406, 18, 25, 20, 1, -25 },
  { 2463, 16, 26, 20, 2, -25 },
  { 2515, 19, 25, 20, 1, -25 },
  { 2575, 18, 25, 20, 1, -25 },
  { 2632, 19, 25, 20, 1, -25 },
  { 2692, 19, 25, 20, 1, -25 },
  { 2752, 16, 25, 20, 2, -25 },
  { 2802, 11, 35, 20, 5, -28 },
  { 2851, 16, 35, 20, 2, -28 },
  { 2921, 11, 35, 20, 4, -28 },
  { 2970, 18, 14, 20, 1, -25 },
  { 3002, 20, 4, 20, 0, 3 },
  { 3012, 8, 7, 20, 6, -28 },
  { 3019, 16, 19, 20, 2, -19 },
  { 3057, 16, 28, 20, 3, -28 },
  { 3113, 17, 19, 20, 2, -19 },
  { 3154, 16, 28, 20, 1, -28 },
  { 3210, 18, 19, 20, 1, -19 },
  { 3253, 18, 28, 20, 2, -28 },
  { 3316, 17, 26, 20, 1, -19 },
  { 3372, 15, 28, 20, 3, -28 },
  { 3425, 17, 28, 20, 2, -28 },
  { 3485, 14, 35, 20, 2, -28 },
  { 3547, 17, 28, 20, 3, -28 },
  { 3607, 17, 28, 20, 2, -28 },
  { 3667, 18, 19, 20, 1, -19 },
  { 3710, 15, 19, 20, 3, -19 },
  { 3746, 18, 20, 20, 1, -19 },
  { 3791, 16, 26, 20, 3, -19 },
  { 3843, 17, 26, 20, 1, -19 },
  { 3899, 14, 19, 20, 4, -19 },
  { 3933, 16, 19, 20, 2, -19 },
  { 3971, 17, 25, 20, 2, -25 },
  { 4025, 16, 19, 20, 2, -19 },
  { 4063, 18, 19, 20, 1, -19 },
  { 4106, 19, 19, 20, 1, -19 },
  { 4152, 18, 19, 20, 1, -19 },
  { 4195, 18, 26, 20, 1, -19 },
  { 4254, 14, 19, 20, 3, -19 },
  { 4288, 15, 35, 20, 3, -28 },
  { 4354, 4, 35, 20, 8, -28 },
  { 4372, 14, 35, 20, 3, -28 },
  { 4434, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_SEMIBOLD36PT7B_H_
