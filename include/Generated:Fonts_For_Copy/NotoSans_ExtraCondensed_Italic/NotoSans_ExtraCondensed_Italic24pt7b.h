#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x08, 0x40, 0x04,
  0x38, 0xC0, 0x66, 0xCD, 0x92, 0x64, 0xD9, 0x80, 0x06, 0x40, 0x88, 0x13,
  0x06, 0x40, 0x88, 0x7F, 0xC6, 0x40, 0xC8, 0x13, 0x06, 0x43, 0xFE, 0x7F,
  0xC6, 0x60, 0xC8, 0x13, 0x02, 0x60, 0xC8, 0x00, 0x02, 0x00, 0x80, 0xFC,
  0x6E, 0x34, 0x0D, 0x03, 0x40, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x2C, 0x0B,
  0x02, 0xC9, 0x33, 0xF8, 0x78, 0x04, 0x03, 0x00, 0x3C, 0x31, 0x23, 0x19,
  0x10, 0x89, 0x84, 0xC8, 0x66, 0xC3, 0x24, 0x99, 0x6E, 0xDA, 0xDB, 0xB4,
  0xC1, 0x66, 0x1B, 0x30, 0x99, 0x0C, 0x88, 0xC4, 0xC6, 0x24, 0x61, 0xC0,
  0x0F, 0x02, 0x61, 0x98, 0x66, 0x1B, 0x06, 0xC1, 0xE0, 0x70, 0x3C, 0x1F,
  0x36, 0xCB, 0x1E, 0xC7, 0xB1, 0xCC, 0x73, 0xFC, 0x79, 0x80, 0x76, 0x66,
  0x4C, 0x07, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x06, 0x06,
  0x06, 0x02, 0x02, 0x02, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x08, 0x88, 0xF9, 0x3F, 0x38,
  0x6C, 0x6C, 0x04, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x33, 0x66, 0x4C, 0xFC, 0x7F, 0x00, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x1F, 0x1B,
  0x33, 0x61, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x86, 0x86, 0x8C,
  0x8C, 0xF8, 0xF0, 0x0E, 0x38, 0xF7, 0x64, 0xC3, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0x0F, 0x83, 0x30, 0x8C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0x8C, 0xC0, 0x60, 0x10, 0x18, 0x0C, 0x0C,
  0x3C, 0x1E, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x19, 0xBC, 0xF8, 0x00,
  0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x0D, 0x82, 0xC1, 0xB0, 0x4C, 0x23, 0x18,
  0x84, 0x63, 0x1A, 0xFF, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x1F, 0xC7,
  0xE1, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x80, 0xF8, 0x27, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x63, 0x78, 0xF8, 0x00, 0x0F, 0x8E, 0x4E, 0x06,
  0x06, 0x03, 0x01, 0x31, 0xFC, 0xE6, 0x61, 0xB0, 0xD8, 0x48, 0x64, 0x33,
  0x39, 0xF8, 0x78, 0x00, 0x7F, 0xBF, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x00,
  0x0F, 0x86, 0x63, 0x0C, 0xC3, 0x30, 0x8C, 0x61, 0xB0, 0x78, 0x1E, 0x0D,
  0x86, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0xB8, 0x7C, 0x00, 0x0F, 0x0C,
  0xCC, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC3, 0x73, 0x9E, 0xC6, 0xC0, 0x60,
  0x30, 0x30, 0x31, 0x78, 0xF8, 0x00, 0x19, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x11, 0xCC, 0x00, 0x0C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C,
  0x61, 0x8C, 0x30, 0x00, 0x81, 0xC3, 0xC3, 0x87, 0x06, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0x20,
  0x00, 0x3E, 0x37, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x20,
  0x20, 0x40, 0x00, 0x60, 0xE0, 0xE0, 0x07, 0xE0, 0x61, 0x86, 0x04, 0x60,
  0x32, 0x11, 0xB3, 0xED, 0x12, 0x79, 0x13, 0xC9, 0x94, 0xCC, 0xA6, 0x4D,
  0x36, 0x49, 0xB6, 0x4E, 0xE2, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x10, 0x0F,
  0x80, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x02, 0xC1, 0xB0, 0x6C, 0x33, 0x0C,
  0xC3, 0x31, 0xFC, 0x7F, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0xE0, 0xC0, 0x1F,
  0x87, 0xF1, 0x8C, 0x63, 0x18, 0xCC, 0x33, 0x1C, 0xFC, 0x3F, 0x0C, 0x66,
  0x19, 0x86, 0x61, 0x98, 0x64, 0x33, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0x23,
  0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x0C,
  0x31, 0x86, 0x60, 0xCC, 0x19, 0x83, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x66,
  0x18, 0xC7, 0x11, 0xC7, 0xF0, 0xF8, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xFC, 0x3F, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0x0F, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x00, 0x07, 0xE3, 0xDC, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC3, 0xD8, 0x7B, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x63,
  0xF8, 0x3F, 0x00, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x86, 0x18, 0x63, 0x06,
  0x30, 0x63, 0xFE, 0x3F, 0xC3, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0x86, 0x18,
  0x41, 0x8C, 0x18, 0xC1, 0x80, 0x1F, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x68, 0xF8,
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x78, 0x38, 0x00, 0x1C, 0x71, 0x8E, 0x18, 0xC1, 0x98, 0x1B,
  0x03, 0x30, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x60, 0x43, 0x0C, 0x30, 0xC3, 0x00, 0x1C, 0x61, 0x86, 0x18, 0xC3,
  0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x3F, 0xFC, 0x1C, 0x07, 0x1C, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0E, 0x14, 0x1E, 0x36, 0x16, 0x36, 0x36, 0x36, 0x34,
  0x36, 0x6C, 0x26, 0x6C, 0x66, 0xCC, 0x66, 0xCC, 0x67, 0x98, 0x67, 0x98,
  0x47, 0x18, 0xC7, 0x18, 0xC6, 0x18, 0x1C, 0x18, 0xE0, 0xC7, 0x0C, 0x3C,
  0x61, 0x63, 0x1B, 0x18, 0xD8, 0x86, 0xCC, 0x32, 0x61, 0x13, 0x18, 0xD8,
  0xC6, 0x86, 0x3C, 0x31, 0xE1, 0x07, 0x18, 0x38, 0xC1, 0x80, 0x0F, 0x83,
  0xB8, 0xE3, 0x18, 0x26, 0x06, 0xC0, 0xD8, 0x36, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xC7, 0xF0, 0x7C, 0x00, 0x1F, 0x87,
  0xF1, 0x8C, 0x63, 0x18, 0xCC, 0x33, 0x0C, 0xC6, 0x37, 0x8F, 0x86, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xB8, 0xE3,
  0x18, 0x26, 0x06, 0xC0, 0xD8, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60,
  0xCC, 0x19, 0x87, 0x30, 0xC7, 0xF0, 0x7C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x1F, 0x87, 0xF1, 0x8C, 0x63, 0x18, 0xCC, 0x33, 0x0C, 0xC6, 0x3F,
  0x0F, 0x86, 0x61, 0x98, 0x66, 0x19, 0x84, 0x33, 0x0C, 0xC3, 0x00, 0x07,
  0xE1, 0xD8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x20, 0xC3, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x66, 0x0C, 0xC3, 0x18, 0x62, 0x0C, 0xC1,
  0x98, 0x33, 0x0C, 0x61, 0x98, 0x33, 0x06, 0x60, 0x8C, 0x31, 0x86, 0x31,
  0x87, 0xF0, 0x7C, 0x00, 0xC1, 0xF0, 0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0x8C,
  0x63, 0x30, 0xCC, 0x33, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0xC1, 0x87, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x8C, 0xC7, 0x8C,
  0xC5, 0x98, 0xCD, 0x18, 0xCD, 0x18, 0xC9, 0x30, 0xD9, 0x30, 0xD1, 0x60,
  0xF1, 0x60, 0xF1, 0x60, 0xA1, 0xC0, 0xE1, 0xC0, 0xE1, 0x80, 0xC3, 0x80,
  0x0C, 0x70, 0xC6, 0x0C, 0xC0, 0xCC, 0x0D, 0x80, 0xD0, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xA0, 0x33, 0x03, 0x30, 0x63, 0x0C, 0x30,
  0xC3, 0x00, 0xC3, 0xE1, 0xB1, 0x98, 0xC4, 0xC2, 0x61, 0xE0, 0xF0, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x0F, 0xE3,
  0xF8, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0x0F, 0x80, 0xC4, 0x46,
  0x66, 0x66, 0x62, 0x23, 0x33, 0x33, 0x30, 0x07, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x02, 0x0F, 0x0F, 0x80, 0x06, 0x01, 0x80, 0xF0, 0x2C,
  0x19, 0x0C, 0x63, 0x19, 0x86, 0xC0, 0xC0, 0xFF, 0xE6, 0x30, 0x1D, 0x9F,
  0xD8, 0xEC, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x33, 0x9B, 0xCF,
  0x40, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0xE3, 0xF8, 0xE6, 0x30,
  0xCC, 0x22, 0x19, 0x86, 0x61, 0x98, 0x66, 0x33, 0x8C, 0xF6, 0x37, 0x00,
  0x1E, 0x7D, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x47, 0x80,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x87, 0x63, 0xF9, 0x8E, 0x63, 0x30,
  0xCC, 0x33, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x38, 0xDE, 0x3D, 0x00, 0x1E,
  0x3F, 0x63, 0x63, 0xC6, 0xCE, 0xF8, 0xC0, 0x80, 0x80, 0xC0, 0xC4, 0x7C,
  0x01, 0xE0, 0x34, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0x83, 0xE0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x3C, 0x06, 0x00, 0x07, 0x61, 0xFC,
  0x63, 0x8C, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x31, 0x86, 0x30, 0xCE,
  0x1B, 0xC3, 0xD0, 0x06, 0x00, 0xC0, 0x18, 0x86, 0x1F, 0xC0, 0xE0, 0x00,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xBC, 0xFE, 0x73, 0x31, 0x98, 0xC8,
  0x6C, 0x36, 0x33, 0x19, 0x8C, 0x86, 0xC2, 0x63, 0x00, 0x08, 0x71, 0x80,
  0x00, 0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x00, 0x01,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x83,
  0xC1, 0x80, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x73, 0x18, 0xCC,
  0x36, 0x0F, 0x82, 0xC1, 0xF0, 0x7C, 0x19, 0x06, 0x61, 0x18, 0xC6, 0x31,
  0x80, 0x0C, 0x21, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86,
  0x10, 0xC3, 0x00, 0x17, 0xB8, 0xFF, 0xF3, 0x9C, 0xCC, 0x63, 0x31, 0x8C,
  0x86, 0x36, 0x31, 0x98, 0xC6, 0x63, 0x19, 0x8C, 0x6C, 0x31, 0x31, 0x8C,
  0xC6, 0x30, 0x17, 0x9F, 0xCE, 0x66, 0x33, 0x19, 0x0D, 0x86, 0xC6, 0x63,
  0x31, 0xB0, 0xD8, 0x4C, 0x60, 0x1E, 0x3F, 0x63, 0x63, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC6, 0x86, 0xC6, 0xDC, 0x78, 0x0B, 0xC3, 0xF8, 0x73, 0x0C, 0x31,
  0x84, 0x21, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x30, 0xC6, 0x3D, 0x86, 0xE0,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x1D, 0x9F, 0xD8,
  0xEC, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x33, 0x9B, 0xCF, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x00, 0x17, 0x3E, 0x38, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x1F, 0x3E, 0x60, 0x60,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0xDC, 0xF8, 0x11, 0x8C, 0xFF,
  0xB1, 0x8C, 0x46, 0x31, 0x8C, 0x43, 0x9C, 0x31, 0xB0, 0xD8, 0xCC, 0x66,
  0x32, 0x1B, 0x09, 0x8C, 0xC6, 0x63, 0x33, 0x9B, 0x8F, 0x40, 0xC3, 0xC3,
  0xC6, 0xC6, 0xC4, 0xCC, 0x4C, 0x58, 0x58, 0x70, 0x70, 0x60, 0x60, 0xC3,
  0x1E, 0x38, 0xF1, 0xCD, 0x9E, 0x6C, 0xF2, 0x65, 0xB3, 0x6D, 0x9B, 0x78,
  0xD3, 0xC7, 0x9C, 0x38, 0xE1, 0xC7, 0x0E, 0x30, 0x00, 0x18, 0xC6, 0x61,
  0x98, 0x6C, 0x0A, 0x03, 0x80, 0xC0, 0x70, 0x1E, 0x0D, 0x86, 0x61, 0x98,
  0xC3, 0x00, 0x08, 0x61, 0x0C, 0x23, 0x04, 0x60, 0x8C, 0x13, 0x02, 0x60,
  0x58, 0x0B, 0x01, 0x40, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x1E, 0x03, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0F, 0x8F, 0xC0, 0x07, 0x0E, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C,
  0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x07, 0x03, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xE0, 0xC0, 0x70, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 7, 6, 8, 2, -17 },
  { 20, 11, 17, 10, 0, -17 },
  { 44, 10, 19, 9, 0, -18 },
  { 68, 13, 17, 15, 1, -17 },
  { 96, 10, 17, 10, 0, -17 },
  { 118, 4, 6, 4, 2, -17 },
  { 121, 8, 21, 6, 0, -17 },
  { 142, 8, 21, 6, -2, -17 },
  { 163, 8, 8, 9, 2, -18 },
  { 171, 9, 11, 10, 1, -14 },
  { 184, 4, 6, 5, -1, -3 },
  { 187, 6, 1, 6, 0, -7 },
  { 188, 3, 3, 5, 0, -3 },
  { 190, 11, 17, 8, -1, -17 },
  { 214, 8, 17, 9, 1, -17 },
  { 231, 7, 17, 9, 2, -17 },
  { 246, 10, 17, 9, -1, -17 },
  { 268, 9, 17, 9, 0, -17 },
  { 288, 10, 17, 9, 0, -17 },
  { 310, 10, 17, 9, 0, -17 },
  { 332, 9, 17, 9, 1, -17 },
  { 352, 9, 17, 9, 1, -17 },
  { 372, 10, 17, 9, 0, -17 },
  { 394, 9, 17, 9, 0, -17 },
  { 414, 5, 13, 5, 0, -13 },
  { 423, 6, 16, 5, -1, -13 },
  { 435, 9, 11, 10, 1, -14 },
  { 448, 9, 7, 10, 1, -12 },
  { 456, 9, 11, 10, 1, -14 },
  { 469, 8, 17, 7, 0, -17 },
  { 486, 13, 19, 14, 1, -17 },
  { 517, 10, 17, 10, -2, -17 },
  { 539, 10, 17, 10, 0, -17 },
  { 561, 10, 17, 9, 1, -17 },
  { 583, 11, 17, 11, 0, -17 },
  { 607, 10, 17, 9, 0, -17 },
  { 629, 10, 17, 8, 0, -17 },
  { 651, 11, 17, 12, 1, -17 },
  { 675, 12, 17, 12, 0, -17 },
  { 701, 9, 17, 6, -1, -17 },
  { 721, 10, 22, 5, -4, -17 },
  { 749, 12, 17, 10, 0, -17 },
  { 775, 6, 17, 8, 0, -17 },
  { 788, 16, 17, 16, 0, -17 },
  { 822, 13, 17, 12, 0, -17 },
  { 850, 11, 17, 12, 1, -17 },
  { 874, 10, 17, 10, 0, -17 },
  { 896, 11, 21, 12, 1, -17 },
  { 925, 10, 17, 10, 0, -17 },
  { 947, 11, 17, 9, -1, -17 },
  { 971, 8, 17, 8, 2, -17 },
  { 988, 11, 17, 11, 1, -17 },
  { 1012, 10, 17, 10, 2, -17 },
  { 1034, 16, 17, 16, 2, -17 },
  { 1068, 12, 17, 9, -1, -17 },
  { 1094, 9, 17, 9, 2, -17 },
  { 1114, 11, 17, 8, -1, -17 },
  { 1138, 9, 21, 7, -1, -17 },
  { 1162, 4, 17, 8, 2, -17 },
  { 1171, 9, 21, 7, -2, -17 },
  { 1195, 10, 9, 10, 0, -17 },
  { 1207, 8, 1, 7, -2, 2 },
  { 1208, 4, 3, 6, 3, -18 },
  { 1210, 9, 13, 10, 1, -13 },
  { 1225, 10, 18, 10, 0, -18 },
  { 1248, 7, 13, 8, 1, -13 },
  { 1260, 10, 18, 10, 1, -18 },
  { 1283, 8, 13, 9, 1, -13 },
  { 1296, 11, 24, 6, -3, -18 },
  { 1329, 11, 19, 10, -1, -13 },
  { 1356, 9, 18, 10, 0, -18 },
  { 1377, 6, 18, 5, 0, -18 },
  { 1391, 9, 24, 5, -3, -18 },
  { 1418, 10, 18, 9, 0, -18 },
  { 1441, 6, 18, 5, 0, -18 },
  { 1455, 14, 13, 15, 0, -13 },
  { 1478, 9, 13, 10, 0, -13 },
  { 1493, 8, 13, 10, 1, -13 },
  { 1506, 11, 19, 10, -1, -13 },
  { 1533, 9, 19, 10, 1, -13 },
  { 1555, 8, 13, 7, 0, -13 },
  { 1568, 8, 13, 8, 0, -13 },
  { 1581, 5, 16, 6, 1, -16 },
  { 1591, 9, 13, 10, 1, -13 },
  { 1606, 8, 13, 8, 1, -13 },
  { 1619, 13, 13, 13, 1, -13 },
  { 1641, 10, 13, 8, -1, -13 },
  { 1658, 11, 19, 8, -2, -13 },
  { 1685, 9, 13, 7, -1, -13 },
  { 1700, 8, 21, 8, 1, -17 },
  { 1721, 2, 24, 9, 3, -18 },
  { 1727, 8, 21, 8, -1, -17 },
  { 1748, 9, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Italic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC24PT7B_H_
