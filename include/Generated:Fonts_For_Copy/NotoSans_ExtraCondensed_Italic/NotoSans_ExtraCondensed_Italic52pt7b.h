#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x3E, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x70, 0x70, 0xE0, 0xE1, 0xC3, 0xC7, 0x87, 0x8E, 0x0E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE0,
  0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC0, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0xF0, 0x3E, 0x60, 0x81,
  0xE3, 0x00, 0x0E, 0x18, 0x00, 0xF0, 0xC0, 0x07, 0x8C, 0x00, 0x3C, 0x60,
  0x00, 0xE3, 0x00, 0x07, 0x98, 0x00, 0x3E, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x6F, 0x80, 0x03, 0x3C, 0x00, 0x19, 0xE0, 0x01, 0x87, 0x00, 0x0C,
  0x38, 0x00, 0x61, 0xC0, 0x03, 0x1E, 0x00, 0x18, 0xF0, 0xC1, 0x8F, 0x07,
  0x8C, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x07, 0xF8, 0x07,
  0x80, 0xF7, 0x80, 0x70, 0x0E, 0x38, 0x0F, 0x01, 0xC3, 0x80, 0xE0, 0x1C,
  0x38, 0x1E, 0x03, 0xC3, 0x81, 0xC0, 0x38, 0x38, 0x38, 0x03, 0x83, 0x83,
  0x80, 0x78, 0x38, 0x70, 0x07, 0x03, 0x87, 0x00, 0x70, 0x78, 0xE0, 0x07,
  0x07, 0x0E, 0x00, 0x70, 0x71, 0xC0, 0x07, 0x07, 0x3C, 0x38, 0x70, 0xF3,
  0x8F, 0xEF, 0x0E, 0x79, 0xFE, 0x71, 0xE7, 0x1C, 0xF7, 0x1C, 0xF3, 0x8F,
  0x7F, 0xCE, 0x38, 0x77, 0xF9, 0xE7, 0x07, 0x3F, 0x1C, 0x70, 0x70, 0x83,
  0xCF, 0x0F, 0x00, 0x38, 0xE0, 0xF0, 0x07, 0x8E, 0x0E, 0x00, 0x70, 0xE0,
  0xE0, 0x0F, 0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0xE0, 0x1E, 0x1C, 0x1E, 0x01,
  0xC1, 0xC1, 0xC0, 0x3C, 0x1C, 0x1C, 0x03, 0x81, 0xC3, 0xC0, 0x78, 0x1C,
  0x38, 0x07, 0x01, 0xC7, 0x80, 0xE0, 0x1F, 0xF0, 0x0E, 0x00, 0xFE, 0x01,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x3C, 0x7D, 0xE1, 0xE1, 0xE7, 0xC7, 0x8F, 0x0F,
  0x1E, 0x78, 0x3C, 0xF1, 0xE0, 0xF3, 0xCF, 0x81, 0xFE, 0x3C, 0x07, 0xF8,
  0xF0, 0x1F, 0xC3, 0xC0, 0x3F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0,
  0x1F, 0x83, 0xC0, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0xFC, 0xF0, 0x7F, 0xE3,
  0xE0, 0xFF, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7,
  0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x41, 0xC0, 0x71, 0xC0, 0x7D, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x78,
  0x78, 0x38, 0x78, 0x10, 0x30, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x3E, 0x07,
  0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x0F, 0x01, 0xF7, 0xE0, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFB, 0xCF, 0x9E, 0xF9, 0xF3, 0x8F,
  0x08, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF8, 0xFC, 0x03,
  0x81, 0xF0, 0x04, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xE0, 0xF8, 0x06, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x82, 0x00, 0x7C, 0x0F, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0xDE,
  0x00, 0x0E, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00,
  0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC1,
  0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x40, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x80, 0x1F, 0x03, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xC1, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x8F, 0xC0, 0x3D, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xE0, 0xFC,
  0x0F, 0x07, 0xE0, 0x78, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8,
  0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x03,
  0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x7C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xCF, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0x83,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x3F,
  0x0F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xE1, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x03,
  0xE1, 0xF0, 0x7E, 0x1F, 0x9F, 0xE0, 0xFF, 0xDE, 0x0F, 0xFB, 0xC0, 0x7F,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x83, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0xFC, 0x3E, 0x0F,
  0x83, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0E, 0x1F, 0x08, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x7F, 0x0E, 0x1C, 0x0F, 0xF8, 0x70, 0xE0, 0xFB, 0xC3, 0x8E, 0x0F, 0x1E,
  0x1C, 0x70, 0x70, 0xE0, 0xE7, 0x87, 0x07, 0x07, 0x38, 0x38, 0x38, 0x71,
  0xC3, 0xC3, 0xC3, 0x8E, 0x1C, 0x1C, 0x1C, 0xE0, 0xE0, 0xE0, 0xE7, 0x0F,
  0x07, 0x07, 0x38, 0x70, 0x78, 0x71, 0xC3, 0x83, 0x83, 0x8E, 0x1C, 0x1C,
  0x1C, 0xF0, 0xE1, 0xE1, 0xC7, 0x07, 0x0F, 0x0E, 0x38, 0x38, 0xF8, 0xE1,
  0xC1, 0xC7, 0xC7, 0x0E, 0x0F, 0xEF, 0xF0, 0x70, 0x7F, 0x3F, 0x03, 0x81,
  0xF0, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x40, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEE,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7C, 0x07, 0xC3,
  0xC0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x00,
  0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C,
  0x03, 0xC1, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x78, 0x7E, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x0F,
  0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x03,
  0xE0, 0x78, 0x0F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x30, 0x0F, 0xC0, 0x40, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF1, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78,
  0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F,
  0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0xC0,
  0x78, 0x3F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F,
  0x80, 0x10, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x01, 0xFF, 0x1F, 0x00, 0xFF, 0x8F, 0x80, 0x7F,
  0x87, 0xC0, 0x7F, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x3C,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0,
  0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0xF3, 0xC0,
  0x3C, 0xE0, 0x3C, 0xF0, 0x0F, 0x1C, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0xE3,
  0xC0, 0x3C, 0x70, 0x3C, 0x78, 0x07, 0x8E, 0x07, 0x9F, 0x01, 0xE1, 0xC1,
  0xE3, 0xC0, 0x3C, 0x38, 0x3C, 0x78, 0x07, 0x87, 0x0F, 0x0F, 0x00, 0xF0,
  0xF1, 0xE1, 0xE0, 0x1E, 0x1E, 0x78, 0x7C, 0x07, 0x83, 0xCF, 0x0F, 0x00,
  0xF0, 0x79, 0xC1, 0xE0, 0x1E, 0x0F, 0x78, 0x3C, 0x03, 0xC1, 0xEE, 0x07,
  0x80, 0x78, 0x3F, 0xC1, 0xE0, 0x1E, 0x07, 0xF8, 0x3C, 0x03, 0xC0, 0xFE,
  0x07, 0x80, 0x78, 0x1F, 0xC0, 0xF0, 0x0F, 0x03, 0xF0, 0x1E, 0x01, 0xC0,
  0x7E, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xE0, 0x1F,
  0x80, 0x1E, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0xC0, 0x1E, 0x03, 0xFC, 0x03,
  0xC0, 0x3F, 0xC0, 0x3C, 0x03, 0xDC, 0x03, 0xC0, 0x3D, 0xC0, 0x3C, 0x03,
  0xDE, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x07, 0x9E, 0x07, 0x80, 0x79, 0xE0,
  0x78, 0x07, 0x9E, 0x07, 0x80, 0x78, 0xE0, 0x78, 0x0F, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0x1E, 0x0F,
  0x1E, 0x01, 0xE0, 0x71, 0xE0, 0x1E, 0x07, 0x1E, 0x01, 0xE0, 0x79, 0xE0,
  0x1E, 0x07, 0x9E, 0x03, 0xC0, 0x7B, 0xC0, 0x3C, 0x07, 0xBC, 0x03, 0xC0,
  0x3B, 0xC0, 0x3C, 0x03, 0xBC, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x03, 0xF8,
  0x07, 0x80, 0x3F, 0x80, 0x78, 0x03, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x78,
  0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F,
  0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x1E,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0xF8, 0x1F, 0x01,
  0xF8, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3C, 0x0F, 0x80, 0xF1, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0,
  0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3,
  0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF8,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80,
  0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3C, 0x1F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x78,
  0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78,
  0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x1E, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFC, 0x78, 0x0F, 0x80, 0x60,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x80,
  0x0F, 0x83, 0x00, 0x7C, 0x0F, 0xDF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8,
  0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF8,
  0x1F, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE,
  0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFE,
  0x00, 0x78, 0x01, 0xEF, 0x80, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0x3E,
  0xF0, 0x03, 0xE0, 0x0F, 0x3C, 0x01, 0xF8, 0x03, 0xCF, 0x00, 0x7E, 0x01,
  0xE3, 0xC0, 0x3F, 0x80, 0x78, 0xF0, 0x0E, 0xE0, 0x3E, 0x3C, 0x03, 0xB8,
  0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xC3, 0xC0, 0x77, 0x81, 0xE0, 0xF0, 0x3D,
  0xE0, 0x78, 0x3C, 0x0F, 0x78, 0x3E, 0x0F, 0x03, 0x9E, 0x0F, 0x03, 0xC1,
  0xE7, 0x83, 0xC0, 0xF0, 0x71, 0xE1, 0xE0, 0x3C, 0x3C, 0x78, 0x78, 0x0F,
  0x0F, 0x1E, 0x1E, 0x03, 0xC3, 0x87, 0x8F, 0x00, 0xF1, 0xE1, 0xC3, 0xC0,
  0x3C, 0x78, 0x71, 0xF0, 0x0F, 0x1C, 0x1C, 0x78, 0x03, 0xCF, 0x07, 0x1E,
  0x00, 0xF3, 0x81, 0xCF, 0x00, 0x3D, 0xE0, 0x73, 0xC0, 0x0F, 0x78, 0x1D,
  0xF0, 0x03, 0xDC, 0x07, 0x78, 0x00, 0xFF, 0x01, 0xDE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x03,
  0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E,
  0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E,
  0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0x70, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x70, 0x38, 0x0F,
  0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xE7,
  0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x87, 0x0F, 0x00, 0xFC, 0x78,
  0x0F, 0xF3, 0xC0, 0xFF, 0xDC, 0x0F, 0xCF, 0xE0, 0xF8, 0x3F, 0x07, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0,
  0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x07, 0xE0,
  0x7C, 0x7F, 0x03, 0xFF, 0x78, 0x0F, 0xF3, 0x80, 0x3F, 0x1C, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xFC,
  0x01, 0xEF, 0xF0, 0x1E, 0xFF, 0xC0, 0xFE, 0x3E, 0x07, 0xE0, 0xF0, 0x3E,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78,
  0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F,
  0x07, 0xE1, 0xF0, 0x7B, 0xFF, 0x03, 0xDF, 0xF0, 0x1C, 0x7F, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFC, 0x60, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x30, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x0F, 0xC7, 0x80, 0x3F, 0xCF, 0x00, 0xFF, 0xFC, 0x03,
  0xF3, 0xF8, 0x0F, 0x83, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0,
  0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x07, 0xC0,
  0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x07,
  0xC7, 0xF0, 0x0F, 0xFD, 0xC0, 0x0F, 0xF3, 0x80, 0x0F, 0xC7, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x1F, 0x0F,
  0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0xF9, 0xE0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x0C, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1E, 0x00,
  0xFF, 0x3C, 0x03, 0xFF, 0x70, 0x0F, 0xCF, 0xE0, 0x3E, 0x0F, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x03, 0xC0,
  0xF8, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x1F, 0xC0, 0x3F, 0xF7, 0x80, 0x3F,
  0xDE, 0x00, 0x7F, 0x3C, 0x00, 0x10, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x04, 0x01, 0xF0, 0x0E, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0xC0,
  0x3D, 0xFE, 0x07, 0xBF, 0xF0, 0x7F, 0x1F, 0x07, 0xE0, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x23, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x87, 0xC0,
  0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0x9E,
  0x00, 0x3D, 0xE0, 0x01, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x03, 0x8F, 0xC3, 0xF8, 0x0E, 0xFF, 0x9F, 0xF0, 0x7B, 0xFE, 0xFF, 0xC1,
  0xFC, 0xFF, 0x9F, 0x07, 0xC1, 0xF8, 0x3C, 0x1F, 0x07, 0xE0, 0xF0, 0x78,
  0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07,
  0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0x1E, 0x1E, 0x03, 0xC0,
  0x78, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E,
  0x3C, 0x07, 0xC0, 0xF0, 0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x0F,
  0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x01, 0xE3, 0xE0, 0x3C,
  0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0x03, 0x8F, 0xC0,
  0x39, 0xFE, 0x07, 0xBF, 0xF0, 0x7F, 0x1F, 0x07, 0xE0, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xE3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7,
  0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDF,
  0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3E,
  0x07, 0x83, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x73, 0xFC, 0x00, 0xF7,
  0xFE, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0E, 0xFF, 0xC0, 0x1E, 0x7F,
  0x80, 0x1E, 0x7F, 0x00, 0x1E, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x78, 0x0F, 0xF3, 0xC0, 0xFF, 0xDC,
  0x0F, 0xCF, 0xE0, 0xF8, 0x3F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07,
  0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0x7C, 0x7F, 0x03, 0xFF, 0x70,
  0x0F, 0xF7, 0x80, 0x7F, 0x3C, 0x00, 0x41, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0x8F, 0x81, 0xCF, 0x81, 0xEF, 0xC0, 0xFF, 0xE0, 0x77, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x0E, 0x0F, 0x80,
  0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC2, 0x01, 0xF0, 0xE0, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3F, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x83,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE2, 0x1F, 0xE0, 0x7F,
  0x03, 0xF8, 0x02, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80,
  0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xDE, 0x03,
  0xF9, 0xC0, 0x04, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE,
  0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xF0, 0x1E,
  0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xF0, 0x3C, 0xF0, 0x3F, 0x03, 0xCF, 0x03,
  0xF0, 0x3C, 0xF0, 0x77, 0x07, 0x8F, 0x07, 0x70, 0x78, 0xF0, 0xF7, 0x0F,
  0x0F, 0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x0F, 0x1E, 0xF1, 0xE0, 0xF1,
  0xCF, 0x1E, 0x0F, 0x3C, 0xF1, 0xC0, 0xF3, 0xCF, 0x3C, 0x0F, 0x38, 0xF3,
  0xC0, 0xF7, 0x8F, 0x78, 0x0F, 0x70, 0xF7, 0x80, 0xF7, 0x0F, 0x70, 0x0F,
  0xF0, 0xFF, 0x00, 0xEE, 0x0E, 0xF0, 0x0E, 0xE0, 0xEE, 0x00, 0xFC, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80,
  0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xE7, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87,
  0x80, 0x3C, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xE0,
  0x78, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC7, 0x80, 0x00,
  0xE3, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x08, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x27, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xA0, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 37, 12, 1, -37 },
  { 57, 15, 13, 18, 5, -37 },
  { 82, 23, 37, 22, 0, -37 },
  { 189, 21, 43, 20, 0, -40 },
  { 302, 28, 39, 32, 2, -38 },
  { 439, 22, 39, 22, 0, -38 },
  { 547, 7, 13, 10, 5, -37 },
  { 559, 16, 45, 13, 1, -37 },
  { 649, 16, 45, 13, -4, -37 },
  { 739, 16, 18, 19, 5, -40 },
  { 775, 19, 25, 22, 2, -31 },
  { 835, 9, 13, 11, -2, -6 },
  { 850, 11, 4, 13, 1, -16 },
  { 856, 5, 6, 11, 1, -6 },
  { 860, 24, 37, 17, -3, -37 },
  { 971, 19, 39, 20, 1, -38 },
  { 1064, 13, 37, 20, 5, -37 },
  { 1125, 22, 38, 20, -2, -38 },
  { 1230, 22, 39, 20, -1, -38 },
  { 1338, 22, 37, 20, -1, -37 },
  { 1440, 22, 38, 20, -1, -37 },
  { 1545, 21, 39, 20, 1, -38 },
  { 1648, 21, 37, 20, 2, -37 },
  { 1746, 21, 39, 20, 0, -38 },
  { 1849, 20, 39, 20, 0, -38 },
  { 1947, 10, 28, 11, 0, -28 },
  { 1982, 14, 35, 11, -3, -28 },
  { 2044, 19, 23, 22, 2, -30 },
  { 2099, 19, 15, 22, 2, -26 },
  { 2135, 19, 23, 22, 2, -30 },
  { 2190, 16, 38, 15, 1, -38 },
  { 2266, 29, 41, 30, 1, -37 },
  { 2415, 21, 37, 21, -3, -37 },
  { 2513, 23, 37, 22, 0, -37 },
  { 2620, 22, 39, 20, 2, -38 },
  { 2728, 23, 37, 24, 0, -37 },
  { 2835, 21, 37, 19, 0, -37 },
  { 2933, 21, 37, 18, 0, -37 },
  { 3031, 25, 39, 26, 2, -38 },
  { 3153, 26, 37, 25, 0, -37 },
  { 3274, 20, 37, 14, -3, -37 },
  { 3367, 20, 47, 11, -8, -37 },
  { 3485, 25, 37, 21, 0, -37 },
  { 3601, 14, 37, 18, 0, -37 },
  { 3666, 35, 37, 34, 0, -37 },
  { 3828, 28, 37, 27, 0, -37 },
  { 3958, 23, 39, 26, 2, -38 },
  { 4071, 22, 37, 21, 0, -37 },
  { 4173, 23, 47, 26, 2, -38 },
  { 4309, 22, 37, 22, 0, -37 },
  { 4411, 22, 39, 20, -1, -38 },
  { 4519, 19, 37, 18, 3, -37 },
  { 4607, 24, 38, 25, 2, -37 },
  { 4721, 21, 37, 21, 4, -37 },
  { 4819, 34, 37, 34, 4, -37 },
  { 4977, 26, 37, 19, -3, -37 },
  { 5098, 19, 37, 19, 4, -37 },
  { 5186, 23, 37, 17, -2, -37 },
  { 5293, 19, 45, 15, -1, -37 },
  { 5400, 9, 37, 18, 5, -37 },
  { 5442, 19, 45, 15, -3, -37 },
  { 5549, 20, 20, 21, 1, -37 },
  { 5599, 17, 3, 16, -5, 4 },
  { 5606, 7, 8, 13, 8, -40 },
  { 5613, 21, 29, 22, 1, -28 },
  { 5690, 21, 41, 22, 0, -40 },
  { 5798, 17, 29, 16, 1, -28 },
  { 5860, 23, 41, 22, 1, -40 },
  { 5978, 18, 29, 20, 1, -28 },
  { 6044, 24, 52, 12, -6, -40 },
  { 6200, 23, 40, 22, -1, -28 },
  { 6315, 20, 40, 21, 0, -40 },
  { 6415, 12, 38, 10, 0, -38 },
  { 6472, 19, 50, 10, -7, -38 },
  { 6591, 21, 40, 19, 0, -40 },
  { 6696, 12, 40, 10, 0, -40 },
  { 6756, 30, 28, 32, 0, -28 },
  { 6861, 20, 28, 21, 0, -28 },
  { 6931, 19, 29, 21, 1, -28 },
  { 7000, 24, 40, 22, -3, -28 },
  { 7120, 21, 40, 22, 1, -28 },
  { 7225, 17, 28, 14, 0, -28 },
  { 7285, 18, 29, 16, -1, -28 },
  { 7351, 13, 35, 12, 1, -34 },
  { 7408, 20, 29, 21, 1, -28 },
  { 7481, 17, 28, 17, 3, -28 },
  { 7541, 28, 28, 28, 3, -28 },
  { 7639, 22, 28, 18, -2, -28 },
  { 7716, 25, 41, 18, -5, -28 },
  { 7845, 18, 28, 15, -2, -28 },
  { 7908, 19, 45, 17, 1, -37 },
  { 8015, 3, 52, 19, 8, -40 },
  { 8035, 19, 45, 17, -3, -37 },
  { 8142, 19, 7, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Italic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC52PT7B_H_
