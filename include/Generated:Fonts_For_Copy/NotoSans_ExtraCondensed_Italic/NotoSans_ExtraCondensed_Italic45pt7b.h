#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0x80, 0x3C, 0x79, 0xE3,
  0xCE, 0x1C, 0x70, 0xE3, 0x8F, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE3,
  0x86, 0x38, 0x70, 0x00, 0x38, 0x70, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00,
  0xC3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0x87, 0x00,
  0x38, 0x60, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x61, 0xC0,
  0x0E, 0x1C, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1C, 0x38,
  0x01, 0xC3, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60, 0x03, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1E, 0x42, 0x0F, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00,
  0x38, 0xC0, 0x0E, 0x20, 0x03, 0xD8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x27,
  0x80, 0x18, 0xE0, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x11, 0xE3,
  0x0C, 0x70, 0xF3, 0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xC0, 0x1C, 0x0F, 0xE0, 0x38, 0x1C, 0xE0, 0x70, 0x1C,
  0xE0, 0x70, 0x38, 0x60, 0xE0, 0x38, 0x60, 0xE0, 0x70, 0xE1, 0xC0, 0x70,
  0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x70, 0xE3, 0x80, 0x60, 0xE7, 0x00, 0xE1,
  0xC7, 0x00, 0xE1, 0xCE, 0x18, 0xE1, 0xCE, 0x7E, 0xE3, 0x9C, 0xFE, 0xE3,
  0x9C, 0xE7, 0xE7, 0x39, 0xC7, 0x7F, 0x39, 0x87, 0x7E, 0x73, 0x87, 0x10,
  0x73, 0x87, 0x00, 0xE3, 0x07, 0x00, 0xE7, 0x06, 0x01, 0xC7, 0x0E, 0x01,
  0x87, 0x0E, 0x03, 0x87, 0x0E, 0x03, 0x07, 0x0E, 0x07, 0x06, 0x1C, 0x0E,
  0x06, 0x1C, 0x0E, 0x07, 0x38, 0x1C, 0x07, 0x78, 0x1C, 0x07, 0xF0, 0x38,
  0x03, 0xE0, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xF7, 0x80,
  0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0x87, 0x9E,
  0x78, 0xE3, 0x8F, 0x3C, 0xF0, 0xE7, 0x1C, 0x1E, 0xE7, 0x83, 0xFC, 0xF0,
  0x3F, 0x1C, 0x07, 0xC3, 0x80, 0xF8, 0x70, 0x1F, 0x0F, 0x07, 0xE1, 0xE1,
  0xFC, 0x3F, 0xFB, 0xC3, 0xFE, 0x78, 0x3F, 0x8F, 0x80, 0x7B, 0xDE, 0xE7,
  0x3B, 0xDC, 0xE7, 0x38, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x10, 0xE0, 0x73, 0x83, 0xFF, 0xF3, 0xFF,
  0xC1, 0xFF, 0x0F, 0x80, 0x7F, 0x03, 0xDC, 0x1E, 0x38, 0x38, 0xF0, 0x41,
  0x80, 0x04, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x0E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0x3B, 0xDF, 0xF7, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x78, 0x70,
  0x3C, 0x38, 0x3C, 0x1C, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0E,
  0x0F, 0x0F, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x1F, 0x07, 0xE3, 0xFC, 0xFF, 0xBE, 0xF7, 0x1C, 0x43,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x38, 0x3C, 0x02, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x38, 0x3E, 0x04, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC1,
  0x80, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xDC, 0x00, 0x3F,
  0x80, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x03, 0x9E,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xC3, 0xC0, 0x38, 0x78,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x33, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x0C, 0x07, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFE, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x7E, 0x03, 0xBF, 0xC1, 0xFF, 0xF0, 0x7E, 0x3E, 0x1F, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x1E,
  0x3C, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xBF, 0x07, 0x83,
  0xC1, 0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0,
  0xF0, 0x38, 0x3C, 0x1E, 0x07, 0x0F, 0x01, 0xE7, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF7, 0x80, 0xF8, 0xF0, 0x38, 0x1C,
  0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x01, 0xE3, 0x80, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x78, 0x78, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8F,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x38, 0x1F, 0x1C, 0x1F, 0x8F, 0x1F, 0x87, 0xFD, 0xC1, 0xFD, 0xE0, 0x7C,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x18, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x1E, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x0E, 0x03, 0x03, 0x86, 0x07, 0xF1, 0xC7, 0x07, 0xF8, 0xE3, 0x07, 0x1C,
  0x73, 0x87, 0x0C, 0x39, 0xC3, 0x0E, 0x1C, 0xC3, 0x87, 0x0C, 0xE1, 0xC3,
  0x86, 0x71, 0xC3, 0x87, 0x38, 0xE1, 0xC3, 0x98, 0x70, 0xE1, 0xCC, 0x38,
  0x70, 0xCE, 0x18, 0x70, 0xE7, 0x0C, 0x38, 0x63, 0x86, 0x1C, 0x71, 0xC3,
  0x1E, 0x30, 0xE1, 0xFB, 0xF8, 0x70, 0xF9, 0xF8, 0x38, 0x38, 0x70, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x02, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x39,
  0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70,
  0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x1C, 0x38, 0x07, 0x1E, 0x01,
  0xC7, 0x80, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x77,
  0x80, 0x1F, 0xC0, 0x07, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3C, 0x3E, 0x03, 0x81, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xE0, 0x70, 0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC0, 0xF1, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xE0,
  0xF0, 0x1C, 0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C,
  0x07, 0x83, 0x80, 0x78, 0x38, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x81, 0xE0, 0x70, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x08,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x20, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3C, 0x7E, 0x03, 0x81, 0xE0, 0x38, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x78, 0x38, 0x07, 0x87, 0x80, 0xF0,
  0x78, 0x1E, 0x07, 0x83, 0xE0, 0x71, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x03, 0x03, 0xE0, 0x08, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x1F, 0xE7, 0x80, 0xFE, 0x3C, 0x0F, 0xF1, 0xE0, 0x07, 0x8E,
  0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x80, 0xF0, 0x3E,
  0x07, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xC0,
  0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x81, 0xE0, 0x0E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0E, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3C,
  0x03, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0xC0, 0x1C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x38, 0x03, 0x80, 0xF0, 0x07,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0,
  0x3C, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xF9, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x0E, 0x0F, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0x9E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0F, 0x00,
  0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x00, 0x70,
  0x1E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x07, 0x70, 0x07, 0x70, 0x1D, 0xC0, 0x3D, 0xC0,
  0x77, 0x00, 0xEF, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x03, 0x9E, 0x07, 0x9C, 0x0E, 0x78, 0x1E, 0x70,
  0x79, 0xE0, 0x79, 0xC1, 0xC7, 0x01, 0xC7, 0x0F, 0x1C, 0x07, 0x1E, 0x38,
  0xF0, 0x3C, 0x79, 0xE3, 0xC0, 0xF1, 0xE7, 0x0F, 0x03, 0x87, 0x9C, 0x38,
  0x0E, 0x0E, 0xE0, 0xE0, 0x38, 0x3B, 0x87, 0x81, 0xE0, 0xFC, 0x1E, 0x07,
  0x83, 0xF0, 0x70, 0x1C, 0x0F, 0xC1, 0xC0, 0x70, 0x3E, 0x0F, 0x01, 0xC0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x01, 0xE0,
  0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xF0, 0x0E, 0x03, 0xF0,
  0x0E, 0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0x70,
  0x1C, 0x07, 0x78, 0x1C, 0x07, 0x38, 0x3C, 0x0F, 0x38, 0x3C, 0x0F, 0x38,
  0x38, 0x0E, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x1E, 0x3C, 0x78, 0x1E, 0x1C,
  0x78, 0x1E, 0x1C, 0x70, 0x1C, 0x1C, 0x70, 0x1C, 0x1C, 0xF0, 0x3C, 0x1C,
  0xF0, 0x3C, 0x1E, 0xF0, 0x38, 0x0E, 0xE0, 0x38, 0x0E, 0xE0, 0x38, 0x0E,
  0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0x70, 0x0F, 0xC0, 0x70, 0x07,
  0xC0, 0x70, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1C,
  0xF0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07,
  0x8E, 0x00, 0xF0, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x87,
  0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xE3, 0xE0, 0x38, 0x3E, 0x07, 0x03, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x87,
  0x80, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0x81, 0xE0, 0xF0, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x0E,
  0x78, 0x00, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00,
  0x78, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0,
  0x3E, 0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xE3, 0xE0, 0x38, 0x3E, 0x07, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x83, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x0E, 0x01, 0xC1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0E, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0x00, 0x04, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE0,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x80, 0x3E,
  0x0E, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E,
  0x00, 0xF0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0E, 0x00, 0xF0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1,
  0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78, 0x1C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x38,
  0x0F, 0x0E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x0F,
  0x03, 0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8F, 0x00,
  0xE7, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x3D, 0xC0, 0x1E, 0x00, 0xE7, 0x00,
  0x78, 0x07, 0x9C, 0x03, 0xE0, 0x1E, 0x70, 0x0F, 0x80, 0xF1, 0xC0, 0x3E,
  0x03, 0xC7, 0x01, 0xF8, 0x0E, 0x1C, 0x07, 0xE0, 0x78, 0x70, 0x3B, 0x81,
  0xE1, 0xC0, 0xEE, 0x0F, 0x07, 0x03, 0xB8, 0x3C, 0x1C, 0x1C, 0xE0, 0xE0,
  0x70, 0x73, 0x87, 0x81, 0xC3, 0xCE, 0x1E, 0x07, 0x0E, 0x38, 0x70, 0x1C,
  0x38, 0xE3, 0xC0, 0x71, 0xC7, 0x8E, 0x03, 0xC7, 0x1C, 0x78, 0x0F, 0x3C,
  0x71, 0xE0, 0x3C, 0xE1, 0xC7, 0x00, 0xF3, 0x87, 0x3C, 0x03, 0xDC, 0x1C,
  0xE0, 0x0F, 0x70, 0x77, 0x80, 0x3D, 0xC1, 0xDE, 0x00, 0xFE, 0x07, 0x70,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00,
  0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE0,
  0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x3C,
  0x03, 0xDC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x20, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03,
  0x8F, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x07, 0x87, 0x00,
  0xE3, 0x80, 0x39, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF3, 0xC7, 0x1E, 0x38, 0x61, 0xC0, 0x00, 0x40, 0x00, 0xFE, 0x70, 0x7F,
  0xBC, 0x3F, 0xFE, 0x0F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0E, 0x1C,
  0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x3F, 0x07, 0xFF, 0x81, 0xFE, 0xE0,
  0x3F, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE1, 0x00, 0x73, 0xF0, 0x1D, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0xF0, 0xF8,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x8E,
  0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0xC3,
  0xC3, 0xFF, 0xE0, 0xE7, 0xF0, 0x39, 0xF8, 0x00, 0x00, 0x20, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x08, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x06, 0x3C, 0x03, 0xFB, 0xC0, 0x7F,
  0xBC, 0x0F, 0xFF, 0x80, 0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x07, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x00, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xB8, 0x03, 0xF3, 0x80, 0x00, 0x20, 0x03, 0xF8,
  0x0F, 0xF8, 0x3C, 0xF0, 0xF0, 0xE3, 0xC1, 0xC7, 0x03, 0x9E, 0x07, 0x38,
  0x1E, 0xF0, 0x39, 0xE1, 0xF3, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x02, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x02,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0xE7, 0x01, 0xFE, 0xF0, 0x3F, 0xFE, 0x03, 0xC3, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xC0, 0xE0, 0x1C,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03,
  0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1F, 0x03, 0xC3, 0xF0, 0x1F, 0xFE, 0x01, 0xFE, 0xE0, 0x0F,
  0xDE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x08, 0x07, 0x80, 0xE1, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC2, 0x01, 0xCF, 0xC0, 0xEF, 0xF0, 0x7F, 0xF8, 0x7C, 0x3C, 0x3E,
  0x0E, 0x1E, 0x07, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1,
  0xC0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1C, 0x07,
  0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x9E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x3C, 0x1C, 0x1E, 0x07, 0x0F, 0x03, 0xC3, 0xC0,
  0xF1, 0xE0, 0x38, 0xF0, 0x0E, 0x38, 0x03, 0x9E, 0x01, 0xEF, 0x00, 0x77,
  0x80, 0x1D, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x3C, 0xF0,
  0x0E, 0x3C, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x1C, 0x1E, 0x07,
  0x07, 0x81, 0xC1, 0xE0, 0xF0, 0x38, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x08, 0x06, 0x01,
  0xCF, 0xC7, 0xE0, 0x77, 0xFB, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x87, 0xE3,
  0xC3, 0xC1, 0xF0, 0x70, 0xF0, 0x78, 0x1C, 0x38, 0x1E, 0x07, 0x1E, 0x07,
  0x83, 0xC7, 0x81, 0xC0, 0xF1, 0xE0, 0x70, 0x38, 0x70, 0x3C, 0x0E, 0x1C,
  0x0F, 0x03, 0x8F, 0x03, 0xC1, 0xE3, 0xC0, 0xE0, 0x78, 0xE0, 0x38, 0x1C,
  0x38, 0x1E, 0x07, 0x0E, 0x07, 0x81, 0xC7, 0x81, 0xC0, 0xF1, 0xE0, 0x70,
  0x3C, 0x70, 0x1C, 0x0E, 0x1C, 0x0F, 0x03, 0x8F, 0x03, 0xC1, 0xE3, 0xC0,
  0xE0, 0x78, 0xF0, 0x38, 0x1E, 0x00, 0x00, 0x08, 0x03, 0x9F, 0x81, 0xDF,
  0xE0, 0xFF, 0xF0, 0xF8, 0x78, 0x7C, 0x1C, 0x3C, 0x0E, 0x1E, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x01, 0xC3, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x00,
  0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x0F, 0x1E, 0x0F,
  0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x70, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0x00, 0x01, 0x00, 0x1C, 0xFC, 0x01, 0xDF, 0xE0, 0x1F, 0xBE,
  0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0,
  0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x1E,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x1F, 0xFE, 0x03,
  0xDF, 0xC0, 0x3D, 0xF8, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7E, 0x70, 0x7F,
  0xBC, 0x3F, 0xFE, 0x0F, 0x0F, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0E, 0x1C,
  0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x3F, 0x07, 0xFF, 0x81, 0xFE, 0xE0,
  0x3F, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x1C, 0xF0, 0x77, 0xC1, 0xBF, 0x0E, 0xC0,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xDE, 0x0F, 0x02, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0xC0, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xF9, 0xFF,
  0x7F, 0xE3, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x03, 0x87, 0x01, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xC0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x87, 0xFD, 0xC1, 0xFC, 0xE0, 0xFC, 0xE0, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0F, 0x38, 0x38,
  0xE1, 0xE3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70,
  0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x70, 0x3E, 0x07, 0xB8, 0x1F, 0x07, 0x9C, 0x0F,
  0x83, 0xCE, 0x0F, 0xC1, 0xC7, 0x07, 0xE1, 0xE3, 0x83, 0x60, 0xE1, 0xC3,
  0xB0, 0x70, 0xE1, 0xD8, 0x78, 0x71, 0xDC, 0x38, 0x38, 0xEE, 0x3C, 0x1C,
  0x77, 0x1C, 0x0E, 0x73, 0x8E, 0x07, 0x39, 0xCF, 0x03, 0xB8, 0xE7, 0x01,
  0xDC, 0x77, 0x80, 0xEE, 0x3B, 0x80, 0x7E, 0x1D, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x78,
  0x0E, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0x73, 0x80,
  0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01,
  0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00,
  0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x27, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0xBF, 0x80,
  0xFF, 0xF8, 0xFC, 0xFF, 0xF8, 0x1F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 32, 11, 0, -32 },
  { 45, 13, 11, 15, 4, -32 },
  { 63, 20, 32, 19, 0, -32 },
  { 143, 18, 37, 18, 0, -34 },
  { 227, 24, 33, 27, 2, -33 },
  { 326, 19, 33, 19, 0, -33 },
  { 405, 5, 11, 8, 5, -32 },
  { 412, 13, 39, 12, 1, -32 },
  { 476, 13, 39, 12, -3, -32 },
  { 540, 14, 15, 16, 4, -34 },
  { 567, 16, 21, 19, 2, -26 },
  { 609, 8, 11, 9, -2, -5 },
  { 620, 10, 4, 12, 1, -14 },
  { 625, 5, 5, 9, 0, -5 },
  { 629, 20, 32, 15, -2, -32 },
  { 709, 17, 33, 18, 1, -33 },
  { 780, 11, 32, 18, 5, -32 },
  { 824, 19, 33, 18, -1, -33 },
  { 903, 19, 33, 18, -1, -33 },
  { 982, 19, 32, 18, -1, -32 },
  { 1058, 19, 32, 18, -1, -32 },
  { 1134, 18, 33, 18, 1, -33 },
  { 1209, 19, 32, 18, 1, -32 },
  { 1285, 18, 33, 18, 0, -33 },
  { 1360, 17, 33, 18, 0, -33 },
  { 1431, 9, 24, 9, 0, -24 },
  { 1458, 11, 30, 9, -2, -24 },
  { 1500, 16, 20, 19, 2, -26 },
  { 1540, 16, 13, 19, 2, -22 },
  { 1566, 17, 20, 19, 2, -26 },
  { 1609, 14, 33, 13, 1, -33 },
  { 1667, 25, 36, 26, 1, -32 },
  { 1780, 18, 32, 18, -3, -32 },
  { 1852, 20, 32, 19, 0, -32 },
  { 1932, 19, 33, 17, 2, -33 },
  { 2011, 20, 32, 21, 0, -32 },
  { 2091, 18, 32, 16, 0, -32 },
  { 2163, 19, 32, 16, 0, -32 },
  { 2239, 21, 33, 22, 2, -33 },
  { 2326, 23, 32, 22, 0, -32 },
  { 2418, 17, 32, 12, -2, -32 },
  { 2486, 17, 41, 9, -7, -32 },
  { 2574, 22, 32, 18, 0, -32 },
  { 2662, 12, 32, 15, 0, -32 },
  { 2710, 30, 32, 29, 0, -32 },
  { 2830, 24, 32, 23, 0, -32 },
  { 2926, 20, 33, 22, 2, -33 },
  { 3009, 19, 32, 18, 0, -32 },
  { 3085, 20, 41, 22, 2, -33 },
  { 3188, 19, 32, 19, 0, -32 },
  { 3264, 20, 33, 17, -1, -33 },
  { 3347, 16, 32, 15, 3, -32 },
  { 3411, 21, 32, 21, 1, -32 },
  { 3495, 18, 32, 18, 4, -32 },
  { 3567, 30, 32, 29, 3, -32 },
  { 3687, 23, 32, 17, -3, -32 },
  { 3779, 17, 32, 16, 3, -32 },
  { 3847, 20, 32, 15, -2, -32 },
  { 3927, 17, 39, 13, -1, -32 },
  { 4010, 7, 32, 15, 5, -32 },
  { 4038, 17, 39, 13, -3, -32 },
  { 4121, 18, 17, 18, 0, -32 },
  { 4160, 14, 2, 14, -4, 4 },
  { 4164, 6, 7, 11, 7, -34 },
  { 4170, 18, 25, 19, 1, -25 },
  { 4227, 18, 34, 19, 0, -34 },
  { 4304, 15, 25, 14, 1, -25 },
  { 4351, 20, 34, 19, 1, -34 },
  { 4436, 15, 25, 17, 1, -25 },
  { 4483, 22, 45, 10, -6, -34 },
  { 4607, 20, 36, 19, -1, -25 },
  { 4697, 17, 34, 19, 0, -34 },
  { 4770, 10, 33, 9, 0, -33 },
  { 4812, 16, 44, 9, -6, -33 },
  { 4900, 18, 34, 16, 0, -34 },
  { 4977, 11, 34, 9, 0, -34 },
  { 5024, 26, 25, 28, 0, -25 },
  { 5106, 17, 25, 19, 0, -25 },
  { 5160, 16, 25, 18, 1, -25 },
  { 5210, 20, 35, 19, -2, -25 },
  { 5298, 18, 36, 19, 1, -25 },
  { 5379, 14, 25, 12, 0, -25 },
  { 5423, 16, 25, 14, -1, -25 },
  { 5473, 11, 30, 11, 1, -30 },
  { 5515, 17, 24, 19, 1, -24 },
  { 5566, 14, 24, 15, 3, -24 },
  { 5608, 25, 24, 24, 2, -24 },
  { 5683, 19, 24, 15, -2, -24 },
  { 5740, 22, 35, 15, -4, -24 },
  { 5837, 16, 24, 13, -2, -24 },
  { 5885, 17, 39, 15, 1, -32 },
  { 5968, 3, 45, 16, 7, -34 },
  { 5985, 17, 39, 15, -3, -32 },
  { 6068, 17, 6, 19, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Italic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC45PT7B_H_
