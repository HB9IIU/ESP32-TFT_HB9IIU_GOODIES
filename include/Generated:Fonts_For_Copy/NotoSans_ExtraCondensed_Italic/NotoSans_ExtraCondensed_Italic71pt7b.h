#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC0, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0xE1, 0xC0,
  0x1F, 0x87, 0x02, 0x00, 0xF8, 0x70, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x7C,
  0x1C, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1F, 0x06, 0x00, 0x00, 0xF8, 0x70,
  0x00, 0x07, 0xC3, 0x80, 0x00, 0x3F, 0x1C, 0x00, 0x01, 0xF8, 0xE0, 0x00,
  0x07, 0xE6, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0E, 0xFE, 0x00, 0x00, 0x73, 0xF0, 0x00, 0x03, 0x8F, 0x80, 0x00,
  0x1C, 0x7E, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x70,
  0x7C, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x1C, 0x3F, 0x00, 0x00, 0xC1, 0xF0,
  0x00, 0x0E, 0x0F, 0x80, 0x80, 0x70, 0xFC, 0x0F, 0x03, 0x8F, 0xC0, 0x7F,
  0x9F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0x78, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x0F,
  0x80, 0x1F, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x01, 0xF0, 0x01, 0xE0,
  0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0xF0,
  0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0x1F, 0x01,
  0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0x3E, 0x1F, 0x00,
  0x07, 0x80, 0xF0, 0xF8, 0x00, 0x1E, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x1F,
  0x1F, 0x07, 0xE3, 0xE0, 0x78, 0x78, 0x3F, 0xCF, 0x81, 0xE3, 0xE1, 0xFF,
  0xBE, 0x0F, 0x8F, 0x0F, 0xFE, 0xF8, 0x3C, 0x7C, 0x7C, 0x79, 0xE1, 0xF1,
  0xE1, 0xE1, 0xF7, 0x8F, 0x8F, 0x8F, 0x07, 0xDF, 0xFE, 0x3C, 0x3C, 0x1F,
  0x7F, 0xF1, 0xF1, 0xF0, 0x7C, 0xFF, 0x87, 0x87, 0x81, 0xF1, 0xF8, 0x3E,
  0x3E, 0x07, 0xC0, 0x00, 0xF0, 0xF0, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x78,
  0x00, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x03, 0xC1,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x1E, 0x03, 0xE0,
  0x03, 0xE0, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x1E, 0x00,
  0x7C, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x01, 0xF7, 0xE0, 0x07,
  0x80, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x81, 0xF0,
  0x7E, 0xFC, 0x0F, 0x87, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xE0,
  0xFC, 0x3E, 0x3F, 0x03, 0xE3, 0xF3, 0xF0, 0x1F, 0x9F, 0x1F, 0x80, 0xFD,
  0xF8, 0xF8, 0x03, 0xEF, 0x8F, 0xC0, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xC3,
  0xE0, 0x07, 0xFE, 0x1F, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xC0,
  0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x3F,
  0xF0, 0x7E, 0x03, 0xFF, 0x83, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xF3, 0xF0,
  0x7F, 0xFF, 0x1F, 0x81, 0xFF, 0xF0, 0xFE, 0x07, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x20, 0x3E, 0x01, 0xC1, 0xF0, 0x0F, 0x8F, 0x00, 0xFF, 0x78, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFB, 0xC0, 0x1F, 0x9E, 0x01, 0xF8, 0xF8, 0x1F, 0xC3,
  0xE0, 0x7C, 0x1F, 0x01, 0xC0, 0xFC, 0x04, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xE7,
  0xC7, 0xF3, 0xF3, 0xF8, 0xFC, 0x7C, 0x3F, 0x0E, 0x0F, 0x81, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xC0, 0x1F, 0x80,
  0x06, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0xC0, 0x0F, 0xE0, 0x04,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x08, 0x00, 0x1F, 0xC0, 0x60, 0x03, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xEF, 0xC0, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x78, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x0F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0x80, 0x7C, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x08, 0x00, 0x1F, 0xC0, 0x70, 0x03, 0xFC, 0x03, 0xF0, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x1F, 0xF0, 0x03, 0xF7, 0xFF,
  0x80, 0x3E, 0x7F, 0xFC, 0x03, 0xEF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFE, 0x07,
  0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0x83,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xF8, 0x07, 0xFF, 0x9F, 0x00,
  0x7F, 0xE7, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x38, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x70, 0x3F, 0x80,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x03, 0xFC,
  0x07, 0x83, 0xE0, 0x1F, 0xFE, 0x0F, 0x07, 0x80, 0x7F, 0xF8, 0x1E, 0x1F,
  0x01, 0xFF, 0xF0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x07,
  0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0x1E, 0x07, 0x87,
  0x81, 0xE0, 0x7C, 0x0F, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x78, 0x1E, 0x03, 0xC0, 0x79, 0xF0, 0x7C, 0x0F, 0x81, 0xF3,
  0xC0, 0xF0, 0x1F, 0x03, 0xC7, 0x81, 0xE0, 0x3C, 0x07, 0x8F, 0x03, 0xC0,
  0x78, 0x0F, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x7C, 0x1F, 0x03, 0xE0, 0x78,
  0xF0, 0x3C, 0x07, 0x80, 0xF1, 0xE0, 0x78, 0x1F, 0x03, 0xC3, 0xC0, 0xF0,
  0x3E, 0x07, 0x87, 0x81, 0xE0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xF8, 0x3C,
  0x1E, 0x07, 0xC3, 0x70, 0xF0, 0x3C, 0x0F, 0x8E, 0xE3, 0xE0, 0x78, 0x1F,
  0xF9, 0xFF, 0x80, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xE0, 0x3F, 0xC3, 0xF8,
  0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x10,
  0x00, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7C, 0x01, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0x80,
  0x07, 0xF0, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0x80, 0x03, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFF, 0x00,
  0x7E, 0x01, 0xFE, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x60, 0x03, 0xF8, 0x00, 0x08,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8,
  0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xF0, 0x01, 0xFF,
  0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x20, 0x7C, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x00,
  0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xE0, 0x01,
  0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xF3, 0xE0, 0x03, 0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF3, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x1F,
  0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x00, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF1, 0xF0,
  0x3F, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF3, 0xE0,
  0x3F, 0x00, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF7, 0xC0,
  0x3E, 0x00, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xFF, 0x80,
  0x7C, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x00, 0x7E, 0x7C, 0x01, 0xF8,
  0x01, 0xF9, 0xF0, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC3, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x7E, 0x00,
  0x7E, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0x0F, 0x8F, 0x80, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xE0, 0x0F, 0x9F, 0x80, 0x1F,
  0x80, 0x3E, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xF8,
  0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x1F,
  0xC0, 0x1F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xF8,
  0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x0F, 0x80, 0x1F, 0xE0, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x02, 0x00, 0x03, 0xF0, 0x06, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0x83, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xBC, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x78, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x79, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x9F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x7C, 0x07, 0xE0,
  0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x00,
  0x3E, 0x07, 0xC3, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x00, 0x7E,
  0x3E, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x01, 0xF8,
  0xF0, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x1E, 0x3E, 0x00, 0x07, 0xE7,
  0xC0, 0x3C, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x79, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x01, 0xEF, 0xC0, 0x00, 0x7D, 0xF0,
  0x03, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x07, 0xBE, 0x00, 0x01, 0xF7, 0x80,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x40,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x81,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x7F, 0xF1,
  0xF0, 0x0F, 0xFF, 0xBE, 0x01, 0xFF, 0xFB, 0xE0, 0x3F, 0xC7, 0xBE, 0x03,
  0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x80, 0xFF, 0x1E, 0xF8, 0x07, 0xFF, 0xCF, 0x80, 0x7F, 0xF8, 0xF0, 0x03,
  0xFF, 0x0F, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0xF8, 0x7F, 0x80, 0x0F, 0x9F,
  0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF7, 0x8F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0xFC, 0x07, 0xFC, 0x3F, 0x80, 0x7D, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0x00,
  0xF8, 0xFF, 0xE0, 0x0F, 0x87, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x83, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x02,
  0x01, 0xFC, 0x3C, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x3F, 0xE3, 0xF0,
  0x00, 0xFF, 0xE7, 0xC0, 0x03, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0xDF, 0x00,
  0x3F, 0xC7, 0xFE, 0x00, 0x7E, 0x03, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xFC, 0x00,
  0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x3D, 0xF0, 0x01, 0xFF, 0xF3, 0xC0, 0x03,
  0xFF, 0xC7, 0x80, 0x03, 0xFF, 0x1F, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x07, 0xF8, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x7F, 0x01,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFE, 0x1F, 0x00, 0x07, 0xFF, 0x1E, 0x00, 0x0F, 0xFF, 0xBE, 0x00, 0x1F,
  0xFF, 0xBE, 0x00, 0x3F, 0xC7, 0xBE, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0x80, 0x0F, 0xE1,
  0xFF, 0x80, 0x07, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xDF, 0x00, 0x03, 0xFF,
  0x9F, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x03,
  0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0xFF, 0x80,
  0x1F, 0x3F, 0xF8, 0x03, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03,
  0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x08, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x3F, 0xE0, 0x7F, 0x80, 0x0F,
  0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xCF, 0xFF, 0x3F, 0xFE, 0x01, 0xF7, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x8F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x08, 0x3E, 0x00, 0x1E, 0x1F, 0xF0, 0x03, 0xC7, 0xFF, 0x00,
  0xF9, 0xFF, 0xE0, 0x1F, 0x7F, 0xFE, 0x03, 0xFF, 0x1F, 0xC0, 0x7F, 0x81,
  0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8,
  0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC7, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x1F, 0xE0, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0xF3, 0xFF, 0xE0, 0x03, 0xEF,
  0xFF, 0xC0, 0x07, 0xDE, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0x3F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x7D, 0xFF,
  0xF8, 0x00, 0xFB, 0xFF, 0xE0, 0x03, 0xF3, 0xFF, 0x80, 0x07, 0xE3, 0xFC,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFE, 0x1F, 0x00, 0x7F, 0xF1, 0xE0, 0x0F, 0xFF, 0xBE, 0x01, 0xFF, 0xFB,
  0xE0, 0x3F, 0xC7, 0xBE, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC,
  0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0x80, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xDF,
  0x80, 0x7F, 0xFD, 0xF0, 0x03, 0xFF, 0x9F, 0x00, 0x1F, 0xE3, 0xF0, 0x00,
  0x78, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xE1, 0xFC, 0x03, 0xC7, 0xF0, 0x0F, 0x9F, 0xE0, 0x1F,
  0x7F, 0xC0, 0x3E, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x03, 0xF0,
  0x04, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xC0, 0xF8, 0x3F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x10, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x07, 0xF0, 0x3E, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC7, 0xFE, 0x03, 0xFF, 0xF7, 0xC0, 0x3F, 0xFC, 0xF0, 0x07,
  0xFF, 0x1E, 0x00, 0x7F, 0xC3, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3F, 0x00, 0x3C, 0x7C, 0x00, 0x79, 0xF8, 0x00, 0xF3, 0xE0,
  0x01, 0xE7, 0xC0, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xEF, 0xC0, 0x1F,
  0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x03, 0xFC, 0x01, 0xF3,
  0xF0, 0x0F, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x3E, 0x3F, 0x01, 0xFF,
  0x00, 0xF8, 0xFC, 0x07, 0xBC, 0x07, 0xE3, 0xF0, 0x3F, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFF, 0xC0, 0xFC, 0x3E, 0x03, 0xDF, 0x03, 0xE0, 0xF8, 0x1F, 0x7C,
  0x0F, 0x83, 0xE0, 0x79, 0xF0, 0x7E, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x3E,
  0x0F, 0x9F, 0x0F, 0xC0, 0xF8, 0x3C, 0x7C, 0x3E, 0x03, 0xE1, 0xF1, 0xF0,
  0xF8, 0x0F, 0x87, 0xC7, 0xC7, 0xE0, 0x3E, 0x3E, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x7C, 0x7C, 0x03, 0xE3, 0xC1, 0xF3, 0xE0, 0x0F, 0x9F, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x1E, 0x7E, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x03, 0xEF,
  0x81, 0xE7, 0xC0, 0x0F, 0xBC, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x1E, 0xF8,
  0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x08, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x47, 0xF8, 0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x80,
  0x01, 0xFE, 0x20, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 52, 17, 1, -51 },
  { 112, 20, 19, 24, 7, -51 },
  { 160, 32, 51, 30, 0, -51 },
  { 364, 29, 58, 28, 0, -54 },
  { 575, 38, 52, 43, 3, -51 },
  { 822, 29, 52, 30, 0, -51 },
  { 1011, 9, 19, 13, 7, -51 },
  { 1033, 22, 62, 18, 1, -51 },
  { 1204, 21, 62, 18, -5, -51 },
  { 1367, 21, 23, 26, 7, -54 },
  { 1428, 26, 34, 31, 3, -42 },
  { 1539, 12, 17, 14, -3, -8 },
  { 1565, 16, 6, 18, 1, -22 },
  { 1577, 7, 9, 14, 1, -8 },
  { 1585, 32, 51, 24, -3, -51 },
  { 1789, 26, 52, 28, 2, -51 },
  { 1958, 18, 51, 28, 7, -51 },
  { 2073, 30, 51, 28, -2, -51 },
  { 2265, 29, 52, 28, -1, -51 },
  { 2454, 29, 51, 28, -1, -51 },
  { 2639, 29, 52, 28, -1, -51 },
  { 2828, 28, 52, 28, 2, -51 },
  { 3010, 29, 51, 28, 2, -51 },
  { 3195, 30, 52, 28, -1, -51 },
  { 3390, 27, 52, 28, 0, -51 },
  { 3566, 14, 39, 14, 0, -38 },
  { 3635, 18, 47, 14, -4, -38 },
  { 3741, 26, 32, 31, 3, -41 },
  { 3845, 26, 20, 31, 3, -35 },
  { 3910, 26, 32, 31, 3, -41 },
  { 4014, 23, 52, 21, 1, -51 },
  { 4164, 39, 57, 42, 2, -51 },
  { 4442, 29, 51, 29, -5, -51 },
  { 4627, 31, 51, 31, 0, -51 },
  { 4825, 30, 52, 27, 3, -51 },
  { 5020, 32, 51, 33, 0, -51 },
  { 5224, 29, 51, 26, 0, -51 },
  { 5409, 29, 51, 25, 0, -51 },
  { 5594, 34, 52, 35, 3, -51 },
  { 5815, 36, 51, 34, 0, -51 },
  { 6045, 28, 51, 18, -4, -51 },
  { 6224, 26, 65, 14, -10, -51 },
  { 6436, 35, 51, 29, 0, -51 },
  { 6660, 19, 51, 24, 0, -51 },
  { 6782, 48, 51, 46, 0, -51 },
  { 7088, 38, 51, 36, 0, -51 },
  { 7331, 32, 52, 35, 2, -51 },
  { 7539, 30, 51, 29, 0, -51 },
  { 7731, 32, 63, 35, 2, -51 },
  { 7983, 30, 51, 30, 0, -51 },
  { 8175, 31, 52, 27, -2, -51 },
  { 8377, 25, 51, 24, 5, -51 },
  { 8537, 33, 52, 34, 2, -51 },
  { 8752, 29, 51, 29, 6, -51 },
  { 8937, 47, 51, 46, 5, -51 },
  { 9237, 35, 51, 26, -4, -51 },
  { 9461, 26, 51, 25, 5, -51 },
  { 9627, 31, 51, 24, -3, -51 },
  { 9825, 27, 62, 20, -2, -51 },
  { 10035, 12, 51, 24, 7, -51 },
  { 10112, 27, 62, 20, -5, -51 },
  { 10322, 27, 28, 28, 1, -51 },
  { 10417, 22, 4, 22, -6, 6 },
  { 10428, 10, 11, 18, 10, -54 },
  { 10442, 28, 40, 30, 2, -39 },
  { 10582, 28, 55, 30, 0, -54 },
  { 10775, 23, 40, 23, 2, -39 },
  { 10890, 31, 55, 30, 2, -54 },
  { 11104, 24, 40, 27, 2, -39 },
  { 11224, 34, 71, 16, -9, -54 },
  { 11526, 32, 56, 30, -2, -39 },
  { 11750, 27, 54, 29, 0, -54 },
  { 11933, 16, 52, 14, 0, -52 },
  { 12037, 25, 69, 14, -9, -52 },
  { 12253, 29, 54, 26, 0, -54 },
  { 12449, 17, 54, 13, 0, -54 },
  { 12564, 42, 39, 44, 0, -39 },
  { 12769, 27, 39, 29, 0, -39 },
  { 12901, 25, 40, 29, 2, -39 },
  { 13026, 31, 56, 30, -3, -39 },
  { 13243, 28, 56, 30, 2, -39 },
  { 13439, 23, 39, 20, 0, -39 },
  { 13552, 24, 40, 22, -1, -39 },
  { 13672, 17, 48, 17, 2, -47 },
  { 13774, 27, 39, 29, 2, -38 },
  { 13906, 23, 38, 24, 4, -38 },
  { 14016, 38, 38, 39, 4, -38 },
  { 14197, 30, 38, 24, -3, -38 },
  { 14340, 35, 55, 24, -7, -38 },
  { 14581, 25, 38, 20, -3, -38 },
  { 14700, 26, 62, 23, 2, -51 },
  { 14902, 5, 71, 26, 10, -54 },
  { 14947, 25, 62, 23, -4, -51 },
  { 15141, 26, 10, 31, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Italic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC71PT7B_H_
