#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x00, 0x00, 0x00, 0x60, 0x70, 0xF0,
  0xE0, 0x31, 0xB9, 0xDC, 0xEE, 0x76, 0x33, 0x19, 0x8D, 0xCE, 0xC6, 0x00,
  0x01, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x0F, 0xFF, 0x3F, 0xFE, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6,
  0x03, 0x18, 0x06, 0x32, 0x7F, 0xF8, 0xFF, 0xF0, 0x63, 0x00, 0xC6, 0x01,
  0x98, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x63, 0x00, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x01, 0xFF, 0x0F, 0xF8, 0x72, 0x61, 0xC8, 0x06, 0x60, 0x19,
  0x00, 0x64, 0x01, 0xD0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0xB8, 0x06, 0xE0, 0x19, 0x80, 0x46, 0x01, 0x38, 0xC5, 0xC3, 0xFF, 0x0F,
  0xF0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x1F,
  0x03, 0x0C, 0xC3, 0x0C, 0x61, 0x86, 0x31, 0x87, 0x18, 0xC3, 0x1C, 0xC1,
  0x8C, 0x60, 0xC6, 0x60, 0x63, 0x30, 0x33, 0xB3, 0xD9, 0x9B, 0xFD, 0xD9,
  0x9F, 0xDD, 0x8D, 0xCC, 0xC6, 0x0E, 0xE3, 0x06, 0x61, 0x87, 0x31, 0x83,
  0x18, 0xC3, 0x8C, 0x61, 0x86, 0x71, 0x83, 0x30, 0xC1, 0xF0, 0xC0, 0x78,
  0x01, 0xC0, 0x0F, 0xC0, 0x77, 0x01, 0x8C, 0x0E, 0x30, 0x39, 0xC0, 0xE6,
  0x03, 0x98, 0x0E, 0xC0, 0x3F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xEC,
  0x77, 0x39, 0x98, 0xEE, 0xE1, 0xB3, 0x87, 0xCC, 0x1E, 0x30, 0x38, 0xE1,
  0xE3, 0x8F, 0x8F, 0xF7, 0x1F, 0x9C, 0x39, 0x9C, 0xE7, 0x31, 0x8C, 0xC0,
  0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x01, 0x84, 0x61, 0x91, 0xFF, 0xC3, 0xF1, 0xE0, 0xF8,
  0x73, 0x08, 0xE0, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x39, 0xCE, 0xE7, 0x33, 0x98, 0x7F, 0xFF, 0x67, 0xFE,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x07,
  0x70, 0x77, 0x07, 0x60, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C,
  0xC1, 0xCC, 0x1C, 0xC1, 0x8C, 0x38, 0xC3, 0x0E, 0x70, 0xFE, 0x07, 0xC0,
  0x03, 0x83, 0x83, 0xC3, 0xE3, 0xF7, 0xB9, 0x98, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC1, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE3, 0x07, 0x0F,
  0xF8, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x58,
  0x03, 0x60, 0x1B, 0x80, 0x6E, 0x03, 0x30, 0x1C, 0xC0, 0x67, 0x03, 0x1C,
  0x0C, 0x70, 0x61, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xE1, 0xFF, 0xEF, 0xFF,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x07, 0xF8, 0x3F,
  0xC3, 0xFE, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x41, 0xC3, 0xFC, 0x1F, 0xC0,
  0x00, 0xF8, 0x1F, 0x81, 0xF4, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x9C, 0x1B, 0xF0, 0xFB, 0x8F, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE6, 0x06, 0x30, 0x71, 0x83, 0x8E, 0x18, 0x71, 0xC1,
  0xFC, 0x07, 0xC0, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xDE, 0x18,
  0x71, 0xC1, 0x8E, 0x0C, 0x70, 0x63, 0x87, 0x1C, 0x70, 0x77, 0x03, 0xF0,
  0x0F, 0x00, 0xF8, 0x1E, 0xE1, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x03, 0x30,
  0x19, 0x81, 0xCE, 0x0E, 0x70, 0xE1, 0xFE, 0x07, 0xE0, 0x01, 0xC0, 0x3F,
  0x83, 0xFC, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0x81, 0xCC, 0x1C, 0x70, 0xE3, 0x8F, 0x1F, 0xF8, 0x7D, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x83, 0xF8, 0x1F, 0x80,
  0x0C, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x78, 0xE1, 0xC0, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x38, 0x18, 0x1C,
  0x0C, 0x06, 0x06, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x60, 0x02, 0x00, 0x00, 0x07, 0x83, 0xF8,
  0x77, 0x88, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x38,
  0x38, 0x1C, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x31, 0x80, 0x0C, 0xC3, 0xF3,
  0x31, 0xD8, 0xCC, 0x66, 0x36, 0x31, 0x8D, 0x8C, 0x63, 0x66, 0x31, 0xB1,
  0x8C, 0x6C, 0x63, 0x1B, 0x18, 0xC4, 0xC6, 0x73, 0x31, 0x98, 0xCC, 0x7B,
  0xE3, 0x1E, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x60, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x03, 0x98, 0x18, 0xC1,
  0xC6, 0x0E, 0x30, 0x61, 0x87, 0x0C, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xC1,
  0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0x07, 0xC0,
  0x1F, 0xE0, 0x7F, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0xC0, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0xE1, 0xCF, 0x07, 0xF0, 0x3F, 0xE0, 0xE1, 0xC3, 0x83,
  0x0C, 0x0E, 0x30, 0x39, 0xC0, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0xE1, 0x8F,
  0x8F, 0xFC, 0x3F, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC2, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0x80,
  0x0F, 0xF0, 0x1F, 0xF0, 0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0xC7, 0x03,
  0x8E, 0x07, 0x18, 0x0E, 0x30, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x83, 0x86,
  0x1E, 0x0C, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0x02, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0xFC, 0xE0, 0xFC, 0xE0,
  0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0x70,
  0x30, 0x78, 0x70, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0x03, 0x83, 0x01, 0x81,
  0x80, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x30, 0x18, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xC0,
  0xE0, 0xE0, 0x70, 0x60, 0x30, 0x30, 0x18, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x06, 0x03, 0x03, 0x01, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0x07, 0x06, 0x0E, 0x06, 0x0E, 0x0E, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x0C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1D, 0xC0, 0x1F, 0x80,
  0x1B, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x39, 0x80, 0x31, 0xC0, 0x31, 0xC0,
  0x71, 0xC0, 0x71, 0xC0, 0x70, 0xC0, 0x60, 0xE0, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E,
  0x06, 0x03, 0x03, 0xFF, 0xFF, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x36, 0x03, 0xE0, 0xD8, 0x1F,
  0x87, 0x60, 0x6E, 0x1D, 0x83, 0xB0, 0x76, 0x0C, 0xC1, 0x98, 0x37, 0x06,
  0x61, 0xDC, 0x39, 0x86, 0x70, 0xE6, 0x39, 0x83, 0x98, 0xCE, 0x0C, 0x67,
  0x38, 0x31, 0x98, 0xE1, 0xC6, 0xE3, 0x07, 0x1B, 0x0C, 0x18, 0x6C, 0x70,
  0x61, 0xE1, 0xC1, 0x87, 0x87, 0x0E, 0x1E, 0x18, 0x38, 0x70, 0xE0, 0x07,
  0x01, 0xC1, 0xC0, 0x60, 0x70, 0x18, 0x3E, 0x0E, 0x0F, 0x83, 0x83, 0x60,
  0xE0, 0xD8, 0x30, 0x76, 0x0C, 0x1D, 0x87, 0x07, 0x71, 0xC1, 0x9C, 0x70,
  0x63, 0x18, 0x38, 0xC6, 0x0E, 0x33, 0x83, 0x8C, 0xE0, 0xC3, 0xB0, 0x30,
  0xEC, 0x1C, 0x1B, 0x07, 0x07, 0xC1, 0xC1, 0xF0, 0x60, 0x78, 0x18, 0x1E,
  0x0E, 0x07, 0x83, 0x80, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x1E, 0xF0, 0x70,
  0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0x66, 0x00, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x39, 0xC0, 0x73, 0x80, 0xC7, 0x03, 0x8E, 0x0E, 0x0E, 0x3C, 0x1F, 0xF0,
  0x1F, 0x80, 0x07, 0x80, 0x1F, 0xC0, 0x7F, 0x83, 0x8F, 0x0E, 0x1C, 0x38,
  0x70, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x61, 0xC3, 0x86, 0x1C, 0x3F,
  0xF0, 0xFF, 0x03, 0xF0, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x07, 0xF0,
  0x1E, 0xF0, 0x70, 0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x30,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x66, 0x00, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xC7, 0x03, 0x8E, 0x0E, 0x0E,
  0x3C, 0x1F, 0xF0, 0x1F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x83, 0x8F,
  0x0E, 0x1C, 0x38, 0x70, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC3,
  0x86, 0x3C, 0x3F, 0xE0, 0xFF, 0x03, 0x98, 0x0C, 0x60, 0x31, 0xC1, 0xC7,
  0x07, 0x1C, 0x1C, 0x30, 0x60, 0xE1, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0x00,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x78, 0x20, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x08, 0x0E, 0x1C, 0x78, 0x3F, 0xF0, 0x3F, 0x80, 0x7F, 0xF7, 0xFF, 0x7F,
  0xE0, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x06, 0x18, 0x0C,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0x86, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x30, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0C,
  0x30, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0x87, 0x07, 0x0E, 0x0E, 0x1E,
  0x38, 0x1F, 0xE0, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE,
  0x06, 0x70, 0x73, 0x83, 0x18, 0x38, 0xC1, 0xC6, 0x1C, 0x30, 0xE1, 0x86,
  0x0C, 0x70, 0x63, 0x03, 0x38, 0x19, 0xC0, 0xCC, 0x06, 0xE0, 0x36, 0x01,
  0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x38, 0x1D, 0x80,
  0xE0, 0x76, 0x07, 0x81, 0x98, 0x1E, 0x0E, 0x60, 0x78, 0x39, 0x83, 0xE1,
  0xC6, 0x0F, 0x87, 0x18, 0x3C, 0x18, 0x61, 0xB0, 0xE1, 0x86, 0xC3, 0x86,
  0x3B, 0x0C, 0x18, 0xCC, 0x70, 0x63, 0x31, 0x81, 0x98, 0xCE, 0x06, 0x63,
  0x38, 0x1B, 0x8C, 0xC0, 0xEC, 0x37, 0x03, 0xB0, 0xD8, 0x0F, 0xC3, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80, 0x3C,
  0x0E, 0x00, 0x03, 0x03, 0x81, 0x83, 0x80, 0xC1, 0x80, 0x71, 0xC0, 0x38,
  0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0E, 0xE0, 0x06, 0x70, 0x07, 0x38, 0x03, 0x0C, 0x03, 0x86, 0x03, 0x83,
  0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7,
  0x0C, 0x38, 0xE1, 0xC6, 0x06, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xE3, 0x86, 0x18, 0x61, 0x86, 0x1C, 0x71, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x38, 0xE1, 0x86, 0x18, 0x61, 0x87, 0x03, 0xF0, 0x3F, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xC0, 0x3E,
  0x03, 0x30, 0x39, 0x81, 0x8E, 0x1C, 0x71, 0xC1, 0x8C, 0x0C, 0xE0, 0x7E,
  0x01, 0x80, 0xFF, 0xFF, 0xF8, 0xEE, 0x73, 0x30, 0x07, 0x98, 0x7D, 0xC7,
  0x3C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0xE0, 0x67, 0x07,
  0x38, 0x39, 0xC1, 0xCC, 0x0C, 0x60, 0xE3, 0x87, 0x1C, 0x78, 0xFF, 0x83,
  0xEC, 0x00, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x9C, 0x1D, 0xF0, 0xF9, 0xC7, 0x8E, 0x38, 0x71, 0x83, 0x9C,
  0x1C, 0xE0, 0xE6, 0x07, 0x30, 0x39, 0x81, 0x9C, 0x1C, 0xE0, 0xE7, 0x06,
  0x38, 0x73, 0xC7, 0x1F, 0xF8, 0xCF, 0x00, 0x07, 0xC3, 0xF1, 0xC4, 0xE0,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x88, 0x7E, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x81, 0xEE, 0x0F, 0xF8, 0x73, 0xC3,
  0x87, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x06, 0x38, 0x18, 0xE0, 0xE3,
  0x83, 0x8E, 0x0C, 0x30, 0x30, 0xC1, 0xC3, 0x87, 0x0E, 0x3C, 0x3F, 0xE0,
  0x7D, 0x80, 0x07, 0xC1, 0xFC, 0x73, 0x9C, 0x33, 0x06, 0xE1, 0xD8, 0x37,
  0x1E, 0xFF, 0x9F, 0xC3, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x04,
  0x7F, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x2E,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xE6, 0x07, 0xFC, 0x1C, 0xF0, 0x70,
  0xE0, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0C, 0x0C, 0x38, 0x18, 0x70, 0x70,
  0xE0, 0xE1, 0xC1, 0xC3, 0x07, 0x06, 0x0E, 0x0E, 0x3C, 0x1C, 0x78, 0x3F,
  0xE0, 0x3E, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x20, 0x70,
  0x73, 0xC0, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x9C, 0x1F, 0xF0, 0xFB, 0xC7, 0x0E,
  0x38, 0x71, 0x83, 0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x30, 0x71, 0x83, 0x1C,
  0x18, 0xE1, 0xC7, 0x0E, 0x30, 0x71, 0x83, 0x1C, 0x18, 0xE1, 0xC0, 0x07,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x87,
  0x0C, 0x30, 0xE3, 0x87, 0x38, 0x33, 0x81, 0x9C, 0x1D, 0xC0, 0xFC, 0x06,
  0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x30, 0xC1, 0x86,
  0x1C, 0x38, 0xE1, 0xC0, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0x0C, 0xE3, 0xC3, 0xFE, 0xFC, 0x7D, 0xFB,
  0x8E, 0x1C, 0x31, 0xC3, 0x86, 0x30, 0x60, 0xCE, 0x1C, 0x39, 0xC3, 0x87,
  0x38, 0x70, 0xC6, 0x0C, 0x18, 0xC1, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C,
  0xE1, 0xC3, 0x18, 0x30, 0x67, 0x06, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x70,
  0x0C, 0xE0, 0xFF, 0x87, 0xDE, 0x38, 0x71, 0xC3, 0x8C, 0x18, 0xE0, 0xC7,
  0x0E, 0x38, 0x71, 0x83, 0x8C, 0x18, 0xE0, 0xC7, 0x0E, 0x38, 0x71, 0x83,
  0x9C, 0x18, 0xE0, 0xC7, 0x0E, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0xE3, 0x86,
  0x30, 0x77, 0x07, 0x60, 0x76, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0xEC, 0x0E,
  0xC0, 0xCC, 0x1C, 0xE1, 0x8E, 0x38, 0x7F, 0x07, 0xE0, 0x03, 0x38, 0x06,
  0xF8, 0x1F, 0x38, 0x3C, 0x70, 0x70, 0xE0, 0xC1, 0xC3, 0x83, 0x87, 0x07,
  0x0E, 0x0E, 0x18, 0x1C, 0x30, 0x30, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x07,
  0x0E, 0x0E, 0x38, 0x3F, 0xF0, 0x77, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x07, 0x98,
  0x7F, 0xC7, 0x3C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0xE0,
  0x67, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x1C, 0x60, 0xE3, 0x8F, 0x1C, 0x78,
  0xFF, 0x83, 0xEC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0x0D, 0xE3, 0xF8, 0x6F, 0x0F, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xC3, 0xFC, 0xF1, 0x1C, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0xC4, 0x38, 0xFE, 0x1F, 0x80, 0x0C, 0x0C, 0x0C, 0x1C, 0x3F,
  0x7F, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0,
  0xE0, 0xC0, 0xC0, 0xF8, 0xF8, 0x18, 0x33, 0x83, 0x38, 0x73, 0x87, 0x30,
  0x73, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1,
  0xCE, 0x1C, 0xC3, 0x8E, 0x78, 0xFD, 0x87, 0x98, 0xC0, 0xF8, 0x1B, 0x07,
  0x60, 0xCC, 0x39, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x19, 0xC3, 0x30, 0x6E,
  0x0D, 0x81, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE1, 0xC1, 0xF8,
  0x70, 0xEE, 0x3C, 0x3B, 0x0F, 0x0C, 0xC3, 0xC7, 0x31, 0xB1, 0x8C, 0x6C,
  0x63, 0x1B, 0x38, 0xCC, 0xCC, 0x33, 0x37, 0x0D, 0xCD, 0x83, 0x63, 0x60,
  0xD8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x38,
  0x78, 0x00, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x77, 0x00,
  0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0xDC, 0x03, 0x98, 0x06, 0x30, 0x1C, 0x70, 0x70, 0xE1, 0xE1, 0xC0,
  0x07, 0x07, 0x07, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C,
  0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xBC, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x43, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x10, 0x1F, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00,
  0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xF0, 0x1F, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x00, 0x18, 0x0B, 0xF0, 0xFF, 0xFF, 0x07,
  0xE8, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 24, 8, 0, -24 },
  { 25, 9, 9, 11, 3, -24 },
  { 36, 15, 24, 14, 0, -24 },
  { 81, 14, 27, 13, 0, -25 },
  { 129, 17, 24, 20, 2, -24 },
  { 180, 14, 24, 14, 0, -24 },
  { 222, 5, 9, 6, 3, -24 },
  { 228, 10, 29, 8, 1, -24 },
  { 265, 10, 29, 8, -2, -24 },
  { 302, 10, 11, 12, 3, -25 },
  { 316, 12, 15, 14, 1, -19 },
  { 339, 5, 8, 7, -1, -4 },
  { 344, 8, 2, 9, 0, -10 },
  { 346, 4, 4, 7, 0, -4 },
  { 348, 16, 24, 11, -2, -24 },
  { 396, 12, 24, 13, 1, -24 },
  { 432, 9, 24, 13, 3, -24 },
  { 459, 14, 24, 13, -1, -24 },
  { 501, 14, 24, 13, -1, -24 },
  { 543, 14, 24, 13, -1, -24 },
  { 585, 13, 24, 13, 0, -24 },
  { 624, 13, 24, 13, 1, -24 },
  { 663, 13, 24, 13, 1, -24 },
  { 702, 13, 24, 13, 0, -24 },
  { 741, 13, 24, 13, 0, -24 },
  { 780, 7, 18, 7, 0, -18 },
  { 796, 9, 22, 7, -2, -18 },
  { 821, 13, 15, 14, 1, -19 },
  { 846, 12, 9, 14, 1, -16 },
  { 860, 13, 15, 14, 1, -19 },
  { 885, 11, 24, 10, 0, -24 },
  { 918, 18, 27, 19, 1, -24 },
  { 979, 13, 24, 13, -2, -24 },
  { 1018, 14, 24, 14, 0, -24 },
  { 1060, 14, 24, 13, 1, -24 },
  { 1102, 15, 24, 15, 0, -24 },
  { 1147, 14, 24, 12, 0, -24 },
  { 1189, 14, 24, 11, 0, -24 },
  { 1231, 16, 24, 16, 1, -24 },
  { 1279, 17, 24, 16, 0, -24 },
  { 1330, 13, 24, 9, -2, -24 },
  { 1369, 13, 30, 7, -5, -24 },
  { 1418, 16, 24, 13, 0, -24 },
  { 1466, 9, 24, 11, 0, -24 },
  { 1493, 22, 24, 21, 0, -24 },
  { 1559, 18, 24, 17, 0, -24 },
  { 1613, 15, 24, 16, 1, -24 },
  { 1658, 14, 24, 13, 0, -24 },
  { 1700, 15, 30, 16, 1, -24 },
  { 1757, 14, 24, 14, 0, -24 },
  { 1799, 15, 24, 12, -1, -24 },
  { 1844, 12, 24, 11, 2, -24 },
  { 1880, 15, 24, 16, 1, -24 },
  { 1925, 13, 24, 13, 3, -24 },
  { 1964, 22, 24, 22, 2, -24 },
  { 2030, 17, 24, 12, -2, -24 },
  { 2081, 13, 24, 12, 2, -24 },
  { 2120, 14, 24, 11, -1, -24 },
  { 2162, 13, 29, 9, -1, -24 },
  { 2210, 6, 24, 11, 3, -24 },
  { 2228, 12, 29, 9, -2, -24 },
  { 2272, 13, 13, 13, 0, -24 },
  { 2294, 11, 2, 10, -3, 3 },
  { 2297, 4, 5, 8, 5, -25 },
  { 2300, 13, 18, 14, 1, -18 },
  { 2330, 13, 25, 14, 0, -25 },
  { 2371, 10, 18, 10, 1, -18 },
  { 2394, 14, 25, 14, 1, -25 },
  { 2438, 11, 18, 13, 1, -18 },
  { 2463, 15, 33, 8, -4, -25 },
  { 2525, 15, 26, 14, -1, -18 },
  { 2574, 13, 25, 14, 0, -25 },
  { 2615, 8, 24, 6, 0, -24 },
  { 2639, 12, 32, 6, -4, -24 },
  { 2687, 13, 25, 12, 0, -25 },
  { 2728, 8, 25, 6, 0, -25 },
  { 2753, 19, 18, 20, 0, -18 },
  { 2796, 13, 18, 14, 0, -18 },
  { 2826, 12, 18, 13, 1, -18 },
  { 2853, 15, 26, 14, -2, -18 },
  { 2902, 13, 26, 14, 1, -18 },
  { 2945, 11, 18, 9, 0, -18 },
  { 2970, 11, 18, 10, 0, -18 },
  { 2995, 8, 22, 8, 1, -22 },
  { 3017, 12, 18, 14, 1, -18 },
  { 3044, 11, 18, 11, 2, -18 },
  { 3069, 18, 18, 18, 2, -18 },
  { 3110, 15, 18, 11, -2, -18 },
  { 3144, 16, 26, 11, -3, -18 },
  { 3196, 11, 18, 9, -1, -18 },
  { 3221, 12, 29, 11, 1, -24 },
  { 3265, 2, 33, 12, 5, -25 },
  { 3274, 12, 29, 11, -2, -24 },
  { 3318, 13, 5, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Italic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC33PT7B_H_
