#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0x39, 0xDC, 0x67, 0x39, 0xCE, 0x63, 0x98, 0xC6,
  0x31, 0x8C, 0xC7, 0x00, 0x01, 0xC6, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60,
  0x31, 0x80, 0x63, 0x00, 0xC6, 0x0F, 0xFF, 0x3F, 0xFE, 0x0C, 0x60, 0x31,
  0x80, 0x63, 0x00, 0xC6, 0x03, 0x1C, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8,
  0x63, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x63,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0xFE, 0x07, 0xFC, 0x3A, 0x61,
  0xC8, 0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0xD0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xB8, 0x02, 0xE0, 0x09, 0x80, 0x66, 0x01, 0x98,
  0x04, 0xE3, 0x17, 0x8F, 0xFC, 0x3F, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x04, 0x00, 0x07, 0x81, 0xC3, 0xF0, 0x61, 0xCC, 0x30, 0x63,
  0x0C, 0x18, 0xC6, 0x0E, 0x31, 0x83, 0x0C, 0xC0, 0xC7, 0x30, 0x31, 0x98,
  0x0C, 0x66, 0x73, 0x3B, 0x3E, 0xCC, 0xDD, 0xB7, 0x66, 0x7F, 0x9B, 0x9C,
  0x8C, 0xC6, 0x03, 0x31, 0x81, 0x8C, 0x60, 0x66, 0x18, 0x31, 0x86, 0x1C,
  0x63, 0x06, 0x18, 0xC3, 0x86, 0x70, 0xC1, 0xF8, 0x70, 0x3C, 0x00, 0x00,
  0xC0, 0x0F, 0xC0, 0x7F, 0x01, 0x8C, 0x0E, 0x30, 0x38, 0xC0, 0xE3, 0x03,
  0x9C, 0x0E, 0x60, 0x3B, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xB9, 0xDC, 0xE6, 0x61, 0x9B, 0x87, 0xEE, 0x1F, 0x38, 0x3C, 0xC0, 0xE3,
  0x87, 0x8E, 0x3F, 0x3F, 0xDC, 0x7E, 0x70, 0x39, 0x9C, 0xE7, 0x31, 0x8C,
  0xE0, 0x01, 0xC0, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x00, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x33, 0x0F, 0xFE, 0x7F, 0xC3,
  0x80, 0xF0, 0x33, 0x0E, 0x70, 0x8C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x71, 0xCE,
  0x38, 0xC7, 0x38, 0xFF, 0xFC, 0x77, 0xF6, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x7E, 0x07, 0xF0,
  0xE7, 0x1C, 0x31, 0x83, 0x38, 0x33, 0x83, 0x30, 0x77, 0x07, 0x70, 0x76,
  0x07, 0x60, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEC, 0x0C, 0xC1, 0xCC,
  0x1C, 0xC3, 0x8C, 0x38, 0xE7, 0x0F, 0xE0, 0x7C, 0x00, 0x07, 0x0F, 0x3E,
  0x7E, 0xEE, 0xCE, 0x8E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0x00, 0x60, 0x0F,
  0xE0, 0x7F, 0xC1, 0x87, 0x04, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x60, 0x0F, 0xE0, 0x7F, 0xC1, 0x87,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x8C, 0x1E, 0x3F, 0xF0, 0x7F,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x0D, 0x80, 0x1B,
  0x00, 0x6E, 0x00, 0xDC, 0x03, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x63, 0x81,
  0xC7, 0x03, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF,
  0xE0, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x07, 0xFC,
  0x1F, 0xE0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x7E, 0x03, 0xFC, 0x06, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC2, 0x0F,
  0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x70, 0x0F, 0xC0, 0xFE, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1D, 0xF0, 0xDF, 0xC7,
  0x8E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x39, 0x81,
  0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0x87, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x06, 0x1C, 0x38, 0x31, 0xC0, 0xEE, 0x01, 0xF0,
  0x07, 0x80, 0x7F, 0x03, 0x9C, 0x1C, 0x38, 0x60, 0xE3, 0x81, 0x8E, 0x06,
  0x30, 0x18, 0xC0, 0x63, 0x83, 0x8F, 0x1C, 0x1F, 0xF0, 0x3F, 0x00, 0x00,
  0xC0, 0x1F, 0x81, 0xFC, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0x67, 0x07,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x9E, 0xF8, 0x7F, 0xC1,
  0xEE, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x1F, 0xC0, 0xFC, 0x00, 0x0E, 0x3C, 0x70, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x78, 0xF1, 0xC0, 0x03, 0x83, 0xC1, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x06, 0x07, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x03, 0x00, 0x10, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x88, 0x70,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x3C, 0xF0, 0x0C, 0x06,
  0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x0E, 0x19, 0x87, 0xE3,
  0x31, 0x8C, 0x4C, 0x33, 0x99, 0x8C, 0x63, 0x31, 0x8C, 0x66, 0x61, 0x8D,
  0x8C, 0x71, 0xB1, 0x8C, 0x66, 0x31, 0x8C, 0xC6, 0x71, 0x18, 0xCE, 0x63,
  0x1F, 0xF8, 0x61, 0xCE, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x20, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x07, 0x60, 0x1D, 0x80, 0x66,
  0x03, 0x98, 0x0C, 0x60, 0x71, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x60, 0xFF,
  0x87, 0xFE, 0x1C, 0x18, 0xE0, 0x63, 0x81, 0xCE, 0x07, 0x70, 0x1D, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0x07, 0xF8, 0x0F, 0xF8, 0x18, 0x70, 0x70, 0x70,
  0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x7F,
  0xC0, 0xFF, 0x03, 0x9F, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x86, 0x0F, 0x0C, 0x7C, 0x3F, 0xF0, 0x7F,
  0x80, 0x00, 0x30, 0x03, 0xFC, 0x0F, 0xF0, 0x38, 0x20, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x30, 0x1F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xF8, 0x18, 0xF0, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC3,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80,
  0xE7, 0x01, 0x8E, 0x07, 0x1C, 0x0E, 0x30, 0x1C, 0xE0, 0x71, 0xC1, 0xE3,
  0x83, 0x86, 0x0E, 0x0C, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x30, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0x83, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x7E, 0x60,
  0x7C, 0xE0, 0xFC, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0x70, 0x38, 0x78, 0x30, 0x3F, 0xF0, 0x1F, 0xE0, 0x07,
  0x03, 0x83, 0x01, 0xC1, 0x80, 0xE1, 0xC0, 0x60, 0xE0, 0x70, 0x70, 0x38,
  0x30, 0x1C, 0x38, 0x0E, 0x1C, 0x06, 0x0E, 0x07, 0x07, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x30, 0x1C, 0x38,
  0x0C, 0x1C, 0x0E, 0x0E, 0x07, 0x06, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xC1,
  0xC0, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x0F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x07, 0x07, 0x83, 0x07,
  0x01, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x31, 0xC0, 0x39,
  0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xEC, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x30,
  0x0E, 0x1C, 0x06, 0x0E, 0x03, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03,
  0xFF, 0xFF, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xB0, 0x1F, 0x83, 0x60, 0x36, 0x0E, 0xC0,
  0xFC, 0x1D, 0x81, 0xB8, 0x3B, 0x07, 0x70, 0x66, 0x0C, 0xC0, 0xCC, 0x39,
  0x83, 0x98, 0x67, 0x07, 0x31, 0xCE, 0x0E, 0x63, 0x9C, 0x18, 0xE6, 0x30,
  0x31, 0xDC, 0xE0, 0xE3, 0xB1, 0xC1, 0xC7, 0xE3, 0x83, 0x8F, 0x87, 0x06,
  0x1F, 0x0C, 0x0C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0x07,
  0x01, 0xC1, 0xE0, 0x70, 0x78, 0x1C, 0x3E, 0x06, 0x0F, 0x81, 0x83, 0x60,
  0xE0, 0xD8, 0x38, 0x77, 0x0E, 0x1D, 0xC3, 0x07, 0x31, 0xC1, 0x8C, 0x70,
  0x63, 0x1C, 0x38, 0xC7, 0x0E, 0x39, 0x83, 0x8E, 0xE0, 0xC1, 0xB8, 0x30,
  0x6E, 0x1C, 0x1B, 0x07, 0x06, 0xC1, 0xC1, 0xF0, 0x60, 0x7C, 0x18, 0x0F,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0x00, 0x60, 0x03, 0xF0, 0x1F, 0xF0, 0x78,
  0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x01, 0x9C, 0x03, 0x38, 0x06, 0x60, 0x1D,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x0E, 0x1E, 0x1E, 0x78,
  0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x63, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x30, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x86,
  0x1C, 0x3F, 0xF0, 0xFF, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x03, 0xF0, 0x1F, 0xF0, 0x78, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x01, 0x9C,
  0x03, 0x38, 0x06, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEC, 0x01,
  0xF8, 0x03, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01, 0xCE,
  0x07, 0x0E, 0x1E, 0x1E, 0x78, 0x3F, 0xE0, 0x3F, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x63, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x7C, 0x3F, 0xE0, 0xFE, 0x03, 0x9C, 0x0E,
  0x70, 0x31, 0xC1, 0xC7, 0x07, 0x0C, 0x1C, 0x38, 0x60, 0xE1, 0x83, 0x8E,
  0x0E, 0x38, 0x1C, 0x00, 0x60, 0x07, 0xFC, 0x1F, 0xF8, 0x38, 0x20, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x10, 0x1C, 0x38, 0xF8, 0x7F, 0xE0,
  0x7F, 0x80, 0x7F, 0xF7, 0xFF, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E,
  0x18, 0x0E, 0x18, 0x0C, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C,
  0x70, 0x18, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x30,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0xF1, 0xC0, 0x7F, 0xC0,
  0x3F, 0x00, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83,
  0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x38, 0xE0, 0xE7,
  0x03, 0x9C, 0x0E, 0x60, 0x3B, 0x80, 0xEC, 0x03, 0xF0, 0x0D, 0xC0, 0x36,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x38, 0x0E, 0xE0,
  0x70, 0x39, 0xC0, 0xE0, 0x73, 0x83, 0xC0, 0xC6, 0x07, 0x83, 0x8C, 0x1F,
  0x07, 0x18, 0x36, 0x1C, 0x30, 0x6C, 0x38, 0x61, 0xD8, 0x60, 0xC3, 0x31,
  0xC1, 0x8E, 0x63, 0x83, 0x19, 0xCE, 0x06, 0x33, 0x9C, 0x0C, 0xE7, 0x30,
  0x19, 0x8E, 0xE0, 0x33, 0x1D, 0xC0, 0x6C, 0x3B, 0x00, 0xD8, 0x7E, 0x03,
  0xF0, 0xD8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0x80,
  0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0E, 0xE0, 0x06, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03,
  0x87, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x3B, 0x83, 0x9C,
  0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE0, 0xC6, 0x06, 0x70, 0x33, 0x01, 0xB8,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xE1, 0x86, 0x18, 0x61,
  0xC7, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xE3, 0x8E, 0x18, 0x61, 0x86, 0x18,
  0x71, 0xC7, 0x03, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x81, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x06, 0xC0, 0x76, 0x03, 0x38,
  0x39, 0xC1, 0x86, 0x18, 0x31, 0xC1, 0xCC, 0x0E, 0xE0, 0x3E, 0x01, 0x80,
  0xFF, 0xFF, 0xF8, 0xE7, 0x1C, 0x63, 0x80, 0x03, 0x00, 0x7E, 0xC7, 0xF6,
  0x38, 0xF3, 0x87, 0x98, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0x38,
  0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xE2, 0xC7, 0xFE,
  0x1F, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC4, 0x0D, 0xF0, 0xFF, 0xC7, 0x8E, 0x38, 0x31, 0xC1, 0x8C,
  0x0C, 0xE0, 0x67, 0x07, 0x38, 0x39, 0x81, 0xCC, 0x0E, 0xE0, 0x67, 0x07,
  0x38, 0x39, 0xC3, 0x9F, 0x3C, 0xFF, 0xC6, 0x7C, 0x00, 0x01, 0x00, 0xFC,
  0x7F, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0x0F, 0xE0, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x8C, 0x0F, 0xD8, 0x3F, 0xF0, 0x71, 0xE1, 0xC3, 0x83, 0x07,
  0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x61, 0xC0, 0xC3, 0x83, 0x87,
  0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xE0, 0xFF, 0xC0, 0xFB,
  0x80, 0x01, 0x00, 0xFC, 0x7F, 0x8E, 0x33, 0x86, 0xE0, 0xDC, 0x3B, 0x07,
  0xE7, 0xDF, 0xF3, 0xE0, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x8F, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7A, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x07, 0xEC, 0x1F, 0xD8, 0x38, 0xF0, 0xE1, 0xE1, 0x83, 0x87,
  0x07, 0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x30, 0xE0, 0x61, 0xC1, 0xC3, 0x83,
  0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x7F, 0xE0, 0x7D, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0xC3, 0xC1, 0xFF,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC8, 0x0D, 0xF0, 0xFF, 0xC7, 0x8E, 0x38, 0x71, 0xC3,
  0x8C, 0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0x83, 0x8C, 0x1C, 0xE0, 0xC7,
  0x06, 0x38, 0x71, 0x83, 0x8C, 0x1C, 0xE0, 0xC7, 0x0E, 0x00, 0x07, 0x07,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x80, 0xF0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x81, 0x0C, 0x38, 0x30, 0xE1, 0xC7, 0x07, 0x38, 0x19, 0xC0,
  0x67, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x1C, 0xE0,
  0x71, 0x81, 0xC6, 0x06, 0x1C, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x07,
  0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0x00, 0x60, 0x80, 0xDF, 0x3E, 0x1F, 0xFF, 0xF1, 0xE3, 0xC7, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x18, 0x38, 0x73, 0x83, 0x06, 0x38, 0x70, 0x63,
  0x87, 0x0E, 0x30, 0x70, 0xE3, 0x06, 0x0E, 0x70, 0x60, 0xC7, 0x0E, 0x1C,
  0x70, 0xE1, 0xC6, 0x0E, 0x1C, 0xE0, 0xC1, 0x8E, 0x0C, 0x18, 0xE1, 0xC3,
  0x80, 0x00, 0x60, 0x6F, 0x87, 0xFE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x60,
  0xE7, 0x07, 0x38, 0x31, 0xC3, 0x8C, 0x1C, 0x60, 0xE7, 0x06, 0x38, 0x31,
  0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x70, 0x01, 0x00, 0xFE, 0x1F,
  0xE1, 0xC7, 0x38, 0x73, 0x07, 0x70, 0x76, 0x07, 0x60, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF0, 0x3E,
  0x00, 0x00, 0x08, 0x06, 0xF8, 0x0F, 0xF8, 0x3C, 0x70, 0x70, 0x60, 0xE0,
  0xC1, 0x81, 0x87, 0x03, 0x0E, 0x06, 0x1C, 0x1C, 0x30, 0x38, 0x60, 0x71,
  0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1C, 0x1E, 0x78, 0x7F, 0xE0, 0xEF,
  0x81, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x03, 0x00, 0x7E, 0xC7, 0xF6, 0x38, 0xF3, 0x87,
  0x98, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0x38, 0x19, 0xC1, 0xCE,
  0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xFE, 0x1F, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x41, 0xBC, 0x7F, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x00, 0x02, 0x01, 0xFC, 0x7F, 0x9C, 0x23, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x87, 0x1F, 0xE3, 0xF8, 0x00, 0x0C, 0x0C, 0x1C, 0x1C, 0x7F, 0x7F,
  0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0xC0, 0xE0, 0xF8, 0xF8, 0x18, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x07,
  0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0x8E,
  0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0xF8, 0xFD, 0x83, 0xCC, 0x00, 0xE0, 0xFC,
  0x1B, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x38, 0xC7, 0x38, 0xE6, 0x1D, 0xC3,
  0xB0, 0x7E, 0x0F, 0xC1, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE1,
  0xE1, 0xF8, 0x78, 0x6E, 0x1C, 0x3B, 0x8F, 0x0E, 0xE3, 0xC3, 0x39, 0xF1,
  0xCE, 0x6C, 0x63, 0x1B, 0x38, 0xCC, 0xCE, 0x33, 0x33, 0x0D, 0xCD, 0xC3,
  0x63, 0x60, 0xD8, 0xD8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE0,
  0xE0, 0x38, 0x38, 0x00, 0x06, 0x0E, 0x0E, 0x38, 0x1C, 0x60, 0x39, 0xC0,
  0x77, 0x00, 0x6C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xEC, 0x03, 0x98, 0x06, 0x38, 0x1C, 0x70, 0x70, 0xE1,
  0xE1, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xF0, 0x1F,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0x80, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x1F, 0x00,
  0x70, 0x1F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F,
  0xF8, 0xF1, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 10, 9, 11, 3, -24 },
  { 40, 15, 24, 14, 0, -24 },
  { 85, 14, 28, 13, 0, -26 },
  { 134, 18, 25, 21, 2, -25 },
  { 191, 14, 25, 15, 0, -25 },
  { 235, 5, 9, 6, 3, -24 },
  { 241, 10, 29, 9, 1, -24 },
  { 278, 10, 29, 9, -2, -24 },
  { 315, 11, 11, 12, 3, -26 },
  { 331, 13, 16, 15, 1, -20 },
  { 357, 6, 8, 7, -2, -4 },
  { 363, 7, 2, 9, 1, -10 },
  { 365, 4, 4, 7, 0, -4 },
  { 367, 16, 24, 11, -2, -24 },
  { 415, 12, 25, 13, 1, -25 },
  { 453, 8, 24, 13, 4, -24 },
  { 477, 14, 25, 13, -1, -25 },
  { 521, 14, 25, 13, -1, -25 },
  { 565, 15, 24, 13, -1, -24 },
  { 610, 14, 24, 13, 0, -24 },
  { 652, 13, 25, 13, 1, -25 },
  { 693, 14, 24, 13, 1, -24 },
  { 735, 14, 25, 13, 0, -25 },
  { 779, 13, 25, 13, 0, -25 },
  { 820, 7, 18, 7, 0, -18 },
  { 836, 9, 22, 7, -2, -18 },
  { 861, 13, 16, 15, 1, -20 },
  { 887, 13, 10, 15, 1, -17 },
  { 904, 13, 16, 15, 1, -20 },
  { 930, 11, 25, 10, 0, -25 },
  { 965, 19, 27, 20, 1, -24 },
  { 1030, 14, 24, 14, -2, -24 },
  { 1072, 15, 24, 15, 0, -24 },
  { 1117, 15, 25, 13, 1, -25 },
  { 1164, 15, 24, 16, 0, -24 },
  { 1209, 14, 24, 12, 0, -24 },
  { 1251, 14, 24, 12, 0, -24 },
  { 1293, 16, 25, 17, 1, -25 },
  { 1343, 17, 24, 16, 0, -24 },
  { 1394, 13, 24, 9, -2, -24 },
  { 1433, 13, 31, 7, -5, -24 },
  { 1484, 17, 24, 14, 0, -24 },
  { 1535, 9, 24, 11, 0, -24 },
  { 1562, 23, 24, 22, 0, -24 },
  { 1631, 18, 24, 17, 0, -24 },
  { 1685, 15, 25, 17, 1, -25 },
  { 1732, 14, 24, 14, 0, -24 },
  { 1774, 15, 31, 17, 1, -25 },
  { 1833, 14, 24, 14, 0, -24 },
  { 1875, 15, 25, 13, -1, -25 },
  { 1922, 12, 24, 12, 2, -24 },
  { 1958, 16, 24, 16, 1, -24 },
  { 2006, 14, 24, 14, 3, -24 },
  { 2048, 23, 24, 22, 2, -24 },
  { 2117, 17, 24, 13, -2, -24 },
  { 2168, 13, 24, 12, 2, -24 },
  { 2207, 15, 24, 11, -1, -24 },
  { 2252, 13, 29, 10, -1, -24 },
  { 2300, 6, 24, 12, 3, -24 },
  { 2318, 13, 29, 10, -2, -24 },
  { 2366, 13, 13, 14, 0, -24 },
  { 2388, 11, 2, 10, -3, 3 },
  { 2391, 5, 5, 8, 5, -26 },
  { 2395, 13, 19, 14, 1, -19 },
  { 2426, 13, 26, 14, 0, -26 },
  { 2469, 11, 19, 11, 1, -19 },
  { 2496, 15, 26, 14, 1, -26 },
  { 2545, 11, 19, 13, 1, -19 },
  { 2572, 16, 34, 8, -4, -26 },
  { 2640, 15, 27, 14, -1, -19 },
  { 2691, 13, 26, 14, 0, -26 },
  { 2734, 8, 25, 7, 0, -25 },
  { 2759, 12, 33, 7, -4, -25 },
  { 2809, 14, 26, 12, 0, -26 },
  { 2855, 8, 26, 6, 0, -26 },
  { 2881, 20, 19, 21, 0, -19 },
  { 2929, 13, 19, 14, 0, -19 },
  { 2960, 12, 19, 14, 1, -19 },
  { 2989, 15, 27, 14, -2, -19 },
  { 3040, 13, 27, 14, 1, -19 },
  { 3084, 11, 19, 9, 0, -19 },
  { 3111, 11, 19, 11, 0, -19 },
  { 3138, 8, 22, 8, 1, -22 },
  { 3160, 13, 18, 14, 1, -18 },
  { 3190, 11, 18, 11, 2, -18 },
  { 3215, 18, 18, 18, 2, -18 },
  { 3256, 15, 18, 12, -2, -18 },
  { 3290, 16, 26, 12, -3, -18 },
  { 3342, 12, 18, 10, -1, -18 },
  { 3369, 12, 29, 11, 1, -24 },
  { 3413, 2, 34, 12, 5, -26 },
  { 3422, 12, 29, 11, -2, -24 },
  { 3466, 13, 4, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Italic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC34PT7B_H_
