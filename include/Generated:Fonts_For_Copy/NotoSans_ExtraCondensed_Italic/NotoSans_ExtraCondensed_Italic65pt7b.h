#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C,
  0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xDB, 0xF0, 0x07, 0xE7, 0x0E, 0x01, 0xF8, 0xE0, 0x40,
  0x3E, 0x1C, 0x00, 0x07, 0x83, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x8C, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x3F, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0xF0,
  0x00, 0x07, 0x3E, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x18, 0x7C, 0x00, 0x07,
  0x0F, 0x80, 0x00, 0xE1, 0xF0, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0x07, 0xC0,
  0x00, 0x60, 0xF0, 0x00, 0x1C, 0x3E, 0x02, 0x03, 0x8F, 0xC0, 0xF0, 0x73,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0x80, 0x3F, 0xE0, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0xF0, 0x0F,
  0x8F, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00,
  0x78, 0x3C, 0x03, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x1F, 0x00, 0x78, 0x0F, 0x07,
  0x80, 0x1E, 0x03, 0xC3, 0xE0, 0x07, 0x81, 0xE0, 0xF0, 0x01, 0xE0, 0x78,
  0x7C, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x3C, 0x07, 0x8F, 0x80, 0x0F, 0x03,
  0xC3, 0xC0, 0x03, 0xC0, 0xF1, 0xE0, 0xFC, 0xF0, 0x3C, 0x78, 0x7F, 0xBC,
  0x1E, 0x3C, 0x3F, 0xFF, 0x07, 0x8F, 0x1F, 0x7F, 0xC3, 0xC7, 0x8F, 0x8F,
  0xF9, 0xF1, 0xE3, 0xC3, 0xDF, 0xF8, 0xF1, 0xE0, 0xF7, 0xFC, 0x3C, 0x78,
  0x3C, 0xFE, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC0, 0x03, 0xC3,
  0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x1E,
  0x1E, 0x03, 0xC0, 0x0F, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x78, 0x01,
  0xE0, 0x78, 0x1E, 0x00, 0xF8, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x03, 0xC0,
  0x1F, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x1E,
  0x00, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0x79,
  0xF0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xC0, 0x07, 0xFC, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x3F, 0x7E,
  0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F,
  0x81, 0xF3, 0xE3, 0xE0, 0x3E, 0x7C, 0x7C, 0x07, 0xDF, 0x1F, 0x00, 0x7F,
  0xE3, 0xE0, 0x0F, 0xF8, 0x7C, 0x01, 0xFF, 0x0F, 0x80, 0x3F, 0xC1, 0xF0,
  0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x07, 0xF8,
  0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xBF, 0x07, 0xFF,
  0xE7, 0xE0, 0x7F, 0xF8, 0x7C, 0x07, 0xFC, 0x0F, 0xC0, 0x1C, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x02, 0x07, 0x80, 0x70, 0x78, 0x07, 0xC7, 0x80, 0x7F, 0x71,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x1F, 0x1E, 0x07, 0xE1, 0xF0, 0x3E,
  0x1F, 0x01, 0xC0, 0xF8, 0x08, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0x80, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x7C,
  0xFB, 0xFF, 0xEF, 0xDF, 0xBE, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F,
  0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0x7C, 0xFC, 0x7C, 0xF8,
  0x7C, 0x70, 0xFC, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0xC0, 0x0E, 0x01, 0xF8, 0x00,
  0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x1F, 0x80, 0x18,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x10, 0x00, 0xFE, 0x03,
  0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x80,
  0x1E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0xC0, 0x07, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x87,
  0xF0, 0x07, 0xCF, 0xFC, 0x03, 0xEF, 0xFF, 0x03, 0xEF, 0xFF, 0x81, 0xFF,
  0x9F, 0xE0, 0xFF, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x3F,
  0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x01, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xC1, 0xFF, 0x07, 0xFF, 0xEF, 0x81,
  0xFF, 0xEF, 0x80, 0x7F, 0xE7, 0xC0, 0x3F, 0xE3, 0xE0, 0x07, 0xC3, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0x20, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0x81, 0xF8, 0x10, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x7F, 0x81, 0xC1, 0xE0, 0x3F, 0xF8, 0x38, 0x78,
  0x0F, 0xFF, 0x07, 0x0F, 0x03, 0xF3, 0xC0, 0xE3, 0xC0, 0x78, 0x78, 0x1C,
  0x78, 0x1E, 0x0F, 0x07, 0x8E, 0x07, 0x81, 0xE0, 0xF3, 0xC0, 0xF0, 0x78,
  0x1E, 0x78, 0x3C, 0x0F, 0x03, 0xCE, 0x07, 0x81, 0xE0, 0x7B, 0xC0, 0xF0,
  0x3C, 0x0E, 0x78, 0x3C, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xE0, 0x79, 0xC0,
  0xF0, 0x3C, 0x0F, 0x78, 0x1C, 0x07, 0x81, 0xCF, 0x07, 0x81, 0xF0, 0x79,
  0xE0, 0xF0, 0x3C, 0x0F, 0x3C, 0x1E, 0x07, 0x81, 0xC7, 0x83, 0xC1, 0xF0,
  0x78, 0xF0, 0x78, 0x3E, 0x0F, 0x1E, 0x0F, 0x0F, 0xC3, 0xC3, 0x81, 0xE1,
  0xB8, 0x70, 0x70, 0x3E, 0x77, 0x1E, 0x0E, 0x07, 0xFC, 0xFF, 0x81, 0xC0,
  0x7F, 0x9F, 0xE0, 0x38, 0x07, 0xE1, 0xF8, 0x07, 0x80, 0x20, 0x0C, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xF0,
  0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x1F, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF8, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x3F, 0xC1,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xC1,
  0xFE, 0x00, 0x3E, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x02, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x3F,
  0x00, 0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xC1, 0xF0,
  0x03, 0xFF, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x03, 0x1F, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x0F, 0xE7, 0xC0, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xDE, 0x00, 0x07, 0xFE, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00,
  0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xE3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x03, 0xC1,
  0xF0, 0x07, 0xC1, 0xE0, 0xF8, 0x7E, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x80,
  0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x07, 0xC0, 0xF0, 0xF8, 0x3E, 0x00, 0xF8,
  0x1E, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC7, 0xC1, 0xF8, 0x03, 0xE0, 0x79,
  0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xEF, 0x80,
  0xF8, 0x03, 0xE0, 0x3D, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xBC, 0x07, 0xC0,
  0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x80, 0xFC, 0x01, 0xF0, 0x0F,
  0xE0, 0x1F, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x0F, 0xE0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x03, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x3F,
  0xE0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0x80,
  0x1E, 0xF8, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x00, 0xFB, 0xE0, 0x0F,
  0x80, 0x1F, 0x7C, 0x01, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x00, 0x7C, 0xF0,
  0x07, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x3E, 0x00, 0x7C,
  0x7C, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0xF8, 0x01, 0xF0, 0xF0, 0x1F, 0x00,
  0x7C, 0x1E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x01, 0xF0, 0x1E,
  0x1F, 0x00, 0x3E, 0x03, 0xC3, 0xE0, 0x07, 0xC0, 0x7C, 0x7C, 0x00, 0xF8,
  0x0F, 0x8F, 0x80, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x3E, 0x7C, 0x00,
  0xF8, 0x03, 0xCF, 0x80, 0x1F, 0x00, 0x79, 0xF0, 0x03, 0xE0, 0x0F, 0xBE,
  0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07,
  0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x03, 0xE0,
  0x01, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x07, 0xF8, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x81,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xC3, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7C, 0x3F,
  0xC0, 0x07, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x0F, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xF0, 0x03, 0xF8,
  0x01, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x40, 0x01, 0xFC, 0x03, 0x80, 0x1F, 0xC0, 0x1F, 0x87, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x80,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xC7,
  0xE0, 0x07, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xFF,
  0x80, 0x3E, 0x0F, 0x80, 0x3F, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xBE, 0x01,
  0xF0, 0x3E, 0x01, 0xF7, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0x9E, 0x01, 0xF0, 0x1F, 0x01, 0xF3, 0xC0, 0x7C, 0x03, 0xE0,
  0x3C, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x8F, 0x03, 0xF0, 0x0F, 0x81, 0xF1,
  0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x3C, 0x0F, 0x80, 0x3E, 0x0F, 0x87, 0x83,
  0xF0, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x80,
  0x1F, 0x0F, 0x83, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x00, 0x7C,
  0x7C, 0x0F, 0x1F, 0x80, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xE0,
  0x3C, 0x7C, 0x00, 0x3E, 0x7C, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0xF3,
  0xE0, 0x00, 0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F,
  0x78, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03,
  0xC3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x1F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xE0, 0x00, 0x3F, 0x87, 0x80, 0x7F, 0xE3, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F,
  0xFD, 0xF0, 0x7F, 0x0E, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00,
  0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7F, 0x03, 0xF0,
  0x7F, 0x81, 0xFF, 0xF7, 0xC0, 0x7F, 0xF3, 0xC0, 0x1F, 0xF1, 0xE0, 0x07,
  0xF0, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0xE0, 0x07, 0xCF, 0xFC, 0x01, 0xF7,
  0xFF, 0x00, 0x7B, 0xFF, 0xE0, 0x3F, 0xE1, 0xF8, 0x0F, 0xF0, 0x3E, 0x03,
  0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xF0, 0x1E, 0xFF, 0xF8, 0x0F,
  0xBF, 0xFC, 0x03, 0xE7, 0xFE, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0x06, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0x03, 0xF8, 0x30, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0xEF, 0x80,
  0x3F, 0xFE, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xC0,
  0x7F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C,
  0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFE, 0x00, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFF, 0xBE, 0x00, 0x7F, 0xF3, 0xC0, 0x03, 0xFE, 0x3C, 0x00,
  0x1F, 0xC3, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF0, 0xF8, 0x1F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x02, 0x0F, 0xE0, 0x38, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xF0, 0x01, 0xFF,
  0x8F, 0x00, 0x3F, 0xFD, 0xF0, 0x07, 0xFF, 0xDF, 0x00, 0x7E, 0x1D, 0xE0,
  0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x01, 0xFC, 0x01,
  0xF0, 0x1F, 0xC0, 0x1F, 0x87, 0xFC, 0x01, 0xFF, 0xF7, 0xC0, 0x0F, 0xFE,
  0x78, 0x00, 0xFF, 0xEF, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x80, 0x0F, 0xC0, 0x0E, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC7, 0xF0, 0x03, 0xE7, 0xFE, 0x01, 0xF7, 0xFF, 0x00, 0xF7,
  0xFF, 0xC0, 0xFF, 0x8F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xEF, 0x80,
  0x07, 0xFB, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xE1, 0xFC, 0x0F, 0xF0,
  0x07, 0x8F, 0xF8, 0x7F, 0xE0, 0x1E, 0x7F, 0xF3, 0xFF, 0x80, 0x7B, 0xFF,
  0xDF, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xF0,
  0x3F, 0x01, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0xF1, 0xFF,
  0x80, 0x79, 0xFF, 0xC0, 0x3D, 0xFF, 0xF0, 0x3F, 0xE3, 0xF8, 0x1F, 0xE0,
  0xFC, 0x0F, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x01, 0xE3, 0xFF, 0x00,
  0x0F, 0x3F, 0xF8, 0x00, 0x7B, 0xFF, 0xE0, 0x07, 0xDC, 0x3F, 0x00, 0x3F,
  0xC0, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0x3F, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x07, 0xC7, 0xF8, 0x00, 0x3E,
  0x0E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x7F, 0xE3,
  0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFD, 0xF0, 0x3F, 0x0E, 0xF0, 0x3F, 0x03,
  0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0xFE,
  0x07, 0xC0, 0x7F, 0x03, 0xF0, 0xFF, 0x81, 0xFF, 0xF7, 0xC0, 0x7F, 0xF3,
  0xC0, 0x3F, 0xF3, 0xE0, 0x0F, 0xF1, 0xF0, 0x00, 0xE0, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE1,
  0xF8, 0x0F, 0x1F, 0x80, 0x79, 0xFC, 0x03, 0xDF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xF0, 0x38, 0x1F, 0x80, 0x20, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x82, 0x00, 0x7E, 0x0E, 0x03, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF4, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0xFE, 0x07, 0xC0, 0xFE, 0x03, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xF7, 0xC0, 0x3F, 0xF3, 0xC0, 0x0F, 0xF1, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xEF, 0x80, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x01,
  0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0xF8, 0x0F, 0xF0, 0x1F, 0x1F,
  0x01, 0xFE, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x78, 0x7C, 0x0F, 0x78, 0x1F,
  0x0F, 0x81, 0xEF, 0x03, 0xE1, 0xF0, 0x7D, 0xE0, 0xF8, 0x3E, 0x0F, 0x3C,
  0x1F, 0x07, 0xC1, 0xEF, 0x83, 0xC0, 0xF8, 0x79, 0xF0, 0xF8, 0x1F, 0x0F,
  0x3E, 0x1F, 0x03, 0xE3, 0xE7, 0xC7, 0xC0, 0x7C, 0x78, 0xF8, 0xF8, 0x0F,
  0x0F, 0x1E, 0x1E, 0x01, 0xE3, 0xE3, 0xC7, 0xC0, 0x3C, 0x78, 0x78, 0xF8,
  0x07, 0x9F, 0x0F, 0x1E, 0x00, 0xF3, 0xC1, 0xE7, 0xC0, 0x1E, 0x78, 0x3C,
  0xF0, 0x03, 0xDF, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0xF7, 0xC0, 0x0F, 0x78,
  0x1E, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x9F, 0xFB, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 47, 15, 1, -46 },
  { 90, 19, 16, 22, 6, -46 },
  { 128, 29, 46, 28, 0, -46 },
  { 295, 27, 53, 25, 0, -49 },
  { 474, 34, 48, 40, 3, -47 },
  { 678, 27, 48, 28, 0, -47 },
  { 840, 8, 16, 12, 7, -46 },
  { 856, 20, 57, 17, 1, -47 },
  { 999, 20, 57, 17, -5, -47 },
  { 1142, 20, 22, 23, 6, -50 },
  { 1197, 24, 30, 28, 3, -38 },
  { 1287, 11, 16, 13, -3, -7 },
  { 1309, 15, 5, 17, 1, -20 },
  { 1319, 7, 8, 13, 1, -7 },
  { 1326, 30, 47, 22, -3, -47 },
  { 1503, 24, 48, 25, 1, -47 },
  { 1647, 16, 46, 25, 7, -46 },
  { 1739, 27, 47, 25, -2, -47 },
  { 1898, 27, 48, 25, -1, -47 },
  { 2060, 27, 47, 25, -1, -47 },
  { 2219, 27, 47, 25, -1, -46 },
  { 2378, 25, 48, 25, 2, -47 },
  { 2528, 26, 46, 25, 2, -46 },
  { 2678, 26, 48, 25, 0, -47 },
  { 2834, 25, 48, 25, 0, -47 },
  { 2984, 13, 36, 13, 0, -35 },
  { 3043, 16, 44, 13, -3, -35 },
  { 3131, 24, 29, 28, 3, -38 },
  { 3218, 24, 18, 28, 3, -32 },
  { 3272, 24, 29, 28, 3, -38 },
  { 3359, 21, 48, 19, 1, -47 },
  { 3485, 35, 52, 38, 2, -47 },
  { 3713, 26, 47, 26, -4, -47 },
  { 3866, 28, 46, 28, 0, -46 },
  { 4027, 28, 48, 25, 2, -47 },
  { 4195, 29, 46, 30, 0, -46 },
  { 4362, 27, 46, 24, 0, -46 },
  { 4518, 27, 46, 22, 0, -46 },
  { 4674, 31, 48, 32, 2, -47 },
  { 4860, 33, 46, 31, 0, -46 },
  { 5050, 25, 46, 17, -3, -46 },
  { 5194, 25, 58, 13, -10, -46 },
  { 5376, 32, 46, 26, 0, -46 },
  { 5560, 18, 46, 22, 0, -46 },
  { 5664, 43, 46, 42, 0, -46 },
  { 5912, 35, 46, 33, 0, -46 },
  { 6114, 29, 48, 32, 2, -47 },
  { 6288, 27, 46, 26, 0, -46 },
  { 6444, 29, 58, 32, 2, -47 },
  { 6655, 28, 46, 27, 0, -46 },
  { 6816, 29, 48, 24, -2, -47 },
  { 6990, 23, 46, 22, 4, -46 },
  { 7123, 30, 47, 31, 2, -46 },
  { 7300, 26, 46, 26, 6, -46 },
  { 7450, 43, 46, 42, 5, -46 },
  { 7698, 33, 46, 24, -4, -46 },
  { 7888, 24, 46, 23, 5, -46 },
  { 8026, 29, 46, 22, -3, -46 },
  { 8193, 25, 57, 18, -2, -47 },
  { 8372, 10, 47, 22, 7, -47 },
  { 8431, 24, 57, 18, -4, -47 },
  { 8602, 25, 24, 26, 1, -46 },
  { 8677, 21, 4, 20, -6, 5 },
  { 8688, 9, 11, 16, 9, -50 },
  { 8701, 25, 36, 28, 2, -35 },
  { 8814, 26, 50, 27, 0, -49 },
  { 8977, 21, 36, 21, 2, -35 },
  { 9072, 28, 50, 27, 2, -49 },
  { 9247, 22, 36, 25, 2, -35 },
  { 9346, 30, 66, 15, -8, -50 },
  { 9594, 28, 51, 28, -1, -35 },
  { 9773, 25, 49, 27, 0, -49 },
  { 9927, 15, 48, 12, 0, -48 },
  { 10017, 23, 64, 13, -8, -48 },
  { 10201, 26, 49, 23, 0, -49 },
  { 10361, 16, 49, 12, 0, -49 },
  { 10459, 38, 35, 40, 0, -35 },
  { 10626, 25, 35, 27, 0, -35 },
  { 10736, 23, 36, 26, 2, -35 },
  { 10840, 29, 50, 27, -3, -35 },
  { 11022, 25, 51, 27, 2, -35 },
  { 11182, 21, 35, 18, 0, -35 },
  { 11274, 22, 36, 21, -1, -35 },
  { 11373, 15, 44, 15, 2, -43 },
  { 11456, 25, 36, 27, 2, -35 },
  { 11569, 21, 35, 22, 4, -35 },
  { 11661, 35, 35, 35, 3, -35 },
  { 11815, 28, 35, 22, -3, -35 },
  { 11938, 31, 51, 22, -6, -35 },
  { 12136, 22, 35, 18, -2, -35 },
  { 12233, 24, 56, 21, 1, -46 },
  { 12401, 5, 65, 24, 9, -50 },
  { 12442, 24, 56, 21, -4, -46 },
  { 12610, 24, 8, 28, 3, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Italic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC65PT7B_H_
