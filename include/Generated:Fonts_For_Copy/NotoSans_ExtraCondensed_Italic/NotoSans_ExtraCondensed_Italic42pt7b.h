#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xE0, 0x00, 0x38, 0xF3, 0x8E, 0x78, 0xE7,
  0x8E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0xCE, 0x18, 0xE3, 0x80,
  0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38,
  0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x01, 0xC7, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0xC7, 0x00,
  0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x06,
  0x18, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1E, 0x62, 0x0E, 0x20, 0x07, 0x30, 0x03, 0x98, 0x01,
  0xCC, 0x00, 0xE4, 0x00, 0x7A, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x37, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x04,
  0x70, 0x06, 0x38, 0x03, 0x1C, 0x41, 0x9C, 0x38, 0xDE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x80, 0x70, 0x3F, 0x01, 0x81, 0xDC, 0x0E, 0x0E, 0x30, 0x30,
  0x30, 0xC1, 0xC1, 0xC3, 0x06, 0x07, 0x0C, 0x38, 0x18, 0x30, 0xC0, 0x61,
  0xC7, 0x03, 0x87, 0x18, 0x0E, 0x1C, 0xE0, 0x38, 0x67, 0x00, 0xE3, 0x9C,
  0xFB, 0x8E, 0xE7, 0xFE, 0x73, 0x99, 0xF9, 0xDC, 0xE7, 0xFE, 0x73, 0x0D,
  0xF3, 0x9C, 0x70, 0x0E, 0x61, 0xC0, 0x71, 0x87, 0x01, 0xCE, 0x1C, 0x0E,
  0x38, 0x70, 0x30, 0xE1, 0x81, 0xC3, 0x0E, 0x06, 0x0C, 0x38, 0x38, 0x30,
  0xC0, 0xC0, 0xC7, 0x07, 0x03, 0xB8, 0x18, 0x0F, 0xE0, 0xE0, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xEE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE3,
  0x9E, 0x71, 0xDE, 0x39, 0xEE, 0x1E, 0xEF, 0x0F, 0x77, 0x03, 0xF3, 0x81,
  0xF9, 0xC0, 0xF8, 0xE0, 0x3C, 0x70, 0x3E, 0x3C, 0x3F, 0x1F, 0xFF, 0x87,
  0xF9, 0xE1, 0xF8, 0x70, 0x3C, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0x61, 0x8E,
  0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x86, 0x07, 0x30, 0x7F, 0xFC, 0xFF, 0xE0, 0xFF, 0x1F,
  0x01, 0xFC, 0x1E, 0x70, 0xE3, 0x83, 0x0E, 0x00, 0x40, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E,
  0x1C, 0x78, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xC3, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x33, 0xDF, 0xF7, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3C,
  0x70, 0xF0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1C,
  0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0E, 0x70,
  0x1D, 0xE0, 0x3B, 0xC0, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7, 0x07, 0xFE, 0x07, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x07, 0xE1, 0xFC, 0x7F, 0xBE, 0xF3,
  0x1C, 0x43, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0x60, 0xF0, 0x20, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0C, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x08, 0x07,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x0F, 0xE0, 0x03, 0x70,
  0x01, 0xDC, 0x00, 0x67, 0x00, 0x3B, 0xC0, 0x1C, 0xE0, 0x06, 0x38, 0x03,
  0x8E, 0x01, 0xC3, 0x80, 0x61, 0xE0, 0x38, 0x70, 0x0C, 0x1C, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0xF0, 0x70, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x20,
  0x3C, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x39, 0xF0, 0x3B, 0xF8, 0x77, 0xF8,
  0x7E, 0x3C, 0x78, 0x3C, 0x78, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C,
  0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0x70,
  0x70, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0xE0, 0xF0, 0xF0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x03, 0x83, 0xC3, 0x80,
  0xE3, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0xE0, 0x1E, 0x78,
  0x1E, 0x3C, 0x1E, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x3C, 0x1E, 0x0F, 0xBE, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0x8F,
  0x0F, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x1E, 0x3E,
  0x1F, 0xEE, 0x0F, 0xCE, 0x07, 0x9E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0x02, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x70,
  0xF8, 0xF0, 0xF0, 0x00, 0xC0, 0x38, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x20, 0xF0, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xE0,
  0x0F, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x87,
  0x00, 0x03, 0x0C, 0x0F, 0x86, 0x38, 0x7F, 0x8C, 0x61, 0xC6, 0x19, 0xC3,
  0x1C, 0x33, 0x0E, 0x38, 0xE6, 0x18, 0x71, 0xDC, 0x70, 0xC3, 0xB0, 0xC3,
  0x86, 0x61, 0x87, 0x0C, 0xC7, 0x0E, 0x3B, 0x8E, 0x18, 0x77, 0x1C, 0x70,
  0xCE, 0x38, 0xE3, 0x9C, 0x73, 0xC6, 0x38, 0xE7, 0x9C, 0x61, 0xFB, 0xF0,
  0xE1, 0xE3, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x07,
  0x0E, 0x07, 0x87, 0x03, 0x83, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x9E, 0x01,
  0xCE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x1C, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x38, 0x1E,
  0x0E, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x1C, 0x1E, 0x07,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80,
  0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1C, 0x07, 0x87, 0x07, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0xF8, 0x20, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x08, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xC3, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1,
  0xC0, 0x78, 0x38, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x78, 0x70,
  0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0E, 0x07, 0x81, 0xC3,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7C, 0x04, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0x8E, 0x03, 0xF8, 0xE0, 0x3F, 0x8E,
  0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xF0,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x38, 0x1C,
  0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x78, 0x07, 0x03, 0xC0, 0x38,
  0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x78, 0x07, 0x03, 0xC0,
  0x38, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x78, 0x07,
  0x03, 0x80, 0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x78,
  0x07, 0x03, 0x80, 0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x0F, 0x00, 0xE0,
  0x70, 0x0F, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x38, 0x3C, 0x07, 0x83, 0x80, 0x78, 0x78, 0x07, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x00, 0xE7,
  0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x38, 0x07, 0x03, 0x80,
  0x70, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0xC0, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1D, 0xC0,
  0xFE, 0x01, 0xDC, 0x0E, 0xE0, 0x39, 0xC0, 0xE6, 0x03, 0xBC, 0x0E, 0x60,
  0x7B, 0x81, 0xE7, 0x07, 0x38, 0x1C, 0x70, 0x73, 0x81, 0xC7, 0x0E, 0x78,
  0x1C, 0x70, 0xE7, 0x81, 0xC7, 0x1C, 0x70, 0x3C, 0x71, 0xC7, 0x03, 0x87,
  0x38, 0x70, 0x38, 0x73, 0x8F, 0x03, 0x87, 0x70, 0xF0, 0x38, 0x77, 0x0E,
  0x07, 0x87, 0xF0, 0xE0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE1, 0xE0, 0x70,
  0x7C, 0x1C, 0x07, 0x07, 0xC1, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x83,
  0xC0, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x38, 0x0F, 0x80, 0x70, 0x1F, 0x01,
  0xE0, 0x7E, 0x03, 0xC0, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xB8, 0x1C,
  0x07, 0x70, 0x78, 0x1E, 0xE0, 0xF0, 0x39, 0xC1, 0xC0, 0x73, 0x83, 0x80,
  0xE7, 0x07, 0x03, 0xC7, 0x1E, 0x07, 0x8E, 0x38, 0x0E, 0x1C, 0x70, 0x1C,
  0x38, 0xE0, 0x38, 0x71, 0xC0, 0xF0, 0xE7, 0x81, 0xC0, 0xEE, 0x03, 0x81,
  0xDC, 0x07, 0x03, 0xB8, 0x0E, 0x07, 0x70, 0x3C, 0x0F, 0xE0, 0x70, 0x1F,
  0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x3E, 0x03, 0x80, 0x7C, 0x0F, 0x00, 0xF0,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0,
  0x0F, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xC3, 0x80,
  0x78, 0x70, 0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0E,
  0x3E, 0x07, 0x83, 0x81, 0xE0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F, 0x07, 0x03,
  0xC3, 0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x87, 0x83, 0xC1,
  0xE1, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xE0, 0xF0, 0x78, 0x1E,
  0x1E, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x01, 0xCF,
  0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0E,
  0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F, 0x07, 0x03,
  0xC3, 0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1,
  0xE7, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0x3C, 0x03, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0x70, 0x0E, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x06, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x20, 0x0F, 0x0C, 0x07,
  0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00,
  0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0,
  0x1C, 0x1E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x03, 0xC1, 0xC0, 0x38, 0x1C,
  0x03, 0x83, 0xC0, 0x38, 0x38, 0x07, 0x83, 0x80, 0x78, 0x38, 0x07, 0x07,
  0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xE0,
  0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0x78, 0x78,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38,
  0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xE0,
  0xE1, 0xC0, 0xE3, 0xC0, 0xE3, 0x80, 0xE3, 0x80, 0xE7, 0x80, 0xE7, 0x00,
  0xEF, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xF7,
  0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x01, 0xE7, 0x01, 0xF0, 0x1C, 0x70, 0x1F,
  0x01, 0xC7, 0x01, 0xF0, 0x3C, 0xF0, 0x3F, 0x03, 0x8F, 0x03, 0x60, 0x78,
  0xF0, 0x76, 0x07, 0x0F, 0x07, 0x60, 0x70, 0xF0, 0x66, 0x0F, 0x0F, 0x0E,
  0x60, 0xE0, 0xF0, 0xE6, 0x1E, 0x0F, 0x1C, 0xE1, 0xC0, 0xF1, 0xCE, 0x1C,
  0x0F, 0x1C, 0xE3, 0xC0, 0xE3, 0x8E, 0x38, 0x0E, 0x38, 0xE7, 0x80, 0xE7,
  0x0E, 0x70, 0x0E, 0x70, 0xE7, 0x00, 0xE7, 0x0E, 0xF0, 0x0E, 0xE0, 0xEE,
  0x00, 0xEE, 0x0E, 0xE0, 0x0E, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0x70,
  0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80,
  0x07, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1,
  0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x00,
  0x70, 0x0F, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78,
  0x78, 0x70, 0x78, 0xF0, 0x78, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0,
  0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x07, 0x0E, 0x07, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0x71, 0xC0,
  0x39, 0xE0, 0x1D, 0xE0, 0x0F, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x80, 0xF1,
  0xC7, 0x8E, 0x38, 0x70, 0xC0, 0x01, 0xE3, 0x83, 0xF9, 0x83, 0xFF, 0xC1,
  0xE3, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0E,
  0x3C, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xC0,
  0xF1, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x07,
  0xBF, 0x03, 0xFB, 0x80, 0xF9, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x9E, 0x03, 0xDF, 0x81, 0xDF, 0xE0, 0xF8, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x80,
  0xE3, 0xC0, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C,
  0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x87, 0x87, 0x77, 0xC3, 0xBF, 0xC1,
  0xCF, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x7F, 0x83, 0xC2, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x10, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0xF0, 0x1F, 0xDC, 0x07, 0xFF, 0x80,
  0xF1, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x0F,
  0x01, 0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x07, 0x01, 0xC1, 0xE0, 0x38, 0x3C,
  0x07, 0x07, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x0F, 0x81, 0xF7, 0xE0, 0x1F, 0xDC, 0x01, 0xF3, 0x80, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xC7, 0x1E, 0x1C, 0xF0, 0x73, 0x81, 0xCE,
  0x07, 0x78, 0x39, 0xC1, 0xE7, 0xFF, 0x3F, 0xF0, 0xFE, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x08, 0x7C, 0xE1,
  0xFF, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0xE0, 0x3F, 0x98, 0x0F, 0xFF, 0x01, 0xE3, 0xE0, 0x78,
  0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0x83, 0xC0,
  0xF0, 0x70, 0x1E, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x0E, 0x0F, 0x03,
  0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0xF8, 0x1E, 0x1F,
  0x03, 0xEF, 0xC0, 0x3F, 0xB8, 0x03, 0xE7, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x01, 0x81, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x3C, 0x07, 0x7E, 0x0E, 0xFF, 0x0F, 0x8F, 0x0F, 0x07,
  0x0F, 0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E,
  0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x78,
  0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x83, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0, 0xE1, 0xE0,
  0x70, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x1E, 0xF0, 0x0E, 0x70, 0x07, 0x70,
  0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x3C, 0x70, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x07, 0x03, 0x83, 0x83,
  0xC1, 0xC1, 0xC0, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x06, 0x3C, 0x1E, 0x03,
  0x3F, 0x3F, 0x83, 0xBF, 0xFF, 0xC1, 0xF1, 0xF8, 0xF0, 0xF0, 0xF8, 0x78,
  0x70, 0x78, 0x3C, 0x78, 0x3C, 0x1C, 0x3C, 0x1E, 0x0E, 0x1C, 0x0E, 0x07,
  0x0E, 0x07, 0x03, 0x87, 0x03, 0x83, 0xC7, 0x83, 0xC1, 0xC3, 0x81, 0xC0,
  0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x78, 0x70, 0x38, 0x3C, 0x78, 0x3C,
  0x1C, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x07, 0x8F, 0x07,
  0x83, 0x87, 0x83, 0xC1, 0xC3, 0x81, 0xC0, 0xE0, 0x06, 0x3C, 0x06, 0x7E,
  0x0E, 0xFF, 0x0F, 0x8F, 0x0F, 0x07, 0x0F, 0x07, 0x1E, 0x07, 0x1E, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38,
  0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x3F, 0xF0,
  0x78, 0xF1, 0xE1, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0,
  0x1D, 0xC0, 0x7B, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x1E,
  0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xC7, 0x87, 0x87, 0xBE, 0x0F, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0x8F, 0x00, 0x33, 0xF0, 0x0E, 0xFF, 0x01, 0xF0, 0xE0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE0,
  0xE0, 0x38, 0x1C, 0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x83,
  0x80, 0xE0, 0x70, 0x1C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x0F,
  0x0F, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0E, 0x7E, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0x83,
  0xF9, 0x83, 0xFF, 0xC1, 0xE3, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x38,
  0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38,
  0x1E, 0x1E, 0x1F, 0x0F, 0xBF, 0x03, 0xFB, 0x80, 0xF9, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x06, 0x3C, 0x19, 0xE0,
  0xEF, 0x83, 0xFE, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x87, 0x86, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x20, 0x70,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0xF3, 0xFD, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x3D, 0x0F, 0xC1, 0xF0, 0x0E, 0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x1C,
  0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0,
  0x38, 0xF0, 0x78, 0xE0, 0x78, 0xE0, 0xF0, 0xF1, 0xF0, 0xFF, 0xF0, 0x7F,
  0x70, 0x7E, 0x70, 0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x79,
  0xC1, 0xC7, 0x0F, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0,
  0x73, 0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x0E, 0xE0,
  0xF8, 0x39, 0xC1, 0xE0, 0x73, 0x83, 0xC1, 0xE7, 0x0F, 0x83, 0x8E, 0x1F,
  0x07, 0x1C, 0x36, 0x1C, 0x78, 0xEC, 0x38, 0xF1, 0x98, 0xF1, 0xE7, 0x31,
  0xC3, 0xCE, 0xE3, 0x87, 0x19, 0xCE, 0x0E, 0x73, 0x9C, 0x1C, 0xE7, 0x38,
  0x3B, 0x8E, 0xE0, 0x77, 0x1D, 0xC0, 0xEC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1C,
  0x03, 0x8F, 0x00, 0xE3, 0x80, 0x3D, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x80, 0xF1, 0xE0,
  0x38, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x1C, 0x0E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1C,
  0xF0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x03,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x02, 0xFC, 0x07, 0xFE, 0x1F,
  0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 30, 10, 0, -30 },
  { 43, 12, 11, 14, 4, -30 },
  { 60, 19, 30, 18, 0, -30 },
  { 132, 17, 34, 16, 0, -32 },
  { 205, 22, 30, 26, 2, -30 },
  { 288, 17, 30, 18, 0, -30 },
  { 352, 6, 11, 8, 4, -30 },
  { 361, 12, 37, 11, 1, -30 },
  { 417, 13, 37, 11, -3, -30 },
  { 478, 13, 14, 15, 4, -32 },
  { 501, 15, 20, 18, 2, -25 },
  { 539, 7, 11, 8, -2, -5 },
  { 549, 9, 3, 11, 1, -13 },
  { 553, 5, 5, 8, 0, -5 },
  { 557, 19, 30, 14, -2, -30 },
  { 629, 15, 30, 16, 1, -30 },
  { 686, 11, 30, 16, 4, -30 },
  { 728, 17, 30, 16, -1, -30 },
  { 792, 18, 30, 16, -1, -30 },
  { 860, 18, 30, 16, -1, -30 },
  { 928, 17, 30, 16, 0, -30 },
  { 992, 16, 30, 16, 1, -30 },
  { 1052, 17, 30, 16, 1, -30 },
  { 1116, 17, 30, 16, 0, -30 },
  { 1180, 16, 30, 16, 0, -30 },
  { 1240, 8, 23, 9, 0, -23 },
  { 1263, 11, 29, 9, -2, -23 },
  { 1303, 15, 18, 18, 2, -24 },
  { 1337, 15, 12, 18, 2, -21 },
  { 1360, 15, 18, 18, 2, -24 },
  { 1394, 13, 30, 12, 1, -30 },
  { 1443, 23, 34, 25, 1, -30 },
  { 1541, 17, 30, 17, -3, -30 },
  { 1605, 18, 30, 18, 0, -30 },
  { 1673, 17, 30, 16, 2, -30 },
  { 1737, 19, 30, 20, 0, -30 },
  { 1809, 17, 30, 15, 0, -30 },
  { 1873, 17, 30, 14, 0, -30 },
  { 1937, 20, 30, 21, 2, -30 },
  { 2012, 21, 30, 20, 0, -30 },
  { 2091, 16, 30, 11, -2, -30 },
  { 2151, 16, 38, 8, -6, -30 },
  { 2227, 20, 30, 17, 0, -30 },
  { 2302, 11, 30, 14, 0, -30 },
  { 2344, 28, 30, 27, 0, -30 },
  { 2449, 23, 30, 22, 0, -30 },
  { 2536, 19, 30, 21, 1, -30 },
  { 2608, 18, 30, 17, 0, -30 },
  { 2676, 19, 37, 21, 1, -30 },
  { 2764, 18, 30, 18, 0, -30 },
  { 2832, 18, 30, 16, -1, -30 },
  { 2900, 15, 30, 14, 3, -30 },
  { 2957, 20, 30, 20, 1, -30 },
  { 3032, 16, 30, 17, 4, -30 },
  { 3092, 28, 30, 27, 3, -30 },
  { 3197, 21, 30, 16, -2, -30 },
  { 3276, 16, 30, 15, 3, -30 },
  { 3336, 19, 30, 14, -2, -30 },
  { 3408, 16, 37, 12, -1, -30 },
  { 3482, 7, 30, 14, 4, -30 },
  { 3509, 16, 37, 12, -3, -30 },
  { 3583, 17, 16, 17, 0, -30 },
  { 3617, 14, 3, 13, -4, 3 },
  { 3623, 6, 7, 10, 6, -32 },
  { 3629, 17, 23, 18, 1, -23 },
  { 3678, 17, 32, 18, 0, -32 },
  { 3746, 14, 23, 13, 1, -23 },
  { 3787, 19, 32, 18, 1, -32 },
  { 3863, 14, 23, 16, 1, -23 },
  { 3904, 20, 42, 10, -5, -32 },
  { 4009, 19, 33, 18, -1, -23 },
  { 4088, 16, 32, 17, 0, -32 },
  { 4152, 10, 31, 8, 0, -31 },
  { 4191, 15, 41, 8, -5, -31 },
  { 4268, 17, 32, 15, 0, -32 },
  { 4336, 10, 32, 8, 0, -32 },
  { 4376, 25, 23, 26, 0, -23 },
  { 4448, 16, 23, 17, 0, -23 },
  { 4494, 15, 23, 17, 1, -23 },
  { 4538, 19, 33, 18, -2, -23 },
  { 4617, 17, 33, 18, 1, -23 },
  { 4688, 14, 23, 12, 0, -23 },
  { 4729, 14, 23, 13, 0, -23 },
  { 4770, 10, 28, 10, 1, -28 },
  { 4805, 16, 23, 17, 1, -23 },
  { 4851, 14, 23, 14, 2, -23 },
  { 4892, 23, 23, 23, 2, -23 },
  { 4959, 18, 23, 14, -2, -23 },
  { 5011, 20, 33, 14, -4, -23 },
  { 5094, 15, 23, 12, -2, -23 },
  { 5138, 15, 37, 14, 1, -30 },
  { 5208, 3, 42, 15, 6, -32 },
  { 5224, 16, 37, 14, -3, -30 },
  { 5298, 15, 6, 18, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Italic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC42PT7B_H_
