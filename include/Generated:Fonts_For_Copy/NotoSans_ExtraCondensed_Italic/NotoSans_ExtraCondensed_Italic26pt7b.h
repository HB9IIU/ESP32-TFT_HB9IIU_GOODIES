#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x04, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x67, 0xDF, 0x36, 0x6C, 0xD9, 0x26,
  0x00, 0x02, 0x20, 0x26, 0x06, 0x60, 0x64, 0x04, 0x40, 0xCC, 0x3F, 0xF0,
  0x88, 0x19, 0x81, 0x98, 0x11, 0x03, 0x30, 0xFF, 0xC2, 0x20, 0x66, 0x06,
  0x60, 0x44, 0x04, 0xC0, 0xCC, 0x00, 0x01, 0x00, 0x20, 0x0E, 0x07, 0xF1,
  0xA4, 0x64, 0x0C, 0x81, 0x90, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xF0,
  0x13, 0x02, 0x60, 0x48, 0x8B, 0x1F, 0xC0, 0xF0, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x1C, 0x18, 0xF0, 0xC2, 0x63, 0x19, 0x98, 0x66, 0x61, 0x13, 0x0C,
  0x4C, 0x33, 0x60, 0xCD, 0xBB, 0x2D, 0xBF, 0xB4, 0xD9, 0xB3, 0x04, 0xCC,
  0x32, 0x30, 0x88, 0x86, 0x26, 0x11, 0x98, 0xC2, 0xC6, 0x0E, 0x00, 0x03,
  0x01, 0xF0, 0x36, 0x0C, 0x41, 0x98, 0x33, 0x06, 0xC0, 0xD8, 0x0E, 0x03,
  0x80, 0xF9, 0xB3, 0x66, 0x6D, 0x8D, 0xB0, 0xE6, 0x18, 0xC7, 0x9F, 0xB1,
  0xE7, 0x00, 0x6F, 0x6D, 0xA0, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x60, 0x60, 0x20, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0xC0, 0x18, 0x32, 0x67, 0xB3, 0xE7, 0x1A, 0x66, 0x08, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x33, 0x66, 0x6C, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x00, 0x07, 0x0F, 0xC6, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC3, 0xC1,
  0xE0, 0xF0, 0xD8, 0x6C, 0x36, 0x1B, 0x19, 0x8C, 0xCC, 0x7E, 0x1E, 0x00,
  0x0C, 0x73, 0xDB, 0xDA, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0x61, 0x8C, 0x00, 0x03, 0x81, 0xFC, 0x31, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0x07, 0xF1, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x0F, 0x07, 0x00, 0x70, 0x0C, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x87, 0x3F, 0x8F, 0xC0, 0x00, 0xC0, 0x70, 0x1C, 0x0F, 0x07,
  0x81, 0x60, 0xD8, 0x26, 0x19, 0x8C, 0xC2, 0x31, 0x8C, 0xC3, 0x3F, 0xEF,
  0xF8, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x0F, 0xC3, 0xF1, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x3F, 0x09, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x87, 0x3F, 0x8F, 0xC0, 0x03, 0xC3, 0xF1, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0xB8, 0xDF, 0x3C, 0xCE, 0x33, 0x0C, 0xC3, 0x30, 0xCC,
  0x33, 0x18, 0xC6, 0x3F, 0x07, 0x80, 0x3F, 0xCF, 0xF4, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x07, 0x03, 0xF1, 0x8C, 0x63, 0x30,
  0xCC, 0x31, 0x8C, 0x66, 0x1F, 0x07, 0x83, 0xF1, 0x8C, 0xE3, 0xB0, 0x6C,
  0x1B, 0x06, 0xC3, 0x3F, 0xC7, 0xE0, 0x07, 0x03, 0xE1, 0x8C, 0xE3, 0x30,
  0xCC, 0x33, 0x0D, 0x83, 0x71, 0xCC, 0x73, 0xF8, 0xF6, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0E, 0x3F, 0x0F, 0x80, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xCE, 0x60, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x31, 0x86, 0x10, 0xC0, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x38, 0x3C, 0x3C, 0x3C, 0x0C, 0x02, 0x00, 0x0E, 0x1F, 0x88, 0xE0,
  0x30, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0xC1, 0x86,
  0x03, 0x10, 0x0C, 0xC7, 0x36, 0x3E, 0xD9, 0x93, 0x4C, 0xCF, 0x33, 0x3C,
  0x88, 0xA2, 0x22, 0x99, 0x9A, 0x66, 0x49, 0xAB, 0x23, 0xB8, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x40, 0x3F, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x36, 0x06, 0xC1, 0xD8, 0x33, 0x06, 0x61, 0x8C, 0x31, 0x8F, 0xF1,
  0xFE, 0x30, 0xCC, 0x19, 0x83, 0x70, 0x6C, 0x0F, 0x81, 0x80, 0x0F, 0x01,
  0xF8, 0x73, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x19, 0xC6, 0x3F, 0x87, 0xE0,
  0xC6, 0x18, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0x63, 0x9F, 0xE3, 0xF8,
  0x00, 0x03, 0xC1, 0xFC, 0x71, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x0F, 0xC0, 0xF8, 0x00, 0x0E, 0x00, 0xFC, 0x1C, 0xE1, 0x86, 0x18, 0x71,
  0x87, 0x18, 0x73, 0x87, 0x30, 0x73, 0x06, 0x30, 0x63, 0x06, 0x60, 0xE6,
  0x0C, 0x61, 0xC6, 0x18, 0x63, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x3F, 0x87, 0xE0, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xC3, 0xF8, 0x00,
  0x0F, 0xE1, 0xF8, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x07, 0xF0, 0xFC, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x1E, 0x31, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x3E, 0xC3, 0xEC, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x1C, 0xE1, 0x87, 0xF8, 0x3F, 0x80, 0x0C, 0x18, 0x60, 0xC7,
  0x06, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC7, 0x06, 0x3F, 0xE1, 0xFF,
  0x0C, 0x18, 0x60, 0xC6, 0x0E, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC6,
  0x0E, 0x30, 0x60, 0x0F, 0xC7, 0xE0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0E, 0x0F, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x0F, 0x83, 0xC0, 0x0C, 0x38, 0x61,
  0x87, 0x18, 0x31, 0xC1, 0x8C, 0x0C, 0xC0, 0x6C, 0x07, 0xE0, 0x36, 0x01,
  0xF0, 0x0F, 0x80, 0x6C, 0x06, 0x70, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63,
  0x06, 0x1C, 0x30, 0x60, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xFF, 0xF8, 0x0E, 0x03, 0x87,
  0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xD8, 0xF0, 0x78, 0x78, 0x2C,
  0x6C, 0x36, 0x36, 0x1B, 0x1B, 0x1B, 0x0D, 0x8D, 0x86, 0xCC, 0xC6, 0x66,
  0x63, 0x36, 0x31, 0x8B, 0x30, 0xC7, 0x18, 0x63, 0x8C, 0x61, 0x86, 0x30,
  0xC7, 0x00, 0x0C, 0x0C, 0x38, 0x31, 0xE1, 0xC7, 0x86, 0x1E, 0x18, 0x78,
  0x61, 0xA1, 0x8C, 0xCC, 0x33, 0x30, 0xCC, 0xC3, 0x33, 0x0C, 0xCC, 0x61,
  0x61, 0x87, 0x86, 0x1E, 0x18, 0x78, 0x61, 0xE3, 0x07, 0x0C, 0x0C, 0x00,
  0x03, 0x80, 0xFE, 0x1C, 0x61, 0x86, 0x30, 0x63, 0x07, 0x60, 0x66, 0x06,
  0x60, 0x6E, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1, 0xCC, 0x18,
  0xE3, 0x87, 0xF0, 0x7E, 0x00, 0x0E, 0x01, 0xF8, 0x77, 0x8C, 0x31, 0x86,
  0x30, 0xC6, 0x19, 0xC7, 0x30, 0xC6, 0x70, 0xFE, 0x1F, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x1C,
  0x61, 0x86, 0x30, 0x63, 0x07, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x06, 0xC0,
  0x6C, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1, 0xCC, 0x18, 0xE3, 0x87, 0xF0, 0x7E,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x01, 0xF8, 0x73, 0x8C,
  0x31, 0x86, 0x30, 0xC6, 0x19, 0xC6, 0x30, 0xC7, 0xF0, 0xFC, 0x1B, 0x06,
  0x70, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0x18, 0x73, 0x0E, 0x00, 0x03, 0xC0,
  0x7F, 0x0E, 0x21, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x83, 0x87,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x00, 0x18, 0x31, 0x83, 0x30, 0x73, 0x06, 0x30, 0x63, 0x06, 0x30, 0x66,
  0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCE, 0x1C, 0xC1, 0x8C, 0x18, 0xC1, 0x8C,
  0x38, 0xC3, 0x0F, 0xE0, 0x7C, 0x00, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0xCC,
  0x19, 0x86, 0x30, 0xC6, 0x38, 0xC6, 0x18, 0xC3, 0x30, 0x66, 0x0D, 0xC1,
  0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0xC1, 0xE0,
  0xE1, 0xF0, 0x70, 0xD8, 0x78, 0x6C, 0x38, 0x66, 0x14, 0x33, 0x1A, 0x19,
  0x8D, 0x18, 0xC4, 0x8C, 0x66, 0x4C, 0x33, 0x26, 0x1B, 0x33, 0x0D, 0x9B,
  0x06, 0x8D, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x30,
  0x70, 0x00, 0x06, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x66, 0x01, 0xB0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x18, 0x01, 0xE0, 0x0F, 0x00, 0xD8, 0x06,
  0xC0, 0x66, 0x07, 0x30, 0x31, 0x83, 0x8E, 0x38, 0x70, 0xC1, 0xE0, 0xF8,
  0xCC, 0x66, 0x63, 0x31, 0xB0, 0xD8, 0x78, 0x3C, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x0F, 0xE1, 0xFC, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x19, 0x0F, 0x80, 0x8C, 0xCC, 0xCC, 0xC4, 0x46, 0x66, 0x66, 0x66, 0x23,
  0x30, 0x07, 0xC1, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x0F, 0x80, 0x03, 0x00, 0xC0, 0x70, 0x34, 0x0D,
  0x86, 0x61, 0x98, 0xC3, 0x60, 0xF8, 0x30, 0xFF, 0xFF, 0xD9, 0x90, 0x1E,
  0xCF, 0xB3, 0x19, 0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x30, 0xCC,
  0x73, 0x1C, 0xFE, 0x1D, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0xB8, 0x7F, 0x38, 0xCE, 0x33, 0x0C, 0xC3, 0x30, 0xD8, 0x36, 0x1D,
  0x86, 0x61, 0xB8, 0xCF, 0x73, 0x78, 0x1F, 0x3F, 0x30, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x87, 0xB1, 0xF6, 0x31, 0x8C, 0x31, 0x86, 0x60,
  0xCC, 0x19, 0x86, 0x30, 0xC6, 0x18, 0xC7, 0x18, 0xC3, 0xF8, 0x3B, 0x00,
  0x1F, 0x3F, 0x31, 0x61, 0x63, 0xC7, 0xFE, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xEC, 0x7C, 0x00, 0xF0, 0x1F, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07,
  0xC0, 0xFC, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xB0, 0xFF, 0x0C, 0x61, 0x86, 0x18,
  0x63, 0x06, 0x30, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC3, 0x1C, 0x3F,
  0x83, 0xD8, 0x01, 0x80, 0x18, 0x03, 0x08, 0x30, 0xFE, 0x07, 0xC0, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xB8, 0x7F, 0x38, 0xCE, 0x33,
  0x0C, 0xC7, 0x31, 0x98, 0x66, 0x19, 0x86, 0x63, 0x18, 0xCC, 0x33, 0x0C,
  0x0C, 0x30, 0x80, 0x00, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18,
  0xE3, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC1, 0xE0, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x38, 0xCC, 0x31, 0x86, 0x60, 0xD8, 0x1F,
  0x03, 0xC0, 0xFC, 0x1D, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x1C, 0x61, 0x80,
  0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0x61, 0x8C, 0x30, 0x1B, 0x9E, 0x2F, 0xFC, 0xE3, 0x99, 0x86, 0x33, 0x0C,
  0x66, 0x30, 0xCC, 0x61, 0xB0, 0xC6, 0x61, 0x8C, 0xC7, 0x19, 0x8C, 0x37,
  0x18, 0xCC, 0x31, 0x98, 0x63, 0x00, 0x1B, 0x85, 0xF3, 0x8C, 0xE3, 0x30,
  0xCC, 0x73, 0x19, 0x86, 0x61, 0x98, 0x66, 0x33, 0x8C, 0xC3, 0x30, 0xC0,
  0x1F, 0x1F, 0x8C, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0x61, 0xB1,
  0xD8, 0xCF, 0xC3, 0xC0, 0x0D, 0xC1, 0x7C, 0x71, 0x8E, 0x31, 0x86, 0x30,
  0xC6, 0x19, 0x83, 0x30, 0xE6, 0x18, 0xC3, 0x18, 0xC7, 0xF8, 0xDE, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x1E, 0xCF, 0xF3, 0x19,
  0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0x1C, 0xFE,
  0x3D, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1B, 0x17, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x1F,
  0x9F, 0x8C, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0x81,
  0xCF, 0xC7, 0xC0, 0x18, 0x43, 0x1F, 0xFD, 0x86, 0x18, 0x61, 0x8C, 0x30,
  0xC3, 0x0C, 0x3C, 0xF0, 0x30, 0xCC, 0x66, 0x19, 0x86, 0x61, 0x98, 0xC6,
  0x33, 0x0C, 0xC3, 0x31, 0xCC, 0x63, 0x18, 0xFE, 0x3D, 0x80, 0xC3, 0xC6,
  0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0xB0, 0xB0, 0xB0, 0xE0, 0xE0, 0xC0,
  0x63, 0x8D, 0x8E, 0x36, 0x79, 0x99, 0xE6, 0x45, 0x19, 0x34, 0xC4, 0xD3,
  0x36, 0x58, 0xD9, 0x63, 0x45, 0x8F, 0x1C, 0x3C, 0x70, 0xE3, 0x83, 0x8E,
  0x00, 0x18, 0xE3, 0x18, 0x66, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0xD8, 0x31, 0x86, 0x31, 0x86, 0x00, 0x0C, 0x30, 0xC7,
  0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0xF0, 0x0E, 0x00, 0x1F, 0x8F, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x0F, 0xE7, 0xE0, 0x00, 0x83, 0xC1, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0C, 0x1C, 0x0E, 0x01, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x07, 0x03, 0xC1, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x3E, 0x0E, 0x00, 0x70, 0x7F, 0x38,
  0xFA, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 19, 6, 0, -19 },
  { 18, 7, 7, 9, 3, -19 },
  { 25, 12, 19, 11, 0, -19 },
  { 54, 11, 22, 10, 0, -20 },
  { 85, 14, 19, 16, 1, -19 },
  { 119, 11, 19, 11, 0, -19 },
  { 146, 3, 7, 5, 3, -19 },
  { 149, 8, 23, 7, 0, -19 },
  { 172, 8, 23, 7, -2, -19 },
  { 195, 7, 9, 9, 3, -20 },
  { 203, 10, 12, 11, 1, -15 },
  { 218, 4, 6, 5, -1, -3 },
  { 221, 6, 2, 7, 0, -8 },
  { 223, 3, 3, 5, 0, -3 },
  { 225, 12, 19, 9, -1, -19 },
  { 254, 9, 19, 10, 1, -19 },
  { 276, 6, 19, 10, 3, -19 },
  { 291, 11, 19, 10, -1, -19 },
  { 318, 10, 19, 10, 0, -19 },
  { 342, 10, 19, 10, 0, -19 },
  { 366, 10, 19, 10, 0, -19 },
  { 390, 10, 19, 10, 1, -19 },
  { 414, 10, 19, 10, 1, -19 },
  { 438, 10, 19, 10, 0, -19 },
  { 462, 10, 19, 10, 0, -19 },
  { 486, 5, 14, 5, 0, -14 },
  { 495, 6, 17, 5, -1, -14 },
  { 508, 10, 12, 11, 1, -15 },
  { 523, 10, 8, 11, 1, -13 },
  { 533, 10, 12, 11, 1, -15 },
  { 548, 9, 19, 8, 0, -19 },
  { 570, 14, 21, 15, 1, -19 },
  { 607, 11, 19, 11, -2, -19 },
  { 634, 11, 19, 11, 0, -19 },
  { 661, 11, 19, 10, 1, -19 },
  { 688, 12, 19, 12, 0, -19 },
  { 717, 11, 19, 10, 0, -19 },
  { 744, 11, 19, 9, 0, -19 },
  { 771, 12, 19, 13, 1, -19 },
  { 800, 13, 19, 13, 0, -19 },
  { 831, 10, 19, 7, -1, -19 },
  { 855, 10, 24, 5, -4, -19 },
  { 885, 13, 19, 11, 0, -19 },
  { 916, 7, 19, 9, 0, -19 },
  { 933, 17, 19, 17, 0, -19 },
  { 974, 14, 19, 13, 0, -19 },
  { 1008, 12, 19, 13, 1, -19 },
  { 1037, 11, 19, 11, 0, -19 },
  { 1064, 12, 23, 13, 1, -19 },
  { 1099, 11, 19, 11, 0, -19 },
  { 1126, 12, 19, 10, -1, -19 },
  { 1155, 9, 19, 9, 2, -19 },
  { 1177, 12, 19, 12, 1, -19 },
  { 1206, 11, 19, 11, 2, -19 },
  { 1233, 17, 19, 17, 2, -19 },
  { 1274, 13, 19, 10, -2, -19 },
  { 1305, 9, 19, 9, 2, -19 },
  { 1327, 11, 19, 9, -1, -19 },
  { 1354, 10, 23, 7, -1, -19 },
  { 1383, 4, 19, 9, 3, -19 },
  { 1393, 10, 23, 7, -2, -19 },
  { 1422, 10, 10, 10, 0, -19 },
  { 1435, 8, 2, 8, -2, 2 },
  { 1437, 3, 4, 6, 4, -20 },
  { 1439, 10, 14, 11, 1, -14 },
  { 1457, 10, 20, 11, 0, -20 },
  { 1482, 8, 14, 8, 1, -14 },
  { 1496, 11, 20, 11, 1, -20 },
  { 1524, 8, 14, 10, 1, -14 },
  { 1538, 12, 26, 6, -3, -20 },
  { 1577, 12, 20, 11, -1, -14 },
  { 1607, 10, 20, 11, 0, -20 },
  { 1632, 6, 19, 5, 0, -19 },
  { 1647, 9, 25, 5, -3, -19 },
  { 1676, 11, 20, 9, 0, -20 },
  { 1704, 6, 20, 5, 0, -20 },
  { 1719, 15, 14, 16, 0, -14 },
  { 1746, 10, 14, 11, 0, -14 },
  { 1764, 9, 14, 11, 1, -14 },
  { 1780, 11, 20, 11, -1, -14 },
  { 1808, 10, 20, 11, 1, -14 },
  { 1833, 8, 14, 7, 0, -14 },
  { 1847, 9, 14, 8, 0, -14 },
  { 1863, 6, 17, 6, 1, -17 },
  { 1876, 10, 14, 11, 1, -14 },
  { 1894, 8, 14, 9, 2, -14 },
  { 1908, 14, 14, 14, 1, -14 },
  { 1933, 11, 14, 9, -1, -14 },
  { 1953, 12, 20, 9, -2, -14 },
  { 1983, 9, 14, 7, -1, -14 },
  { 1999, 9, 23, 9, 1, -19 },
  { 2025, 2, 26, 10, 4, -20 },
  { 2032, 10, 23, 9, -2, -19 },
  { 2061, 10, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Italic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC26PT7B_H_
