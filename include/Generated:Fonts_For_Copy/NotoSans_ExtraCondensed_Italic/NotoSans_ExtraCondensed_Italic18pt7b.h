#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x62, 0x10, 0x8C, 0x40, 0x01, 0x8C, 0x00, 0xDE, 0xA5,
  0x2B, 0x00, 0x09, 0x0A, 0x12, 0x12, 0x7F, 0x34, 0x24, 0x2C, 0xFE, 0x48,
  0x48, 0x50, 0x90, 0x04, 0x08, 0x79, 0x52, 0x85, 0x0C, 0x0C, 0x1C, 0x28,
  0x55, 0x6F, 0x84, 0x08, 0x00, 0x31, 0x28, 0xB4, 0x92, 0x49, 0x44, 0xAE,
  0xAB, 0xD5, 0x14, 0x9A, 0x49, 0x2C, 0xA4, 0x70, 0x1C, 0x2C, 0xD1, 0xA3,
  0xC7, 0x0C, 0x3D, 0xCB, 0x1A, 0x36, 0xEF, 0x60, 0x7E, 0x80, 0x0C, 0x61,
  0x0C, 0x21, 0x84, 0x10, 0x43, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x10, 0xC2,
  0x10, 0x84, 0x21, 0x18, 0x84, 0x62, 0x31, 0x10, 0x31, 0x3A, 0x75, 0x48,
  0x30, 0xC3, 0x0C, 0xFC, 0xC3, 0x0C, 0x30, 0x2D, 0x60, 0x7F, 0xF0, 0x01,
  0x03, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0xC0,
  0x0C, 0x2C, 0x89, 0x16, 0x28, 0xD1, 0xA2, 0xC5, 0x9B, 0x22, 0xC7, 0x00,
  0x13, 0xFB, 0x22, 0x26, 0x64, 0x44, 0xC0, 0x0E, 0x13, 0x01, 0x01, 0x03,
  0x02, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xFC, 0x1C, 0x4C, 0x08, 0x10,
  0x61, 0x8E, 0x06, 0x0C, 0x18, 0x34, 0xCF, 0x00, 0x06, 0x0C, 0x38, 0xE1,
  0x44, 0x8B, 0x26, 0x89, 0xF8, 0x20, 0xC1, 0x80, 0x1E, 0x60, 0x81, 0x02,
  0x0F, 0x13, 0x02, 0x04, 0x08, 0x34, 0xCF, 0x00, 0x0E, 0x30, 0xC1, 0x06,
  0x0B, 0x99, 0x22, 0x45, 0x8B, 0x32, 0x47, 0x80, 0x7E, 0x08, 0x10, 0x60,
  0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00, 0x1C, 0x6C, 0x89, 0x12,
  0x67, 0x8E, 0x36, 0xC5, 0x0A, 0x16, 0x67, 0x80, 0x1C, 0x6C, 0x8B, 0x14,
  0x68, 0xDB, 0xBE, 0x04, 0x18, 0x20, 0xCF, 0x00, 0x23, 0x20, 0x00, 0x00,
  0xCC, 0x10, 0xC4, 0x00, 0x00, 0x00, 0x23, 0x11, 0x80, 0x04, 0x66, 0x30,
  0x60, 0xE0, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x1D, 0xCC,
  0x20, 0x38, 0xB0, 0x43, 0x08, 0x43, 0x08, 0x40, 0x00, 0x30, 0xC0, 0x07,
  0x82, 0x31, 0x04, 0x81, 0x27, 0x52, 0x54, 0xA5, 0x49, 0x52, 0xB5, 0xAD,
  0xB1, 0x00, 0x40, 0x19, 0x01, 0x80, 0x06, 0x0C, 0x28, 0x51, 0xA2, 0x44,
  0x99, 0x3E, 0xC5, 0x0E, 0x1C, 0x20, 0x1E, 0x33, 0x33, 0x23, 0x22, 0x26,
  0x7C, 0x66, 0x46, 0x46, 0x46, 0xCC, 0xF8, 0x1E, 0x65, 0x82, 0x0C, 0x18,
  0x20, 0x40, 0x81, 0x02, 0x06, 0x47, 0x80, 0x1C, 0x37, 0x33, 0x21, 0x21,
  0x23, 0x63, 0x63, 0x42, 0x46, 0x44, 0xDC, 0xF0, 0x1E, 0x60, 0xC1, 0x02,
  0x04, 0x1F, 0x30, 0x40, 0x81, 0x06, 0x0F, 0x80, 0x1E, 0x60, 0xC1, 0x02,
  0x04, 0x1F, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x00, 0x1F, 0x31, 0x60, 0x40,
  0xC0, 0xC0, 0x8E, 0x82, 0x86, 0x86, 0x84, 0xC4, 0x7C, 0x10, 0x98, 0xCC,
  0x64, 0x22, 0x11, 0x09, 0xFC, 0xC6, 0x42, 0x21, 0x11, 0x98, 0xCC, 0x40,
  0x1E, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x0F, 0x00,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x78, 0x11, 0x99, 0x8C, 0x84, 0x82, 0xC1, 0xC1, 0xE0, 0xD0, 0x48,
  0x24, 0x13, 0x19, 0x8C, 0x40, 0x11, 0x8C, 0x42, 0x11, 0x8C, 0x42, 0x11,
  0x8F, 0x80, 0x18, 0x33, 0x87, 0x38, 0x72, 0x8E, 0x28, 0xA2, 0x9E, 0x69,
  0x66, 0x94, 0x4A, 0x44, 0xA4, 0x4E, 0xCC, 0xCC, 0x8C, 0x80, 0x10, 0xCE,
  0x23, 0x88, 0xA2, 0x29, 0x8A, 0x66, 0x91, 0xB4, 0x47, 0x11, 0xC4, 0x63,
  0x18, 0x86, 0x00, 0x1E, 0x32, 0x63, 0x43, 0xC3, 0xC3, 0x82, 0x82, 0x86,
  0x86, 0x8C, 0xC8, 0x70, 0x1C, 0x36, 0x33, 0x23, 0x22, 0x22, 0x6C, 0x78,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0x1E, 0x32, 0x63, 0x43, 0xC3, 0xC3, 0x82,
  0x82, 0x86, 0x86, 0x8C, 0xC8, 0x70, 0x10, 0x10, 0x18, 0x1C, 0x36, 0x33,
  0x23, 0x22, 0x26, 0x7C, 0x78, 0x48, 0x48, 0x4C, 0xCC, 0xCC, 0x1E, 0x64,
  0x83, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x18, 0x34, 0xCF, 0x00, 0x7F, 0x20,
  0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x00, 0x23, 0x63,
  0x62, 0x42, 0x42, 0x46, 0xC6, 0xC4, 0x84, 0x8C, 0x8C, 0x98, 0xF0, 0x87,
  0x0A, 0x34, 0x49, 0x92, 0x24, 0x58, 0xA1, 0xC3, 0x06, 0x08, 0x00, 0x42,
  0x14, 0x63, 0x46, 0x2C, 0xE6, 0xCA, 0x4C, 0xA4, 0xD2, 0xCD, 0x28, 0xF3,
  0x8E, 0x30, 0xE7, 0x0E, 0x70, 0xC6, 0x00, 0x11, 0x8C, 0x86, 0xC3, 0x40,
  0xE0, 0x60, 0x20, 0x38, 0x1C, 0x16, 0x19, 0x08, 0x8C, 0x40, 0x46, 0x89,
  0x32, 0x45, 0x8A, 0x1C, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x00, 0x1F, 0x03,
  0x02, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xFC, 0x1C,
  0x43, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x38, 0x92,
  0x6D, 0x92, 0x49, 0x36, 0x1E, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18,
  0x30, 0x40, 0x81, 0x06, 0x08, 0x70, 0x08, 0x18, 0x51, 0xA2, 0x48, 0xF0,
  0x80, 0x7F, 0xF0, 0xB4, 0x1B, 0x36, 0x26, 0x66, 0x46, 0x44, 0x44, 0xCC,
  0x4C, 0x7C, 0x10, 0x20, 0xC1, 0x82, 0xC6, 0xC8, 0xB1, 0x62, 0x8D, 0x1A,
  0x2C, 0xD7, 0x00, 0x1C, 0xD2, 0x18, 0x41, 0x0C, 0x30, 0x49, 0xE0, 0x01,
  0x01, 0x01, 0x03, 0x1B, 0x36, 0x26, 0x66, 0x46, 0x44, 0xC4, 0xCC, 0x4C,
  0x7C, 0x1C, 0x69, 0x9A, 0x25, 0xCE, 0x30, 0x60, 0x44, 0xF0, 0x03, 0x07,
  0x04, 0x0C, 0x0E, 0x1E, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x60, 0xC0, 0x1B, 0x36, 0x26, 0x66, 0x46, 0x44, 0xC4, 0xCC,
  0x4C, 0x7C, 0x08, 0x08, 0x98, 0xF0, 0x10, 0x20, 0xC1, 0x82, 0xC6, 0xC9,
  0xB3, 0x66, 0x89, 0x12, 0x6C, 0xD1, 0x00, 0x31, 0x02, 0x22, 0x66, 0x44,
  0x4C, 0x80, 0x0C, 0x10, 0x02, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x20,
  0x82, 0x18, 0xC0, 0x10, 0x20, 0xC1, 0x82, 0x24, 0x8B, 0x3C, 0x70, 0xF1,
  0x62, 0x4C, 0x91, 0x00, 0x11, 0x33, 0x22, 0x26, 0x64, 0x44, 0xC8, 0x2C,
  0xC6, 0xEC, 0x99, 0xB3, 0x26, 0x44, 0x88, 0x91, 0x32, 0x64, 0xCC, 0x91,
  0x10, 0x2C, 0x6C, 0x9B, 0x36, 0x48, 0x91, 0x26, 0xCD, 0x10, 0x1C, 0x6C,
  0x9B, 0x34, 0x68, 0xF1, 0x62, 0x48, 0xF0, 0x16, 0x1B, 0x11, 0x31, 0x31,
  0x23, 0x23, 0x22, 0x66, 0x5C, 0x40, 0x40, 0xC0, 0xC0, 0x1B, 0x36, 0x26,
  0x66, 0x46, 0x44, 0xC4, 0xCC, 0x4C, 0x7C, 0x08, 0x08, 0x08, 0x18, 0x2C,
  0xE2, 0x18, 0x61, 0x04, 0x10, 0xC2, 0x00, 0x39, 0x94, 0x18, 0x60, 0xC1,
  0x86, 0x93, 0xC0, 0x11, 0x8E, 0xF2, 0x31, 0x88, 0x42, 0x30, 0xC0, 0x22,
  0x44, 0x8B, 0x36, 0x48, 0x91, 0x26, 0xCC, 0xF0, 0x8E, 0x28, 0xA6, 0x92,
  0xCA, 0x28, 0xC3, 0x00, 0x8C, 0xE3, 0x29, 0xDA, 0x74, 0xBD, 0x2A, 0xCA,
  0xA3, 0x28, 0xCC, 0x33, 0x00, 0x33, 0x12, 0x16, 0x14, 0x18, 0x18, 0x38,
  0x28, 0x6C, 0xCC, 0x18, 0x8C, 0xC6, 0x43, 0x61, 0xA0, 0xF0, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x02, 0x03, 0x07, 0x00, 0x1E, 0x78, 0x30, 0x41, 0x82,
  0x08, 0x30, 0x41, 0xF0, 0x06, 0x18, 0x20, 0xC1, 0x02, 0x04, 0x30, 0xE0,
  0x40, 0x81, 0x06, 0x0C, 0x18, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x30, 0xC2,
  0x08, 0x20, 0x83, 0x0C, 0x41, 0x0C, 0x30, 0x86, 0x30, 0x07, 0xD9, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 5, 5, 6, 2, -13 },
  { 14, 8, 13, 8, 0, -13 },
  { 27, 7, 15, 7, 0, -14 },
  { 41, 9, 13, 11, 1, -13 },
  { 56, 7, 13, 8, 0, -13 },
  { 68, 2, 5, 3, 2, -13 },
  { 70, 6, 16, 5, 0, -13 },
  { 82, 5, 16, 5, -1, -13 },
  { 92, 5, 6, 7, 2, -14 },
  { 96, 6, 9, 8, 1, -11 },
  { 103, 3, 4, 4, -1, -2 },
  { 105, 4, 2, 5, 0, -6 },
  { 106, 2, 2, 4, 0, -2 },
  { 107, 8, 13, 6, -1, -13 },
  { 120, 7, 13, 7, 0, -13 },
  { 132, 4, 13, 7, 2, -13 },
  { 139, 8, 13, 7, -1, -13 },
  { 152, 7, 13, 7, 0, -13 },
  { 164, 7, 13, 7, 0, -13 },
  { 176, 7, 13, 7, 0, -13 },
  { 188, 7, 13, 7, 0, -13 },
  { 200, 7, 13, 7, 1, -13 },
  { 212, 7, 13, 7, 0, -13 },
  { 224, 7, 13, 7, 0, -13 },
  { 236, 4, 10, 4, 0, -10 },
  { 241, 5, 12, 4, -1, -10 },
  { 249, 6, 8, 8, 1, -10 },
  { 255, 6, 5, 8, 1, -9 },
  { 259, 6, 8, 8, 1, -10 },
  { 265, 6, 13, 5, 0, -13 },
  { 275, 10, 15, 11, 0, -13 },
  { 294, 7, 13, 7, -1, -13 },
  { 306, 8, 13, 8, 0, -13 },
  { 319, 7, 13, 7, 1, -13 },
  { 331, 8, 13, 8, 0, -13 },
  { 344, 7, 13, 7, 0, -13 },
  { 356, 7, 13, 6, 0, -13 },
  { 368, 8, 13, 9, 1, -13 },
  { 381, 9, 13, 9, 0, -13 },
  { 396, 7, 13, 5, -1, -13 },
  { 408, 7, 16, 4, -3, -13 },
  { 422, 9, 13, 7, 0, -13 },
  { 437, 5, 13, 6, 0, -13 },
  { 446, 12, 13, 12, 0, -13 },
  { 466, 10, 13, 9, 0, -13 },
  { 483, 8, 13, 9, 1, -13 },
  { 496, 8, 13, 7, 0, -13 },
  { 509, 8, 16, 9, 1, -13 },
  { 525, 8, 13, 8, 0, -13 },
  { 538, 7, 13, 7, 0, -13 },
  { 550, 7, 13, 6, 1, -13 },
  { 562, 8, 13, 9, 1, -13 },
  { 575, 7, 13, 7, 2, -13 },
  { 587, 12, 13, 12, 1, -13 },
  { 607, 9, 13, 7, -1, -13 },
  { 622, 7, 13, 6, 1, -13 },
  { 634, 8, 13, 6, -1, -13 },
  { 647, 6, 16, 5, 0, -13 },
  { 659, 3, 13, 6, 2, -13 },
  { 664, 7, 16, 5, -1, -13 },
  { 678, 7, 7, 7, 0, -13 },
  { 685, 6, 2, 5, -2, 1 },
  { 687, 2, 3, 4, 3, -14 },
  { 688, 8, 10, 8, 0, -10 },
  { 698, 7, 14, 8, 0, -14 },
  { 711, 6, 10, 6, 0, -10 },
  { 719, 8, 14, 8, 0, -14 },
  { 733, 7, 10, 7, 0, -10 },
  { 742, 8, 18, 4, -2, -14 },
  { 760, 8, 14, 8, 0, -10 },
  { 774, 7, 14, 7, 0, -14 },
  { 787, 4, 13, 3, 0, -13 },
  { 794, 6, 17, 3, -2, -13 },
  { 807, 7, 14, 7, 0, -14 },
  { 820, 4, 14, 3, 0, -14 },
  { 827, 11, 10, 11, 0, -10 },
  { 841, 7, 10, 7, 0, -10 },
  { 850, 7, 10, 7, 0, -10 },
  { 859, 8, 14, 8, -1, -10 },
  { 873, 8, 14, 8, 0, -10 },
  { 887, 6, 10, 5, 0, -10 },
  { 895, 6, 10, 6, 0, -10 },
  { 903, 5, 12, 4, 0, -12 },
  { 911, 7, 10, 7, 0, -10 },
  { 920, 6, 10, 6, 1, -10 },
  { 928, 10, 10, 10, 1, -10 },
  { 941, 8, 10, 6, -1, -10 },
  { 951, 9, 14, 6, -2, -10 },
  { 967, 7, 10, 5, -1, -10 },
  { 976, 7, 16, 6, 0, -13 },
  { 990, 1, 18, 7, 3, -14 },
  { 993, 6, 16, 6, -1, -13 },
  { 1005, 6, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Italic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC18PT7B_H_
