#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x1C, 0x00, 0x3C, 0x79, 0xC3, 0x8E,
  0x3C, 0x71, 0xE7, 0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xC3, 0x0E,
  0x38, 0x70, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x38, 0x70, 0x03, 0x86, 0x00, 0x30,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x18, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xC3, 0x00, 0x18, 0x70, 0x01,
  0x87, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7B, 0x38,
  0x3C, 0xC2, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xE2, 0x00, 0x39, 0x80, 0x0E,
  0x60, 0x03, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x02, 0xF0, 0x01, 0x9C, 0x00, 0x67, 0x80, 0x18, 0xE0,
  0x06, 0x38, 0x01, 0x1E, 0x00, 0xC7, 0x08, 0x33, 0xC3, 0xCD, 0xE0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x70, 0x3F,
  0x81, 0xC0, 0xE7, 0x03, 0x83, 0x8E, 0x0E, 0x07, 0x1C, 0x1C, 0x0C, 0x38,
  0x70, 0x38, 0x70, 0xE0, 0x70, 0xE3, 0x80, 0xE1, 0xC7, 0x01, 0x83, 0x1C,
  0x07, 0x0E, 0x38, 0x0E, 0x1C, 0xE0, 0x1C, 0x39, 0xCF, 0xB8, 0xE7, 0x3F,
  0xF1, 0xCC, 0x77, 0xE7, 0x39, 0xCF, 0xFE, 0x67, 0x0D, 0xF9, 0xCE, 0x19,
  0xC3, 0x18, 0x70, 0x0E, 0x70, 0xE0, 0x18, 0xE1, 0xC0, 0x71, 0xC3, 0x81,
  0xC3, 0x07, 0x03, 0x86, 0x1C, 0x0E, 0x1C, 0x38, 0x1C, 0x38, 0x70, 0x70,
  0x71, 0xC0, 0xE0, 0xE3, 0x83, 0x80, 0xEE, 0x07, 0x01, 0xFC, 0x1C, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0x3C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x3C, 0x07, 0x8E, 0x01, 0xE3, 0x80,
  0x79, 0xC0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x71, 0xCE, 0x3C, 0xE3, 0xCF, 0x78, 0xF3,
  0x9C, 0x1D, 0xEF, 0x07, 0xF3, 0x81, 0xFC, 0xE0, 0x3E, 0x38, 0x0F, 0x8E,
  0x03, 0xC3, 0x81, 0xF0, 0xF0, 0xFE, 0x3F, 0xFB, 0x87, 0xFC, 0xF0, 0xFE,
  0x3C, 0x7B, 0xDC, 0xE7, 0x7B, 0x9C, 0xE7, 0x30, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x63,
  0x81, 0xEE, 0x2F, 0xFF, 0x87, 0xFF, 0x07, 0xF0, 0x3E, 0x01, 0xDC, 0x0E,
  0x70, 0x78, 0xE0, 0xC3, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x0F, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x60, 0xE0,
  0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x3B, 0xDF, 0xF7, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xDF, 0x07, 0x8F, 0x0F, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x70, 0xF0,
  0xF0, 0xF1, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0xF8,
  0x3F, 0x0F, 0xE3, 0xFC, 0xF7, 0x3C, 0xE7, 0x3C, 0x47, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F,
  0x1F, 0x03, 0x03, 0xC0, 0x40, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F,
  0x1F, 0x03, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0xC0, 0x7C, 0x3F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00,
  0x37, 0x80, 0x0E, 0xF0, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x07,
  0x1E, 0x00, 0xE3, 0xC0, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x70,
  0x78, 0x0C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x82, 0x03, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3E, 0x10, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x8F, 0x01, 0xDF, 0xC1,
  0xFF, 0xF0, 0xFE, 0x78, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0x0F, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1E, 0x07, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xF0,
  0x78, 0x3C, 0x3C, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x07, 0xF0, 0x03, 0xDE, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x1C, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF9, 0xE0, 0x78, 0x78, 0x78,
  0x3C, 0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x38, 0x3E, 0x1E, 0x1F,
  0x0F, 0xFB, 0x83, 0xFB, 0xC1, 0xF9, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0x03, 0xC3, 0xE1,
  0xF0, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0x00,
  0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03,
  0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0x9E, 0x10, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x0E, 0x03, 0xC0,
  0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0E, 0x0F,
  0xC3, 0x1C, 0x1F, 0xE3, 0x1C, 0x38, 0xC3, 0x38, 0x71, 0xC3, 0x38, 0x61,
  0xC3, 0x30, 0xE1, 0xC7, 0x70, 0xC3, 0x87, 0x71, 0xC3, 0x87, 0x71, 0xC3,
  0x86, 0x61, 0xC3, 0x86, 0x61, 0x87, 0x0E, 0xE1, 0x87, 0x0C, 0xE3, 0x87,
  0x0C, 0xE3, 0x8F, 0x1C, 0xE3, 0x8F, 0x38, 0xE1, 0xDB, 0xF0, 0xE1, 0xF3,
  0xE0, 0xE0, 0xE1, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0,
  0x38, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x3C, 0x38,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x38, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xE0, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1E, 0x1F, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0E,
  0x01, 0xE1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x78, 0x38,
  0x3F, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xCE, 0x07, 0xC0, 0x83, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x10, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x3E, 0x03, 0x81, 0xE0, 0x78, 0x0E,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x38, 0x38, 0x07, 0x83, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x07, 0x0F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xF3, 0xE0, 0x7C, 0x02,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xF8, 0xF0, 0x3F, 0xC7, 0x81, 0xFE, 0x38, 0x0F,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x07, 0x80, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x01, 0xE0, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x03, 0xC0,
  0x38, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x1E,
  0x00, 0x38, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x80, 0x07,
  0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0x80,
  0x07, 0x9C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1D, 0xC0, 0x1D, 0xC0,
  0xEE, 0x00, 0xFE, 0x07, 0x70, 0x0E, 0xF0, 0x3B, 0x80, 0x77, 0x03, 0xDC,
  0x07, 0x38, 0x1E, 0xE0, 0x3B, 0xC0, 0xE7, 0x03, 0xDE, 0x07, 0x38, 0x1C,
  0xE0, 0x79, 0xC1, 0xE7, 0x03, 0xCE, 0x0E, 0x38, 0x1C, 0x70, 0x73, 0xC0,
  0xE3, 0x87, 0x1E, 0x07, 0x1C, 0x38, 0xE0, 0x78, 0xE3, 0x87, 0x03, 0xC7,
  0x1C, 0x78, 0x1C, 0x39, 0xC3, 0xC0, 0xE1, 0xCE, 0x1E, 0x07, 0x0E, 0xF0,
  0xE0, 0x78, 0x77, 0x07, 0x03, 0xC3, 0xF8, 0x78, 0x1C, 0x1F, 0x83, 0xC0,
  0xE0, 0x7C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0x80,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x0E,
  0x03, 0xE0, 0x1E, 0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x1C, 0x07, 0x70, 0x1C,
  0x07, 0x70, 0x3C, 0x07, 0x70, 0x3C, 0x07, 0x70, 0x38, 0x0F, 0x78, 0x38,
  0x0E, 0x38, 0x38, 0x0E, 0x38, 0x78, 0x0E, 0x38, 0x78, 0x1E, 0x38, 0x70,
  0x1E, 0x38, 0x70, 0x1C, 0x3C, 0x70, 0x1C, 0x1C, 0xF0, 0x1C, 0x1C, 0xF0,
  0x3C, 0x1C, 0xE0, 0x3C, 0x1C, 0xE0, 0x38, 0x1C, 0xE0, 0x38, 0x1F, 0xE0,
  0x38, 0x0F, 0xC0, 0x78, 0x0F, 0xC0, 0x78, 0x0F, 0xC0, 0x70, 0x0F, 0xC0,
  0x70, 0x0F, 0xC0, 0x70, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xF3, 0xE0, 0x78, 0x1E,
  0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x00, 0xE7, 0x80, 0x1C,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x0F, 0x70, 0x01, 0xEE,
  0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C,
  0x01, 0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xC1, 0xE0, 0x38, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x38, 0x1C,
  0x0F, 0x07, 0x83, 0xC0, 0xF3, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x01, 0xF3, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0,
  0x0F, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xDE, 0x00,
  0x3B, 0xC0, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x1E,
  0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC1,
  0xE0, 0x38, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x78, 0x1C, 0x1F,
  0x07, 0x87, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x71, 0xC0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC1,
  0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7C, 0x04, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x40, 0x1E, 0x0E,
  0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x0E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x78,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0E, 0x0E, 0x0F,
  0x07, 0x07, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x38,
  0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x03, 0xBC, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x7B, 0x80, 0x3C, 0x03, 0x9C, 0x03,
  0xE0, 0x3C, 0xE0, 0x1F, 0x01, 0xE7, 0x01, 0xF0, 0x0E, 0x38, 0x0F, 0x80,
  0xF1, 0xC0, 0x7C, 0x07, 0x0E, 0x07, 0x60, 0x78, 0x70, 0x3F, 0x03, 0xC3,
  0x81, 0xF8, 0x1C, 0x1C, 0x1D, 0xC1, 0xE0, 0xE0, 0xEE, 0x0E, 0x07, 0x0E,
  0x70, 0x70, 0x78, 0x73, 0x87, 0x83, 0xC3, 0x9C, 0x38, 0x1E, 0x38, 0xE3,
  0xC0, 0xF1, 0xC7, 0x1E, 0x07, 0x9C, 0x38, 0xE0, 0x3C, 0xE1, 0xCF, 0x01,
  0xE7, 0x0E, 0x70, 0x0F, 0x70, 0x77, 0x80, 0x7B, 0x83, 0xBC, 0x03, 0xFC,
  0x1D, 0xC0, 0x1D, 0xC0, 0xFE, 0x00, 0xEE, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC3,
  0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x77, 0x80, 0x03, 0xDE, 0x00, 0x0E, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78,
  0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0,
  0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0E, 0xF0, 0x0F, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87,
  0x83, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x3C, 0xE0, 0x0F, 0xE0,
  0x07, 0x7F, 0xFF, 0xFF, 0xF0, 0xF1, 0xE7, 0x8E, 0x3C, 0x70, 0xC0, 0x01,
  0xF1, 0xC0, 0xFE, 0xE0, 0x7F, 0xB8, 0x3C, 0x7E, 0x1E, 0x0F, 0x87, 0x83,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x1F, 0xEE,
  0x07, 0xFB, 0x80, 0xF8, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x8F, 0x01, 0xDF, 0xC0, 0xFF, 0xF0, 0xFC, 0x78, 0x7C, 0x1C, 0x3C,
  0x0E, 0x1E, 0x07, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07,
  0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xE1, 0xE3, 0xFF, 0xE1, 0xDF,
  0xE0, 0xE7, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xC2, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x41, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x38, 0x03,
  0xFB, 0x80, 0x7F, 0xB8, 0x0F, 0x1F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xC0, 0xF0, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F,
  0x80, 0x7F, 0xB8, 0x07, 0xFB, 0x80, 0x3E, 0x38, 0x00, 0x00, 0xF8, 0x07,
  0xF8, 0x1F, 0xF8, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x0F,
  0x78, 0x1C, 0xF0, 0x79, 0xC7, 0xE3, 0xFF, 0x8F, 0xFC, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x01,
  0x0F, 0xDE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFA, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x0B, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7C, 0x60, 0x1F, 0xDC, 0x07, 0xFB, 0x81, 0xE3, 0xF0, 0x78, 0x3E, 0x0F,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x38, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC3,
  0xE0, 0x3F, 0xDC, 0x07, 0xFF, 0x80, 0x7C, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x20, 0x3C,
  0x07, 0x9F, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x9F, 0x01, 0xDF, 0xC0, 0xFF,
  0xF0, 0xFC, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x0F,
  0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38,
  0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x00, 0x01, 0xC0,
  0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0xF0, 0x70, 0x78, 0x1C, 0x1C, 0x0F, 0x0F, 0x03, 0xC7, 0x80,
  0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0x77,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xEE, 0x00, 0xF3, 0xC0, 0x38, 0xF0,
  0x0E, 0x3C, 0x07, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x1E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x3E, 0x1F, 0x01, 0xDF, 0xCF, 0xE0,
  0x6F, 0xF7, 0xFC, 0x3F, 0x3F, 0x8F, 0x0F, 0x87, 0xC3, 0xC3, 0xC1, 0xE0,
  0xF0, 0xE0, 0x78, 0x3C, 0x78, 0x1C, 0x0E, 0x1E, 0x07, 0x03, 0x87, 0x03,
  0xC0, 0xE1, 0xC0, 0xF0, 0x78, 0x70, 0x38, 0x1E, 0x3C, 0x0E, 0x07, 0x0F,
  0x03, 0x81, 0xC3, 0x81, 0xE0, 0x70, 0xE0, 0x78, 0x3C, 0x38, 0x1C, 0x0F,
  0x1E, 0x07, 0x03, 0x87, 0x81, 0xC0, 0xE1, 0xC0, 0xF0, 0x78, 0x70, 0x3C,
  0x1E, 0x3C, 0x0E, 0x07, 0x0F, 0x03, 0x81, 0xC3, 0xC1, 0xE0, 0x70, 0x07,
  0x3E, 0x03, 0xBF, 0x81, 0xBF, 0xE1, 0xF8, 0xF0, 0xF8, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0E, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x03, 0xC3, 0x81,
  0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1E, 0x3C,
  0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1,
  0xE0, 0x70, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x0F,
  0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F,
  0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0x80, 0x01, 0xC7, 0x80, 0x3B, 0xF8, 0x07, 0xFF, 0x81, 0xD8, 0xF0,
  0x3E, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x07, 0x80, 0xE0,
  0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x0F,
  0x03, 0x81, 0xF0, 0xF0, 0x3F, 0xFC, 0x0F, 0x7F, 0x01, 0xEF, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xF1, 0x81, 0xFD, 0xC1, 0xFE, 0xE1, 0xE3, 0xF1, 0xE0, 0xF8, 0xF0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x0F, 0x83, 0xFD, 0xC1, 0xFF, 0xE0,
  0x7C, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x07, 0x3C, 0x19, 0xF0, 0x6F, 0xC3, 0xBE, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC7, 0x82, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x81, 0xE3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xC0, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0xCF, 0xFB,
  0xFE, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1E, 0x03, 0xF8, 0x7F, 0x07, 0xE0, 0x0E, 0x03, 0x87, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C, 0x78, 0x1C, 0x3C,
  0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1,
  0xC0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x0F, 0x87, 0xFF, 0xC1, 0xFD, 0xC0, 0xFC, 0xE0, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x38, 0xE1,
  0xE3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x3B,
  0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x3C, 0x07, 0x70, 0x3C, 0x0F, 0x70, 0x3C, 0x0E,
  0x70, 0x7C, 0x1E, 0x70, 0x7C, 0x1C, 0x70, 0xFC, 0x1C, 0x70, 0xFC, 0x3C,
  0x70, 0xFC, 0x38, 0x71, 0xDC, 0x78, 0x71, 0xDC, 0x70, 0x71, 0x9C, 0x70,
  0x73, 0x9C, 0xF0, 0x73, 0x9C, 0xE0, 0x77, 0x1C, 0xE0, 0xF7, 0x1D, 0xC0,
  0xF6, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xEE, 0x1F, 0x80, 0xEC, 0x1F, 0x80,
  0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x0F, 0x01, 0xC3,
  0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xCF, 0x00, 0x78, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC3, 0xC0,
  0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7,
  0x80, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 31, 10, 0, -31 },
  { 44, 13, 11, 15, 4, -31 },
  { 62, 20, 31, 19, 0, -31 },
  { 140, 18, 36, 17, 0, -33 },
  { 221, 23, 32, 27, 2, -32 },
  { 313, 18, 32, 19, 0, -32 },
  { 385, 5, 11, 8, 5, -31 },
  { 392, 13, 39, 11, 1, -32 },
  { 456, 13, 39, 11, -3, -32 },
  { 520, 14, 15, 16, 4, -34 },
  { 547, 16, 21, 19, 2, -26 },
  { 589, 8, 11, 9, -2, -5 },
  { 600, 10, 4, 11, 1, -14 },
  { 605, 5, 5, 9, 0, -5 },
  { 609, 20, 32, 15, -2, -32 },
  { 689, 16, 32, 17, 1, -32 },
  { 753, 11, 31, 17, 5, -31 },
  { 796, 18, 32, 17, -1, -32 },
  { 868, 18, 32, 17, -1, -32 },
  { 940, 19, 32, 17, -1, -32 },
  { 1016, 18, 31, 17, 0, -31 },
  { 1086, 17, 32, 17, 1, -32 },
  { 1154, 18, 31, 17, 1, -31 },
  { 1224, 18, 32, 17, 0, -32 },
  { 1296, 17, 32, 17, 0, -32 },
  { 1364, 9, 24, 9, 0, -24 },
  { 1391, 11, 30, 9, -2, -24 },
  { 1433, 16, 19, 19, 2, -25 },
  { 1471, 16, 13, 19, 2, -22 },
  { 1497, 16, 19, 19, 2, -25 },
  { 1535, 14, 32, 13, 1, -32 },
  { 1591, 24, 36, 26, 1, -32 },
  { 1699, 18, 32, 18, -3, -32 },
  { 1771, 19, 31, 19, 0, -31 },
  { 1845, 18, 32, 17, 2, -32 },
  { 1917, 20, 31, 20, 0, -31 },
  { 1995, 18, 31, 16, 0, -31 },
  { 2065, 18, 31, 15, 0, -31 },
  { 2135, 21, 32, 22, 2, -32 },
  { 2219, 22, 31, 21, 0, -31 },
  { 2305, 17, 31, 11, -2, -31 },
  { 2371, 16, 39, 9, -6, -31 },
  { 2449, 21, 31, 18, 0, -31 },
  { 2531, 12, 31, 15, 0, -31 },
  { 2578, 29, 31, 28, 0, -31 },
  { 2691, 24, 31, 23, 0, -31 },
  { 2784, 19, 32, 22, 2, -32 },
  { 2860, 19, 31, 18, 0, -31 },
  { 2934, 19, 39, 22, 2, -32 },
  { 3027, 19, 31, 18, 0, -31 },
  { 3101, 19, 32, 17, -1, -32 },
  { 3177, 16, 31, 15, 3, -31 },
  { 3239, 21, 31, 21, 1, -31 },
  { 3321, 17, 31, 18, 4, -31 },
  { 3387, 29, 31, 29, 3, -31 },
  { 3500, 22, 31, 16, -3, -31 },
  { 3586, 16, 31, 16, 3, -31 },
  { 3648, 19, 31, 15, -2, -31 },
  { 3722, 16, 39, 12, -1, -32 },
  { 3800, 8, 32, 15, 4, -32 },
  { 3832, 17, 39, 12, -3, -32 },
  { 3915, 17, 16, 18, 0, -31 },
  { 3949, 14, 2, 13, -4, 4 },
  { 3953, 6, 7, 11, 6, -34 },
  { 3959, 18, 24, 19, 1, -24 },
  { 4013, 17, 33, 18, 0, -33 },
  { 4084, 14, 24, 14, 1, -24 },
  { 4126, 20, 33, 19, 1, -33 },
  { 4209, 15, 24, 17, 1, -24 },
  { 4254, 20, 45, 10, -5, -34 },
  { 4367, 19, 35, 19, -1, -24 },
  { 4451, 17, 33, 18, 0, -33 },
  { 4522, 10, 32, 8, 0, -32 },
  { 4562, 16, 43, 8, -6, -32 },
  { 4648, 18, 33, 16, 0, -33 },
  { 4723, 11, 33, 8, 0, -33 },
  { 4769, 26, 24, 27, 0, -24 },
  { 4847, 17, 24, 18, 0, -24 },
  { 4898, 16, 24, 18, 1, -24 },
  { 4946, 19, 34, 18, -2, -24 },
  { 5027, 17, 35, 19, 1, -24 },
  { 5102, 14, 24, 12, 0, -24 },
  { 5144, 14, 24, 14, 0, -24 },
  { 5186, 11, 29, 10, 1, -29 },
  { 5226, 17, 24, 18, 1, -24 },
  { 5277, 14, 24, 15, 3, -24 },
  { 5319, 24, 24, 24, 2, -24 },
  { 5391, 19, 24, 15, -2, -24 },
  { 5448, 21, 35, 15, -4, -24 },
  { 5540, 16, 24, 12, -2, -24 },
  { 5588, 16, 38, 14, 1, -31 },
  { 5664, 4, 44, 16, 6, -34 },
  { 5686, 16, 38, 14, -3, -31 },
  { 5762, 16, 5, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Italic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC44PT7B_H_
