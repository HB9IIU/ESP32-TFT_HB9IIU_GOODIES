#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x07, 0x00, 0x3C, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F,
  0x38, 0x71, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x8C,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xDE, 0x07, 0x98, 0x41, 0xE3, 0x00, 0x38, 0x60, 0x07, 0x18,
  0x00, 0xE3, 0x00, 0x1E, 0x60, 0x03, 0xCC, 0x00, 0x3D, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xBC,
  0x00, 0x37, 0x80, 0x06, 0x78, 0x00, 0xCF, 0x00, 0x31, 0xE0, 0x06, 0x3C,
  0x00, 0xC7, 0x88, 0x18, 0xE1, 0x82, 0x3C, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x0E, 0x03, 0xF0, 0x0E, 0x03,
  0xFC, 0x07, 0x03, 0x8E, 0x07, 0x01, 0xC7, 0x03, 0x81, 0xC3, 0x83, 0x80,
  0xE1, 0xC1, 0xC0, 0x70, 0xE1, 0xC0, 0x70, 0x70, 0xE0, 0x38, 0x38, 0xE0,
  0x1C, 0x38, 0x70, 0x0E, 0x1C, 0x70, 0x0E, 0x0E, 0x38, 0x07, 0x07, 0x38,
  0x23, 0x87, 0x38, 0xFD, 0xC3, 0x9C, 0xFE, 0xE3, 0x9C, 0x73, 0xF1, 0xCE,
  0x71, 0xDF, 0xCE, 0x30, 0xEF, 0xC7, 0x38, 0x73, 0xC7, 0x1C, 0x38, 0x03,
  0x9C, 0x1C, 0x03, 0x8E, 0x0E, 0x01, 0xC7, 0x06, 0x01, 0xC3, 0x87, 0x00,
  0xE1, 0xC3, 0x80, 0xE1, 0xC1, 0xC0, 0x70, 0xE0, 0xC0, 0x70, 0x70, 0xE0,
  0x38, 0x38, 0x70, 0x38, 0x1C, 0x70, 0x1C, 0x07, 0x78, 0x1C, 0x03, 0xF8,
  0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1E, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78,
  0x03, 0x87, 0x80, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0xDE,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0xF1, 0xEF, 0x0E, 0x3C, 0x71, 0xE7, 0x87, 0x9C, 0x78,
  0x7B, 0xCF, 0x03, 0xBC, 0xF0, 0x3F, 0x8F, 0x03, 0xF8, 0xE0, 0x3F, 0x0E,
  0x01, 0xE0, 0xE0, 0x3E, 0x0F, 0x03, 0xF0, 0xF0, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xC7, 0x83, 0xF8, 0x78, 0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x1C, 0xF3,
  0x8E, 0x38, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE3, 0x83,
  0xCC, 0x1F, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x3E, 0x01, 0xD8, 0x0E, 0x70,
  0xF9, 0xE1, 0xC3, 0x82, 0x0F, 0x00, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x7D, 0xF0, 0x7C, 0x78, 0x3C, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x0E,
  0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x03, 0x9E, 0x03, 0xCE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x7E, 0x0F, 0xE3, 0xFE, 0x7D, 0xCF, 0xBC, 0xF3, 0xC4, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x3F, 0x00, 0xC0, 0xF0, 0x08,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x3E, 0x01, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x08,
  0x03, 0xE0, 0xC0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0D, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0xC0, 0x03,
  0xBC, 0x00, 0x73, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x1C, 0x78, 0x01,
  0xC7, 0x80, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x0E, 0x0F, 0x01,
  0xC0, 0xF0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x77, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x08, 0x03, 0xE0, 0xC0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x20,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x79, 0xF0, 0x0E,
  0x7F, 0x01, 0xDF, 0xF0, 0x7F, 0x1E, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0xE0,
  0xF8, 0x1E, 0x1E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0x01, 0xE1, 0xE0, 0x78, 0x1E, 0x0E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x78, 0x0F, 0x1E, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x3C,
  0x70, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x03, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0F, 0x9E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x1E,
  0x01, 0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00,
  0xF1, 0xC0, 0x7C, 0x70, 0x1F, 0x1E, 0x0F, 0x87, 0x87, 0xE1, 0xFF, 0xF8,
  0x3F, 0xDE, 0x07, 0xE7, 0x00, 0x41, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0x83,
  0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF3, 0xE0, 0x83, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x60,
  0x70, 0xE0, 0xFF, 0x1C, 0x70, 0x7F, 0xC7, 0x1C, 0x3C, 0x61, 0xC6, 0x0E,
  0x38, 0x73, 0x87, 0x0E, 0x1C, 0xE1, 0xC3, 0x87, 0x30, 0xE0, 0xC1, 0x9C,
  0x38, 0x70, 0x67, 0x0E, 0x1C, 0x39, 0xC7, 0x07, 0x0E, 0x61, 0xC3, 0x83,
  0x38, 0x70, 0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x87, 0x1E, 0x18, 0xE1, 0xC7,
  0x8E, 0x38, 0x73, 0x67, 0x0E, 0x1F, 0xDF, 0x83, 0x83, 0xE7, 0xC0, 0xE0,
  0x60, 0x40, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x01, 0xFE, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0,
  0x70, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x70, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x81,
  0xE1, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x9C, 0x03, 0xE0, 0x40,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x18, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3C,
  0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xF0,
  0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xC7, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0x3E, 0x03,
  0xE0, 0x18, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xE3, 0xC0,
  0x7F, 0x8F, 0x01, 0xFE, 0x3C, 0x07, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xC0,
  0x70, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x38, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x3C, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0x3E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0xE0, 0x01,
  0xE7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0x87,
  0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0x78, 0x1F,
  0xE0, 0x1E, 0xE0, 0x3B, 0xC0, 0x3B, 0xC0, 0x77, 0x80, 0xF7, 0x81, 0xE7,
  0x01, 0xCF, 0x03, 0xCE, 0x07, 0x9C, 0x07, 0x9C, 0x0E, 0x38, 0x0E, 0x38,
  0x1C, 0xF0, 0x3C, 0x70, 0x79, 0xE0, 0x78, 0xE0, 0xE3, 0xC0, 0xF1, 0xC3,
  0xC7, 0x01, 0xC3, 0x87, 0x1E, 0x03, 0x87, 0x1E, 0x3C, 0x0F, 0x0E, 0x38,
  0x78, 0x1E, 0x1C, 0xF0, 0xF0, 0x3C, 0x39, 0xC1, 0xC0, 0x70, 0x77, 0x87,
  0x80, 0xE0, 0xEE, 0x0F, 0x03, 0xC1, 0xDC, 0x1E, 0x07, 0x83, 0xF8, 0x38,
  0x0F, 0x07, 0xE0, 0x70, 0x1C, 0x0F, 0xC1, 0xE0, 0x38, 0x1F, 0x03, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x7E, 0x00, 0xF0, 0x3F, 0x00, 0x70,
  0x1F, 0x80, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x07, 0xB8, 0x0E,
  0x03, 0xDC, 0x07, 0x01, 0xEE, 0x07, 0x80, 0xE7, 0x03, 0xC0, 0x73, 0xC1,
  0xE0, 0x79, 0xE0, 0xE0, 0x3C, 0x70, 0x70, 0x1E, 0x38, 0x78, 0x0E, 0x1C,
  0x3C, 0x0F, 0x0E, 0x1E, 0x07, 0x87, 0x8E, 0x03, 0xC3, 0xCF, 0x01, 0xC0,
  0xE7, 0x80, 0xE0, 0x73, 0xC0, 0xF0, 0x39, 0xE0, 0x78, 0x1C, 0xE0, 0x3C,
  0x0F, 0x70, 0x1C, 0x07, 0xF8, 0x0E, 0x03, 0xFC, 0x0F, 0x00, 0xFC, 0x07,
  0x80, 0x7E, 0x03, 0xC0, 0x3F, 0x01, 0xC0, 0x1F, 0x80, 0xE0, 0x0F, 0xC0,
  0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xE7, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78,
  0x0F, 0x01, 0xE1, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xC3, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xE7,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xE1, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xC3, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF0, 0x38,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0E, 0x1F, 0x81,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xC3, 0x80,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE0, 0x60, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x08, 0x03, 0xE0, 0xF0, 0x7C, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x38, 0x38,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x38,
  0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80,
  0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0xF0, 0x07, 0x80, 0x3D, 0xE0, 0x0F, 0x00, 0x7B, 0xC0,
  0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x03, 0xCF, 0x00, 0xF8, 0x07, 0x1E, 0x03,
  0xF0, 0x1E, 0x3C, 0x07, 0xE0, 0x3C, 0x78, 0x1D, 0xC0, 0xF0, 0xF0, 0x3B,
  0x81, 0xE1, 0xC0, 0x77, 0x03, 0x83, 0x81, 0xDE, 0x0F, 0x07, 0x03, 0xBC,
  0x1E, 0x0E, 0x0F, 0x78, 0x78, 0x1C, 0x1C, 0xE0, 0xF0, 0x38, 0x39, 0xC1,
  0xC0, 0x70, 0xF3, 0x87, 0x80, 0xE1, 0xC7, 0x0F, 0x01, 0xC7, 0x8E, 0x3C,
  0x03, 0x8E, 0x1C, 0x78, 0x07, 0x1C, 0x38, 0xE0, 0x0E, 0x78, 0x73, 0xC0,
  0x1C, 0xE0, 0xE7, 0x80, 0x39, 0xC1, 0xCE, 0x00, 0x77, 0x03, 0xBC, 0x01,
  0xEE, 0x07, 0x70, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00,
  0x70, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0x3B, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0x8F, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x3C, 0x78, 0x0F, 0x0E, 0x07, 0x83, 0x81, 0xE0, 0xE0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78,
  0x03, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x08, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE1, 0xC3,
  0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3,
  0xC7, 0x87, 0x0E, 0x1C, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x07, 0x8E, 0x01,
  0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x3C, 0x1E, 0x07, 0x0F, 0x01, 0xC3, 0x80,
  0x79, 0xE0, 0x1E, 0x70, 0x03, 0xBC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0xF3, 0xC7, 0x9E, 0x38, 0x71, 0xC3, 0x00, 0x70, 0x00, 0x3F,
  0x3C, 0x0F, 0xF7, 0x03, 0xFE, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0x81,
  0xF0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0xF8,
  0x3E, 0x3F, 0x03, 0xFE, 0xE0, 0x7F, 0x9C, 0x07, 0xE3, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x18,
  0x03, 0xDF, 0xC0, 0x77, 0xFC, 0x0E, 0xFF, 0x83, 0xF0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C,
  0x3C, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70,
  0xF0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0x9F, 0xE0, 0x71, 0xF8, 0x00,
  0x00, 0x30, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x08, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x18, 0x78, 0x03, 0xF3, 0xC0, 0x3F, 0xDC, 0x03,
  0xFE, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0,
  0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x0F,
  0x80, 0xF8, 0xFC, 0x03, 0xFE, 0xE0, 0x1F, 0xE7, 0x00, 0x7E, 0x70, 0x00,
  0x00, 0x38, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xDF, 0x0F, 0x0F, 0x1E, 0x07,
  0x1E, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x1E, 0x78, 0x3E, 0x78, 0xFC,
  0x7F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x10, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF2, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF3, 0xC0, 0x3F, 0xDC, 0x03, 0xFE,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C,
  0x0F, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x0F, 0x80,
  0xF8, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xEF, 0x00, 0x7E, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x80, 0x78, 0x06, 0x07, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x60, 0x1E, 0xFE, 0x07, 0x7F, 0x81, 0xFF, 0xF0,
  0x7C, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78,
  0x0E, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x07,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x1C, 0x07, 0x0F, 0x01, 0xC3, 0xC0,
  0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x78, 0x3C, 0x0E,
  0x0F, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x39,
  0xE0, 0x07, 0x3C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xCE, 0x00, 0xF1, 0xC0, 0x1C, 0x3C, 0x03, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xC0, 0x70, 0x3C, 0x0E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x73, 0xF8, 0xFC, 0x07, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xC3,
  0xF1, 0xF0, 0xF8, 0x3E, 0x0F, 0x0F, 0x03, 0xC0, 0xE0, 0xF0, 0x3C, 0x0E,
  0x0E, 0x03, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0,
  0x78, 0x1C, 0x1C, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0x3C, 0x3C, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0x38, 0x38,
  0x0E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0,
  0x70, 0x70, 0x1C, 0x07, 0x0F, 0x01, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x0F,
  0x03, 0xC0, 0xF0, 0x00, 0x06, 0x01, 0xCF, 0xE0, 0x77, 0xF8, 0x1F, 0xFF,
  0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7,
  0x80, 0xE1, 0xE0, 0x38, 0x78, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0,
  0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x38,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x1C, 0x3C,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0xF0,
  0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0x80, 0x39, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81,
  0xE1, 0xE1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x0E, 0x7F, 0x00, 0x77, 0xFC, 0x03, 0xBB, 0xE0, 0x1F, 0x0F, 0x01,
  0xF0, 0x38, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x03,
  0xC1, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0x80, 0x78,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xFF,
  0xE0, 0x3D, 0xFE, 0x01, 0xE7, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0x3C, 0x0F, 0xF7, 0x03, 0xFE, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x03, 0xE1, 0xE0, 0xF8, 0x3E, 0x3F, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x07,
  0xE7, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x7C, 0x1D, 0xF8, 0x3F, 0xE0,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x07, 0xFF, 0x07,
  0xDF, 0x0F, 0x02, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0xC0, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x1F, 0xF3, 0xFE, 0x7F, 0xE0, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78,
  0x70, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38,
  0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x3F, 0x0F, 0xFF, 0x81,
  0xFE, 0xE0, 0x3F, 0x38, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01,
  0xEE, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xC3, 0xC3,
  0x87, 0x87, 0x1E, 0x0E, 0x3C, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xEF,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x03, 0xDC, 0x07, 0x81, 0xE7, 0x03,
  0xE0, 0x79, 0xC0, 0xF8, 0x1C, 0x70, 0x7E, 0x0F, 0x1C, 0x1F, 0x83, 0xC7,
  0x07, 0xE0, 0xE1, 0xC3, 0xB8, 0x78, 0x70, 0xEE, 0x1C, 0x1C, 0x7B, 0x8F,
  0x07, 0x1C, 0xE3, 0xC1, 0xC7, 0x38, 0xE0, 0x73, 0x8E, 0x78, 0x1C, 0xE3,
  0x9C, 0x07, 0x38, 0xEF, 0x01, 0xDC, 0x3B, 0x80, 0x77, 0x0E, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x03, 0x80, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00, 0xF3, 0x80, 0x0F,
  0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1C, 0x07,
  0x81, 0xE0, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x40, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x08, 0x00, 0xBF, 0x80, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFC, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 34, 11, 0, -34 },
  { 52, 13, 13, 16, 5, -34 },
  { 74, 21, 34, 20, 0, -34 },
  { 164, 19, 39, 18, 0, -36 },
  { 257, 25, 34, 29, 2, -34 },
  { 364, 20, 34, 20, 0, -34 },
  { 449, 6, 13, 9, 5, -34 },
  { 459, 14, 41, 12, 1, -34 },
  { 531, 14, 41, 12, -3, -34 },
  { 603, 14, 16, 17, 5, -36 },
  { 631, 17, 22, 20, 2, -28 },
  { 678, 8, 11, 10, -2, -5 },
  { 689, 10, 3, 12, 1, -14 },
  { 693, 4, 5, 10, 1, -5 },
  { 696, 21, 34, 16, -2, -34 },
  { 786, 17, 34, 18, 1, -34 },
  { 859, 12, 34, 18, 5, -34 },
  { 910, 20, 34, 18, -2, -34 },
  { 995, 20, 34, 18, -1, -34 },
  { 1080, 20, 34, 18, -1, -34 },
  { 1165, 20, 34, 18, -1, -34 },
  { 1250, 19, 34, 18, 1, -34 },
  { 1331, 19, 34, 18, 1, -34 },
  { 1412, 19, 34, 18, 0, -34 },
  { 1493, 18, 34, 18, 0, -34 },
  { 1570, 9, 25, 10, 0, -25 },
  { 1599, 12, 31, 10, -2, -25 },
  { 1646, 17, 21, 20, 2, -27 },
  { 1691, 17, 13, 20, 2, -23 },
  { 1719, 17, 21, 20, 2, -27 },
  { 1764, 15, 34, 14, 1, -34 },
  { 1828, 26, 38, 28, 1, -34 },
  { 1952, 19, 34, 19, -3, -34 },
  { 2033, 21, 34, 20, 0, -34 },
  { 2123, 20, 34, 18, 2, -34 },
  { 2208, 21, 34, 22, 0, -34 },
  { 2298, 19, 34, 17, 0, -34 },
  { 2379, 19, 34, 16, 0, -34 },
  { 2460, 22, 34, 23, 2, -34 },
  { 2554, 24, 34, 23, 0, -34 },
  { 2656, 18, 34, 12, -2, -34 },
  { 2733, 18, 43, 10, -7, -34 },
  { 2830, 23, 34, 19, 0, -34 },
  { 2928, 13, 34, 16, 0, -34 },
  { 2984, 31, 34, 30, 0, -34 },
  { 3116, 25, 34, 24, 0, -34 },
  { 3223, 21, 34, 23, 2, -34 },
  { 3313, 20, 34, 19, 0, -34 },
  { 3398, 21, 42, 23, 2, -34 },
  { 3509, 20, 34, 20, 0, -34 },
  { 3594, 20, 34, 18, -1, -34 },
  { 3679, 17, 34, 16, 3, -34 },
  { 3752, 21, 34, 22, 2, -34 },
  { 3842, 19, 34, 19, 4, -34 },
  { 3923, 31, 34, 31, 3, -34 },
  { 4055, 24, 34, 17, -3, -34 },
  { 4157, 18, 34, 17, 3, -34 },
  { 4234, 21, 34, 16, -2, -34 },
  { 4324, 17, 42, 13, -1, -34 },
  { 4414, 7, 34, 16, 5, -34 },
  { 4444, 18, 42, 13, -3, -34 },
  { 4539, 18, 18, 19, 1, -34 },
  { 4580, 15, 3, 14, -4, 4 },
  { 4586, 6, 8, 12, 7, -36 },
  { 4592, 19, 26, 20, 1, -26 },
  { 4654, 19, 36, 20, 0, -36 },
  { 4740, 15, 26, 15, 1, -26 },
  { 4789, 21, 36, 20, 1, -36 },
  { 4884, 16, 26, 18, 1, -26 },
  { 4936, 22, 47, 11, -6, -36 },
  { 5066, 21, 37, 20, -1, -26 },
  { 5164, 18, 36, 19, 0, -36 },
  { 5245, 11, 35, 9, 0, -35 },
  { 5294, 17, 46, 9, -6, -35 },
  { 5392, 19, 36, 17, 0, -36 },
  { 5478, 11, 36, 9, 0, -36 },
  { 5528, 28, 26, 29, 0, -26 },
  { 5619, 18, 26, 19, 0, -26 },
  { 5678, 17, 26, 19, 1, -26 },
  { 5734, 21, 37, 20, -2, -26 },
  { 5832, 19, 37, 20, 1, -26 },
  { 5920, 15, 26, 13, 0, -26 },
  { 5969, 16, 26, 15, -1, -26 },
  { 6021, 12, 31, 11, 1, -31 },
  { 6068, 18, 25, 19, 1, -25 },
  { 6125, 15, 25, 16, 3, -25 },
  { 6172, 26, 25, 26, 2, -25 },
  { 6254, 20, 25, 16, -2, -25 },
  { 6317, 22, 36, 16, -4, -25 },
  { 6416, 17, 25, 13, -2, -25 },
  { 6470, 17, 41, 15, 1, -34 },
  { 6558, 3, 47, 17, 7, -36 },
  { 6576, 17, 41, 15, -3, -34 },
  { 6664, 17, 6, 20, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Italic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC47PT7B_H_
