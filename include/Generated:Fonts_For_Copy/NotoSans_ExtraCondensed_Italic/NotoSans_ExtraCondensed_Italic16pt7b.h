#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x0C, 0xC0, 0xDB, 0xAA, 0x1A, 0x28, 0x53,
  0xF2, 0x85, 0x12, 0x7E, 0x50, 0xA2, 0xC0, 0x08, 0x3C, 0xB3, 0x87, 0x06,
  0x06, 0x0C, 0x29, 0x53, 0xC1, 0x04, 0x00, 0x20, 0x52, 0x94, 0x94, 0xA8,
  0xAB, 0xB5, 0x55, 0x29, 0x29, 0x4A, 0xCE, 0x08, 0x78, 0x91, 0x62, 0x86,
  0x1C, 0xAA, 0x9D, 0x12, 0x67, 0xE0, 0xEA, 0x08, 0x84, 0x42, 0x21, 0x08,
  0xC6, 0x21, 0x8C, 0x21, 0x00, 0x10, 0x84, 0x31, 0x8C, 0x62, 0x10, 0x88,
  0x44, 0x22, 0x00, 0x2A, 0x7E, 0xB0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00,
  0x2D, 0x60, 0xF0, 0xF0, 0x03, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0xC0, 0x08, 0x72, 0x59, 0x45, 0x14, 0x53, 0xCB, 0x2D, 0x1C,
  0x7E, 0xA2, 0x64, 0x44, 0x4C, 0x80, 0x0C, 0x3C, 0x08, 0x10, 0x20, 0x83,
  0x04, 0x10, 0x41, 0x07, 0xE0, 0x18, 0xF0, 0x41, 0x04, 0x63, 0x82, 0x08,
  0x29, 0xBC, 0x04, 0x30, 0xC5, 0x2C, 0xA4, 0x92, 0xFF, 0xF1, 0x04, 0x3C,
  0x82, 0x18, 0x78, 0x20, 0x82, 0x0A, 0x6F, 0x00, 0x06, 0x38, 0xC1, 0x04,
  0x0F, 0x13, 0x26, 0xCD, 0x91, 0x23, 0x80, 0x7E, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0xC3, 0x00, 0x08, 0xF2, 0x59, 0x24, 0xE3, 0x92, 0x8A,
  0x28, 0x9C, 0x08, 0xF6, 0x51, 0x45, 0x16, 0xCF, 0x08, 0x21, 0x38, 0x2C,
  0x00, 0x06, 0xC0, 0x11, 0x00, 0x00, 0x02, 0x64, 0xC0, 0x0C, 0xEE, 0x20,
  0x60, 0x60, 0x40, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x83, 0x33, 0x08,
  0x00, 0x13, 0xC2, 0x11, 0x98, 0x88, 0x40, 0x11, 0x80, 0x06, 0x04, 0x84,
  0x24, 0x14, 0xEA, 0x95, 0x4A, 0xA9, 0x95, 0x4F, 0xA0, 0x08, 0x07, 0xC0,
  0x0C, 0x30, 0xC5, 0x14, 0xD3, 0xD9, 0x45, 0x1C, 0x40, 0x3E, 0x44, 0x89,
  0x37, 0xCF, 0x91, 0x22, 0x45, 0x93, 0xC0, 0x08, 0xF6, 0x10, 0xC2, 0x08,
  0x20, 0x82, 0x08, 0x3C, 0x3E, 0x44, 0x89, 0x16, 0x28, 0x51, 0xA2, 0x4D,
  0xB3, 0xC0, 0x3E, 0x40, 0x81, 0x07, 0x8F, 0x10, 0x20, 0x41, 0x83, 0xC0,
  0x3E, 0x40, 0x81, 0x06, 0x0F, 0x10, 0x20, 0x41, 0x82, 0x00, 0x0C, 0x7D,
  0x82, 0x0C, 0x10, 0x27, 0x42, 0x85, 0x1A, 0x23, 0xC0, 0x31, 0x23, 0x22,
  0x22, 0x7E, 0x7E, 0x46, 0x44, 0x44, 0xC4, 0x8C, 0x3C, 0x61, 0x04, 0x10,
  0x43, 0x08, 0x20, 0x8F, 0x00, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10,
  0xC2, 0x08, 0x63, 0x00, 0x33, 0x24, 0x2C, 0x28, 0x70, 0x70, 0x58, 0x58,
  0x48, 0xC8, 0x88, 0x32, 0x22, 0x64, 0x44, 0x4C, 0xF0, 0x30, 0xE6, 0x18,
  0xC7, 0x18, 0xA7, 0x1C, 0xA5, 0x14, 0xA2, 0xA4, 0x5C, 0x9B, 0x32, 0x64,
  0x00, 0x31, 0x98, 0x8C, 0x47, 0x66, 0xB2, 0x51, 0x28, 0x94, 0x4E, 0x66,
  0x21, 0x00, 0x08, 0x79, 0x9A, 0x3C, 0x70, 0xE1, 0x42, 0x85, 0x12, 0x67,
  0x80, 0x3C, 0x4C, 0x99, 0x36, 0x4F, 0x98, 0x20, 0x41, 0x82, 0x00, 0x08,
  0x79, 0x9A, 0x3C, 0x70, 0xE1, 0x42, 0x85, 0x12, 0x67, 0x83, 0x06, 0x04,
  0x00, 0x3C, 0x4C, 0x99, 0x36, 0x4F, 0x16, 0x2C, 0x49, 0x92, 0x20, 0x08,
  0x7D, 0x83, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x12, 0x67, 0x80, 0xFC, 0x82,
  0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x00, 0x66, 0x8D, 0x12, 0x2C, 0x51,
  0xA2, 0x44, 0x89, 0x33, 0xC0, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x34, 0x70,
  0xE1, 0xC3, 0x00, 0xC4, 0x79, 0x8B, 0x33, 0x6E, 0x4D, 0x59, 0x2A, 0x29,
  0x45, 0x38, 0xA6, 0x18, 0xC3, 0x10, 0x00, 0x13, 0x12, 0x14, 0x14, 0x18,
  0x18, 0x18, 0x28, 0x68, 0x4C, 0xCC, 0xCD, 0x25, 0x94, 0x61, 0x84, 0x10,
  0x43, 0x0C, 0x00, 0x1E, 0x0C, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x60, 0x83,
  0xE0, 0x1C, 0xE2, 0x08, 0x20, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x0E,
  0x00, 0xAA, 0xAD, 0x54, 0x1C, 0x70, 0xC2, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x0C, 0x20, 0x8E, 0x00, 0x18, 0x62, 0x89, 0x47, 0x10, 0xF8, 0xCC, 0x1A,
  0x7D, 0x92, 0x24, 0x59, 0xB2, 0x6C, 0x68, 0x30, 0x82, 0x0B, 0x35, 0x94,
  0x51, 0x45, 0x3C, 0xAC, 0x1C, 0xA6, 0x10, 0x43, 0x0C, 0x30, 0x70, 0x02,
  0x04, 0x08, 0xF2, 0xCC, 0x91, 0x22, 0xCD, 0x93, 0x63, 0x40, 0x18, 0xB6,
  0x52, 0x7B, 0x0C, 0x30, 0x78, 0x07, 0x0C, 0x08, 0x0C, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0xC0, 0x1A, 0x59, 0x92,
  0x24, 0x59, 0xB2, 0x6C, 0x68, 0x10, 0x65, 0x8E, 0x00, 0x30, 0x82, 0x0B,
  0x35, 0x94, 0x53, 0x49, 0x2C, 0xA6, 0x33, 0x02, 0x26, 0x44, 0x44, 0xC8,
  0x0C, 0x30, 0x02, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0x20, 0x86, 0x30,
  0x30, 0x82, 0x09, 0x2D, 0xA5, 0x1C, 0x51, 0x4D, 0xA6, 0x32, 0x22, 0x26,
  0x44, 0x44, 0xC8, 0x29, 0x9B, 0x59, 0x28, 0x94, 0xCA, 0x4D, 0x25, 0x92,
  0x99, 0x00, 0x2C, 0xD6, 0x51, 0x4D, 0x24, 0xB2, 0x98, 0x18, 0xB6, 0x51,
  0x47, 0x3C, 0xB2, 0x70, 0x16, 0x34, 0xC9, 0x12, 0x24, 0x49, 0xB2, 0x58,
  0x81, 0x06, 0x0C, 0x00, 0x1A, 0x59, 0x92, 0x24, 0x59, 0xB2, 0x6C, 0x68,
  0x10, 0x60, 0x81, 0x00, 0x29, 0xD8, 0x84, 0x21, 0x18, 0x80, 0x3B, 0x50,
  0x82, 0x18, 0x52, 0xE0, 0x12, 0x36, 0x64, 0x44, 0x4C, 0x60, 0x26, 0x49,
  0x92, 0x24, 0xC9, 0x12, 0x6C, 0x68, 0x8C, 0xE5, 0x2A, 0x53, 0x98, 0xC0,
  0x89, 0x99, 0x9B, 0xAA, 0xAA, 0xAC, 0xCC, 0xCC, 0x88, 0x32, 0x68, 0x50,
  0xC1, 0x87, 0x0A, 0x24, 0xC8, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x1C,
  0x18, 0x18, 0x10, 0x10, 0x20, 0xE0, 0x3C, 0x30, 0x86, 0x10, 0x82, 0x12,
  0xF0, 0x0C, 0x41, 0x04, 0x10, 0x8C, 0x08, 0x21, 0x84, 0x10, 0x60, 0x40,
  0xFF, 0xFF, 0x18, 0x20, 0x82, 0x18, 0x60, 0xC4, 0x30, 0x82, 0x08, 0xE2,
  0x00, 0xC6, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 2, -11 },
  { 9, 7, 11, 7, 0, -11 },
  { 19, 7, 13, 6, 0, -12 },
  { 31, 8, 12, 10, 1, -12 },
  { 43, 7, 12, 7, 0, -12 },
  { 54, 2, 4, 3, 2, -11 },
  { 55, 5, 15, 4, 0, -12 },
  { 65, 5, 15, 4, -1, -12 },
  { 75, 4, 5, 6, 2, -12 },
  { 78, 6, 7, 7, 1, -9 },
  { 84, 3, 4, 3, -1, -2 },
  { 86, 4, 1, 4, 0, -5 },
  { 87, 2, 2, 3, 0, -2 },
  { 88, 8, 11, 5, -1, -11 },
  { 99, 6, 12, 6, 0, -12 },
  { 108, 4, 11, 6, 2, -11 },
  { 114, 7, 12, 6, -1, -12 },
  { 125, 6, 12, 6, 0, -12 },
  { 134, 6, 12, 6, 0, -12 },
  { 143, 6, 11, 6, 0, -11 },
  { 152, 7, 12, 6, 0, -12 },
  { 163, 7, 11, 6, 0, -11 },
  { 173, 6, 12, 6, 0, -12 },
  { 182, 6, 12, 6, 0, -12 },
  { 191, 3, 9, 3, 0, -9 },
  { 195, 4, 11, 3, -1, -9 },
  { 201, 6, 7, 7, 1, -9 },
  { 207, 6, 5, 7, 1, -8 },
  { 211, 6, 7, 7, 1, -9 },
  { 217, 5, 12, 5, 0, -12 },
  { 225, 9, 13, 9, 0, -12 },
  { 240, 6, 11, 6, -1, -11 },
  { 249, 7, 11, 7, 0, -11 },
  { 259, 6, 12, 6, 1, -12 },
  { 268, 7, 11, 7, 0, -11 },
  { 278, 7, 11, 6, 0, -11 },
  { 288, 7, 11, 6, 0, -11 },
  { 298, 7, 12, 8, 1, -12 },
  { 309, 8, 11, 8, 0, -11 },
  { 320, 6, 11, 4, -1, -11 },
  { 329, 6, 14, 3, -2, -11 },
  { 340, 8, 11, 6, 0, -11 },
  { 351, 4, 11, 5, 0, -11 },
  { 357, 11, 11, 10, 0, -11 },
  { 373, 9, 11, 8, 0, -11 },
  { 386, 7, 12, 8, 1, -12 },
  { 397, 7, 11, 6, 0, -11 },
  { 407, 7, 15, 8, 1, -12 },
  { 421, 7, 11, 7, 0, -11 },
  { 431, 7, 12, 6, 0, -12 },
  { 442, 6, 11, 6, 1, -11 },
  { 451, 7, 11, 8, 1, -11 },
  { 461, 7, 11, 6, 1, -11 },
  { 471, 11, 11, 10, 1, -11 },
  { 487, 8, 11, 6, -1, -11 },
  { 498, 6, 11, 6, 1, -11 },
  { 507, 7, 11, 5, -1, -11 },
  { 517, 6, 15, 5, 0, -12 },
  { 529, 2, 11, 5, 2, -11 },
  { 532, 6, 15, 5, -1, -12 },
  { 544, 6, 6, 6, 0, -11 },
  { 549, 5, 1, 5, -1, 1 },
  { 550, 3, 2, 4, 2, -12 },
  { 551, 7, 9, 7, 0, -9 },
  { 559, 6, 12, 7, 0, -12 },
  { 568, 6, 9, 5, 0, -9 },
  { 575, 7, 12, 7, 0, -12 },
  { 586, 6, 9, 6, 0, -9 },
  { 593, 8, 16, 4, -2, -12 },
  { 609, 7, 13, 7, 0, -9 },
  { 621, 6, 12, 7, 0, -12 },
  { 630, 4, 12, 3, 0, -12 },
  { 636, 6, 16, 3, -2, -12 },
  { 648, 6, 12, 6, 0, -12 },
  { 657, 4, 12, 3, 0, -12 },
  { 663, 9, 9, 10, 0, -9 },
  { 674, 6, 9, 7, 0, -9 },
  { 681, 6, 9, 7, 0, -9 },
  { 688, 7, 13, 7, -1, -9 },
  { 700, 7, 13, 7, 0, -9 },
  { 712, 5, 9, 4, 0, -9 },
  { 718, 5, 9, 5, 0, -9 },
  { 724, 4, 11, 4, 0, -11 },
  { 730, 7, 9, 7, 0, -9 },
  { 738, 5, 9, 5, 1, -9 },
  { 744, 8, 9, 9, 1, -9 },
  { 753, 7, 9, 6, -1, -9 },
  { 761, 8, 13, 5, -2, -9 },
  { 774, 6, 9, 5, -1, -9 },
  { 781, 6, 14, 5, 0, -11 },
  { 792, 1, 16, 6, 2, -12 },
  { 794, 6, 14, 5, -1, -11 },
  { 805, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Italic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC16PT7B_H_
