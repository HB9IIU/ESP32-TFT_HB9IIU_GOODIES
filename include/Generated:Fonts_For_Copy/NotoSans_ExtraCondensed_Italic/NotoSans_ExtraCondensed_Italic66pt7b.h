#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x20,
  0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x1F,
  0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x87,
  0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x21, 0xF0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xF3, 0x0F, 0x00, 0xF8, 0xE0, 0x40, 0x3E, 0x1C, 0x00, 0x07, 0xC3, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF1, 0x80, 0x00, 0x3F, 0x30, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1B, 0xF0, 0x00, 0x07, 0x3E, 0x00, 0x00, 0xE7,
  0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x61, 0xF0, 0x00,
  0x1C, 0x3E, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x70, 0xF8, 0x00, 0x0C, 0x1F,
  0x04, 0x01, 0x87, 0xC0, 0x40, 0x71, 0xF8, 0x1F, 0x0E, 0x7E, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0xF0, 0x07, 0xC1, 0xE0, 0x3C, 0x00,
  0xF0, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8,
  0x78, 0x00, 0x78, 0x1E, 0x1F, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x03, 0xE0,
  0x78, 0xF8, 0x00, 0x78, 0x1F, 0x1E, 0x0F, 0x8F, 0x03, 0xC7, 0xC3, 0xF9,
  0xE0, 0x78, 0xF0, 0xFF, 0xBC, 0x1E, 0x3E, 0x3F, 0xF7, 0x83, 0xC7, 0x8F,
  0x9F, 0xF0, 0xF9, 0xF1, 0xE1, 0xEF, 0x3E, 0x3C, 0x78, 0x3D, 0xFF, 0x8F,
  0x8F, 0x07, 0xBF, 0xE1, 0xE3, 0xC0, 0xF3, 0xF8, 0x78, 0x78, 0x1E, 0x1C,
  0x0F, 0x1F, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0xF8, 0x00, 0x78, 0x78, 0x1F,
  0x00, 0x1E, 0x0F, 0x03, 0xC0, 0x03, 0xC3, 0xE0, 0x78, 0x00, 0xF0, 0x78,
  0x0F, 0x00, 0x1E, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x7C, 0x01,
  0xE0, 0x1E, 0x0F, 0x00, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x3F,
  0xF0, 0x03, 0xC0, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x0F, 0x87, 0xC7,
  0xC1, 0xF1, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x8F, 0x81, 0xF1, 0xF3,
  0xF0, 0x3E, 0x7C, 0x7C, 0x07, 0xCF, 0x8F, 0x80, 0xFD, 0xF3, 0xE0, 0x0F,
  0xFC, 0x7C, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xE1, 0xF0, 0x03, 0xF8, 0x3E,
  0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0xFF,
  0x83, 0xF0, 0x3F, 0xF0, 0x7F, 0x0F, 0xFF, 0x07, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFC, 0x7C, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x03, 0x07, 0x80, 0x7C, 0x78, 0x07, 0xF7, 0x87,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xBC, 0x01, 0xF9, 0xE0, 0x3F, 0x1F, 0x07, 0xE1,
  0xF0, 0x1E, 0x0F, 0x80, 0xC0, 0xF8, 0x04, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x08, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF,
  0x7C, 0x20, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xBE, 0x3F, 0x7E, 0x7E, 0x7C, 0xFC, 0x7C, 0x78, 0x7C, 0x30, 0xFC, 0x20,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x03, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xF8, 0x1F, 0x80, 0x1C, 0x01, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x1F, 0xC0, 0x78, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x77, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x7E, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x80, 0x03, 0xF8, 0x18, 0x00, 0xFE, 0x03, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x04,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC1, 0xE0, 0x07, 0xC7, 0xFC, 0x03, 0xE7, 0xFF, 0x01, 0xF7,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xF0, 0x7F, 0x81, 0xF8, 0x3F,
  0x80, 0x7C, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x3E, 0x01, 0xFC, 0x0F, 0xC0,
  0xFF, 0x03, 0xF8, 0x7F, 0xC0, 0x7F, 0xFD, 0xF0, 0x1F, 0xFE, 0xFC, 0x03,
  0xFF, 0x3E, 0x00, 0x7F, 0x8F, 0x80, 0x03, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x02,
  0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xC1, 0xFC, 0x18, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x60, 0x0F, 0x07, 0x80, 0x7F, 0xF0, 0xF0, 0x78,
  0x0F, 0xFE, 0x0F, 0x0F, 0x01, 0xFF, 0xE0, 0xF0, 0xF0, 0x3E, 0x1E, 0x0F,
  0x1E, 0x03, 0xC3, 0xE0, 0xF1, 0xE0, 0x78, 0x3C, 0x0F, 0x1C, 0x0F, 0x03,
  0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0x0E, 0x3C, 0x1E, 0x07, 0xC1, 0xE3, 0x81,
  0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0x78, 0x1E,
  0x78, 0x3C, 0x0F, 0x81, 0xC7, 0x03, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F,
  0x03, 0xCF, 0x07, 0xC0, 0xF0, 0x3C, 0xF0, 0x78, 0x1F, 0x07, 0x8F, 0x07,
  0x81, 0xE0, 0x78, 0xF0, 0x78, 0x1E, 0x07, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0xF0, 0x78, 0x3E, 0x0E, 0x0F, 0x07, 0x87, 0xE1, 0xE0, 0xE0, 0x7C, 0xEF,
  0x3C, 0x0E, 0x03, 0xFE, 0xFF, 0x80, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0x01,
  0xF8, 0x7E, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x03,
  0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3E, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFC, 0x1C, 0x00, 0x7F, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x20,
  0x03, 0xFC, 0x1C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0,
  0x7E, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x04, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0xFF,
  0xE0, 0x7C, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0x0F,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01,
  0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE3,
  0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0x3C, 0x03, 0xC3, 0xE0,
  0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x07, 0xC7, 0xE0, 0x0F,
  0x83, 0xC0, 0xF8, 0x7C, 0x00, 0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0x0F, 0x83,
  0xC1, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xC3,
  0xE0, 0xFC, 0x01, 0xF0, 0x3C, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE3, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE7, 0x80, 0xF8,
  0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xEF, 0x81, 0xF0, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x03, 0xE0,
  0x3F, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x80,
  0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x07, 0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x03,
  0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xE0,
  0x01, 0xF0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xC0,
  0x1F, 0x3C, 0x00, 0xF8, 0x03, 0xE7, 0x80, 0x3E, 0x00, 0x7C, 0xF8, 0x07,
  0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x7C, 0x7C,
  0x07, 0xE0, 0x0F, 0x87, 0x80, 0xF8, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0x3E,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x1F, 0x80,
  0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF0, 0x7C, 0x00, 0xF8, 0x1E, 0x0F,
  0x80, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x7C, 0x7E, 0x00, 0xF8, 0x0F,
  0x8F, 0x80, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x1E, 0x3E, 0x00, 0xF8,
  0x03, 0xC7, 0xC0, 0x1F, 0x00, 0x7D, 0xF0, 0x03, 0xE0, 0x0F, 0xBE, 0x00,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x03, 0xDF,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x07, 0xFC, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x1F,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC0,
  0xFE, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE1, 0xF8, 0x01,
  0xFC, 0x01, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x0F, 0xE0, 0x1C, 0x00, 0xFE,
  0x00, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x07,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0xF7, 0x80, 0x3F, 0x0F, 0xC0, 0x1E, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xDE,
  0x00, 0xF8, 0x3E, 0x00, 0xF3, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x78, 0x07,
  0xC0, 0xF8, 0x07, 0xCF, 0x01, 0xF8, 0x1F, 0x00, 0xF3, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xCF, 0x81, 0xF8, 0x0F, 0x80,
  0xF1, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0x87,
  0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x1F, 0x0F,
  0xC0, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x7C, 0x7E, 0x00,
  0x7C, 0x3C, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x01, 0xF1,
  0xF0, 0x3C, 0x7E, 0x00, 0x3E, 0x3C, 0x07, 0x8F, 0x80, 0x07, 0xCF, 0x80,
  0xF1, 0xF0, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x00, 0x1F, 0x3C, 0x03, 0xCF,
  0x80, 0x03, 0xEF, 0x80, 0x7B, 0xF0, 0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00,
  0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E,
  0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0x80, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x07, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF9,
  0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE, 0x78, 0x07, 0xFF,
  0xBE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x3E, 0x01,
  0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0xFB, 0xE0, 0x1F,
  0xFE, 0xF8, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xC7, 0xFC, 0x01, 0xF3, 0xFF, 0x00, 0x7D, 0xFF, 0xE0,
  0x1F, 0xFB, 0xF8, 0x0F, 0xF8, 0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0xFE, 0x01,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xE0,
  0x7F, 0x01, 0xF8, 0x1F, 0xE0, 0xFC, 0x07, 0xBF, 0xFE, 0x03, 0xEF, 0xFF,
  0x80, 0xF9, 0xFF, 0xC0, 0x3C, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xF8, 0x10, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x08, 0x1F, 0xC1, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xF9, 0xF8, 0x00,
  0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C,
  0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xFC,
  0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xF0, 0x03,
  0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0x7C, 0x00, 0x3F, 0xF3, 0xE0, 0x00, 0xFE,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0xFC, 0x1F, 0x81, 0xF0, 0x7C,
  0x07, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x1F,
  0x07, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x08, 0x1F, 0x80, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xC0,
  0x07, 0xFF, 0x3C, 0x00, 0x7F, 0xFB, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0xFF, 0x80,
  0x1F, 0xFF, 0x7C, 0x00, 0x7F, 0xFB, 0xE0, 0x01, 0xFF, 0x9F, 0x00, 0x07,
  0xF1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x40,
  0x07, 0xE0, 0x03, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE3, 0xF0,
  0x03, 0xE7, 0xFC, 0x01, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF,
  0xE0, 0x7F, 0x83, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x08, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFD, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x0F,
  0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x03,
  0xE7, 0xFC, 0x1F, 0xF0, 0x07, 0x9F, 0xFC, 0x7F, 0xF0, 0x0F, 0x7F, 0xFD,
  0xFF, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF9, 0xFF, 0x00, 0x79, 0xFF, 0xC0,
  0x3D, 0xFF, 0xF0, 0x1E, 0xFF, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0x3E,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFC, 0x0F,
  0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00,
  0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF1,
  0xFF, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x79, 0xFF, 0xE0, 0x03, 0xDF, 0x7F,
  0x00, 0x3F, 0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFE,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7D, 0xFF, 0xE0, 0x07, 0xCF, 0xFE,
  0x00, 0x3E, 0x3F, 0xC0, 0x01, 0xF0, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE, 0x78, 0x07, 0xFF, 0xBE,
  0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x3E, 0x01, 0xFC,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0xFF, 0xFB, 0xE0, 0x1F, 0xFE,
  0xF8, 0x03, 0xFF, 0x7E, 0x00, 0x7F, 0x1F, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x1F, 0xC0, 0x79, 0xFE, 0x03, 0xDF, 0xE0, 0x1E,
  0xFF, 0x01, 0xFF, 0x88, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xCF, 0xC0, 0x7C, 0x03, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x20, 0x07, 0xE0, 0x78, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0C, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0xFF, 0x03,
  0xF0, 0xFF, 0x01, 0xFF, 0xF7, 0x80, 0xFF, 0xF3, 0xC0, 0x3F, 0xF3, 0xE0,
  0x0F, 0xF1, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x3F,
  0x80, 0x7C, 0x7C, 0x03, 0xF8, 0x07, 0xC7, 0xC0, 0x7F, 0x80, 0x7C, 0x7C,
  0x07, 0xF8, 0x0F, 0x87, 0xC0, 0x7F, 0x80, 0xF8, 0x7C, 0x0F, 0x78, 0x1F,
  0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x7C, 0x1F, 0x78, 0x1F, 0x07, 0xC1, 0xE7,
  0x83, 0xE0, 0x7C, 0x1E, 0x78, 0x3E, 0x07, 0xC3, 0xE7, 0x83, 0xC0, 0x7C,
  0x3C, 0x78, 0x7C, 0x07, 0xC7, 0xC7, 0x87, 0xC0, 0x7C, 0x78, 0x78, 0xF8,
  0x07, 0xC7, 0x87, 0x8F, 0x80, 0x7C, 0xF8, 0x78, 0xF0, 0x07, 0xCF, 0x0F,
  0x9F, 0x00, 0x78, 0xF0, 0xF9, 0xF0, 0x07, 0x9F, 0x0F, 0xBE, 0x00, 0x79,
  0xE0, 0xFB, 0xE0, 0x07, 0xBE, 0x0F, 0xBC, 0x00, 0x7B, 0xC0, 0xF7, 0xC0,
  0x07, 0xBC, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0xF7, 0x80, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xF0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x20, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x3F, 0xC0, 0x01, 0x7F, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 48, 16, 1, -47 },
  { 97, 18, 17, 22, 7, -47 },
  { 136, 30, 47, 28, 0, -47 },
  { 313, 27, 54, 26, 0, -50 },
  { 496, 35, 49, 40, 3, -48 },
  { 711, 27, 49, 28, 0, -48 },
  { 877, 8, 17, 12, 7, -47 },
  { 894, 20, 57, 17, 1, -47 },
  { 1037, 20, 57, 17, -5, -47 },
  { 1180, 20, 22, 24, 6, -50 },
  { 1235, 24, 31, 28, 3, -39 },
  { 1328, 12, 16, 13, -3, -7 },
  { 1352, 15, 5, 17, 1, -20 },
  { 1362, 7, 9, 13, 1, -8 },
  { 1370, 30, 47, 22, -3, -47 },
  { 1547, 25, 49, 26, 1, -48 },
  { 1701, 16, 47, 26, 7, -47 },
  { 1795, 28, 48, 26, -2, -48 },
  { 1963, 27, 49, 26, -1, -48 },
  { 2129, 27, 48, 26, -1, -48 },
  { 2291, 27, 48, 26, -1, -47 },
  { 2453, 25, 49, 26, 2, -48 },
  { 2607, 27, 47, 26, 2, -47 },
  { 2766, 27, 49, 26, 0, -48 },
  { 2932, 26, 49, 26, 0, -48 },
  { 3092, 13, 37, 13, 0, -36 },
  { 3153, 16, 45, 13, -3, -36 },
  { 3243, 24, 29, 28, 3, -38 },
  { 3330, 24, 19, 28, 3, -33 },
  { 3387, 24, 29, 28, 3, -38 },
  { 3474, 21, 49, 19, 1, -48 },
  { 3603, 36, 54, 39, 2, -48 },
  { 3846, 26, 47, 27, -4, -47 },
  { 3999, 29, 47, 28, 0, -47 },
  { 4170, 28, 49, 25, 2, -48 },
  { 4342, 30, 47, 31, 0, -47 },
  { 4519, 27, 47, 24, 0, -47 },
  { 4678, 27, 47, 23, 0, -47 },
  { 4837, 32, 49, 32, 2, -48 },
  { 5033, 33, 47, 32, 0, -47 },
  { 5227, 25, 47, 17, -3, -47 },
  { 5374, 25, 60, 13, -10, -47 },
  { 5562, 32, 47, 27, 0, -47 },
  { 5750, 18, 47, 22, 0, -47 },
  { 5856, 44, 47, 43, 0, -47 },
  { 6115, 35, 47, 34, 0, -47 },
  { 6321, 30, 49, 33, 2, -48 },
  { 6505, 28, 47, 27, 0, -47 },
  { 6670, 30, 59, 33, 2, -48 },
  { 6892, 28, 47, 28, 0, -47 },
  { 7057, 29, 49, 25, -2, -48 },
  { 7235, 24, 47, 23, 4, -47 },
  { 7376, 31, 48, 31, 2, -47 },
  { 7562, 26, 47, 27, 6, -47 },
  { 7715, 43, 47, 43, 5, -47 },
  { 7968, 33, 47, 24, -4, -47 },
  { 8162, 24, 47, 24, 5, -47 },
  { 8303, 29, 47, 22, -3, -47 },
  { 8474, 25, 59, 19, -2, -48 },
  { 8659, 10, 47, 22, 7, -47 },
  { 8718, 24, 59, 19, -4, -48 },
  { 8895, 25, 25, 26, 1, -47 },
  { 8974, 21, 5, 20, -6, 5 },
  { 8988, 9, 10, 16, 10, -50 },
  { 9000, 26, 37, 28, 2, -36 },
  { 9121, 26, 51, 28, 0, -50 },
  { 9287, 21, 37, 21, 2, -36 },
  { 9385, 29, 51, 28, 2, -50 },
  { 9570, 22, 37, 25, 2, -36 },
  { 9672, 31, 66, 15, -8, -50 },
  { 9928, 29, 52, 28, -1, -36 },
  { 10117, 25, 50, 27, 0, -50 },
  { 10274, 15, 49, 13, 0, -49 },
  { 10366, 24, 65, 13, -9, -49 },
  { 10561, 27, 50, 24, 0, -50 },
  { 10730, 16, 50, 13, 0, -50 },
  { 10830, 39, 36, 40, 0, -36 },
  { 11006, 25, 36, 27, 0, -36 },
  { 11119, 23, 37, 27, 2, -36 },
  { 11226, 29, 51, 28, -3, -36 },
  { 11411, 26, 52, 28, 2, -36 },
  { 11580, 21, 36, 18, 0, -36 },
  { 11675, 23, 37, 21, -1, -36 },
  { 11782, 16, 44, 16, 2, -43 },
  { 11870, 25, 36, 27, 2, -35 },
  { 11983, 22, 35, 22, 4, -35 },
  { 12080, 36, 35, 36, 3, -35 },
  { 12238, 28, 35, 23, -3, -35 },
  { 12361, 32, 51, 22, -6, -35 },
  { 12565, 23, 35, 19, -2, -35 },
  { 12666, 24, 57, 22, 2, -47 },
  { 12837, 4, 66, 24, 10, -50 },
  { 12870, 24, 57, 22, -4, -47 },
  { 13041, 24, 9, 28, 3, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Italic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC66PT7B_H_
