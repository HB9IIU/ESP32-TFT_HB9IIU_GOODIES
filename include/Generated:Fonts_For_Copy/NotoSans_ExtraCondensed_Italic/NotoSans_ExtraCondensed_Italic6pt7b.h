#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x80, 0x7F, 0x40, 0x55, 0xC0, 0xFD, 0xD0, 0xDF, 0x80, 0x6A,
  0x80, 0xF8, 0xC0, 0x74, 0xC0, 0x80, 0x80, 0x5A, 0xFF, 0xF0, 0x57, 0x57,
  0x7D, 0xF7, 0x7B, 0x60, 0x69, 0x40, 0xDF, 0xF7, 0xA0, 0xB0, 0xD0, 0xF0,
  0xF0, 0xDA, 0x7E, 0xE4, 0x7F, 0xFA, 0xE0, 0x72, 0x60, 0xF6, 0xE0, 0xFB,
  0xFA, 0x72, 0xF0, 0xBE, 0xE0, 0x6A, 0x55, 0xC0, 0xAB, 0x60, 0xAB, 0x57,
  0xDE, 0x6E, 0xD0, 0x76, 0xE0, 0xF7, 0x40, 0x76, 0xE4, 0xF7, 0x60, 0xE7,
  0xEA, 0x40, 0xB6, 0xE0, 0xEA, 0xBB, 0xEA, 0xE9, 0x60, 0xEA, 0x40, 0x5B,
  0xEA, 0x80, 0xF0, 0x56, 0x80, 0x70, 0xC0, 0x80, 0xFB, 0x00, 0x6F, 0xC0,
  0xEC, 0x2E, 0xEC, 0xEC, 0x25, 0x25, 0x80, 0xFB, 0x60, 0x6F, 0xC0, 0x70,
  0x15, 0xC0, 0x67, 0xC0, 0xF8, 0xFD, 0xE0, 0xFC, 0xFC, 0xFE, 0xFB, 0x20,
  0xE8, 0xD8, 0x6A, 0xFC, 0xF8, 0xDA, 0xA0, 0xEC, 0x6D, 0x60, 0xE8, 0x5A,
  0x80, 0xFC, 0x56, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 2, 0, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 2, 4, 3, 0, -4 },
  { 10, 1, 1, 1, 1, -4 },
  { 11, 2, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 1, 2, 2, 1, -5 },
  { 15, 2, 3, 3, 0, -4 },
  { 16, 1, 2, 1, 0, -1 },
  { 17, 1, 1, 2, 0, -2 },
  { 18, 1, 1, 1, 0, -1 },
  { 19, 2, 4, 2, 0, -4 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 1, 4, 2, 1, -4 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 3, 4, 2, 0, -4 },
  { 28, 3, 4, 2, 0, -4 },
  { 30, 2, 4, 2, 0, -4 },
  { 31, 2, 4, 2, 0, -4 },
  { 32, 1, 3, 1, 0, -3 },
  { 33, 1, 4, 1, 0, -3 },
  { 34, 2, 2, 3, 0, -3 },
  { 35, 2, 2, 3, 0, -3 },
  { 36, 2, 2, 3, 0, -3 },
  { 37, 2, 4, 2, 0, -4 },
  { 38, 3, 5, 4, 0, -4 },
  { 40, 2, 4, 2, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 2, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 2, 4, 2, 0, -4 },
  { 48, 2, 4, 2, 0, -4 },
  { 49, 3, 4, 3, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 2, 4, 2, 0, -4 },
  { 54, 2, 5, 1, -1, -4 },
  { 56, 3, 4, 2, 0, -4 },
  { 58, 2, 4, 2, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 2, 0, -4 },
  { 67, 3, 5, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 3, 4, 2, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 2, 4, 2, 1, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 3, 4, 2, 0, -4 },
  { 81, 3, 4, 2, 0, -4 },
  { 83, 2, 4, 2, 0, -4 },
  { 84, 2, 5, 2, 0, -4 },
  { 86, 1, 4, 2, 1, -4 },
  { 87, 2, 5, 2, 0, -4 },
  { 89, 2, 2, 2, 0, -4 },
  { 90, 2, 1, 2, -1, 0 },
  { 91, 1, 1, 2, 1, -5 },
  { 92, 3, 3, 3, 0, -3 },
  { 94, 2, 5, 3, 0, -5 },
  { 96, 2, 3, 2, 0, -3 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 2, 3, 2, 0, -3 },
  { 100, 3, 6, 1, -1, -5 },
  { 103, 3, 4, 3, 0, -3 },
  { 105, 2, 5, 2, 0, -5 },
  { 107, 1, 4, 1, 0, -4 },
  { 108, 2, 5, 1, -1, -4 },
  { 110, 2, 5, 2, 0, -5 },
  { 112, 1, 5, 1, 0, -5 },
  { 113, 4, 3, 4, 0, -3 },
  { 115, 2, 3, 2, 0, -3 },
  { 116, 2, 3, 2, 0, -3 },
  { 117, 2, 4, 3, 0, -3 },
  { 118, 3, 4, 3, 0, -3 },
  { 120, 2, 3, 2, 0, -3 },
  { 121, 2, 3, 2, 0, -3 },
  { 122, 2, 4, 1, 0, -4 },
  { 123, 2, 3, 2, 0, -3 },
  { 124, 2, 3, 2, 0, -3 },
  { 125, 4, 3, 3, 0, -3 },
  { 127, 2, 3, 2, 0, -3 },
  { 128, 3, 4, 2, -1, -3 },
  { 130, 2, 3, 2, 0, -3 },
  { 131, 2, 5, 2, 0, -4 },
  { 133, 1, 6, 2, 1, -5 },
  { 134, 2, 5, 2, 0, -4 },
  { 136, 2, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Italic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC6PT7B_H_
