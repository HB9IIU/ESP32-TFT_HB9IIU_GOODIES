#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x7D, 0x7C, 0x79, 0x2C, 0xDA, 0xF7, 0x70, 0x69,
  0x7E, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xE0, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x48, 0x76, 0xDC, 0xF8, 0x65, 0x2C, 0x65, 0x1C, 0x2B, 0x74,
  0x73, 0x1C, 0x73, 0xDC, 0x65, 0x28, 0x75, 0x5C, 0x77, 0x9C, 0x90, 0x98,
  0x71, 0x80, 0xFC, 0xC7, 0x00, 0xD6, 0x80, 0x7B, 0xFF, 0x84, 0x5F, 0xC0,
  0x6D, 0x5C, 0x72, 0x4E, 0x6E, 0xDC, 0x69, 0x4C, 0x69, 0x48, 0x78, 0xAA,
  0xE0, 0x56, 0x6A, 0xA0, 0x5A, 0x80, 0x25, 0x25, 0x80, 0x69, 0x6C, 0x5A,
  0xC0, 0x4A, 0x9D, 0xED, 0x00, 0x55, 0xEA, 0xA0, 0x76, 0xDE, 0x6F, 0xC8,
  0x76, 0xDA, 0x80, 0x6D, 0x6C, 0x71, 0x2C, 0x69, 0x28, 0x76, 0xDC, 0xFA,
  0x80, 0xAD, 0x7C, 0xAA, 0x00, 0x69, 0x6C, 0xEA, 0x80, 0x69, 0x4C, 0x5A,
  0xA0, 0xF8, 0x55, 0xA0, 0x4A, 0x80, 0xE0, 0x80, 0x76, 0xE0, 0x4E, 0xDC,
  0x6B, 0x2E, 0xDC, 0x57, 0x60, 0x2D, 0x24, 0xA0, 0x76, 0xE5, 0x00, 0x4E,
  0xDC, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x4D, 0x6C, 0x5A, 0x80, 0x7B, 0xBD,
  0x76, 0xE0, 0x56, 0xE0, 0x76, 0xE9, 0x00, 0x76, 0xE4, 0x80, 0x6A, 0x67,
  0x7A, 0x80, 0xB6, 0xE0, 0xBB, 0x40, 0xBF, 0xEA, 0xA9, 0x60, 0x56, 0x24,
  0x48, 0x5B, 0x69, 0x49, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 1, -5 },
  { 4, 3, 5, 3, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 3, 5, 3, 0, -5 },
  { 13, 1, 2, 1, 1, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 6, 2, -1, -5 },
  { 19, 2, 2, 3, 1, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 1, 0, -1 },
  { 25, 3, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 1, 5, 3, 1, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 1, 4, 1, 0, -4 },
  { 47, 1, 5, 1, 0, -4 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 2, 5, 2, 0, -5 },
  { 55, 4, 6, 4, 0, -5 },
  { 58, 2, 5, 3, 0, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 3, 5, 3, 0, -5 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 3, 5, 2, 0, -5 },
  { 70, 4, 5, 3, 0, -5 },
  { 73, 4, 5, 3, 0, -5 },
  { 76, 2, 5, 2, 0, -5 },
  { 78, 3, 6, 1, -1, -5 },
  { 81, 3, 5, 3, 0, -5 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 5, 5, 5, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 3, 5, 3, 0, -5 },
  { 96, 3, 6, 3, 0, -5 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 5, 2, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 2, 5, 3, 1, -5 },
  { 109, 5, 5, 5, 0, -5 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 2, 5, 2, 1, -5 },
  { 117, 3, 5, 2, 0, -5 },
  { 119, 2, 6, 2, 0, -5 },
  { 121, 1, 5, 2, 1, -5 },
  { 122, 2, 6, 2, 0, -5 },
  { 124, 3, 3, 3, 0, -5 },
  { 126, 3, 1, 2, -1, 0 },
  { 127, 1, 1, 2, 1, -5 },
  { 128, 3, 4, 3, 0, -4 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 4, 2, 0, -4 },
  { 133, 3, 5, 3, 0, -5 },
  { 135, 3, 4, 3, 0, -4 },
  { 137, 3, 7, 2, -1, -5 },
  { 140, 3, 6, 3, 0, -4 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 2, 5, 1, 0, -5 },
  { 147, 3, 7, 1, -1, -5 },
  { 150, 3, 5, 3, 0, -5 },
  { 152, 2, 5, 1, 0, -5 },
  { 154, 4, 4, 4, 0, -4 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 3, 4, 3, 0, -4 },
  { 160, 3, 6, 3, 0, -4 },
  { 163, 3, 6, 3, 0, -4 },
  { 166, 2, 4, 2, 0, -4 },
  { 167, 2, 4, 2, 0, -4 },
  { 168, 2, 5, 2, 0, -5 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 3, 4, 2, 0, -4 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 3, 4, 2, 0, -4 },
  { 178, 4, 6, 2, -1, -4 },
  { 181, 2, 4, 2, 0, -4 },
  { 182, 3, 6, 2, 0, -5 },
  { 185, 1, 7, 3, 1, -5 },
  { 186, 2, 6, 2, 0, -5 },
  { 188, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Italic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC7PT7B_H_
