#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x3E, 0x3C, 0xF0, 0xF3, 0xC7,
  0xCF, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x1C, 0x70, 0xF1, 0xC3,
  0xCF, 0x0E, 0x38, 0x38, 0xE0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00,
  0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xCC, 0x70, 0x3C, 0x60, 0x81, 0xC3, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0x80,
  0x07, 0x8C, 0x00, 0x3C, 0x60, 0x00, 0xF3, 0x00, 0x07, 0xB0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x0D, 0xE0, 0x00, 0x6F, 0x80, 0x03, 0x3C, 0x00, 0x31,
  0xE0, 0x01, 0x8F, 0x00, 0x0C, 0x78, 0x00, 0x63, 0xC0, 0x06, 0x1E, 0x18,
  0x31, 0xE0, 0xF1, 0x9F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x7E, 0x00, 0xE0,
  0x1F, 0xE0, 0x1C, 0x07, 0x3C, 0x07, 0x01, 0xE3, 0x80, 0xE0, 0x38, 0x70,
  0x38, 0x0F, 0x0E, 0x07, 0x01, 0xC1, 0xC1, 0xC0, 0x38, 0x38, 0x38, 0x07,
  0x07, 0x0E, 0x01, 0xC1, 0xE3, 0xC0, 0x38, 0x38, 0x70, 0x07, 0x07, 0x1E,
  0x00, 0xE0, 0xE3, 0x80, 0x1C, 0x1C, 0xF0, 0x07, 0x87, 0x1C, 0x7E, 0xF0,
  0xE7, 0x9F, 0xDE, 0x3C, 0xE3, 0xFD, 0xC7, 0x3C, 0xE3, 0xB9, 0xE7, 0x3C,
  0x77, 0xF9, 0xE7, 0x0E, 0x7E, 0x38, 0xE1, 0xC7, 0x8F, 0x38, 0x38, 0x01,
  0xC7, 0x07, 0x00, 0x70, 0xE0, 0xE0, 0x0E, 0x3C, 0x1C, 0x03, 0x87, 0x07,
  0x80, 0x70, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C, 0x03, 0x83, 0x83, 0x80, 0xE0,
  0x70, 0xE0, 0x1C, 0x0E, 0x1C, 0x07, 0x01, 0xC7, 0x81, 0xE0, 0x38, 0xE0,
  0x38, 0x07, 0xFC, 0x0F, 0x00, 0xFF, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xE7,
  0x80, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80, 0x78, 0x38, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x00, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x87, 0x8F, 0x3C, 0x3C,
  0xF1, 0xE3, 0xC7, 0x87, 0x9E, 0x78, 0x3C, 0xF3, 0xC1, 0xEF, 0x3C, 0x07,
  0xF9, 0xE0, 0x3F, 0x8F, 0x01, 0xFC, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E,
  0x03, 0xF0, 0xF0, 0x3F, 0x87, 0xC3, 0xFC, 0x3F, 0xFD, 0xF0, 0xFF, 0xC7,
  0x83, 0xFC, 0x3E, 0x03, 0x00, 0x00, 0x3E, 0x78, 0xF1, 0xE3, 0x8F, 0x1E,
  0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x06, 0x1C, 0x0E, 0x38,
  0x3F, 0x67, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x3F, 0x00, 0xF7, 0x03,
  0xCE, 0x0F, 0x9E, 0x0E, 0x1C, 0x08, 0x3C, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3E, 0x3C, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07,
  0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x3E, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF8, 0xF3, 0xDF, 0x3C, 0x71, 0xE1, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xF0, 0x7C, 0x03, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1C, 0x0F, 0x80,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x80, 0x1F,
  0x07, 0x03, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xDE, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x1E,
  0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1C,
  0x1E, 0x01, 0xE0, 0xE0, 0x0E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0x78, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x30, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x10, 0x03, 0xE0, 0xE0, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x7C, 0x03, 0xCF, 0xE0, 0x3D, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0x78, 0x7C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x0F,
  0x03, 0xE0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x70, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xE0,
  0x0F, 0x1F, 0x00, 0x7D, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x3C, 0x0F,
  0x81, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF8,
  0x0F, 0x07, 0xE1, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E,
  0x1E, 0x07, 0xE1, 0xF1, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xBC, 0x07, 0xF3,
  0xC0, 0x08, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x08, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0x00, 0x10, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFE, 0x0C, 0x1F, 0x08, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x01, 0xF0, 0x70, 0xE0,
  0x7F, 0xC7, 0x0E, 0x0F, 0xF8, 0x71, 0xC0, 0xE3, 0x87, 0x1C, 0x1C, 0x38,
  0x71, 0xC3, 0x83, 0x87, 0x38, 0x38, 0x70, 0x73, 0x87, 0x07, 0x07, 0x38,
  0x70, 0x70, 0x77, 0x07, 0x07, 0x0E, 0x70, 0xE0, 0xF0, 0xE7, 0x0E, 0x0E,
  0x0E, 0x70, 0xE0, 0xE0, 0xE7, 0x0E, 0x1E, 0x1C, 0xE0, 0xE1, 0xE1, 0xCE,
  0x0E, 0x1C, 0x38, 0xE0, 0xE3, 0xC3, 0x8E, 0x0E, 0x3C, 0x70, 0xE0, 0xFE,
  0xFF, 0x0E, 0x0F, 0xCF, 0xE0, 0xE0, 0x78, 0x7C, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00,
  0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x78, 0x3F, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x3F, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF0,
  0x1E, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3E,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x83, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0x1F, 0xC0,
  0x1E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x07,
  0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0,
  0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x3C, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x02,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0xF8, 0xF8, 0x0F, 0xF8, 0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF8, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x7F, 0x07, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0B, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03,
  0xC3, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFB, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x3C,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x1F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xEF, 0x00, 0x3B,
  0xC0, 0x7B, 0xC0, 0x1E, 0xF0, 0x1E, 0xF0, 0x07, 0x3C, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x3E, 0x03, 0xCF, 0x03, 0xCF, 0x00, 0xF1,
  0xC1, 0xE3, 0xC0, 0x78, 0x70, 0x78, 0xF0, 0x1E, 0x1C, 0x1C, 0x3C, 0x07,
  0x87, 0x0F, 0x1E, 0x01, 0xE1, 0xC3, 0x87, 0x80, 0x78, 0x71, 0xE1, 0xE0,
  0x3C, 0x1C, 0x78, 0x78, 0x0F, 0x07, 0x3C, 0x1E, 0x03, 0xC1, 0xCF, 0x0F,
  0x00, 0xF0, 0x77, 0x83, 0xC0, 0x38, 0x1D, 0xE0, 0xF0, 0x1E, 0x07, 0xF0,
  0x3C, 0x07, 0x81, 0xFC, 0x0F, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x1F,
  0x81, 0xE0, 0x1C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x3C, 0x07, 0xE0,
  0x07, 0x80, 0xFC, 0x00, 0xF0, 0x1F, 0x80, 0x3C, 0x07, 0xF8, 0x07, 0x80,
  0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0x73, 0x80,
  0xF0, 0x1E, 0x70, 0x1E, 0x03, 0xCE, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x0F,
  0x3C, 0x1E, 0x01, 0xC7, 0x83, 0xC0, 0x78, 0x70, 0x78, 0x0F, 0x0E, 0x0F,
  0x01, 0xE1, 0xC1, 0xE0, 0x3C, 0x3C, 0x78, 0x0F, 0x07, 0x8F, 0x01, 0xE0,
  0xF1, 0xE0, 0x3C, 0x0E, 0x3C, 0x07, 0x81, 0xC7, 0x00, 0xF0, 0x39, 0xE0,
  0x3C, 0x07, 0xBC, 0x07, 0x80, 0xF7, 0x80, 0xF0, 0x1E, 0xF0, 0x1E, 0x03,
  0xDC, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xFE, 0x03,
  0xC0, 0x1F, 0xC0, 0x78, 0x03, 0xF0, 0x0E, 0x00, 0x7E, 0x03, 0xC0, 0x07,
  0xC0, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x7C, 0x07,
  0xC0, 0x78, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x78, 0xFE, 0x01, 0xE0, 0xF8, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x3F, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x07,
  0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78,
  0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0xFC, 0x7E, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x78, 0x7E, 0x01, 0xE0,
  0xF8, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x07, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xF0, 0x38, 0x0F, 0x80, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0xC0, 0x1F, 0x03, 0xE3, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE1,
  0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0,
  0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1,
  0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xE1, 0xE0, 0x07,
  0x0F, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x73, 0xC0,
  0x03, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x01,
  0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0x01, 0xEF, 0x00,
  0x7E, 0x01, 0xE7, 0x80, 0x3F, 0x00, 0xF3, 0xC0, 0x3F, 0x80, 0xF9, 0xE0,
  0x1F, 0x80, 0x78, 0xF0, 0x0F, 0xC0, 0x3C, 0x78, 0x0F, 0xE0, 0x3C, 0x3C,
  0x07, 0x70, 0x1E, 0x1E, 0x07, 0xB8, 0x1F, 0x0F, 0x03, 0x9C, 0x0F, 0x07,
  0x81, 0xCE, 0x07, 0x83, 0xC1, 0xE7, 0x07, 0x81, 0xE0, 0xE3, 0x83, 0xC0,
  0xF0, 0xF1, 0xC1, 0xE0, 0x78, 0x78, 0xE1, 0xE0, 0x3C, 0x38, 0x70, 0xF0,
  0x1E, 0x3C, 0x38, 0xF0, 0x0F, 0x1C, 0x1C, 0x78, 0x07, 0x9E, 0x0E, 0x3C,
  0x03, 0xCF, 0x07, 0x3C, 0x01, 0xE7, 0x03, 0x9E, 0x00, 0xF7, 0x83, 0xDE,
  0x00, 0x7B, 0x81, 0xEF, 0x00, 0x3D, 0xC0, 0xF7, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x0E, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xEF, 0x00,
  0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x1C, 0x78,
  0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x07, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xC7, 0x00, 0xF0, 0xF0,
  0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x0E, 0x78, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3, 0x87, 0x00,
  0x78, 0x00, 0x1F, 0xE7, 0x03, 0xFE, 0xF0, 0x7F, 0xFF, 0x07, 0xC3, 0xF0,
  0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x78,
  0x6E, 0x07, 0xFE, 0xE0, 0x3F, 0xCE, 0x01, 0xF8, 0xE0, 0x04, 0x10, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x78, 0x03, 0x9F, 0xC0, 0x7B, 0xFE, 0x07,
  0xFF, 0xF0, 0x7E, 0x1F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x07, 0xE1, 0xF0, 0xF7, 0xFE, 0x0F, 0x7F, 0xC0, 0xE3,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7C, 0x10, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x30, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x03, 0xC3, 0x80, 0x1F, 0xEF, 0x00, 0x7F, 0xDE, 0x01, 0xFF,
  0xFC, 0x03, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0xFC, 0x03, 0xC3,
  0x70, 0x07, 0xFE, 0xE0, 0x07, 0xF9, 0xC0, 0x0F, 0xE7, 0x80, 0x02, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xBE, 0x07, 0x87,
  0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0xF1, 0xE0, 0x7C, 0x79, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFC,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x0C, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF4, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x9E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x9F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x70, 0x0F, 0xFB,
  0xC0, 0x7F, 0xFF, 0x01, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x1E, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x78, 0x03, 0xF9, 0xE0, 0x01, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x20, 0x1F, 0x00, 0xE0, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x78,
  0x03, 0x9F, 0xC0, 0x7B, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x1E, 0x07, 0xC1,
  0xF0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0x70, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x00, 0x40, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x23, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x10,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87,
  0x80, 0x38, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07,
  0xBC, 0x00, 0x3B, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7E, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x0E, 0x7F, 0x1F, 0xE0, 0x7B, 0xFE, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xE0, 0xF0, 0x78, 0x1F, 0x03,
  0xC3, 0xE0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x38, 0x3C, 0x07, 0x81, 0xE0,
  0xF0, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78,
  0x0F, 0x01, 0xC1, 0xE0, 0x3C, 0x0F, 0x07, 0x80, 0xE0, 0x3C, 0x3C, 0x07,
  0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E,
  0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x0F,
  0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x80, 0x39, 0xFC,
  0x07, 0xBF, 0xE0, 0x7F, 0xFE, 0x07, 0xE1, 0xE0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87,
  0x80, 0x70, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFF, 0x07, 0x87, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE1, 0xE0, 0xF8, 0x7C,
  0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0x9F, 0xC0, 0x1E, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF8,
  0x7C, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x87, 0xC0, 0x77, 0xFE, 0x03, 0xDF,
  0xF0, 0x0F, 0x3F, 0x80, 0x3C, 0x10, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xE7, 0x03, 0xFE, 0xF0, 0x7F, 0xFF, 0x07,
  0x83, 0xF0, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3,
  0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x83,
  0xF0, 0x78, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xDE, 0x03, 0xF9, 0xE0, 0x04,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x03, 0x9F, 0x07, 0xBF, 0x07,
  0x7F, 0x07, 0x71, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x81,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC2, 0x01, 0xF0, 0xE0, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x03, 0xFF, 0x3F, 0xF1, 0xFF, 0x83,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xE0, 0x7F,
  0x03, 0xF8, 0x02, 0x00, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF8,
  0x7E, 0x0F, 0x8F, 0xE0, 0x7F, 0xDE, 0x07, 0xFD, 0xC0, 0x3F, 0x1C, 0x00,
  0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x7B, 0xC0, 0xFC, 0x0F, 0x78, 0x1F,
  0x81, 0xEF, 0x03, 0xF0, 0x79, 0xE0, 0xFE, 0x0F, 0x3C, 0x1F, 0xC1, 0xC7,
  0x87, 0xF8, 0x78, 0xF0, 0xEF, 0x0F, 0x1E, 0x1D, 0xE3, 0xC3, 0xC7, 0xBC,
  0x78, 0x78, 0xE7, 0x0E, 0x0F, 0x3C, 0xE3, 0xC1, 0xE7, 0x1C, 0x78, 0x3C,
  0xE3, 0x9E, 0x07, 0xBC, 0x73, 0xC0, 0xF7, 0x0E, 0x70, 0x1D, 0xE1, 0xDE,
  0x03, 0xB8, 0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x38,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00,
  0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x09, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE7, 0xF9, 0xFF, 0xFC, 0x07, 0xFD,
  0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 36, 12, 1, -36 },
  { 55, 14, 13, 17, 5, -36 },
  { 78, 23, 36, 22, 0, -36 },
  { 182, 21, 42, 20, 0, -39 },
  { 293, 27, 38, 31, 2, -37 },
  { 422, 21, 38, 22, 0, -37 },
  { 522, 7, 13, 10, 5, -36 },
  { 534, 15, 45, 13, 1, -37 },
  { 619, 16, 45, 13, -4, -37 },
  { 709, 15, 17, 18, 5, -39 },
  { 741, 19, 24, 22, 2, -30 },
  { 798, 9, 13, 10, -2, -6 },
  { 813, 11, 4, 13, 1, -16 },
  { 819, 5, 6, 10, 1, -6 },
  { 823, 24, 37, 17, -3, -37 },
  { 934, 19, 38, 20, 1, -37 },
  { 1025, 13, 36, 20, 5, -36 },
  { 1084, 22, 37, 20, -2, -37 },
  { 1186, 21, 38, 20, -1, -37 },
  { 1286, 21, 37, 20, -1, -37 },
  { 1384, 21, 37, 20, -1, -36 },
  { 1482, 20, 38, 20, 1, -37 },
  { 1577, 20, 36, 20, 2, -36 },
  { 1667, 21, 38, 20, 0, -37 },
  { 1767, 20, 38, 20, 0, -37 },
  { 1862, 10, 28, 10, 0, -28 },
  { 1897, 13, 35, 10, -3, -28 },
  { 1954, 19, 22, 22, 2, -29 },
  { 2007, 19, 14, 22, 2, -25 },
  { 2041, 19, 22, 22, 2, -29 },
  { 2094, 16, 37, 15, 1, -37 },
  { 2168, 28, 41, 30, 1, -37 },
  { 2312, 20, 37, 21, -3, -37 },
  { 2405, 22, 36, 22, 0, -36 },
  { 2504, 21, 38, 20, 2, -37 },
  { 2604, 23, 36, 24, 0, -36 },
  { 2708, 21, 36, 19, 0, -36 },
  { 2803, 21, 36, 18, 0, -36 },
  { 2898, 24, 38, 25, 2, -37 },
  { 3012, 26, 36, 25, 0, -36 },
  { 3129, 20, 36, 13, -3, -36 },
  { 3219, 20, 46, 10, -8, -36 },
  { 3334, 25, 36, 21, 0, -36 },
  { 3447, 14, 36, 17, 0, -36 },
  { 3510, 34, 36, 33, 0, -36 },
  { 3663, 27, 36, 26, 0, -36 },
  { 3785, 23, 38, 25, 2, -37 },
  { 3895, 22, 36, 21, 0, -36 },
  { 3994, 23, 46, 25, 2, -37 },
  { 4127, 22, 36, 21, 0, -36 },
  { 4226, 22, 38, 19, -1, -37 },
  { 4331, 18, 36, 18, 3, -36 },
  { 4412, 23, 37, 24, 2, -36 },
  { 4519, 21, 36, 21, 4, -36 },
  { 4614, 33, 36, 33, 4, -36 },
  { 4763, 26, 36, 19, -3, -36 },
  { 4880, 19, 36, 18, 4, -36 },
  { 4966, 22, 36, 17, -2, -36 },
  { 5065, 19, 45, 14, -1, -37 },
  { 5172, 8, 37, 17, 5, -37 },
  { 5209, 19, 45, 14, -3, -37 },
  { 5316, 19, 19, 20, 1, -36 },
  { 5362, 16, 3, 15, -4, 4 },
  { 5368, 7, 8, 13, 7, -39 },
  { 5375, 20, 29, 22, 1, -28 },
  { 5448, 20, 40, 21, 0, -39 },
  { 5548, 17, 29, 16, 1, -28 },
  { 5610, 23, 40, 22, 1, -39 },
  { 5725, 18, 29, 19, 1, -28 },
  { 5791, 24, 51, 12, -6, -39 },
  { 5944, 22, 40, 22, -1, -28 },
  { 6054, 20, 39, 21, 0, -39 },
  { 6152, 12, 38, 10, 0, -38 },
  { 6209, 19, 50, 10, -7, -38 },
  { 6328, 21, 39, 18, 0, -39 },
  { 6431, 12, 39, 10, 0, -39 },
  { 6490, 30, 28, 31, 0, -28 },
  { 6595, 20, 28, 21, 0, -28 },
  { 6665, 18, 29, 21, 1, -28 },
  { 6731, 22, 40, 21, -2, -28 },
  { 6841, 20, 40, 22, 1, -28 },
  { 6941, 16, 28, 14, 0, -28 },
  { 6997, 18, 29, 16, -1, -28 },
  { 7063, 13, 35, 12, 1, -34 },
  { 7120, 20, 28, 21, 1, -27 },
  { 7190, 17, 27, 17, 3, -27 },
  { 7248, 27, 27, 28, 3, -27 },
  { 7340, 21, 27, 18, -2, -27 },
  { 7411, 25, 39, 17, -5, -27 },
  { 7533, 18, 27, 14, -2, -27 },
  { 7594, 19, 44, 17, 1, -36 },
  { 7699, 4, 51, 19, 7, -39 },
  { 7725, 18, 44, 17, -3, -36 },
  { 7824, 19, 6, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Italic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC51PT7B_H_
