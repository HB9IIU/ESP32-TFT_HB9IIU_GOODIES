#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xF0, 0x56, 0x74, 0xEC, 0x29, 0x37, 0x80, 0x55, 0xBC,
  0xD6, 0xB8, 0x6D, 0x3B, 0xC0, 0xC0, 0x2A, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0xB4, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x6E, 0xDB, 0x80,
  0x76, 0xA0, 0x64, 0xA5, 0x80, 0x64, 0xB3, 0x80, 0x25, 0xDE, 0x80, 0x6B,
  0x13, 0x80, 0x2B, 0x5B, 0x80, 0x64, 0xA5, 0x00, 0x6D, 0xDB, 0x80, 0x76,
  0xB3, 0x80, 0x42, 0x42, 0x80, 0x2B, 0x10, 0xFC, 0x88, 0xE0, 0x45, 0x29,
  0x00, 0x32, 0x6F, 0xDF, 0x41, 0x80, 0x13, 0x37, 0x5D, 0x65, 0x6A, 0xAE,
  0x34, 0x88, 0x84, 0x65, 0x59, 0xAC, 0x69, 0x59, 0x80, 0x69, 0x39, 0x00,
  0x34, 0x8B, 0x96, 0x55, 0x5B, 0xAA, 0x69, 0x29, 0x80, 0x24, 0xA4, 0x94,
  0x56, 0x4C, 0xAA, 0x56, 0xB0, 0x4A, 0x57, 0xBA, 0xD8, 0x55, 0x5B, 0xAA,
  0x25, 0x99, 0xAE, 0x6D, 0xA9, 0x00, 0x25, 0x99, 0xAE, 0x60, 0x6D, 0xAB,
  0x40, 0x71, 0x23, 0x80, 0xEA, 0xA0, 0x55, 0x5A, 0xAE, 0xB7, 0x69, 0x00,
  0xAD, 0x75, 0x6A, 0x50, 0x56, 0x44, 0xCC, 0xBA, 0x49, 0x00, 0x65, 0x29,
  0x80, 0x69, 0x49, 0x20, 0xFC, 0x24, 0x92, 0x70, 0x2E, 0x80, 0xE0, 0x80,
  0x76, 0xF0, 0x49, 0xDB, 0x80, 0x72, 0x60, 0x11, 0x6A, 0xAE, 0x7E, 0x70,
  0x32, 0x64, 0x44, 0x48, 0x76, 0xF3, 0x80, 0x49, 0xDB, 0x40, 0x46, 0xA0,
  0x20, 0xA4, 0x94, 0x49, 0xAD, 0x80, 0x56, 0xA0, 0x7D, 0x6D, 0x60, 0x76,
  0xD0, 0x76, 0xE0, 0x76, 0xE9, 0x00, 0x76, 0xF2, 0x80, 0x72, 0x40, 0xE9,
  0x60, 0x7A, 0x80, 0x76, 0xE0, 0xB5, 0x40, 0xAD, 0xBD, 0x40, 0x69, 0x60,
  0x55, 0x22, 0x4C, 0x6A, 0x60, 0x29, 0x65, 0x30, 0xFF, 0x55, 0x68, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 3, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 3, 6, 3, 0, -6 },
  { 17, 1, 2, 2, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 2, 3, 3, 1, -6 },
  { 25, 3, 4, 3, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 2, 6, 3, 1, -6 },
  { 38, 3, 6, 3, 0, -6 },
  { 41, 3, 6, 3, 0, -6 },
  { 44, 3, 6, 3, 0, -6 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 6, 3, 0, -6 },
  { 53, 3, 6, 3, 0, -6 },
  { 56, 3, 6, 3, 0, -6 },
  { 59, 3, 6, 3, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 4, 3, 0, -5 },
  { 67, 3, 2, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -5 },
  { 70, 3, 6, 2, 0, -6 },
  { 73, 5, 7, 5, 0, -6 },
  { 78, 4, 6, 3, -1, -6 },
  { 81, 4, 6, 3, 0, -6 },
  { 84, 4, 6, 3, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 3, 6, 3, 0, -6 },
  { 93, 3, 6, 3, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 3, 6, 2, 0, -6 },
  { 105, 3, 8, 2, -1, -6 },
  { 108, 4, 6, 3, 0, -6 },
  { 111, 2, 6, 3, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 4, 6, 4, 0, -6 },
  { 120, 4, 6, 4, 0, -6 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 4, 7, 4, 0, -6 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 3, 6, 3, 0, -6 },
  { 136, 2, 6, 3, 1, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 3, 6, 3, 1, -6 },
  { 144, 5, 6, 5, 1, -6 },
  { 148, 4, 6, 3, 0, -6 },
  { 151, 3, 6, 3, 1, -6 },
  { 154, 3, 6, 3, 0, -6 },
  { 157, 3, 7, 2, 0, -6 },
  { 160, 1, 6, 3, 1, -6 },
  { 161, 3, 7, 2, -1, -6 },
  { 164, 3, 3, 3, 0, -6 },
  { 166, 3, 1, 2, -1, 0 },
  { 167, 1, 1, 2, 1, -6 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 3, 6, 3, 0, -6 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 4, 6, 3, 0, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 8, 2, -1, -6 },
  { 184, 3, 6, 3, 0, -4 },
  { 187, 3, 6, 3, 0, -6 },
  { 190, 2, 6, 2, 0, -6 },
  { 192, 3, 8, 2, -1, -6 },
  { 195, 3, 6, 3, 0, -6 },
  { 198, 2, 6, 2, 0, -6 },
  { 200, 5, 4, 5, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 3, 6, 3, 0, -4 },
  { 210, 3, 6, 3, 0, -4 },
  { 213, 3, 4, 2, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 2, 5, 2, 0, -5 },
  { 219, 3, 4, 3, 0, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 5, 4, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 4, 6, 3, -1, -4 },
  { 231, 3, 4, 2, 0, -4 },
  { 233, 3, 7, 3, 0, -6 },
  { 236, 1, 8, 3, 1, -6 },
  { 237, 2, 7, 3, 0, -6 },
  { 239, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Italic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC8PT7B_H_
