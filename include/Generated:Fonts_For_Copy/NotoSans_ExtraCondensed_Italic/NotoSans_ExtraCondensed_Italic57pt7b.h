#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x1F, 0x3E, 0x3E,
  0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C,
  0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0xF0,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0x83, 0xC0, 0x01, 0xE0, 0xE1, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFB, 0x3C, 0x07, 0xCE, 0x18, 0x1F, 0x18, 0x00,
  0x3C, 0x30, 0x00, 0x78, 0x60, 0x00, 0xF0, 0xC0, 0x01, 0xE3, 0x80, 0x03,
  0xC6, 0x00, 0x07, 0x8C, 0x00, 0x0F, 0x98, 0x00, 0x0F, 0xB0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x6F, 0x80, 0x00, 0xCF, 0x80, 0x01, 0x9F,
  0x00, 0x07, 0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x78, 0x00, 0x30, 0xF0,
  0x00, 0x61, 0xE0, 0x01, 0xC7, 0xC2, 0x03, 0x0F, 0x07, 0x06, 0x7E, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0xE0, 0x07,
  0x00, 0xFF, 0x80, 0x3C, 0x03, 0xCF, 0x00, 0xE0, 0x1E, 0x3C, 0x07, 0x80,
  0x70, 0xF0, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x0E, 0x0F, 0x03, 0x80, 0x78,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x70, 0x07, 0x03, 0xC3, 0xC0, 0x1C, 0x0E,
  0x0E, 0x00, 0xF0, 0x38, 0x78, 0x03, 0xC1, 0xE1, 0xC0, 0x0F, 0x07, 0x8F,
  0x00, 0x38, 0x1C, 0x38, 0x00, 0xE0, 0x71, 0xE1, 0xE3, 0x83, 0xCF, 0x1F,
  0xCE, 0x0E, 0x3C, 0x7F, 0xB8, 0x79, 0xE3, 0xDE, 0xE1, 0xE7, 0x9E, 0x3F,
  0xCF, 0x3C, 0x70, 0xFF, 0xF8, 0xF3, 0xC3, 0xDF, 0xC7, 0x8E, 0x0F, 0x3E,
  0x1E, 0x78, 0x3C, 0x00, 0xF1, 0xE0, 0xF0, 0x03, 0x87, 0x03, 0x80, 0x1E,
  0x1C, 0x0E, 0x00, 0x70, 0xF0, 0x78, 0x03, 0xC3, 0xC1, 0xE0, 0x0E, 0x0F,
  0x07, 0x80, 0x78, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0xF0, 0x0F, 0x03, 0x83,
  0xC0, 0x38, 0x0E, 0x0E, 0x01, 0xE0, 0x38, 0x78, 0x07, 0x00, 0xE1, 0xE0,
  0x3C, 0x03, 0xCF, 0x00, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x1F, 0xC0, 0x3C,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3,
  0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xBC, 0x1F, 0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x1E,
  0x3C, 0x7C, 0x1F, 0x3C, 0x78, 0x1F, 0x7C, 0x78, 0x0F, 0x78, 0xF8, 0x0F,
  0xF8, 0xF0, 0x0F, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x3F, 0xE0, 0xFE, 0xFD,
  0xF0, 0x7F, 0xF9, 0xF0, 0x7F, 0xF1, 0xF0, 0x1F, 0xE0, 0xF8, 0x02, 0x00,
  0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F,
  0x1E, 0x38, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x02,
  0x0F, 0x03, 0xC7, 0x01, 0xFB, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0xF9, 0xC1, 0xF8, 0xF0, 0x78,
  0x7C, 0x18, 0x1E, 0x04, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x11, 0xEF, 0xFF, 0xFB,
  0xEF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1,
  0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xBE, 0x7C, 0xF3, 0xE3,
  0xC7, 0x0F, 0x08, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x78, 0x3F, 0x00, 0x60,
  0x1F, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xE0,
  0x7E, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x80, 0x0F, 0xC0, 0xC0, 0x1F,
  0x80, 0xFC, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x7C, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x38,
  0xF8, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE1,
  0xF0, 0x03, 0xC1, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01,
  0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x02, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xC0, 0xC0, 0x1F, 0x80, 0xFC, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x1E,
  0x7F, 0x80, 0x7D, 0xFF, 0x80, 0xF7, 0xFF, 0x01, 0xFE, 0x3F, 0x03, 0xF0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC0,
  0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE1, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07,
  0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x01, 0xF3,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xE0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xC0,
  0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x0F, 0x07,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0x3E,
  0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xBC, 0x07, 0xFC, 0xF0, 0x07, 0xC7,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0x9F, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0E, 0x0F, 0xC1,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x7E, 0x0F, 0x07, 0x01, 0xFF,
  0x0F, 0x0F, 0x03, 0xFF, 0x0F, 0x0E, 0x07, 0x8F, 0x0F, 0x0E, 0x0F, 0x0F,
  0x0F, 0x1E, 0x0E, 0x0E, 0x0F, 0x1C, 0x1E, 0x0E, 0x0E, 0x3C, 0x1C, 0x1E,
  0x0E, 0x3C, 0x3C, 0x1E, 0x0E, 0x38, 0x38, 0x1C, 0x0E, 0x38, 0x38, 0x1C,
  0x1E, 0x78, 0x78, 0x3C, 0x1C, 0x78, 0x78, 0x3C, 0x1C, 0x70, 0x70, 0x38,
  0x1C, 0x70, 0x70, 0x78, 0x3C, 0x70, 0x70, 0x78, 0x38, 0x70, 0x70, 0x78,
  0x38, 0x70, 0x70, 0xF8, 0x70, 0xF0, 0x70, 0xF8, 0x70, 0xF0, 0x71, 0xF8,
  0xE0, 0xF0, 0x7F, 0xBF, 0xC0, 0xF0, 0x7F, 0x3F, 0xC0, 0xF0, 0x3E, 0x1F,
  0x00, 0xF0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E,
  0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xE7,
  0xC0, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0x07, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3C, 0x07, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x0C, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xF1, 0xFF, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3C, 0x01,
  0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0x7C,
  0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x3C, 0x03, 0xF0, 0x01, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0xF0,
  0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80,
  0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80,
  0x3E, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x08,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0xFC, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0xFF,
  0x80, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0x3D, 0xF0, 0x0F, 0x78, 0x01, 0xF7,
  0x80, 0x3D, 0xE0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xCF,
  0x00, 0xF3, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x3C, 0x3C,
  0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x78, 0x78, 0x03, 0xC3, 0xC1, 0xE1, 0xE0,
  0x1F, 0x0F, 0x0F, 0x8F, 0x80, 0x7C, 0x3C, 0x3C, 0x3E, 0x01, 0xE0, 0xF1,
  0xF0, 0xF8, 0x07, 0x83, 0xC7, 0x83, 0xC0, 0x1E, 0x0F, 0x1E, 0x0F, 0x00,
  0xF8, 0x3C, 0xF0, 0x7C, 0x03, 0xE0, 0xF3, 0xC1, 0xF0, 0x0F, 0x03, 0xDE,
  0x07, 0xC0, 0x3C, 0x0F, 0x78, 0x1E, 0x00, 0xF0, 0x3F, 0xC0, 0x78, 0x07,
  0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x03, 0xFC, 0x0F, 0x80, 0x78, 0x0F, 0xE0,
  0x3C, 0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x07, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x78, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80, 0x1E,
  0x00, 0xFF, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFE, 0x01, 0xF0,
  0x0F, 0xBC, 0x03, 0xC0, 0x1F, 0x78, 0x07, 0x80, 0x3C, 0xF0, 0x0F, 0x00,
  0x79, 0xE0, 0x3E, 0x00, 0xF3, 0xC0, 0x7C, 0x03, 0xE7, 0xC0, 0xF0, 0x07,
  0xC7, 0x81, 0xE0, 0x0F, 0x0F, 0x07, 0xC0, 0x1E, 0x1E, 0x0F, 0x80, 0x3C,
  0x3C, 0x1E, 0x00, 0xF8, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x78, 0x03, 0xC0,
  0xF1, 0xF0, 0x07, 0x81, 0xE3, 0xE0, 0x1F, 0x03, 0xC7, 0x80, 0x3E, 0x07,
  0x8F, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0xF0, 0x1E, 0x7C, 0x01, 0xE0, 0x1E,
  0xF8, 0x07, 0xC0, 0x3D, 0xE0, 0x0F, 0x80, 0x7B, 0xC0, 0x1E, 0x00, 0xF7,
  0x80, 0x3C, 0x01, 0xEF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xC0,
  0x1E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE3, 0xE0,
  0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xF1, 0xFE, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x7C, 0x07, 0x81, 0xF8,
  0x0F, 0x83, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xF1, 0xFE, 0x01, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1F, 0x01, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0,
  0x1F, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xFC, 0x07, 0x83, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x03,
  0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC,
  0x1E, 0x01, 0xF0, 0x06, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x80, 0x0F, 0xC0, 0xF0, 0x1F,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x05, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x81, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xE0,
  0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03,
  0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81,
  0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE0, 0x01, 0xE7,
  0x80, 0x0F, 0x80, 0x0F, 0x9E, 0x00, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0x01, 0xF1, 0xE0, 0x07, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x80, 0x1E, 0x1E,
  0x00, 0xFE, 0x00, 0xF8, 0x78, 0x03, 0xF8, 0x03, 0xC1, 0xE0, 0x0E, 0xE0,
  0x1F, 0x07, 0x80, 0x7F, 0x80, 0x7C, 0x1E, 0x01, 0xFE, 0x01, 0xE0, 0x78,
  0x0F, 0x78, 0x0F, 0x81, 0xE0, 0x3D, 0xE0, 0x3E, 0x07, 0x80, 0xF7, 0x81,
  0xF0, 0x1E, 0x07, 0x9E, 0x07, 0xC0, 0x78, 0x1E, 0x78, 0x1E, 0x01, 0xE0,
  0x71, 0xE0, 0xF8, 0x07, 0x83, 0xC7, 0x83, 0xE0, 0x3E, 0x0F, 0x1E, 0x0F,
  0x00, 0xF8, 0x78, 0x78, 0x7C, 0x03, 0xE1, 0xE1, 0xE1, 0xE0, 0x0F, 0x87,
  0x87, 0x8F, 0x80, 0x3E, 0x3C, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x78, 0xF0,
  0x03, 0xE7, 0x81, 0xE7, 0xC0, 0x0F, 0x9E, 0x07, 0x9E, 0x00, 0x3E, 0x78,
  0x1C, 0xF8, 0x00, 0xFB, 0xC0, 0x73, 0xE0, 0x03, 0xEF, 0x01, 0xCF, 0x00,
  0x0F, 0x78, 0x07, 0x7C, 0x00, 0x3D, 0xE0, 0x1D, 0xE0, 0x00, 0xF7, 0x80,
  0xF7, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x3E,
  0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x07,
  0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C,
  0x03, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0,
  0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x7C,
  0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x07, 0x00, 0x3E, 0x1E, 0x01, 0xFE, 0x3C,
  0x07, 0xFE, 0x78, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0xF0, 0x1F, 0x81, 0xF0, 0x7E, 0x03,
  0xF3, 0xFC, 0x07, 0xFF, 0x78, 0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xE0, 0x01,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x7D, 0xFF, 0x00, 0xF7, 0xFE, 0x01, 0xEF, 0xFE,
  0x03, 0xF8, 0x7C, 0x0F, 0xE0, 0x78, 0x1F, 0x80, 0xF0, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xE0, 0x3E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0xCF, 0xC0, 0xF7, 0xFF, 0x01,
  0xE7, 0xFC, 0x03, 0xC7, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x08, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x20, 0x3F, 0x9C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x3F, 0xCF, 0x80, 0x1F,
  0xFB, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF0, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x1E, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF9, 0xFE, 0x00, 0x7F,
  0xF7, 0x80, 0x0F, 0xF9, 0xE0, 0x01, 0xFC, 0x78, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE1,
  0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xE0,
  0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3C, 0x3C, 0x0F, 0xC7, 0xC3, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x02, 0x07, 0xE0, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xC8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x3F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x87, 0x80, 0x1F, 0xF3, 0xC0, 0x1F, 0xF9, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF8, 0x07, 0xC1, 0xF8,
  0x03, 0xF3, 0xFC, 0x01, 0xFF, 0xDE, 0x00, 0x7F, 0xDF, 0x00, 0x1F, 0xCF,
  0x80, 0x01, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x01, 0x00, 0x7E, 0x00, 0xF0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0xBF, 0xE0,
  0x3D, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0xFC, 0x1F, 0x81, 0xF0, 0x7E,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF8, 0x07,
  0x83, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x07,
  0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80,
  0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0,
  0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78,
  0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x09, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03,
  0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x78,
  0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0xE0,
  0x7E, 0x01, 0xE7, 0xF8, 0x7F, 0x80, 0xF7, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF,
  0x7F, 0xF0, 0x3F, 0x0F, 0xF0, 0xF8, 0x3F, 0x03, 0xF0, 0x3C, 0x1F, 0x81,
  0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x0F, 0x07, 0xC0, 0x7C, 0x07, 0x87, 0xC0,
  0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC0, 0x7C, 0x3E,
  0x03, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE1,
  0xE0, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78,
  0x7C, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x07, 0x87, 0xC0, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x03, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x3F, 0xC0, 0x3D,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xB8, 0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83,
  0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x78,
  0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07,
  0x83, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x78, 0x3E,
  0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80,
  0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x78, 0x07,
  0x83, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0xFC, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x1E,
  0x7F, 0xC0, 0x07, 0xBF, 0xF0, 0x01, 0xEF, 0xFE, 0x00, 0x7F, 0x0F, 0x80,
  0x3F, 0x81, 0xE0, 0x0F, 0xC0, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0xCF, 0xC0, 0x0F, 0x7F, 0xE0, 0x07, 0xDF, 0xF0, 0x01, 0xF3, 0xF8, 0x00,
  0x78, 0x10, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x1E, 0x01, 0xFF, 0x3C,
  0x07, 0xFE, 0x78, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF0, 0x7E, 0x03,
  0xF3, 0xFC, 0x07, 0xFF, 0x78, 0x07, 0xFD, 0xF0, 0x07, 0xF3, 0xE0, 0x01,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC7, 0xC0, 0xF3, 0xF0, 0x3D, 0xFC, 0x0F,
  0xFE, 0x03, 0xBF, 0x81, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xC0, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xC0, 0x3E, 0x0F, 0x8F, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x1F, 0x00,
  0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x1F,
  0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x83, 0xF8, 0x1F, 0xBD, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xBC, 0x03, 0xF8, 0xF0, 0x01, 0x80, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x79, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x0F, 0x03, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x3F, 0x01,
  0xF3, 0xC0, 0x7E, 0x03, 0xC7, 0x80, 0xFC, 0x07, 0x9F, 0x03, 0xF8, 0x1F,
  0x3E, 0x07, 0xF0, 0x3C, 0x7C, 0x1F, 0xE0, 0x78, 0xF8, 0x3F, 0xC1, 0xE1,
  0xF0, 0x77, 0x83, 0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xC3, 0xDE, 0x1E, 0x0F,
  0x8F, 0x3C, 0x3C, 0x1F, 0x1E, 0x78, 0xF0, 0x3C, 0x38, 0xF1, 0xE0, 0x78,
  0xF1, 0xE7, 0xC0, 0xF1, 0xE3, 0xCF, 0x01, 0xE7, 0x87, 0x9E, 0x03, 0xCF,
  0x0E, 0x78, 0x07, 0x9C, 0x1C, 0xF0, 0x0F, 0x78, 0x39, 0xE0, 0x1E, 0xF0,
  0x77, 0x80, 0x3D, 0xC0, 0xEF, 0x00, 0x7F, 0x81, 0xDC, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0xC0,
  0x1E, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0,
  0x00, 0xF1, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x9F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x09, 0xFE, 0x00, 0x5F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x90, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 41, 13, 1, -41 },
  { 68, 16, 15, 19, 6, -41 },
  { 98, 26, 41, 24, 0, -41 },
  { 232, 23, 46, 22, 0, -43 },
  { 365, 30, 42, 35, 3, -41 },
  { 523, 24, 42, 24, 0, -41 },
  { 649, 7, 15, 11, 6, -41 },
  { 663, 17, 50, 15, 1, -41 },
  { 770, 17, 50, 15, -4, -41 },
  { 877, 17, 19, 21, 6, -44 },
  { 918, 21, 27, 25, 2, -34 },
  { 989, 10, 14, 12, -3, -6 },
  { 1007, 13, 5, 15, 1, -18 },
  { 1016, 6, 7, 12, 1, -7 },
  { 1022, 26, 41, 19, -3, -41 },
  { 1156, 21, 42, 22, 1, -41 },
  { 1267, 14, 41, 22, 6, -41 },
  { 1339, 24, 41, 22, -2, -41 },
  { 1462, 24, 42, 22, -1, -41 },
  { 1588, 24, 41, 22, -1, -41 },
  { 1711, 24, 42, 22, -1, -41 },
  { 1837, 23, 42, 22, 1, -41 },
  { 1958, 23, 41, 22, 2, -41 },
  { 2076, 23, 42, 22, 0, -41 },
  { 2197, 22, 42, 22, 0, -41 },
  { 2313, 11, 31, 12, 0, -31 },
  { 2356, 15, 39, 12, -3, -31 },
  { 2430, 21, 25, 25, 2, -33 },
  { 2496, 21, 16, 25, 2, -28 },
  { 2538, 21, 25, 25, 2, -33 },
  { 2604, 18, 41, 16, 1, -41 },
  { 2697, 32, 46, 33, 1, -41 },
  { 2881, 23, 41, 23, -4, -41 },
  { 2999, 25, 41, 25, 0, -41 },
  { 3128, 24, 42, 22, 2, -41 },
  { 3254, 26, 41, 27, 0, -41 },
  { 3388, 23, 41, 21, 0, -41 },
  { 3506, 23, 41, 20, 0, -41 },
  { 3624, 27, 42, 28, 2, -41 },
  { 3766, 29, 41, 28, 0, -41 },
  { 3915, 22, 41, 15, -3, -41 },
  { 4028, 21, 52, 12, -8, -41 },
  { 4165, 28, 41, 23, 0, -41 },
  { 4309, 15, 41, 19, 0, -41 },
  { 4386, 38, 41, 37, 0, -41 },
  { 4581, 31, 41, 29, 0, -41 },
  { 4740, 25, 42, 28, 2, -41 },
  { 4872, 24, 41, 23, 0, -41 },
  { 4995, 25, 51, 28, 2, -41 },
  { 5155, 24, 41, 24, 0, -41 },
  { 5278, 24, 42, 21, -1, -41 },
  { 5404, 20, 41, 20, 4, -41 },
  { 5507, 26, 42, 27, 2, -41 },
  { 5644, 23, 41, 23, 5, -41 },
  { 5762, 38, 41, 37, 4, -41 },
  { 5957, 28, 41, 21, -3, -41 },
  { 6101, 21, 41, 20, 4, -41 },
  { 6209, 25, 41, 19, -2, -41 },
  { 6338, 22, 50, 16, -2, -41 },
  { 6476, 9, 41, 19, 6, -41 },
  { 6523, 22, 50, 16, -4, -41 },
  { 6661, 22, 22, 23, 1, -41 },
  { 6722, 18, 3, 17, -5, 5 },
  { 6729, 8, 9, 14, 8, -44 },
  { 6738, 23, 32, 24, 1, -31 },
  { 6830, 23, 44, 24, 0, -43 },
  { 6957, 19, 32, 18, 1, -31 },
  { 7033, 26, 44, 24, 1, -43 },
  { 7176, 20, 32, 22, 1, -31 },
  { 7256, 27, 58, 13, -7, -44 },
  { 7452, 25, 45, 24, -1, -31 },
  { 7593, 22, 43, 23, 0, -43 },
  { 7712, 13, 42, 11, 0, -42 },
  { 7781, 20, 56, 11, -7, -42 },
  { 7921, 23, 43, 21, 0, -43 },
  { 8045, 14, 43, 11, 0, -43 },
  { 8121, 33, 31, 35, 0, -31 },
  { 8249, 22, 31, 23, 0, -31 },
  { 8335, 21, 32, 23, 1, -31 },
  { 8419, 26, 44, 24, -3, -31 },
  { 8562, 23, 45, 24, 1, -31 },
  { 8692, 18, 31, 16, 0, -31 },
  { 8762, 20, 32, 18, -1, -31 },
  { 8842, 14, 39, 14, 1, -38 },
  { 8911, 22, 32, 24, 1, -31 },
  { 8999, 19, 31, 19, 3, -31 },
  { 9073, 31, 31, 31, 3, -31 },
  { 9194, 25, 31, 20, -3, -31 },
  { 9291, 27, 45, 19, -5, -31 },
  { 9443, 20, 31, 16, -2, -31 },
  { 9521, 21, 50, 19, 1, -41 },
  { 9653, 4, 58, 21, 8, -44 },
  { 9682, 20, 50, 19, -3, -41 },
  { 9807, 21, 8, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Italic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC57PT7B_H_
