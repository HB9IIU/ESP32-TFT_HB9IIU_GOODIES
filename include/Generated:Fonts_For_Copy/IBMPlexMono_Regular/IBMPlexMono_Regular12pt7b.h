#ifndef _IBMPLEXMONO_REGULAR12PT7B_H_
#define _IBMPLEXMONO_REGULAR12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xB6, 0x80, 0x14, 0x49, 0x99, 0x42, 0x9D, 0xD2, 0x24, 0x21,
  0xEA, 0xE8, 0xE0, 0xE2, 0x6B, 0x78, 0x80, 0x63, 0x2A, 0x53, 0x42, 0xCA,
  0x54, 0xC6, 0x38, 0x91, 0x01, 0x35, 0x53, 0xB3, 0x3B, 0xE0, 0x34, 0x44,
  0x88, 0x84, 0x44, 0x30, 0xC2, 0x22, 0x11, 0x12, 0x22, 0xC0, 0x20, 0x8F,
  0xC8, 0x52, 0x20, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x69, 0x40, 0xE0, 0xC0,
  0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x72, 0x28, 0xAB, 0xAE, 0x28,
  0x9C, 0x63, 0x8A, 0x08, 0x20, 0x82, 0x3F, 0x74, 0x42, 0x11, 0x13, 0x1F,
  0x74, 0x42, 0xE1, 0x86, 0x2E, 0x0C, 0x28, 0x92, 0x24, 0x5F, 0xC1, 0x02,
  0xFC, 0x21, 0xF8, 0x86, 0x2E, 0x32, 0x21, 0xF8, 0xC6, 0x2E, 0xFC, 0x42,
  0x21, 0x10, 0x88, 0x7A, 0x28, 0x9C, 0x8A, 0x38, 0x9E, 0x74, 0x63, 0x17,
  0x84, 0x4C, 0xC6, 0x48, 0x00, 0xD2, 0x80, 0x08, 0x99, 0x06, 0x08, 0x20,
  0xF8, 0x3E, 0x83, 0x04, 0x11, 0x32, 0x00, 0x74, 0x42, 0x62, 0x00, 0x8C,
  0x74, 0x6F, 0x5C, 0xD6, 0xF0, 0x70, 0x10, 0x50, 0xA1, 0x46, 0x4F, 0x91,
  0x61, 0xFA, 0x28, 0xBC, 0x8A, 0x38, 0xBE, 0x76, 0x61, 0x08, 0x43, 0x2E,
  0xF2, 0x28, 0xA3, 0x8E, 0x28, 0xBC, 0xFC, 0x21, 0xF8, 0x42, 0x1F, 0xFC,
  0x21, 0xF8, 0x42, 0x10, 0x74, 0x61, 0x09, 0xC6, 0x2F, 0x8C, 0x63, 0xF8,
  0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x78, 0x42, 0x10, 0x86, 0x2E,
  0x8E, 0x6B, 0x28, 0xD2, 0x48, 0xA3, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x8E,
  0xF7, 0x5A, 0xC6, 0x31, 0xCE, 0x73, 0x5A, 0xCE, 0x71, 0x72, 0x28, 0xA3,
  0x8E, 0x28, 0x9C, 0xFA, 0x28, 0xE2, 0xFA, 0x08, 0x20, 0x72, 0x28, 0xA3,
  0x8E, 0x28, 0x9C, 0x20, 0xE0, 0xFA, 0x28, 0xE2, 0xFA, 0x49, 0xA3, 0x7A,
  0x28, 0x38, 0x18, 0x28, 0xDE, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x8C, 0x63, 0x18, 0xC6, 0x2E, 0xC2, 0x89, 0x11, 0x22, 0x85, 0x0A, 0x08,
  0x83, 0x05, 0x4B, 0x66, 0xCD, 0x9B, 0x32, 0xC6, 0xC8, 0xA0, 0x81, 0x85,
  0x11, 0x63, 0xC2, 0x88, 0xB1, 0x41, 0x02, 0x04, 0x08, 0xF8, 0x21, 0x08,
  0x21, 0x08, 0x3F, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x82, 0x10, 0x82, 0x10,
  0x82, 0x10, 0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x21, 0x44, 0xA2,
  0x84, 0xF8, 0xD0, 0x72, 0x20, 0xBE, 0x8B, 0xF0, 0x84, 0x21, 0x7C, 0xC6,
  0x31, 0xF8, 0x74, 0x61, 0x08, 0xB8, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x78,
  0x74, 0x7F, 0x08, 0xB8, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0xF8, 0x0D,
  0xC8, 0xA2, 0x72, 0x07, 0xA1, 0xF8, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x88,
  0x30, 0xC0, 0x38, 0x20, 0x82, 0x08, 0xFC, 0x11, 0x0F, 0x11, 0x11, 0x11,
  0xF0, 0x82, 0x08, 0x23, 0x92, 0x8D, 0x22, 0x8C, 0xE1, 0x08, 0x42, 0x10,
  0x84, 0xF8, 0xFA, 0x9A, 0x69, 0xA6, 0x90, 0xB6, 0x63, 0x18, 0xC4, 0x74,
  0x63, 0x18, 0xB8, 0xBE, 0x63, 0x18, 0xFE, 0x10, 0x7C, 0x63, 0x18, 0xBC,
  0x21, 0xEC, 0xC2, 0x08, 0x23, 0xE0, 0x7C, 0x78, 0x38, 0xBC, 0x20, 0x8F,
  0xC8, 0x20, 0x82, 0x07, 0x8C, 0x63, 0x18, 0xBC, 0x8C, 0x52, 0xA5, 0x10,
  0x93, 0x65, 0xB3, 0x66, 0xCC, 0x80, 0x8A, 0x88, 0x65, 0x44, 0x8E, 0x25,
  0x14, 0x30, 0x82, 0x30, 0xF8, 0x4C, 0xCC, 0x7C, 0x39, 0x08, 0x41, 0x70,
  0xC4, 0x21, 0x0E, 0xFF, 0xE0, 0xE1, 0x08, 0x44, 0x1D, 0x84, 0x21, 0x38,
  0xC6, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 3, 3, 7, 2, -9 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 1, -9 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 7, 8, 7, 0, -8 },
  { 33, 1, 3, 7, 3, -9 },
  { 34, 4, 11, 7, 2, -9 },
  { 40, 4, 11, 7, 1, -9 },
  { 46, 6, 6, 7, 1, -7 },
  { 51, 5, 7, 7, 1, -7 },
  { 56, 3, 4, 7, 2, -2 },
  { 58, 3, 1, 7, 2, -4 },
  { 59, 1, 2, 7, 3, -2 },
  { 60, 5, 11, 7, 1, -9 },
  { 67, 6, 8, 7, 1, -8 },
  { 73, 6, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 5, 8, 7, 1, -8 },
  { 89, 7, 8, 7, 0, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 5, 8, 7, 1, -8 },
  { 106, 5, 8, 7, 1, -8 },
  { 111, 6, 8, 7, 1, -8 },
  { 117, 5, 8, 7, 1, -8 },
  { 122, 1, 7, 7, 3, -7 },
  { 123, 3, 9, 7, 2, -7 },
  { 127, 5, 7, 7, 1, -7 },
  { 132, 5, 3, 7, 1, -5 },
  { 134, 5, 7, 7, 1, -7 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 5, 9, 7, 1, -8 },
  { 150, 7, 8, 7, 0, -8 },
  { 157, 6, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 6, 8, 7, 1, -8 },
  { 174, 5, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 6, 8, 7, 1, -8 },
  { 210, 5, 8, 7, 1, -8 },
  { 215, 5, 8, 7, 1, -8 },
  { 220, 5, 8, 7, 1, -8 },
  { 225, 6, 8, 7, 1, -8 },
  { 231, 6, 8, 7, 1, -8 },
  { 237, 6, 10, 7, 1, -8 },
  { 245, 6, 8, 7, 1, -8 },
  { 251, 6, 8, 7, 1, -8 },
  { 257, 7, 8, 7, 0, -8 },
  { 264, 5, 8, 7, 1, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 7, 8, 7, 0, -8 },
  { 283, 7, 8, 7, 0, -8 },
  { 290, 7, 8, 7, 0, -8 },
  { 297, 6, 8, 7, 1, -8 },
  { 303, 3, 11, 7, 3, -9 },
  { 308, 5, 11, 7, 1, -9 },
  { 315, 4, 11, 7, 1, -9 },
  { 321, 6, 5, 7, 1, -8 },
  { 325, 5, 1, 7, 1, 1 },
  { 326, 2, 2, 7, 2, -9 },
  { 327, 6, 6, 7, 1, -6 },
  { 332, 5, 9, 7, 1, -9 },
  { 338, 5, 6, 7, 1, -6 },
  { 342, 5, 9, 7, 1, -9 },
  { 348, 5, 6, 7, 1, -6 },
  { 352, 6, 9, 7, 1, -9 },
  { 359, 6, 9, 7, 1, -7 },
  { 366, 5, 9, 7, 1, -9 },
  { 372, 6, 9, 7, 1, -9 },
  { 379, 4, 11, 7, 1, -9 },
  { 385, 6, 9, 7, 1, -9 },
  { 392, 5, 9, 7, 1, -9 },
  { 398, 6, 6, 7, 1, -6 },
  { 403, 5, 6, 7, 1, -6 },
  { 407, 5, 6, 7, 1, -6 },
  { 411, 5, 8, 7, 1, -6 },
  { 416, 5, 8, 7, 1, -6 },
  { 421, 6, 6, 7, 1, -6 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 6, 8, 7, 0, -8 },
  { 436, 5, 6, 7, 1, -6 },
  { 440, 5, 6, 7, 1, -6 },
  { 444, 7, 6, 7, 0, -6 },
  { 450, 5, 6, 7, 1, -6 },
  { 454, 6, 8, 7, 1, -6 },
  { 460, 5, 6, 7, 1, -6 },
  { 464, 5, 11, 7, 1, -9 },
  { 471, 1, 11, 7, 3, -9 },
  { 473, 5, 11, 7, 1, -9 },
  { 480, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Regular12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_REGULAR12PT7B_H_
