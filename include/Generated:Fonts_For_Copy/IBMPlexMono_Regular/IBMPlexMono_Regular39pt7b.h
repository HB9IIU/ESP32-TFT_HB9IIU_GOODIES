#ifndef _IBMPLEXMONO_REGULAR39PT7B_H_
#define _IBMPLEXMONO_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xC3,
  0x0C, 0x20, 0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xE7, 0x80, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x60, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x7F, 0x83,
  0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xC0, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF0, 0xFF, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE6, 0x7E, 0x78,
  0x61, 0xE7, 0x06, 0x0C, 0x70, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x07,
  0x86, 0x00, 0x3C, 0x60, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x06, 0x7E, 0x00, 0x61, 0xE0, 0x06, 0x0E, 0x00, 0x60,
  0xE0, 0x06, 0x0F, 0x20, 0x60, 0xE7, 0x06, 0x0E, 0xF8, 0x61, 0xE7, 0xE6,
  0x7C, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x1C, 0xFF, 0x00,
  0xE7, 0xFC, 0x03, 0x3C, 0x38, 0x1C, 0xE0, 0xE0, 0xE3, 0x01, 0x83, 0x8C,
  0x06, 0x1C, 0x30, 0x18, 0x70, 0xE0, 0xE3, 0x83, 0xC3, 0x8E, 0x07, 0xFC,
  0x70, 0x0F, 0xF1, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xE3, 0xFC, 0x07, 0x1F, 0xF8, 0x1C, 0xF0, 0xE0, 0xE3, 0x81, 0x83,
  0x8E, 0x07, 0x1C, 0x38, 0x1C, 0x60, 0xE0, 0x73, 0x83, 0x81, 0x8C, 0x0F,
  0x0E, 0x70, 0x1F, 0xFB, 0x80, 0x3F, 0xCE, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3C, 0x3E, 0x01, 0xC0, 0x70, 0x1E,
  0x02, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x1F, 0x8F, 0xE0, 0xFC, 0xF7,
  0x87, 0xEF, 0x1E, 0x38, 0x70, 0x79, 0xC7, 0x03, 0xCE, 0x38, 0x0F, 0x61,
  0xC0, 0x3F, 0x0E, 0x00, 0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x83,
  0xBC, 0x3F, 0xF8, 0xE0, 0xFF, 0x87, 0x81, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0xE0, 0x6F, 0x8E, 0x3E,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x3B, 0xC0, 0x07, 0x1C, 0x00, 0xF0, 0xE0, 0x1E, 0x07, 0x01, 0xC0,
  0x78, 0x08, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0x73,
  0x80, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x70, 0x7F,
  0x1F, 0x0F, 0xE3, 0xE1, 0xFC, 0x7C, 0x3F, 0x87, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x07, 0x8F,
  0x00, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x1E, 0x70,
  0x03, 0xC7, 0x00, 0x78, 0x70, 0x0F, 0x87, 0x00, 0x70, 0x70, 0x02, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xF0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x78,
  0x80, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x8C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x40, 0x01, 0xD8, 0x00, 0xFF, 0x00,
  0x79, 0xF0, 0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF9, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x1F, 0x81, 0xDF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x07, 0xE7, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x40, 0x03, 0xD8, 0x00, 0xEF, 0x00,
  0x79, 0xF0, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE3, 0xF0,
  0x3D, 0xFF, 0x87, 0x7F, 0xF8, 0xFC, 0x0F, 0x9E, 0x00, 0xF3, 0x80, 0x0F,
  0xF0, 0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E,
  0xE0, 0x03, 0x8E, 0x00, 0xF1, 0xF0, 0x3C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0xC0, 0x03, 0xB0, 0x01, 0xEC, 0x00, 0x73, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x03, 0xE7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x01, 0xC7, 0x00, 0x78, 0x78, 0x1E, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xFE, 0x0F, 0x81, 0xE3, 0xC0, 0x0E, 0x70, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0x7B, 0xF0,
  0x3E, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xB8,
  0x00, 0xF7, 0x80, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0x70, 0x7F, 0xCE, 0x07,
  0xF3, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0xFB, 0xFF, 0x9E, 0x3C, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x79, 0xF3, 0xC7, 0x8E,
  0x1C, 0x78, 0xE1, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80, 0x1E, 0x40, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x78,
  0x3E, 0x3C, 0x03, 0xCE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x7C,
  0xDC, 0x3F, 0xB6, 0x1F, 0xED, 0x87, 0x87, 0xE1, 0xC1, 0xF8, 0x60, 0x3E,
  0x38, 0x0F, 0x8E, 0x03, 0xE3, 0x80, 0xF8, 0xE0, 0x3E, 0x18, 0x0D, 0x87,
  0x03, 0x61, 0xC1, 0xDC, 0x7F, 0xB7, 0x0F, 0xED, 0xC1, 0xF3, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x8F, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x78,
  0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xFC, 0x00,
  0x0E, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x3C, 0xF0, 0x07,
  0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF,
  0x00, 0x73, 0xC0, 0x3C, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xC0,
  0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x38,
  0x07, 0x9E, 0x00, 0xF7, 0x00, 0x1B, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x01, 0x9E, 0x00, 0xF3, 0x80, 0x78, 0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x07, 0xCE,
  0x01, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77,
  0x00, 0x7B, 0x80, 0x79, 0xC0, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x78, 0x3E, 0x3C, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x73, 0xC0, 0x3C, 0xF8, 0x3F, 0x1F,
  0xFD, 0xC3, 0xFE, 0x70, 0x3F, 0x1C, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x60, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E,
  0x78, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xF0, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0,
  0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F,
  0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0xF0, 0x0F, 0xC7, 0x00,
  0xF8, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0E,
  0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0xCF, 0x00,
  0x1E, 0xF0, 0x01, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0x7E,
  0xC1, 0xDF, 0xB8, 0x67, 0xEE, 0x39, 0xF9, 0xCE, 0x7E, 0x77, 0x1F, 0x8D,
  0xC7, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x1E, 0x1F, 0x87, 0x07, 0xE0, 0xC1,
  0xF8, 0x20, 0x7E, 0x08, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1C, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x70, 0x1F,
  0xB8, 0x0F, 0xCE, 0x07, 0xE7, 0x03, 0xF3, 0xC1, 0xF8, 0xE0, 0xFC, 0x70,
  0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x83, 0x8F, 0xC1, 0xC7, 0xE0, 0xF3, 0xF0,
  0x39, 0xF8, 0x1C, 0xFC, 0x07, 0x7E, 0x03, 0xBF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9C,
  0x00, 0x73, 0x80, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xF0,
  0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDC, 0x01, 0xEE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF0,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x38,
  0xF0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xF7,
  0x00, 0x1C, 0xF0, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0xDC, 0x01, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C,
  0x0F, 0x0E, 0x03, 0x87, 0x01, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0F,
  0x70, 0x03, 0xB8, 0x01, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x03, 0xE7, 0x80, 0x1E, 0xE0, 0x01, 0x9C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x72, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x73,
  0xF0, 0x3E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1C, 0xF8, 0x3E,
  0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x7B, 0x80, 0x03,
  0xDE, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xF0,
  0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xF0, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x1C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xD8,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00,
  0xEE, 0x0F, 0x06, 0x70, 0x78, 0x33, 0x87, 0xC3, 0x9C, 0x3E, 0x1C, 0xE1,
  0xB8, 0xE7, 0x0D, 0xC7, 0x38, 0xEE, 0x38, 0xC7, 0x31, 0xC6, 0x39, 0x8E,
  0x31, 0x8E, 0x71, 0xCC, 0x73, 0x8E, 0xE3, 0x9C, 0x77, 0x0C, 0xC3, 0xB8,
  0x66, 0x1D, 0x83, 0xB0, 0xEC, 0x1D, 0x87, 0xE0, 0xFC, 0x3F, 0x03, 0xE1,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0x8F, 0x00,
  0x3C, 0x38, 0x03, 0xC1, 0xE0, 0x1C, 0x07, 0x81, 0xE0, 0x1C, 0x1E, 0x00,
  0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x70, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xDE, 0x00, 0x1E, 0x70, 0x01, 0xE1, 0xC0, 0x0E, 0x0F, 0x00, 0xF0, 0x38,
  0x07, 0x01, 0xE0, 0x70, 0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xF3, 0xC0,
  0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x80, 0x07,
  0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x03,
  0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xF3,
  0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3B,
  0x80, 0x07, 0x9C, 0x00, 0x71, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x01, 0xCF,
  0x00, 0x0E, 0xE0, 0x00, 0xE4, 0x00, 0x05, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x21, 0xCF, 0x1E, 0x38, 0x71, 0xC3, 0x07, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0xC1, 0xE0, 0xF8, 0xE0, 0x0E, 0x08, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x03, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC,
  0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x37, 0x3F,
  0xFD, 0xF7, 0xFE, 0x7C, 0x7E, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x71, 0xF8, 0x39, 0xFF, 0x1D, 0xFF, 0xCF, 0x81, 0xF7, 0x80, 0x7B,
  0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0xF0, 0x0F, 0x7C,
  0x0F, 0xBB, 0xFF, 0x9C, 0xFF, 0x8E, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xC1, 0xE7, 0x80, 0x7B, 0x80, 0x19, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x11, 0xC0, 0x0C, 0xF0, 0x0F, 0x3E, 0x0F, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC1,
  0xF8, 0x70, 0xFF, 0x9C, 0x7F, 0xF7, 0x3E, 0x0D, 0xDE, 0x00, 0xF7, 0x00,
  0x3D, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x83, 0x71, 0xFF, 0xDC, 0x3F, 0xE7, 0x07, 0xE1, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0xF0, 0x3C, 0x70, 0x07, 0xBC, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x0C, 0x3C, 0x0F, 0x8F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xFA, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x3C, 0x03, 0x87, 0xC1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF3, 0x80, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xF8,
  0xEF, 0xFC, 0xF8, 0x3E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xEE, 0x00, 0xF3,
  0x80, 0x78, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x0F, 0x03, 0x8F, 0x00, 0xE7,
  0x80, 0x3B, 0xF0, 0x0F, 0xFC, 0x03, 0xF7, 0x80, 0xF8, 0xF0, 0x3C, 0x1E,
  0x0E, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0x73,
  0x80, 0x1E, 0xE0, 0x03, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE7, 0x87, 0x9D, 0xF9, 0xFB,
  0xBF, 0x7F, 0xF8, 0xF8, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F,
  0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E,
  0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC,
  0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x70, 0xE3, 0xF0, 0xE7, 0xF8, 0xEF,
  0xFC, 0xF8, 0x3E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x70, 0x07, 0xBC, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEF, 0x00, 0x39, 0xC0, 0x1E, 0x7C,
  0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0xE3, 0xF0, 0x73, 0xFE,
  0x3B, 0xFF, 0x9F, 0x03, 0xEF, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x1E, 0xF8, 0x1F, 0x77, 0xFF, 0x39, 0xFF,
  0x1C, 0x7E, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE1, 0xC3, 0xFE,
  0x71, 0xFF, 0xDC, 0xF8, 0x37, 0x78, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D, 0xE0, 0x0F, 0x3E, 0x0D, 0xC7, 0xFF,
  0x70, 0xFF, 0x9C, 0x1F, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x81, 0xD8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x07,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0x81, 0xF7, 0x00, 0x33, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x38, 0x00, 0x1D, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xBF,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x0F, 0x8F, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x38, 0x78, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0xE0, 0x78, 0x3F, 0x03, 0xC1, 0xD8, 0x3E, 0x0E, 0xC1,
  0xF0, 0x77, 0x0D, 0x83, 0xB8, 0x6E, 0x19, 0xC3, 0x30, 0xCE, 0x39, 0x8E,
  0x71, 0xCC, 0x71, 0x8C, 0x63, 0x8C, 0x63, 0x9C, 0x63, 0x1C, 0xC3, 0xB8,
  0x66, 0x1D, 0xC3, 0x30, 0xEC, 0x19, 0x83, 0x60, 0xFC, 0x1B, 0x07, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x01, 0xE7, 0x00,
  0x78, 0xF0, 0x1E, 0x0F, 0x03, 0x80, 0xF0, 0xE0, 0x0E, 0x3C, 0x01, 0xE7,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x3B, 0xC0, 0x0F, 0x38, 0x03, 0xC7, 0x80, 0x70, 0x78, 0x1C, 0x07,
  0x07, 0x80, 0xF1, 0xE0, 0x0F, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x87,
  0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0xFF, 0xC1, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0x00, 0x63, 0xF0, 0x0C, 0xFF, 0x03, 0xB8, 0xF0, 0x77, 0x0F, 0x0C,
  0xC0, 0xE3, 0xB8, 0x1F, 0xF7, 0x01, 0xFC, 0xE0, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 27, 23, 9, -27 },
  { 22, 10, 11, 23, 7, -29 },
  { 36, 22, 27, 23, 1, -27 },
  { 111, 20, 35, 23, 2, -31 },
  { 199, 22, 27, 23, 1, -27 },
  { 274, 21, 27, 23, 1, -27 },
  { 345, 3, 11, 23, 10, -29 },
  { 350, 11, 35, 23, 8, -30 },
  { 399, 11, 35, 23, 4, -30 },
  { 448, 20, 19, 23, 2, -22 },
  { 496, 19, 19, 23, 2, -21 },
  { 542, 7, 11, 23, 8, -5 },
  { 552, 11, 3, 23, 6, -13 },
  { 557, 6, 5, 23, 9, -5 },
  { 561, 16, 35, 23, 4, -30 },
  { 631, 19, 27, 23, 2, -27 },
  { 696, 20, 27, 23, 2, -27 },
  { 764, 18, 27, 23, 3, -27 },
  { 825, 18, 27, 23, 2, -27 },
  { 886, 21, 27, 23, 1, -27 },
  { 957, 18, 27, 23, 3, -27 },
  { 1018, 19, 27, 23, 2, -27 },
  { 1083, 18, 27, 23, 3, -27 },
  { 1144, 19, 27, 23, 2, -27 },
  { 1209, 19, 27, 23, 2, -27 },
  { 1274, 6, 20, 23, 9, -20 },
  { 1289, 7, 26, 23, 8, -20 },
  { 1312, 17, 23, 23, 3, -23 },
  { 1361, 19, 10, 23, 2, -17 },
  { 1385, 17, 23, 23, 3, -23 },
  { 1434, 17, 27, 23, 3, -27 },
  { 1492, 18, 31, 23, 2, -27 },
  { 1562, 21, 27, 23, 1, -27 },
  { 1633, 18, 27, 23, 3, -27 },
  { 1694, 18, 27, 23, 3, -27 },
  { 1755, 17, 27, 23, 4, -27 },
  { 1813, 16, 27, 23, 4, -27 },
  { 1867, 17, 27, 23, 4, -27 },
  { 1925, 18, 27, 23, 2, -27 },
  { 1986, 17, 27, 23, 3, -27 },
  { 2044, 17, 27, 23, 3, -27 },
  { 2102, 16, 27, 23, 3, -27 },
  { 2156, 20, 27, 23, 3, -27 },
  { 2224, 16, 27, 23, 5, -27 },
  { 2278, 18, 27, 23, 3, -27 },
  { 2339, 17, 27, 23, 3, -27 },
  { 2397, 19, 27, 23, 2, -27 },
  { 2462, 17, 27, 23, 4, -27 },
  { 2520, 19, 33, 23, 2, -27 },
  { 2599, 17, 27, 23, 4, -27 },
  { 2657, 19, 27, 23, 2, -27 },
  { 2722, 21, 27, 23, 1, -27 },
  { 2793, 17, 27, 23, 3, -27 },
  { 2851, 21, 27, 23, 1, -27 },
  { 2922, 21, 27, 23, 1, -27 },
  { 2993, 21, 27, 23, 1, -27 },
  { 3064, 22, 27, 23, 1, -27 },
  { 3139, 20, 27, 23, 2, -27 },
  { 3207, 11, 35, 23, 9, -30 },
  { 3256, 16, 35, 23, 4, -30 },
  { 3326, 11, 35, 23, 4, -30 },
  { 3375, 20, 16, 23, 2, -27 },
  { 3415, 19, 3, 23, 2, 4 },
  { 3423, 6, 8, 23, 7, -31 },
  { 3429, 18, 20, 23, 3, -20 },
  { 3474, 17, 29, 23, 4, -29 },
  { 3536, 17, 20, 23, 3, -20 },
  { 3579, 18, 29, 23, 2, -29 },
  { 3645, 18, 20, 23, 3, -20 },
  { 3690, 18, 29, 23, 3, -29 },
  { 3756, 19, 31, 23, 3, -23 },
  { 3830, 16, 29, 23, 4, -29 },
  { 3888, 17, 30, 23, 4, -30 },
  { 3952, 14, 38, 23, 4, -30 },
  { 4019, 18, 29, 23, 4, -29 },
  { 4085, 17, 29, 23, 3, -29 },
  { 4147, 19, 20, 23, 2, -20 },
  { 4195, 16, 20, 23, 4, -20 },
  { 4235, 18, 20, 23, 3, -20 },
  { 4280, 17, 28, 23, 4, -20 },
  { 4340, 18, 28, 23, 2, -20 },
  { 4403, 19, 20, 23, 3, -20 },
  { 4451, 17, 20, 23, 3, -20 },
  { 4494, 19, 27, 23, 2, -27 },
  { 4559, 16, 20, 23, 4, -20 },
  { 4599, 19, 20, 23, 2, -20 },
  { 4647, 21, 20, 23, 1, -20 },
  { 4700, 19, 20, 23, 2, -20 },
  { 4748, 19, 28, 23, 2, -20 },
  { 4815, 17, 20, 23, 3, -20 },
  { 4858, 15, 35, 23, 4, -30 },
  { 4924, 3, 35, 23, 10, -30 },
  { 4938, 15, 35, 23, 4, -30 },
  { 5004, 19, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Regular39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_REGULAR39PT7B_H_
