#ifndef _IBMPLEXMONO_REGULAR54PT7B_H_
#define _IBMPLEXMONO_REGULAR54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3E, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x01, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0x03, 0xFF,
  0xCF, 0xFE, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x38, 0xFE, 0x1F,
  0x87, 0x07, 0xE3, 0xE0, 0xE0, 0x7E, 0xF8, 0x1C, 0x07, 0x1F, 0x03, 0x80,
  0x83, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x01, 0xF0,
  0x38, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7F, 0x1C, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xE1, 0xFC,
  0x00, 0x1C, 0x0F, 0x80, 0x03, 0x81, 0xF0, 0x00, 0x70, 0x1F, 0x00, 0x0E,
  0x03, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x0F, 0x80, 0x07, 0x01, 0xF3,
  0x00, 0xE0, 0x3E, 0xF0, 0x1C, 0x07, 0xBF, 0x03, 0x81, 0xF3, 0xF0, 0x70,
  0x7E, 0x3F, 0xCE, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x7F, 0xE0, 0x00, 0xF3, 0xFF,
  0xC0, 0x07, 0x9F, 0x0F, 0x80, 0x1E, 0x78, 0x1E, 0x00, 0xF1, 0xC0, 0x3C,
  0x03, 0xCF, 0x00, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x70, 0xF0, 0x0F, 0x03,
  0xC3, 0xC0, 0x3C, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x03, 0xC3, 0xC0,
  0xF0, 0x0F, 0x0F, 0x01, 0xC0, 0x3C, 0x78, 0x07, 0x81, 0xE1, 0xE0, 0x1F,
  0x0F, 0x8F, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x3C, 0x3C, 0x3E, 0x01, 0xE1, 0xE0,
  0x38, 0x07, 0x87, 0x00, 0xF0, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0xF0, 0x07,
  0x07, 0x83, 0xC0, 0x1C, 0x3C, 0x0F, 0x00, 0x70, 0xF0, 0x3C, 0x01, 0xC7,
  0x80, 0xF0, 0x07, 0x1E, 0x03, 0xC0, 0x3C, 0xF0, 0x07, 0x00, 0xF3, 0xC0,
  0x1E, 0x03, 0x9E, 0x00, 0x3C, 0x3E, 0x78, 0x00, 0xFF, 0xF3, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x04, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xFF, 0x00, 0xFE, 0x1F, 0xBE, 0x03,
  0xF8, 0x7C, 0xFC, 0x1E, 0x03, 0xE1, 0xF0, 0x78, 0x1F, 0x03, 0xE1, 0xE0,
  0x7C, 0x07, 0xC7, 0x81, 0xE0, 0x0F, 0x9E, 0x0F, 0x80, 0x1F, 0x70, 0x3E,
  0x00, 0x7F, 0xC0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0x80,
  0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x81, 0xF8, 0x01,
  0xDF, 0x03, 0xF8, 0x1E, 0x3E, 0x07, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x40, 0x0F, 0x00, 0x27, 0xC0, 0xF0, 0x1E, 0x7F, 0x8F,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xC7, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07,
  0xC0, 0xFF, 0x83, 0xF0, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0x83, 0xFE,
  0x0F, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x38,
  0x07, 0xC0, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xC3, 0xF0,
  0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x38,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xF0, 0x03,
  0xF1, 0xF0, 0x00, 0xFC, 0x30, 0x00, 0x3E, 0x08, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x80, 0x00, 0x3E, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x03,
  0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x79,
  0xFF, 0xF8, 0x3D, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x40, 0x00, 0x7C, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0xE0, 0x7F, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE1, 0xFC, 0x00,
  0xF1, 0xFF, 0xE0, 0x3C, 0xFF, 0xFC, 0x1F, 0x7F, 0xFF, 0x87, 0xBC, 0x0F,
  0xF1, 0xEC, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0x0F, 0xC0, 0x07,
  0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x9F, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0,
  0x01, 0xFC, 0xFF, 0x01, 0xDE, 0x1F, 0xFF, 0xE7, 0x83, 0xFF, 0xF3, 0xE0,
  0x3F, 0xF8, 0xF8, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x1F, 0x0F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x8F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0x30, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0xF8, 0xF7, 0x80, 0xFF, 0x7B, 0xC0, 0xFF, 0xBD, 0xE0, 0xFF, 0xEE, 0xF0,
  0x7C, 0x1F, 0x70, 0x7C, 0x07, 0xF8, 0x3C, 0x03, 0xFC, 0x1E, 0x00, 0xFE,
  0x0F, 0x00, 0x7F, 0x07, 0x80, 0x3F, 0x83, 0xC0, 0x1F, 0xC1, 0xE0, 0x0F,
  0xE0, 0xF0, 0x07, 0xF0, 0x78, 0x03, 0xF8, 0x3C, 0x01, 0xFC, 0x1E, 0x01,
  0xEE, 0x0F, 0x00, 0xF7, 0x07, 0xC0, 0x7B, 0xC1, 0xF9, 0xDD, 0xE0, 0xFF,
  0xEE, 0xF0, 0x3F, 0xE7, 0x78, 0x0F, 0xE3, 0xBC, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x02, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x21, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0xC7, 0xF0, 0x3D, 0xE1,
  0xFF, 0xFC, 0xF0, 0x7F, 0xFE, 0x78, 0x1F, 0xFE, 0x3C, 0x03, 0xFC, 0x00,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xEF, 0x00, 0x03, 0xF3, 0xC0, 0x01, 0xF8, 0xF0, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x07,
  0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF0,
  0x3F, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x03, 0xC3, 0xE0, 0x00,
  0xF1, 0xF8, 0x00, 0x3C, 0xFF, 0x00, 0x0F, 0x7F, 0xC0, 0x03, 0xDE, 0xF8,
  0x00, 0xFF, 0xBE, 0x00, 0x3F, 0xC7, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03,
  0xC0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x7E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xEE, 0x01, 0xEF, 0xF7, 0x80, 0xF7, 0xFB, 0xC0, 0xF3, 0xFC, 0xF0, 0x79,
  0xFE, 0x78, 0x38, 0xFF, 0x3C, 0x3C, 0x7F, 0x8F, 0x1E, 0x3F, 0xC7, 0x8E,
  0x1F, 0xE1, 0xCF, 0x0F, 0xF0, 0xF7, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0,
  0xF0, 0x1F, 0xE0, 0x38, 0x0F, 0xF0, 0x18, 0x07, 0xF8, 0x04, 0x03, 0xFC,
  0x04, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3C, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0,
  0x0F, 0xF3, 0xC0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xE0,
  0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x78,
  0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3E,
  0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F,
  0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x07,
  0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xEF, 0xF0, 0x01, 0xEF, 0xF0, 0x01,
  0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0xFE, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFE,
  0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D,
  0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xF3,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x7F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x00, 0x1F,
  0xCF, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x0C, 0x3E, 0x00, 0x01, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xCF, 0xE0, 0x01, 0xF8, 0xFF,
  0x80, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x80, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0,
  0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0x9E, 0x03, 0xE0, 0x3C, 0xF0, 0x3F, 0x01, 0xE7, 0x81, 0xF8, 0x0F,
  0x3C, 0x0F, 0xE0, 0x71, 0xE0, 0x7F, 0x03, 0x8F, 0x03, 0xF8, 0x3C, 0x78,
  0x3D, 0xC1, 0xE3, 0xC1, 0xEE, 0x0F, 0x1E, 0x0E, 0x78, 0x78, 0xF0, 0x73,
  0xC3, 0xC7, 0x87, 0x9E, 0x1E, 0x1C, 0x3C, 0x70, 0xF0, 0xF1, 0xE3, 0x87,
  0x87, 0x8E, 0x1E, 0x3C, 0x3C, 0x70, 0xF1, 0xE1, 0xE7, 0x87, 0x8F, 0x0F,
  0x3C, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0x83, 0xCE, 0x07, 0x9C, 0x1E, 0x70,
  0x3D, 0xE0, 0xF7, 0x81, 0xEF, 0x07, 0xBC, 0x07, 0x78, 0x3D, 0xE0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF3, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x38, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x80, 0x40, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x80, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x01, 0xBC, 0x3F,
  0x81, 0xEF, 0xF7, 0xFF, 0xF3, 0xFC, 0xFF, 0xFC, 0x7F, 0x1F, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x3F, 0x80, 0xF0, 0xFF, 0xE0, 0xF1, 0xFF, 0xF0, 0xF3, 0xFF,
  0xF8, 0xF7, 0x81, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFE, 0x00, 0x7C, 0xF7, 0x81, 0xFC, 0xF3, 0xFF, 0xF8, 0xF1, 0xFF,
  0xF0, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x0F,
  0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x0C, 0xF8, 0x00, 0x21, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x02, 0x1E, 0x00,
  0x07, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3F, 0x03, 0xF8, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F, 0x03, 0xFF,
  0x0F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x1F, 0xC0, 0xEF, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0xEF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x41, 0xF0, 0x00,
  0x38, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x0F, 0xE0, 0x7F, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0xE0, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x3F,
  0x70, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xF9, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0xF8, 0xFF, 0xC3,
  0xE7, 0xFF, 0x8F, 0xBF, 0xFF, 0x3F, 0xE0, 0xFE, 0xFE, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF7, 0x80, 0x03,
  0xE3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0x78, 0x07,
  0xE0, 0x3C, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x87,
  0xE0, 0x03, 0xC7, 0xE0, 0x01, 0xE7, 0xF0, 0x00, 0xF7, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xCF, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0xF0, 0x03, 0xE0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x8F, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x3E, 0x3C, 0xFE, 0x1F, 0xEF, 0x7F, 0xCF, 0xFB, 0xDF, 0xF7, 0xFF, 0xFC,
  0x3D, 0x87, 0xFE, 0x07, 0xC0, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F,
  0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01,
  0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0x03,
  0xE3, 0xFF, 0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF, 0x83, 0xFB, 0xF8,
  0x03, 0xEF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0xF9, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x0F,
  0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0xFF, 0xE0, 0xF1, 0xFF, 0xF0,
  0xF3, 0xFF, 0xF8, 0xF7, 0x81, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7C, 0xF7, 0x81, 0xFC, 0xF3, 0xFF, 0xF8,
  0xF1, 0xFF, 0xF0, 0xF0, 0xFF, 0xE0, 0xF0, 0x3F, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0xCF,
  0x1F, 0xFF, 0xEF, 0x1F, 0xC0, 0xEF, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0xEF, 0x1F, 0xFF, 0xEF,
  0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0x80,
  0xFF, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF,
  0x00, 0x3F, 0x7F, 0x03, 0xBC, 0xFF, 0xFE, 0xF1, 0xFF, 0xF3, 0xC3, 0xFF,
  0x8F, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF0,
  0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC, 0x07, 0xE0, 0x1D, 0xE0, 0x3F,
  0x00, 0xEF, 0x01, 0xFC, 0x0F, 0x78, 0x0E, 0xE0, 0x79, 0xC0, 0x77, 0x03,
  0xCE, 0x07, 0x38, 0x1E, 0x78, 0x39, 0xC0, 0xE3, 0xC1, 0xCF, 0x07, 0x1E,
  0x0E, 0x38, 0x38, 0xF0, 0x71, 0xC1, 0xC3, 0x87, 0x8E, 0x1E, 0x1C, 0x38,
  0x70, 0xF0, 0xE1, 0xC3, 0x87, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0x70, 0x71,
  0xC1, 0xE7, 0x83, 0x8E, 0x0F, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0xE7, 0x81,
  0xCE, 0x07, 0xBC, 0x0E, 0x70, 0x1D, 0xE0, 0x77, 0x80, 0xEE, 0x03, 0xF8,
  0x07, 0x70, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x01,
  0x81, 0xFE, 0x00, 0x3C, 0x7F, 0xE0, 0x07, 0x1F, 0xFE, 0x01, 0xE3, 0xC7,
  0xC0, 0x3C, 0xF0, 0x7C, 0x07, 0x1E, 0x07, 0xC1, 0xE3, 0x80, 0x7C, 0x7C,
  0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0xC3, 0x80, 0x07, 0xF8, 0x30, 0x00,
  0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 38, 32, 12, -38 },
  { 39, 14, 15, 32, 9, -40 },
  { 66, 31, 38, 32, 1, -38 },
  { 214, 27, 51, 32, 3, -44 },
  { 387, 30, 39, 32, 1, -38 },
  { 534, 30, 39, 32, 1, -38 },
  { 681, 4, 15, 32, 14, -40 },
  { 689, 16, 48, 32, 11, -41 },
  { 785, 15, 48, 32, 6, -41 },
  { 875, 28, 27, 32, 2, -31 },
  { 970, 26, 26, 32, 3, -29 },
  { 1055, 10, 15, 32, 11, -7 },
  { 1074, 16, 4, 32, 8, -18 },
  { 1082, 8, 7, 32, 12, -7 },
  { 1089, 23, 48, 32, 5, -41 },
  { 1227, 26, 39, 32, 3, -38 },
  { 1354, 27, 38, 32, 3, -38 },
  { 1483, 25, 38, 32, 4, -38 },
  { 1602, 25, 39, 32, 3, -38 },
  { 1724, 28, 38, 32, 2, -38 },
  { 1857, 25, 39, 32, 4, -38 },
  { 1979, 26, 39, 32, 3, -38 },
  { 2106, 25, 38, 32, 4, -38 },
  { 2225, 26, 39, 32, 3, -38 },
  { 2352, 26, 38, 32, 3, -38 },
  { 2476, 8, 28, 32, 12, -28 },
  { 2504, 10, 36, 32, 11, -28 },
  { 2549, 23, 31, 32, 5, -32 },
  { 2639, 26, 15, 32, 3, -24 },
  { 2688, 23, 31, 32, 5, -32 },
  { 2778, 24, 38, 32, 4, -38 },
  { 2892, 25, 44, 32, 3, -38 },
  { 3030, 29, 38, 32, 2, -38 },
  { 3168, 24, 38, 32, 5, -38 },
  { 3282, 25, 39, 32, 4, -38 },
  { 3404, 24, 38, 32, 5, -38 },
  { 3518, 23, 38, 32, 5, -38 },
  { 3628, 24, 38, 32, 5, -38 },
  { 3742, 25, 39, 32, 3, -38 },
  { 3864, 24, 38, 32, 4, -38 },
  { 3978, 23, 38, 32, 5, -38 },
  { 4088, 22, 39, 32, 4, -38 },
  { 4196, 26, 38, 32, 5, -38 },
  { 4320, 23, 38, 32, 6, -38 },
  { 4430, 25, 38, 32, 4, -38 },
  { 4549, 24, 38, 32, 4, -38 },
  { 4663, 26, 39, 32, 3, -38 },
  { 4790, 24, 38, 32, 5, -38 },
  { 4904, 26, 47, 32, 3, -38 },
  { 5057, 25, 38, 32, 5, -38 },
  { 5176, 27, 39, 32, 2, -38 },
  { 5308, 30, 38, 32, 1, -38 },
  { 5451, 24, 39, 32, 4, -38 },
  { 5568, 28, 38, 32, 2, -38 },
  { 5701, 29, 38, 32, 2, -38 },
  { 5839, 30, 38, 32, 1, -38 },
  { 5982, 30, 38, 32, 1, -38 },
  { 6125, 27, 38, 32, 3, -38 },
  { 6254, 15, 48, 32, 12, -41 },
  { 6344, 23, 48, 32, 5, -41 },
  { 6482, 15, 48, 32, 5, -41 },
  { 6572, 28, 22, 32, 2, -38 },
  { 6649, 26, 4, 32, 3, 5 },
  { 6662, 9, 10, 32, 10, -42 },
  { 6674, 26, 30, 32, 4, -29 },
  { 6772, 24, 41, 32, 5, -40 },
  { 6895, 23, 30, 32, 5, -29 },
  { 6982, 24, 41, 32, 3, -40 },
  { 7105, 25, 30, 32, 4, -29 },
  { 7199, 25, 40, 32, 4, -40 },
  { 7324, 26, 43, 32, 4, -32 },
  { 7464, 22, 40, 32, 5, -40 },
  { 7574, 23, 40, 32, 6, -40 },
  { 7689, 20, 51, 32, 5, -40 },
  { 7817, 25, 40, 32, 6, -40 },
  { 7942, 24, 40, 32, 4, -40 },
  { 8062, 26, 29, 32, 3, -29 },
  { 8157, 22, 29, 32, 5, -29 },
  { 8237, 25, 30, 32, 4, -29 },
  { 8331, 24, 40, 32, 5, -29 },
  { 8451, 24, 40, 32, 3, -29 },
  { 8571, 26, 28, 32, 4, -28 },
  { 8662, 24, 30, 32, 4, -29 },
  { 8752, 26, 38, 32, 2, -38 },
  { 8876, 22, 29, 32, 5, -28 },
  { 8956, 26, 28, 32, 3, -28 },
  { 9047, 29, 28, 32, 2, -28 },
  { 9149, 26, 28, 32, 3, -28 },
  { 9240, 27, 39, 32, 3, -28 },
  { 9372, 23, 28, 32, 5, -28 },
  { 9453, 21, 48, 32, 6, -41 },
  { 9579, 4, 48, 32, 14, -41 },
  { 9603, 21, 48, 32, 6, -41 },
  { 9729, 27, 12, 32, 3, -22 },
};

const GFXfont IBMPlexMono_Regular54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_REGULAR54PT7B_H_
