#ifndef _IBMPLEXMONO_REGULAR30PT7B_H_
#define _IBMPLEXMONO_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF, 0xF0,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x01, 0x8E, 0x00, 0x63,
  0x00, 0x38, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x03, 0xF1, 0xFC,
  0xFC, 0x7F, 0x07, 0x18, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06,
  0x38, 0x3F, 0x8F, 0xCF, 0xE3, 0xF0, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x1C,
  0x00, 0xC7, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x07, 0xF0, 0x1F, 0xFC, 0x3D, 0x9E, 0x31, 0x86, 0x71, 0x84,
  0x71, 0x80, 0x71, 0x80, 0x31, 0x80, 0x3D, 0x80, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xFC, 0x01, 0x8E, 0x01, 0x86, 0x01, 0x87, 0x01, 0x87, 0x21, 0x86,
  0xF1, 0x8E, 0x79, 0x9E, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x3C, 0x03, 0x7F, 0x07, 0xE3, 0x06, 0xC3, 0x0E, 0xC3, 0x8C,
  0xC3, 0x9C, 0xC3, 0x18, 0xC3, 0x30, 0x7F, 0x30, 0x3C, 0x40, 0x00, 0x00,
  0x00, 0x3C, 0x0E, 0xFE, 0x0C, 0xC7, 0x18, 0xC3, 0x39, 0xC3, 0x31, 0xC3,
  0x70, 0xC3, 0x60, 0xC7, 0xE0, 0xFE, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xE0,
  0x38, 0x70, 0x30, 0x20, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x3E, 0x0F, 0x77, 0x0F, 0xE3, 0x9C, 0xC1, 0xD8,
  0xC0, 0xF8, 0xC0, 0x78, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0xDC, 0x7F, 0x8E,
  0x1F, 0x07, 0xFF, 0xFF, 0x03, 0x83, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x71, 0x8E, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xC0,
  0x03, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x38, 0x18, 0x18, 0x08, 0x10,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3D, 0xE7, 0x9C, 0x71, 0x8E, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x60,
  0x1B, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC3, 0x0F, 0x1E, 0x3C, 0x78, 0xF0,
  0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0x60, 0x19, 0xC0, 0xE3,
  0x87, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x76, 0x01, 0xCC,
  0x0F, 0x18, 0x1C, 0x30, 0x30, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF,
  0x87, 0x07, 0x38, 0x0E, 0xE0, 0x39, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0,
  0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE2, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x20, 0x0C, 0xC0, 0x3B, 0xE0, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xB8, 0x03, 0xB8,
  0x03, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x18, 0x38,
  0x30, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x3F, 0xF8, 0xFF, 0xE7,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x67, 0xC1,
  0xBF, 0xC7, 0x87, 0x98, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x40, 0x1F, 0x80, 0x67, 0x07, 0x8F, 0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x67,
  0xC3, 0xBF, 0xCF, 0x87, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0xE0, 0x1D, 0x80, 0x67, 0x87, 0x8F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0x07, 0x98, 0x06, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8,
  0x06, 0x30, 0x30, 0x7F, 0x81, 0xFE, 0x1C, 0x0E, 0xE0, 0x1F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x77, 0x03, 0x8F, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x18, 0x06, 0xE0, 0x1F, 0x80, 0x7C, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x87, 0xCF, 0xF7, 0x1F, 0x98, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x79, 0xE7, 0x9E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE7, 0x9C, 0x71, 0x8E, 0x30,
  0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x00,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0xC0, 0xF0, 0x0C, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x9E, 0x1C, 0xE0,
  0x7E, 0x01, 0x90, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x3F, 0x01, 0xF0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03,
  0xE0, 0x1F, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x06,
  0x60, 0x1B, 0x80, 0x7C, 0x1C, 0xF0, 0xFB, 0xC7, 0x1F, 0x18, 0x3C, 0x60,
  0xF3, 0x83, 0xCE, 0x0F, 0x18, 0x3C, 0x60, 0xF1, 0x87, 0xC7, 0xEF, 0x0F,
  0xB6, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E,
  0x70, 0x0C, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x18,
  0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x30, 0x1D, 0x80, 0x6C,
  0x03, 0x60, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x67, 0xFE, 0x3F, 0xF9, 0x80,
  0xEC, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1D,
  0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x07, 0x70,
  0x0D, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x0D, 0xC0, 0x73,
  0x83, 0x87, 0xFC, 0x07, 0xE0, 0xFF, 0x87, 0xFE, 0x30, 0x39, 0x80, 0xEC,
  0x03, 0x60, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x39,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xBF, 0xFD, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xBF, 0xFD, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x0E, 0x60, 0x1F, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0xC1,
  0xFF, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF,
  0xF7, 0x0F, 0x9C, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0xE0, 0x3E, 0x07, 0x70, 0xF3, 0xFE, 0x1F, 0x80, 0xC0, 0x1F, 0x00, 0xEC,
  0x07, 0x30, 0x38, 0xC1, 0xC3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03,
  0x78, 0x0D, 0xF0, 0x3C, 0xC0, 0xF3, 0x83, 0x87, 0x0C, 0x1C, 0x30, 0x38,
  0xC0, 0x73, 0x01, 0xCC, 0x03, 0xB0, 0x0E, 0xC0, 0x1C, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F,
  0xD8, 0x6F, 0x61, 0xBC, 0xCC, 0xF3, 0x33, 0xCE, 0xCF, 0x1E, 0x3C, 0x78,
  0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x20, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x1F, 0xB0, 0x7E, 0xE1, 0xF9, 0x87, 0xE6, 0x1F, 0x9C, 0x7E,
  0x31, 0xF8, 0xE7, 0xE1, 0x9F, 0x86, 0x7E, 0x1D, 0xF8, 0x37, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3C, 0x0F, 0xC0, 0x7F, 0x83, 0x87,
  0x1C, 0x0E, 0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0x60,
  0x19, 0xC0, 0xE3, 0x87, 0x0F, 0xF8, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xB0,
  0x1D, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03,
  0xBF, 0xFD, 0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87,
  0x1C, 0x0E, 0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0x60,
  0x19, 0xC0, 0xE3, 0x87, 0x0F, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xF8, 0x07, 0xE0, 0xFF, 0xC7, 0xFF, 0xB0, 0x1D, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xBF, 0xFD, 0xFF,
  0x8C, 0x30, 0x61, 0xC3, 0x07, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0x30, 0x1D,
  0x80, 0x7C, 0x03, 0x80, 0x07, 0xF0, 0x3F, 0xF8, 0xE0, 0x7B, 0x80, 0x77,
  0x00, 0x8E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x20, 0x0F,
  0xE0, 0x1D, 0xE0, 0x71, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x06, 0x60, 0x19, 0xC0, 0xE7, 0x87, 0x8F,
  0xFC, 0x0F, 0xC0, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x70,
  0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06,
  0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE1, 0xC7, 0x63, 0xC6, 0x63,
  0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x6C, 0x36, 0x6C, 0x36, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x38, 0x1C, 0xE0, 0x07, 0x70, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x1C,
  0x38, 0x0C, 0x38, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x18,
  0x18, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x18, 0x38, 0x38, 0x1C,
  0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x4C, 0xE6, 0x33, 0x1F, 0x80, 0x7F, 0xC1, 0xC1, 0xC7, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x07, 0xFC, 0x3F, 0xF8, 0xF0, 0x31, 0xC0, 0x63, 0x80, 0xC7,
  0x01, 0x8E, 0x0F, 0x0F, 0xF7, 0xC7, 0xC7, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xF8, 0xDF, 0xE7, 0x87,
  0xB8, 0x0D, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF8, 0x0D, 0xE0, 0xED, 0xFE, 0x63, 0xE0, 0x0F, 0x83, 0xFE, 0x70,
  0x7E, 0x03, 0xC0, 0x4C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x2E, 0x03, 0x70, 0x73, 0xFE, 0x0F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xE3, 0x3F, 0xDB, 0x83, 0xF8,
  0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x0E, 0xF0, 0xF3, 0xFD, 0x8F, 0x8C, 0x0F, 0xC0, 0x7F, 0xC3, 0x87,
  0x98, 0x06, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x06, 0x38, 0x38, 0x7F, 0xC0, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x3F, 0x81, 0xFF, 0x83, 0x87, 0x0E, 0x07,
  0x18, 0x0E, 0x30, 0x1C, 0x70, 0x38, 0xF0, 0xE0, 0xFF, 0x80, 0x7E, 0x03,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0xC0, 0x1F, 0x00,
  0x1E, 0x00, 0x7E, 0x01, 0xCF, 0xFF, 0x87, 0xF8, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x78, 0xDF, 0xED, 0x0F,
  0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1B, 0xFE, 0x7F, 0xC0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0xE0,
  0x73, 0x83, 0x8E, 0x1C, 0x39, 0xE0, 0xEE, 0x03, 0xFC, 0x0F, 0xF0, 0x3C,
  0xE0, 0xE1, 0xC3, 0x83, 0x8E, 0x06, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x70,
  0xFF, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xDE, 0x7B, 0x79, 0xFE, 0x78, 0xF0, 0xC3, 0xC3, 0x0F,
  0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3,
  0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xC0, 0xC7, 0x8D, 0xFE, 0xD0, 0xFE, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x98, 0x06,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xD8, 0x06, 0x78, 0x78, 0xFF, 0xC0, 0xFC, 0x00, 0xC7, 0xC6, 0xFF, 0x3C,
  0x3D, 0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0xC0, 0x6F, 0x07, 0x6F, 0xF3, 0x1F, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0x19, 0xFE, 0xDC, 0x1F,
  0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x77, 0x87, 0x9F, 0xEC, 0x7C, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFE, 0x3F, 0xFC, 0xFC, 0x1B, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x04, 0x60, 0x01, 0xC0, 0x03, 0xF8, 0x07,
  0xFC, 0x01, 0xF8, 0x00, 0x70, 0x01, 0xD0, 0x07, 0xF0, 0x38, 0xFF, 0xC0,
  0xFC, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07,
  0xF0, 0xB7, 0xFB, 0x1E, 0x30, 0xE0, 0x0F, 0x80, 0x76, 0x01, 0x9C, 0x0E,
  0x30, 0x30, 0xC0, 0xC3, 0x87, 0x06, 0x18, 0x18, 0x60, 0x73, 0x80, 0xCC,
  0x03, 0x30, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xC1, 0x83, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE3, 0xC3, 0x63, 0x46, 0x62, 0x46, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x26, 0x24, 0x24, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0xE0, 0x1D, 0xC0, 0xE3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x3F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x0E, 0x1C, 0x30,
  0x71, 0xC0, 0xEE, 0x01, 0xC0, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0x98, 0x06,
  0x70, 0x38, 0xC0, 0xC3, 0x87, 0x06, 0x18, 0x1C, 0x60, 0x33, 0x00, 0xCC,
  0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x03, 0x80, 0x30, 0xFE,
  0x0F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xF0, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x07,
  0xF0, 0x7F, 0x0E, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xF0, 0xFE, 0x00, 0x3C, 0x0D,
  0xF8, 0x3E, 0x70, 0xF0, 0xE6, 0xC1, 0xFB, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 21, 18, 7, -21 },
  { 12, 8, 8, 18, 5, -22 },
  { 20, 18, 21, 18, 0, -21 },
  { 68, 16, 27, 18, 1, -24 },
  { 122, 16, 21, 18, 1, -21 },
  { 164, 16, 21, 18, 1, -21 },
  { 206, 2, 8, 18, 8, -22 },
  { 208, 9, 27, 18, 6, -23 },
  { 239, 9, 27, 18, 3, -23 },
  { 270, 16, 15, 18, 1, -17 },
  { 300, 14, 14, 18, 2, -16 },
  { 325, 6, 8, 18, 6, -4 },
  { 331, 8, 2, 18, 5, -10 },
  { 333, 4, 4, 18, 7, -4 },
  { 335, 12, 27, 18, 3, -23 },
  { 376, 14, 21, 18, 2, -21 },
  { 413, 15, 21, 18, 2, -21 },
  { 453, 14, 21, 18, 2, -21 },
  { 490, 15, 21, 18, 1, -21 },
  { 530, 16, 21, 18, 1, -21 },
  { 572, 14, 21, 18, 2, -21 },
  { 609, 14, 21, 18, 2, -21 },
  { 646, 14, 21, 18, 2, -21 },
  { 683, 14, 21, 18, 2, -21 },
  { 720, 14, 21, 18, 2, -21 },
  { 757, 4, 16, 18, 7, -16 },
  { 765, 6, 20, 18, 6, -16 },
  { 780, 12, 17, 18, 3, -18 },
  { 806, 14, 8, 18, 2, -13 },
  { 820, 12, 17, 18, 3, -18 },
  { 846, 13, 21, 18, 2, -21 },
  { 881, 14, 24, 18, 2, -21 },
  { 923, 16, 21, 18, 1, -21 },
  { 965, 13, 21, 18, 3, -21 },
  { 1000, 14, 21, 18, 2, -21 },
  { 1037, 13, 21, 18, 3, -21 },
  { 1072, 13, 21, 18, 3, -21 },
  { 1107, 13, 21, 18, 3, -21 },
  { 1142, 14, 21, 18, 2, -21 },
  { 1179, 14, 21, 18, 2, -21 },
  { 1216, 12, 21, 18, 3, -21 },
  { 1248, 12, 21, 18, 2, -21 },
  { 1280, 14, 21, 18, 3, -21 },
  { 1317, 12, 21, 18, 4, -21 },
  { 1349, 14, 21, 18, 2, -21 },
  { 1386, 14, 21, 18, 2, -21 },
  { 1423, 14, 21, 18, 2, -21 },
  { 1460, 13, 21, 18, 3, -21 },
  { 1495, 14, 26, 18, 2, -21 },
  { 1541, 13, 21, 18, 3, -21 },
  { 1576, 15, 21, 18, 1, -21 },
  { 1616, 16, 21, 18, 1, -21 },
  { 1658, 14, 21, 18, 2, -21 },
  { 1695, 16, 21, 18, 1, -21 },
  { 1737, 16, 21, 18, 1, -21 },
  { 1779, 16, 21, 18, 1, -21 },
  { 1821, 16, 21, 18, 1, -21 },
  { 1863, 16, 21, 18, 1, -21 },
  { 1905, 8, 27, 18, 7, -23 },
  { 1932, 12, 27, 18, 3, -23 },
  { 1973, 8, 27, 18, 3, -23 },
  { 2000, 16, 12, 18, 1, -21 },
  { 2024, 14, 2, 18, 2, 3 },
  { 2028, 4, 6, 18, 6, -24 },
  { 2031, 15, 15, 18, 2, -15 },
  { 2060, 13, 22, 18, 3, -22 },
  { 2096, 12, 15, 18, 3, -15 },
  { 2119, 13, 22, 18, 2, -22 },
  { 2155, 14, 15, 18, 2, -15 },
  { 2182, 14, 22, 18, 2, -22 },
  { 2221, 15, 23, 18, 2, -17 },
  { 2265, 12, 22, 18, 3, -22 },
  { 2298, 13, 22, 18, 3, -22 },
  { 2334, 11, 28, 18, 3, -22 },
  { 2373, 14, 22, 18, 3, -22 },
  { 2412, 14, 22, 18, 2, -22 },
  { 2451, 14, 15, 18, 2, -15 },
  { 2478, 12, 15, 18, 3, -15 },
  { 2501, 14, 15, 18, 2, -15 },
  { 2528, 13, 21, 18, 3, -15 },
  { 2563, 13, 21, 18, 2, -15 },
  { 2598, 15, 15, 18, 2, -15 },
  { 2627, 14, 15, 18, 2, -15 },
  { 2654, 15, 21, 18, 1, -21 },
  { 2694, 12, 15, 18, 3, -15 },
  { 2717, 14, 15, 18, 2, -15 },
  { 2744, 16, 15, 18, 1, -15 },
  { 2774, 14, 15, 18, 2, -15 },
  { 2801, 14, 21, 18, 2, -15 },
  { 2838, 12, 15, 18, 3, -15 },
  { 2861, 12, 27, 18, 3, -23 },
  { 2902, 2, 27, 18, 8, -23 },
  { 2909, 12, 27, 18, 3, -23 },
  { 2950, 14, 6, 18, 2, -12 },
};

const GFXfont IBMPlexMono_Regular30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_REGULAR30PT7B_H_
