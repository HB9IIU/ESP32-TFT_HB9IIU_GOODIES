#ifndef _IBMPLEXMONO_REGULAR7PT7B_H_
#define _IBMPLEXMONO_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x66, 0xFF, 0xA0, 0x47, 0xC6, 0x5D, 0x60, 0xDE, 0x8F,
  0xB0, 0x68, 0x5A, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0xA0, 0x4F, 0x6A, 0x44,
  0xF4, 0x60, 0xC0, 0x80, 0x6A, 0x49, 0x00, 0x69, 0xB9, 0x60, 0x6A, 0x22,
  0x70, 0x69, 0x24, 0xF0, 0x61, 0x61, 0xE0, 0x26, 0xAA, 0x70, 0xF3, 0x1C,
  0x64, 0x69, 0x60, 0xFA, 0x24, 0x40, 0x69, 0x69, 0x70, 0x69, 0x96, 0x60,
  0x90, 0x41, 0x80, 0x72, 0x30, 0xFF, 0x89, 0xC0, 0xC5, 0x48, 0x6B, 0xDD,
  0xA6, 0x26, 0x67, 0x90, 0xD7, 0x5E, 0x69, 0x88, 0x70, 0xD6, 0xDC, 0xF3,
  0xCE, 0xF3, 0xC8, 0x69, 0x8B, 0x70, 0xB7, 0xDA, 0xF2, 0x4E, 0xD5, 0xC0,
  0xBA, 0x6A, 0x92, 0x4E, 0x9F, 0xBD, 0x90, 0xB6, 0xFA, 0x69, 0x99, 0x60,
  0xD7, 0x48, 0x69, 0x99, 0x66, 0xD7, 0x6A, 0x78, 0x61, 0xF0, 0xF4, 0x44,
  0x40, 0xB6, 0xDC, 0x99, 0x66, 0x20, 0x9D, 0xB7, 0x50, 0x96, 0x46, 0x90,
  0x96, 0x64, 0x40, 0xF2, 0x44, 0xF0, 0xEA, 0xB0, 0x92, 0x24, 0xC0, 0xD5,
  0x70, 0x26, 0x90, 0xF0, 0x80, 0x62, 0xEF, 0x9A, 0xDC, 0xD6, 0x70, 0x17,
  0x99, 0x70, 0x69, 0xE7, 0xFE, 0x4E, 0x7A, 0x66, 0xF0, 0x9A, 0xDA, 0x59,
  0x2E, 0x75, 0x70, 0x97, 0x6A, 0x92, 0x4E, 0xDF, 0xDD, 0xD6, 0xD0, 0x69,
  0x96, 0xD6, 0xE8, 0x79, 0x95, 0x30, 0xBA, 0x70, 0x69, 0x7F, 0x4F, 0x44,
  0x70, 0xB6, 0xF0, 0x9A, 0x62, 0xDB, 0x75, 0x96, 0x2F, 0x9A, 0x62, 0x40,
  0xEA, 0x70, 0xE7, 0xB0, 0xFC, 0xEB, 0xB0, 0x5A,
};

const GFXglyph IBMPlexMono_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 2, 6, 4, 1, -5 },
  { 19, 2, 6, 4, 1, -5 },
  { 21, 4, 4, 4, 0, -4 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 1, 1, 4, 2, -1 },
  { 28, 3, 6, 4, 1, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 1, 4, 4, 2, -4 },
  { 61, 2, 5, 4, 1, -4 },
  { 63, 3, 4, 4, 1, -4 },
  { 65, 4, 2, 4, 0, -3 },
  { 66, 3, 4, 4, 1, -4 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 4, 6, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 2, 5, 4, 1, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 3, 5, 4, 1, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 3, 5, 4, 1, -5 },
  { 110, 4, 6, 4, 0, -5 },
  { 113, 3, 5, 4, 1, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 3, 5, 4, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 2, 6, 4, 2, -5 },
  { 140, 3, 6, 4, 1, -5 },
  { 143, 2, 6, 4, 1, -5 },
  { 145, 4, 3, 4, 0, -5 },
  { 147, 4, 1, 4, 0, 0 },
  { 148, 1, 1, 4, 1, -5 },
  { 149, 4, 4, 4, 0, -4 },
  { 151, 3, 5, 4, 1, -5 },
  { 153, 3, 4, 4, 1, -4 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 3, 5, 4, 1, -5 },
  { 162, 4, 5, 4, 0, -4 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 3, 5, 4, 1, -5 },
  { 169, 2, 6, 4, 1, -5 },
  { 171, 3, 5, 4, 1, -5 },
  { 173, 3, 5, 4, 1, -5 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 3, 4, 4, 1, -4 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 3, 5, 4, 1, -4 },
  { 183, 4, 5, 4, 0, -4 },
  { 186, 3, 4, 4, 1, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 5, 4, 0, -4 },
  { 204, 3, 4, 4, 1, -4 },
  { 206, 2, 6, 4, 1, -5 },
  { 208, 1, 6, 4, 2, -5 },
  { 209, 2, 6, 4, 1, -5 },
  { 211, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_Regular7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_REGULAR7PT7B_H_
