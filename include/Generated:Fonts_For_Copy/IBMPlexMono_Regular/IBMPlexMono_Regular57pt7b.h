#ifndef _IBMPLEXMONO_REGULAR57PT7B_H_
#define _IBMPLEXMONO_REGULAR57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE7, 0x1F, 0xE3, 0xF0, 0x70, 0x7F, 0x3E, 0x07, 0x03, 0xF3,
  0xE0, 0x70, 0x1E, 0x7C, 0x07, 0x00, 0x87, 0xC0, 0x70, 0x00, 0x7C, 0x07,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x7C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3E, 0x07, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x1F, 0xC7, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0xFE, 0x00,
  0x07, 0x03, 0xF0, 0x00, 0x70, 0x1F, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x70,
  0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xF2,
  0x00, 0x70, 0x0F, 0x30, 0x07, 0x01, 0xF7, 0x80, 0x70, 0x1F, 0xFE, 0x07,
  0x03, 0xE7, 0xF0, 0x70, 0x7E, 0x3F, 0xC7, 0x1F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x0F, 0xFC, 0x00, 0x1E, 0x1F, 0xFE, 0x00, 0x1E, 0x3F, 0xFF, 0x00, 0x3C,
  0x7C, 0x1F, 0x00, 0x3C, 0x78, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x78,
  0xF0, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x81, 0xE0,
  0xF0, 0x07, 0x83, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0xF0, 0x07, 0x87, 0xC0,
  0xF0, 0x07, 0x87, 0x80, 0x78, 0x0F, 0x0F, 0x00, 0x7C, 0x1F, 0x0F, 0x00,
  0x3F, 0xFF, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x7F, 0xFC, 0x00, 0xF0, 0x7F, 0xFC,
  0x00, 0xF0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x1E, 0x01, 0xE1, 0xE0, 0x0F,
  0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x81, 0xE0, 0x0F,
  0x07, 0x81, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x0F, 0x1F, 0x01, 0xE0, 0x0F,
  0x1E, 0x01, 0xE0, 0x0F, 0x3E, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0xF8, 0x3E,
  0x78, 0x00, 0x7F, 0xFC, 0x78, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x08, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0x01, 0xFE, 0x1F, 0x1F, 0x01, 0xE0,
  0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xC1, 0xC0, 0x7C, 0x07, 0xE1, 0xC0,
  0x7C, 0x03, 0xF1, 0xC0, 0x78, 0x01, 0xF3, 0xC0, 0xF8, 0x00, 0xFB, 0xC0,
  0xF8, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x3B, 0xF0, 0x3F, 0x80, 0xF1, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0xE7, 0xE0, 0x78, 0x1F, 0x9F, 0xF1, 0xE3, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8,
  0x1F, 0x81, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x1F, 0xC1, 0xFF, 0x81, 0xFC,
  0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0x80, 0x7C, 0x00, 0x18, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF0, 0x40, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE0,
  0xE0, 0x00, 0x7C, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x30, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x7F, 0x00, 0x3C, 0x7F, 0xF8, 0x0F, 0x3F, 0xFF, 0x03,
  0xDF, 0xFF, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0x9F, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x7C, 0x7F, 0xF8,
  0x0F, 0x9F, 0xFF, 0x81, 0xE7, 0xFF, 0xF8, 0x7D, 0xE0, 0x7F, 0x8F, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x07,
  0xE0, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F,
  0x3F, 0x80, 0x0D, 0xE3, 0xFC, 0x07, 0x7C, 0x3F, 0xFF, 0xEF, 0x83, 0xFF,
  0xF9, 0xE0, 0x3F, 0xFC, 0x7C, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3F, 0x1F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC2, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7D,
  0xE0, 0x1F, 0x0F, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFE, 0xFF, 0x03, 0xFF,
  0xBF, 0xC0, 0xF8, 0x3F, 0xF0, 0x7C, 0x07, 0xFC, 0x1E, 0x00, 0xFF, 0x07,
  0x80, 0x3F, 0xC1, 0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0xFF,
  0x0F, 0x80, 0x3F, 0xC3, 0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xFC, 0x3E, 0x00,
  0xFF, 0x0F, 0x80, 0x3F, 0xC1, 0xE0, 0x0F, 0xF0, 0x78, 0x03, 0xFC, 0x1E,
  0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC0, 0xFC, 0x6F, 0xF0, 0x3F, 0xFB, 0xFC,
  0x07, 0xFC, 0xF7, 0x80, 0xFF, 0x3D, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x1F, 0x8F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0,
  0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x71, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xF0, 0xFE, 0x07, 0xBE, 0x0F, 0xFF, 0xF7, 0xC0, 0xFF, 0xFC,
  0xF8, 0x0F, 0xFF, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x84, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xF8, 0x1F, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x9F,
  0xC0, 0x00, 0xF9, 0xFE, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF9, 0xF0, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0xFE,
  0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xDE, 0x01, 0xEF, 0xF7, 0x80, 0x7B,
  0xFC, 0xF0, 0x1E, 0xFF, 0x3C, 0x0F, 0x3F, 0xCF, 0x83, 0xCF, 0xF1, 0xE1,
  0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x0F, 0x1E, 0x3F, 0xC3, 0xCF, 0x0F, 0xF0,
  0xFB, 0xC3, 0xFC, 0x1E, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x0E, 0x03, 0xFC, 0x03, 0x00, 0xFF, 0x00, 0xC0, 0x3F, 0xC0,
  0x20, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xEF, 0x00, 0x1F, 0xF7, 0xC0, 0x0F, 0xF9, 0xE0, 0x07,
  0xFC, 0xF8, 0x03, 0xFE, 0x7C, 0x01, 0xFF, 0x1E, 0x00, 0xFF, 0x8F, 0x80,
  0x7F, 0xC3, 0xC0, 0x3F, 0xE1, 0xF0, 0x1F, 0xF0, 0xF8, 0x0F, 0xF8, 0x3C,
  0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03, 0xE0, 0xFF, 0x81,
  0xF0, 0x7F, 0xC0, 0x78, 0x3F, 0xE0, 0x3E, 0x1F, 0xF0, 0x0F, 0x0F, 0xF8,
  0x07, 0xC7, 0xFC, 0x03, 0xE3, 0xFE, 0x00, 0xF1, 0xFF, 0x00, 0x7C, 0xFF,
  0x80, 0x1E, 0x7F, 0xC0, 0x0F, 0xBF, 0xE0, 0x07, 0xDF, 0xF0, 0x01, 0xEF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8,
  0x00, 0x7F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xEF, 0x80, 0x07, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xC3, 0xF0, 0x00, 0xFE, 0x3E, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF2, 0x00, 0x00, 0x1F, 0x30, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0xFC,
  0x07, 0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x79, 0xE0, 0x3F, 0x81,
  0xE7, 0x80, 0xFE, 0x07, 0x9E, 0x07, 0xF8, 0x1E, 0x78, 0x1E, 0xE0, 0x79,
  0xF0, 0x7B, 0x81, 0xE7, 0xC1, 0xCF, 0x07, 0x8F, 0x0F, 0x3C, 0x1E, 0x3C,
  0x3C, 0xF0, 0x78, 0xF0, 0xF3, 0xC3, 0xE3, 0xC3, 0xC7, 0x0F, 0x0F, 0x0E,
  0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x3C, 0x70, 0x3C, 0xF0, 0xF3, 0xC0, 0xF3,
  0xC3, 0xCF, 0x03, 0xCF, 0x0F, 0xBC, 0x0F, 0x3C, 0x1E, 0xF0, 0x1E, 0xF0,
  0x7B, 0x80, 0x7B, 0xC1, 0xFE, 0x01, 0xEF, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xC0,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x03, 0xC1, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xF8,
  0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x03, 0xC3, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x1B, 0xC1, 0xFC, 0x0F,
  0x7F, 0xBF, 0xFF, 0xC7, 0xF3, 0xFF, 0xF8, 0xFE, 0x1F, 0xFC, 0x07, 0xC0,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x1F, 0xFC,
  0x0F, 0x9F, 0xFF, 0x83, 0xEF, 0xFF, 0xF0, 0xFB, 0x80, 0xFE, 0x3F, 0x80,
  0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0x3F, 0x80, 0x0F, 0xCF, 0xB8, 0x0F, 0xE3, 0xEF, 0xFF,
  0xF0, 0xF9, 0xFF, 0xF8, 0x3E, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0xC0, 0xFE, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x0E, 0x7C,
  0x00, 0x08, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x7C, 0x00, 0x0F, 0x3E,
  0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x07, 0xC0, 0xFF, 0xF1, 0xF0, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0xDF,
  0x1F, 0xE0, 0x77, 0xC7, 0xE0, 0x07, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xF1,
  0xFE, 0x07, 0x7C, 0x3F, 0xFF, 0xDF, 0x07, 0xFF, 0xE7, 0xC0, 0xFF, 0xF1,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xC0, 0x0F, 0xC3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x21, 0xF0, 0x00, 0x1C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xF0, 0x1E, 0x1F,
  0xF8, 0x3C, 0xFF, 0xFC, 0x79, 0xFF, 0xFC, 0xF7, 0x03, 0xF9, 0xE8, 0x01,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0x80, 0x0F, 0xF1, 0xF0,
  0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x1F,
  0x8F, 0x3F, 0xC3, 0xFC, 0xF3, 0xFE, 0x7F, 0xEF, 0x7F, 0xEF, 0xFE, 0xF4,
  0x3E, 0xC3, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0x3F, 0x01, 0xE1, 0xFF, 0x83,
  0xCF, 0xFF, 0xC7, 0x9F, 0xFF, 0xCF, 0x70, 0x3F, 0x9E, 0x80, 0x1F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x1F, 0xFC, 0x0F, 0x9F, 0xFF, 0x83,
  0xEF, 0xFF, 0xF0, 0xFB, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F,
  0x80, 0x0F, 0xCF, 0xB8, 0x0F, 0xE3, 0xEF, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8,
  0x3E, 0x1F, 0xFC, 0x0F, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF1, 0xF0, 0x7F,
  0xFE, 0x7C, 0x3F, 0xFF, 0xDF, 0x1F, 0xE0, 0x77, 0xC7, 0xE0, 0x07, 0xF3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xFE, 0x07, 0x7C, 0x3F, 0xFF, 0xDF, 0x07,
  0xFF, 0xE7, 0xC0, 0xFF, 0xF1, 0xF0, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x7D, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0x80, 0x7F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x10, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF2,
  0x00, 0x00, 0x7C, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBF, 0x80, 0x03,
  0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF,
  0x9F, 0x07, 0xFF, 0x1F, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x03,
  0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x3D, 0xC0, 0x3B, 0x80, 0xF7, 0x81, 0xEE, 0x03, 0x9E,
  0x07, 0x38, 0x0E, 0x78, 0x1C, 0xE0, 0x79, 0xE0, 0x73, 0xC1, 0xE7, 0x81,
  0xCF, 0x07, 0x9E, 0x0F, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x78, 0xF0, 0xE1,
  0xC1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x38,
  0xF0, 0xF1, 0xC0, 0xE3, 0xC1, 0xC7, 0x03, 0x8F, 0x07, 0x1C, 0x0F, 0x38,
  0x1E, 0x70, 0x3C, 0xE0, 0x7B, 0xC0, 0x73, 0x81, 0xEE, 0x01, 0xCE, 0x07,
  0xB8, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x60, 0xFF, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0xF1, 0xFF, 0xC0,
  0x0F, 0x3E, 0x3E, 0x00, 0xE3, 0xC1, 0xF0, 0x1E, 0x78, 0x0F, 0x81, 0xE7,
  0x80, 0xF8, 0x3C, 0x70, 0x07, 0xE7, 0xCF, 0x00, 0x3F, 0xF8, 0xF0, 0x01,
  0xFF, 0x8F, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 41, 34, 13, -40 },
  { 42, 14, 16, 34, 10, -42 },
  { 70, 32, 40, 34, 1, -40 },
  { 230, 28, 53, 34, 3, -46 },
  { 416, 32, 41, 34, 1, -40 },
  { 580, 32, 41, 34, 1, -40 },
  { 744, 4, 16, 34, 15, -42 },
  { 752, 16, 51, 34, 12, -43 },
  { 854, 17, 51, 34, 6, -43 },
  { 963, 30, 28, 34, 2, -32 },
  { 1068, 27, 28, 34, 4, -31 },
  { 1163, 10, 16, 34, 12, -8 },
  { 1183, 16, 4, 34, 9, -19 },
  { 1191, 8, 8, 34, 13, -7 },
  { 1199, 24, 51, 34, 5, -43 },
  { 1352, 28, 41, 34, 3, -40 },
  { 1496, 29, 40, 34, 3, -40 },
  { 1641, 27, 40, 34, 4, -40 },
  { 1776, 27, 41, 34, 3, -40 },
  { 1915, 30, 40, 34, 2, -40 },
  { 2065, 26, 41, 34, 4, -40 },
  { 2199, 27, 41, 34, 4, -40 },
  { 2338, 26, 40, 34, 4, -40 },
  { 2468, 28, 41, 34, 3, -40 },
  { 2612, 27, 40, 34, 4, -40 },
  { 2747, 8, 31, 34, 13, -30 },
  { 2778, 10, 38, 34, 12, -30 },
  { 2826, 24, 33, 34, 5, -34 },
  { 2925, 27, 15, 34, 4, -25 },
  { 2976, 24, 33, 34, 5, -34 },
  { 3075, 25, 41, 34, 4, -40 },
  { 3204, 26, 46, 34, 4, -40 },
  { 3354, 30, 40, 34, 2, -40 },
  { 3504, 26, 40, 34, 5, -40 },
  { 3634, 27, 41, 34, 4, -40 },
  { 3773, 26, 40, 34, 5, -40 },
  { 3903, 25, 40, 34, 5, -40 },
  { 4028, 25, 40, 34, 5, -40 },
  { 4153, 27, 41, 34, 3, -40 },
  { 4292, 25, 40, 34, 5, -40 },
  { 4417, 24, 40, 34, 5, -40 },
  { 4537, 23, 41, 34, 4, -40 },
  { 4655, 28, 40, 34, 5, -40 },
  { 4795, 24, 40, 34, 7, -40 },
  { 4915, 26, 40, 34, 4, -40 },
  { 5045, 25, 40, 34, 5, -40 },
  { 5170, 28, 41, 34, 3, -40 },
  { 5314, 26, 40, 34, 5, -40 },
  { 5444, 28, 50, 34, 3, -40 },
  { 5619, 26, 40, 34, 5, -40 },
  { 5749, 28, 41, 34, 3, -40 },
  { 5893, 32, 40, 34, 1, -40 },
  { 6053, 25, 41, 34, 5, -40 },
  { 6182, 30, 40, 34, 2, -40 },
  { 6332, 30, 40, 34, 2, -40 },
  { 6482, 32, 40, 34, 1, -40 },
  { 6642, 32, 40, 34, 1, -40 },
  { 6802, 28, 40, 34, 3, -40 },
  { 6942, 16, 51, 34, 13, -43 },
  { 7044, 24, 51, 34, 5, -43 },
  { 7197, 16, 51, 34, 5, -43 },
  { 7299, 29, 23, 34, 3, -40 },
  { 7383, 28, 4, 34, 3, 6 },
  { 7397, 9, 11, 34, 11, -44 },
  { 7410, 27, 31, 34, 4, -30 },
  { 7515, 26, 43, 34, 5, -42 },
  { 7655, 24, 31, 34, 5, -30 },
  { 7748, 26, 43, 34, 3, -42 },
  { 7888, 26, 31, 34, 4, -30 },
  { 7989, 27, 42, 34, 4, -42 },
  { 8131, 28, 45, 34, 4, -33 },
  { 8289, 23, 42, 34, 6, -42 },
  { 8410, 25, 43, 34, 6, -43 },
  { 8545, 21, 54, 34, 5, -43 },
  { 8687, 27, 42, 34, 6, -42 },
  { 8829, 25, 42, 34, 5, -42 },
  { 8961, 28, 30, 34, 3, -30 },
  { 9066, 23, 30, 34, 6, -30 },
  { 9153, 26, 31, 34, 4, -30 },
  { 9254, 26, 41, 34, 5, -30 },
  { 9388, 26, 41, 34, 3, -30 },
  { 9522, 28, 29, 34, 4, -29 },
  { 9624, 26, 31, 34, 4, -30 },
  { 9725, 28, 40, 34, 2, -40 },
  { 9865, 24, 30, 34, 5, -29 },
  { 9955, 27, 29, 34, 4, -29 },
  { 10053, 30, 29, 34, 2, -29 },
  { 10162, 28, 29, 34, 3, -29 },
  { 10264, 28, 40, 34, 3, -29 },
  { 10404, 24, 29, 34, 5, -29 },
  { 10491, 22, 51, 34, 6, -43 },
  { 10632, 4, 51, 34, 15, -43 },
  { 10658, 22, 51, 34, 6, -43 },
  { 10799, 28, 13, 34, 3, -24 },
};

const GFXfont IBMPlexMono_Regular57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_REGULAR57PT7B_H_
