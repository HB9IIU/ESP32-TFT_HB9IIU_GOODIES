#ifndef _IBMPLEXMONO_REGULAR9PT7B_H_
#define _IBMPLEXMONO_REGULAR9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x36, 0xD4, 0xAD, 0xB0, 0x23, 0xAA, 0xC1, 0xD5, 0xC4,
  0xED, 0xBC, 0xB6, 0xCC, 0x62, 0x93, 0x69, 0x34, 0xC0, 0x6A, 0xA9, 0x89,
  0x12, 0x94, 0x25, 0x5C, 0xA0, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x32,
  0x24, 0x48, 0x88, 0x72, 0x63, 0x54, 0xB8, 0x23, 0x28, 0x42, 0x3C, 0xE9,
  0x26, 0x8F, 0x74, 0x4C, 0x38, 0xB8, 0x11, 0x95, 0x2F, 0x88, 0xF8, 0xE9,
  0x9E, 0x68, 0xE9, 0x9E, 0xFA, 0x24, 0x44, 0x74, 0x5D, 0x98, 0xB8, 0xE9,
  0x9F, 0x24, 0x88, 0x8C, 0x16, 0x84, 0x30, 0xF0, 0xF0, 0x84, 0x36, 0x80,
  0x69, 0x24, 0x04, 0xE9, 0xFD, 0xF8, 0xE0, 0x22, 0x94, 0xA7, 0xC4, 0xE9,
  0xE9, 0x9E, 0xE9, 0x88, 0x9E, 0xE9, 0x99, 0x9E, 0xF8, 0xF8, 0x8F, 0xF8,
  0xF8, 0x88, 0x72, 0x61, 0x34, 0xBC, 0x99, 0xF9, 0x99, 0xF4, 0x44, 0x4F,
  0xE4, 0x9B, 0xC0, 0x9A, 0xCA, 0xA9, 0x88, 0x88, 0x8F, 0x9B, 0xDD, 0x99,
  0x99, 0xDD, 0xBB, 0x72, 0x63, 0x14, 0xB8, 0xE9, 0x9E, 0x88, 0x72, 0x63,
  0x14, 0xB8, 0x82, 0xE9, 0x9E, 0xA9, 0x74, 0x58, 0x38, 0xB8, 0xF9, 0x08,
  0x42, 0x10, 0x99, 0x99, 0x9E, 0x8A, 0x54, 0xA5, 0x10, 0x8C, 0x6B, 0x7D,
  0xAC, 0xCA, 0x88, 0x65, 0x44, 0x8A, 0x94, 0x42, 0x10, 0x78, 0x88, 0x44,
  0x7C, 0xF2, 0x49, 0x27, 0x88, 0x84, 0x42, 0x23, 0xD5, 0x57, 0x22, 0x95,
  0x10, 0xF0, 0xC0, 0xEA, 0xEA, 0xD0, 0x88, 0xE9, 0x99, 0xE0, 0xEB, 0x89,
  0xE0, 0x11, 0xDB, 0x99, 0xF0, 0xE9, 0xF8, 0xF0, 0x74, 0xF4, 0x44, 0xF0,
  0x1E, 0xAE, 0x8F, 0x9F, 0x88, 0xE9, 0x99, 0x90, 0x60, 0xC4, 0x44, 0xF0,
  0x23, 0x92, 0x49, 0xE0, 0x88, 0xBC, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0,
  0xBF, 0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9, 0x99,
  0xE8, 0x80, 0xDB, 0x99, 0xF1, 0x10, 0xF4, 0x44, 0xF0, 0xE9, 0xE1, 0xE0,
  0x27, 0xC8, 0x42, 0x1C, 0x99, 0x99, 0xF0, 0x9A, 0xAA, 0x40, 0xAD, 0x77,
  0xB5, 0x00, 0xBA, 0x4A, 0x90, 0x8A, 0x94, 0xA2, 0x11, 0x00, 0xF2, 0x48,
  0xF0, 0x69, 0x72, 0x93, 0xFF, 0xC9, 0x14, 0x96, 0x6C, 0x80,
};

const GFXglyph IBMPlexMono_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -7 },
  { 21, 2, 8, 5, 2, -7 },
  { 23, 3, 8, 5, 1, -7 },
  { 26, 5, 4, 5, 0, -5 },
  { 29, 4, 5, 5, 1, -5 },
  { 32, 1, 2, 5, 2, -1 },
  { 33, 3, 1, 5, 1, -3 },
  { 34, 1, 1, 5, 2, -1 },
  { 35, 4, 8, 5, 1, -7 },
  { 39, 5, 6, 5, 0, -6 },
  { 43, 5, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 1, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 5, 6, 5, 0, -6 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 1, 5, 5, 2, -5 },
  { 75, 1, 6, 5, 2, -5 },
  { 76, 4, 5, 5, 1, -5 },
  { 79, 4, 3, 5, 1, -4 },
  { 81, 4, 5, 5, 1, -5 },
  { 84, 4, 6, 5, 1, -6 },
  { 87, 4, 7, 5, 1, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 1, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 5, 8, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 3, 8, 5, 2, -7 },
  { 184, 4, 8, 5, 1, -7 },
  { 188, 2, 8, 5, 1, -7 },
  { 190, 5, 4, 5, 0, -6 },
  { 193, 4, 1, 5, 1, 1 },
  { 194, 1, 2, 5, 2, -8 },
  { 195, 4, 5, 5, 1, -5 },
  { 198, 4, 7, 5, 1, -7 },
  { 202, 4, 5, 5, 1, -5 },
  { 205, 4, 7, 5, 1, -7 },
  { 209, 4, 5, 5, 1, -5 },
  { 212, 4, 7, 5, 1, -7 },
  { 216, 4, 8, 5, 1, -6 },
  { 220, 4, 7, 5, 1, -7 },
  { 224, 4, 7, 5, 1, -7 },
  { 228, 3, 9, 5, 1, -7 },
  { 232, 4, 7, 5, 1, -7 },
  { 236, 4, 7, 5, 1, -7 },
  { 240, 5, 5, 5, 0, -5 },
  { 244, 4, 5, 5, 1, -5 },
  { 247, 4, 5, 5, 1, -5 },
  { 250, 4, 7, 5, 1, -5 },
  { 254, 4, 7, 5, 1, -5 },
  { 258, 4, 5, 5, 1, -5 },
  { 261, 4, 5, 5, 1, -5 },
  { 264, 5, 6, 5, 0, -6 },
  { 268, 4, 5, 5, 1, -5 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 5, 5, 5, 0, -5 },
  { 278, 4, 5, 5, 1, -5 },
  { 281, 5, 7, 5, 0, -5 },
  { 286, 4, 5, 5, 1, -5 },
  { 289, 3, 8, 5, 1, -7 },
  { 292, 1, 8, 5, 2, -7 },
  { 293, 3, 8, 5, 1, -7 },
  { 296, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_Regular9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_REGULAR9PT7B_H_
