#ifndef _IBMPLEXMONO_REGULAR61PT7B_H_
#define _IBMPLEXMONO_REGULAR61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xC0, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x0F, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xFC, 0x07,
  0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xCF, 0x3F, 0xE0, 0xFC, 0x1E, 0x0F, 0xE1, 0xF0, 0x3C, 0x0F, 0xC7, 0xC0,
  0x78, 0x0F, 0x0F, 0x80, 0xF0, 0x0C, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x01, 0xE1, 0xFC,
  0x00, 0x03, 0xC0, 0xFC, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x10, 0x03, 0xC0, 0x7C, 0x70,
  0x07, 0x80, 0xF9, 0xF0, 0x0F, 0x03, 0xF7, 0xF0, 0x1E, 0x07, 0xC7, 0xF8,
  0x3C, 0x3F, 0x87, 0xFE, 0x79, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xE1, 0xFF, 0xC0, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x1E, 0x1F, 0xFF,
  0xC0, 0x07, 0xC7, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x3E, 0x1E,
  0x00, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x3C,
  0x1E, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x0F, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x00,
  0xF0, 0xF8, 0x03, 0xE0, 0x3E, 0x1E, 0x00, 0x7E, 0x0F, 0x87, 0xC0, 0x07,
  0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0xFC, 0x20, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0x87, 0xFF, 0xE0, 0x01, 0xE0, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xF0, 0x1F, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF8, 0x1E,
  0x00, 0x78, 0x1E, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0xF0,
  0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0x07, 0x8F, 0x80, 0x1F, 0x01, 0xE1,
  0xE0, 0x01, 0xF0, 0x7C, 0x7C, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x03, 0xFF,
  0xE3, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0x7E, 0x03,
  0xFE, 0x3E, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xF0, 0x1F, 0x01, 0xF0,
  0x78, 0x1F, 0x00, 0x7C, 0x3C, 0x0F, 0x80, 0x1F, 0x1E, 0x07, 0xC0, 0x0F,
  0xCF, 0x03, 0xE0, 0x03, 0xF7, 0x81, 0xF0, 0x00, 0xFB, 0x80, 0xF8, 0x00,
  0x3F, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xDF, 0x81, 0xF8,
  0x00, 0xE7, 0xE0, 0x7F, 0x01, 0xE1, 0xF8, 0x1F, 0xFF, 0xF0, 0x7E, 0x07,
  0xFF, 0xF0, 0x1F, 0x81, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x80, 0x0F, 0x80, 0x0B, 0xE0, 0x1F, 0x00, 0xF7, 0xF8, 0x3E,
  0x0F, 0xEF, 0xFE, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x38, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x03, 0xF8, 0x1F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x03,
  0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x04,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x7C, 0x0C, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x84, 0x00, 0x00, 0x7C, 0x70,
  0x00, 0x07, 0xE7, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x7F, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x78, 0xFF, 0xFE,
  0x03, 0xCF, 0xFF, 0xF8, 0x1E, 0xF0, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xFC, 0x04, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x84, 0x00, 0x00, 0x7C, 0x30, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x3E, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0x0F, 0xFF,
  0x00, 0xF9, 0xFF, 0xFE, 0x07, 0xDF, 0xFF, 0xF8, 0x7D, 0xF0, 0x1F, 0xE3,
  0xEE, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7F,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0xF7, 0xC3,
  0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x1F, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x0F, 0x83, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xE0, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1F, 0x78, 0x01, 0xF0, 0xF7, 0x80, 0x7F, 0x8F, 0xF8, 0x0F,
  0xFC, 0xFF, 0x81, 0xFF, 0xEF, 0xF8, 0x1F, 0x06, 0xFF, 0x03, 0xE0, 0x1F,
  0xF0, 0x3C, 0x01, 0xFF, 0x03, 0xC0, 0x0F, 0xF0, 0x7C, 0x00, 0xFF, 0x07,
  0xC0, 0x0F, 0xF0, 0x7C, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xF0, 0x7C, 0x00,
  0xFF, 0x07, 0xC0, 0x0F, 0xF0, 0x7C, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xF0,
  0x7C, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xF0, 0x3C, 0x00, 0xFF, 0x03, 0xE0,
  0x1F, 0xF0, 0x3E, 0x03, 0xFF, 0x81, 0xFC, 0x6F, 0xF8, 0x1F, 0xFE, 0xF7,
  0x80, 0xFF, 0xCF, 0x78, 0x07, 0xF8, 0xF7, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00,
  0x20, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x04,
  0x0F, 0x80, 0x00, 0x38, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x7F,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x20, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x1B, 0xE0, 0xFE, 0x07, 0xDF, 0x07, 0xFF, 0xFC, 0xF8,
  0x1F, 0xFF, 0xC7, 0xC0, 0x3F, 0xFC, 0x3E, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x1F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x3F, 0xC0, 0x00,
  0xF9, 0xFF, 0x00, 0x03, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x3F,
  0xF3, 0xF0, 0x00, 0xFF, 0x87, 0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x0F, 0xF0,
  0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFB, 0xC0, 0x1E, 0xFF, 0xBC, 0x03, 0xEF, 0xFB, 0xE0,
  0x3C, 0xFF, 0x9E, 0x03, 0xCF, 0xF9, 0xF0, 0x78, 0xFF, 0x8F, 0x07, 0x8F,
  0xF8, 0xF0, 0xF8, 0xFF, 0x8F, 0x8F, 0x0F, 0xF8, 0x78, 0xF0, 0xFF, 0x87,
  0xDE, 0x0F, 0xF8, 0x3D, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8,
  0x0F, 0x80, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x07, 0x00, 0xFF, 0x80, 0x60,
  0x0F, 0xF8, 0x02, 0x00, 0xFF, 0x80, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xE0, 0x03,
  0xFF, 0x7C, 0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0x9F,
  0x00, 0x3F, 0xF1, 0xF0, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0xC7, 0xC0, 0x1F,
  0xF8, 0x7C, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x1F,
  0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF,
  0xC0, 0x7C, 0x1F, 0xF8, 0x0F, 0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x1F,
  0x0F, 0xFC, 0x03, 0xE1, 0xFF, 0x80, 0x3E, 0x3F, 0xF0, 0x07, 0xC7, 0xFE,
  0x00, 0xF8, 0xFF, 0xC0, 0x0F, 0x9F, 0xF8, 0x01, 0xF3, 0xFF, 0x00, 0x1F,
  0x7F, 0xE0, 0x03, 0xEF, 0xFC, 0x00, 0x7D, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7E, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x61,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF1, 0x00, 0x00,
  0x0F, 0xDE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x07,
  0xE7, 0xF8, 0x00, 0x7F, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xFE, 0x03, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x1F, 0x7C, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xF0, 0x1E, 0x7C, 0x07,
  0xF0, 0x1E, 0x7C, 0x07, 0xF0, 0x1E, 0x7C, 0x07, 0xF0, 0x1E, 0x7C, 0x0F,
  0xF0, 0x1E, 0x3C, 0x0F, 0x78, 0x1E, 0x3C, 0x0F, 0x78, 0x1E, 0x3C, 0x0F,
  0x78, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x78, 0x3E, 0x3C, 0x1E,
  0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C,
  0x1E, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x78,
  0x1F, 0x3C, 0x1E, 0x78, 0x0F, 0x3C, 0x1E, 0x78, 0x0F, 0x3C, 0x1E, 0x78,
  0x0F, 0x3C, 0x1E, 0xF0, 0x0F, 0x7C, 0x1E, 0xF0, 0x0F, 0xFC, 0x1E, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x30,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x0F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x04, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x06,
  0x00, 0x03, 0xE0, 0x10, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x0D, 0xE0, 0x7F, 0x01, 0xF7, 0xFC, 0xFF, 0xFF,
  0x9F, 0xF1, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xE0, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0x80,
  0x3E, 0x1F, 0xFE, 0x07, 0xCF, 0xFF, 0xE0, 0xFB, 0xFF, 0xFE, 0x1F, 0x70,
  0x1F, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0x70, 0x1F, 0xE3, 0xEF,
  0xFF, 0xF8, 0x7C, 0xFF, 0xFE, 0x0F, 0x87, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x02, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x0F, 0x80,
  0x00, 0xF3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x3F, 0x81,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xFE, 0x07,
  0xC0, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0x1F, 0x0F, 0xFF, 0xF3, 0xE3, 0xFC,
  0x0F, 0x7C, 0xFE, 0x00, 0x7F, 0x9F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xF9, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x0F, 0x7C, 0x3F,
  0xFF, 0xCF, 0x83, 0xFF, 0xF1, 0xF0, 0x3F, 0xFC, 0x3E, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x81, 0xF0, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0xFE, 0x03, 0xE1, 0xFF, 0xC1, 0xF3, 0xFF, 0xF0, 0xFB,
  0xFF, 0xFC, 0x7D, 0xC0, 0x7F, 0x3F, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x81,
  0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x7C, 0x03, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3E, 0x3F, 0x80, 0x01, 0xF3, 0xFE, 0x00, 0x0F, 0xBF, 0xF0, 0x00,
  0x7F, 0xEF, 0xC0, 0x03, 0xFE, 0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xE3, 0xE7,
  0xF8, 0x7F, 0xCF, 0xBF, 0xF3, 0xFF, 0xBE, 0xFF, 0xCF, 0xFE, 0xFE, 0x1F,
  0xF0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0,
  0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03,
  0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF,
  0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07,
  0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0,
  0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03,
  0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF,
  0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0xC0, 0x7C, 0x3F,
  0xF8, 0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xB8, 0x0F, 0xE7, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0x0F, 0xFF, 0x03, 0xE7, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF,
  0x0F, 0xB8, 0x0F, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xB8, 0x0F,
  0xF1, 0xF7, 0xFF, 0xFC, 0x3E, 0x7F, 0xFF, 0x07, 0xC3, 0xFF, 0xC0, 0xF8,
  0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x1F,
  0xFF, 0x8F, 0x87, 0xFF, 0xF9, 0xF1, 0xFE, 0x07, 0xBE, 0x7F, 0x00, 0x3F,
  0xCF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x07, 0xBE, 0x1F, 0xFF, 0xE7, 0xC1, 0xFF, 0xF8,
  0xF8, 0x1F, 0xFE, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xC3, 0xE0, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x10, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x1B, 0xEF, 0xF0, 0x3D, 0xF3, 0xFF, 0xFC, 0xF8, 0xFF,
  0xFC, 0x7C, 0x1F, 0xFC, 0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x78, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x01, 0xFC,
  0x03, 0xDF, 0x00, 0xFE, 0x01, 0xE7, 0x80, 0x7F, 0x00, 0xF3, 0xC0, 0x3B,
  0x80, 0x79, 0xE0, 0x3D, 0xC0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x0E,
  0x78, 0x1E, 0x3C, 0x07, 0x3C, 0x0F, 0x1F, 0x03, 0x8E, 0x07, 0x87, 0x83,
  0xC7, 0x03, 0xC3, 0xC1, 0xE3, 0xC1, 0xE1, 0xE0, 0xE1, 0xE0, 0xF0, 0xF0,
  0x70, 0xF0, 0x78, 0x78, 0x38, 0x38, 0x78, 0x3C, 0x3C, 0x1C, 0x3C, 0x0E,
  0x1E, 0x0F, 0x1E, 0x07, 0x8E, 0x07, 0x8F, 0x03, 0xC7, 0x03, 0xC7, 0x81,
  0xE3, 0x80, 0xE3, 0xC0, 0xF3, 0xC0, 0x71, 0xC0, 0x79, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x1E, 0xF0, 0x0E, 0x70, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xBC,
  0x03, 0xFC, 0x01, 0xDE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x1F, 0xE0, 0x00, 0xF0,
  0xFF, 0xC0, 0x03, 0xC7, 0xFF, 0x80, 0x0F, 0x1E, 0x1F, 0x00, 0x3C, 0xF0,
  0x3E, 0x01, 0xE3, 0xC0, 0x7C, 0x07, 0x9E, 0x00, 0xF8, 0x3E, 0x78, 0x03,
  0xF1, 0xF1, 0xE0, 0x07, 0xFF, 0x8F, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x1F,
  0xF0, 0x30, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 9, 44, 37, 14, -43 },
  { 51, 15, 17, 37, 11, -45 },
  { 83, 35, 43, 37, 1, -43 },
  { 272, 31, 56, 37, 3, -49 },
  { 489, 35, 44, 37, 1, -43 },
  { 682, 33, 44, 37, 2, -43 },
  { 864, 5, 17, 37, 16, -45 },
  { 875, 18, 54, 37, 12, -46 },
  { 997, 18, 54, 37, 6, -46 },
  { 1119, 31, 30, 37, 3, -35 },
  { 1236, 29, 30, 37, 4, -34 },
  { 1345, 12, 17, 37, 12, -8 },
  { 1371, 18, 5, 37, 9, -21 },
  { 1383, 9, 8, 37, 14, -7 },
  { 1392, 26, 54, 37, 5, -46 },
  { 1568, 30, 44, 37, 3, -43 },
  { 1733, 31, 43, 37, 3, -43 },
  { 1900, 29, 43, 37, 4, -43 },
  { 2056, 29, 44, 37, 3, -43 },
  { 2216, 32, 43, 37, 2, -43 },
  { 2388, 29, 44, 37, 4, -43 },
  { 2548, 29, 44, 37, 4, -43 },
  { 2708, 28, 43, 37, 4, -43 },
  { 2859, 30, 44, 37, 3, -43 },
  { 3024, 29, 43, 37, 4, -43 },
  { 3180, 9, 32, 37, 14, -31 },
  { 3216, 12, 40, 37, 12, -31 },
  { 3276, 26, 35, 37, 5, -36 },
  { 3390, 29, 16, 37, 4, -27 },
  { 3448, 26, 35, 37, 5, -36 },
  { 3562, 26, 44, 37, 5, -43 },
  { 3705, 28, 50, 37, 4, -43 },
  { 3880, 33, 43, 37, 2, -43 },
  { 4058, 28, 43, 37, 5, -43 },
  { 4209, 29, 44, 37, 4, -43 },
  { 4369, 27, 43, 37, 6, -43 },
  { 4515, 27, 43, 37, 5, -43 },
  { 4661, 27, 43, 37, 5, -43 },
  { 4807, 29, 44, 37, 3, -43 },
  { 4967, 27, 43, 37, 5, -43 },
  { 5113, 26, 43, 37, 5, -43 },
  { 5253, 24, 44, 37, 5, -43 },
  { 5385, 30, 43, 37, 5, -43 },
  { 5547, 26, 43, 37, 7, -43 },
  { 5687, 28, 43, 37, 4, -43 },
  { 5838, 27, 43, 37, 5, -43 },
  { 5984, 30, 44, 37, 3, -43 },
  { 6149, 28, 43, 37, 5, -43 },
  { 6300, 30, 53, 37, 3, -43 },
  { 6499, 28, 43, 37, 5, -43 },
  { 6650, 30, 44, 37, 3, -43 },
  { 6815, 33, 43, 37, 2, -43 },
  { 6993, 27, 44, 37, 5, -43 },
  { 7142, 32, 43, 37, 2, -43 },
  { 7314, 32, 43, 37, 2, -43 },
  { 7486, 33, 43, 37, 2, -43 },
  { 7664, 35, 43, 37, 1, -43 },
  { 7853, 31, 43, 37, 3, -43 },
  { 8020, 17, 54, 37, 14, -46 },
  { 8135, 26, 54, 37, 5, -46 },
  { 8311, 17, 54, 37, 6, -46 },
  { 8426, 31, 25, 37, 3, -43 },
  { 8523, 29, 4, 37, 4, 6 },
  { 8538, 10, 12, 37, 11, -48 },
  { 8553, 30, 33, 37, 4, -32 },
  { 8677, 27, 46, 37, 6, -45 },
  { 8833, 26, 33, 37, 5, -32 },
  { 8941, 27, 46, 37, 4, -45 },
  { 9097, 29, 33, 37, 4, -32 },
  { 9217, 29, 45, 37, 4, -45 },
  { 9381, 30, 48, 37, 4, -35 },
  { 9561, 25, 45, 37, 6, -45 },
  { 9702, 27, 45, 37, 6, -45 },
  { 9854, 22, 57, 37, 6, -45 },
  { 10011, 29, 45, 37, 6, -45 },
  { 10175, 27, 45, 37, 5, -45 },
  { 10327, 30, 32, 37, 3, -32 },
  { 10447, 25, 32, 37, 6, -32 },
  { 10547, 29, 33, 37, 4, -32 },
  { 10667, 27, 44, 37, 6, -32 },
  { 10816, 27, 44, 37, 4, -32 },
  { 10965, 29, 31, 37, 5, -31 },
  { 11078, 28, 33, 37, 4, -32 },
  { 11194, 30, 43, 37, 2, -43 },
  { 11356, 25, 32, 37, 6, -31 },
  { 11456, 29, 31, 37, 4, -31 },
  { 11569, 33, 31, 37, 2, -31 },
  { 11697, 29, 31, 37, 4, -31 },
  { 11810, 30, 43, 37, 3, -31 },
  { 11972, 26, 31, 37, 5, -31 },
  { 12073, 24, 54, 37, 6, -46 },
  { 12235, 4, 54, 37, 16, -46 },
  { 12262, 24, 54, 37, 6, -46 },
  { 12424, 30, 13, 37, 3, -25 },
};

const GFXfont IBMPlexMono_Regular61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_REGULAR61PT7B_H_
