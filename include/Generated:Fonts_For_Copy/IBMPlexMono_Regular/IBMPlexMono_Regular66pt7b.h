#ifndef _IBMPLEXMONO_REGULAR66PT7B_H_
#define _IBMPLEXMONO_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xF0,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x9E, 0x3F, 0xE0,
  0xFF, 0x0F, 0x07, 0xF8, 0x7E, 0x07, 0x80, 0xFE, 0x7E, 0x03, 0xC0, 0x3E,
  0x3F, 0x01, 0xE0, 0x0E, 0x1F, 0x80, 0xF0, 0x04, 0x0F, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0xFC, 0x07, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x3C, 0x0F, 0xE0, 0x00,
  0x1E, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x78, 0x03, 0xE2, 0x00, 0x3C, 0x01, 0xF1, 0x80, 0x1E, 0x00, 0xF9,
  0xE0, 0x0F, 0x00, 0xFD, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0x03, 0xC0, 0x7E,
  0x3F, 0xC1, 0xE0, 0xFF, 0x0F, 0xFC, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC7, 0xFF, 0xE0, 0x00, 0x3E,
  0x3F, 0xFF, 0x80, 0x03, 0xE3, 0xF0, 0x7C, 0x00, 0x1F, 0x3E, 0x01, 0xF0,
  0x01, 0xF1, 0xF0, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x7C, 0x03,
  0xC1, 0xF0, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x7C, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x3E, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x7C, 0x00, 0x3F, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xFE,
  0x00, 0x1E, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x0F, 0x81, 0xE0, 0x03, 0xC0,
  0x7C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x03, 0xC0,
  0x07, 0x83, 0xE0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x01, 0xE1, 0xF0,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x07,
  0xC7, 0x80, 0x07, 0xC0, 0x7C, 0x7C, 0x00, 0x3F, 0x07, 0xE3, 0xC0, 0x00,
  0xFF, 0xFE, 0x3E, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x20,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xE1, 0xFD, 0xFC, 0x03,
  0xFE, 0x3F, 0x8F, 0xC0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x7C, 0x07, 0xC0, 0x3F, 0x87, 0xC0, 0xFC, 0x01, 0xFC, 0x78, 0x0F,
  0xC0, 0x0F, 0xC7, 0x80, 0xF8, 0x00, 0x7E, 0x78, 0x0F, 0x80, 0x03, 0xF7,
  0x80, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x06, 0xFC, 0x07, 0xF0, 0x01, 0xE7,
  0xE0, 0x3F, 0xC0, 0x7E, 0x3F, 0x03, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x19, 0xF0, 0x0F, 0x80,
  0x3E, 0xFF, 0x83, 0xE0, 0x7F, 0xBF, 0xFC, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F,
  0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xBE, 0x00, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x0F,
  0xF0, 0xF8, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x01,
  0xFE, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x0F, 0x80, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x01, 0xF8, 0x08,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0x00, 0x00, 0x0F, 0xCF,
  0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x03, 0xC3, 0xFF, 0xE0, 0x0F,
  0x1F, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xC0, 0xF7, 0xFF, 0xFF, 0x83, 0xFE,
  0x03, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x10, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0xFC, 0x7F, 0xFC, 0x01, 0xF1,
  0xFF, 0xFE, 0x07, 0xE7, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFE, 0x1F, 0x7C,
  0x07, 0xFE, 0x3E, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xDF, 0x1F, 0xF0, 0x1F, 0x7E,
  0x1F, 0xFF, 0xFE, 0xF8, 0x3F, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0,
  0x1F, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1,
  0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xF0, 0x0F, 0xC1,
  0xFE, 0x3F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE1, 0xFE, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x70, 0x00, 0x03,
  0xF0, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x1F, 0x87, 0x9F, 0x00, 0xFF, 0x8F, 0xBE, 0x03, 0xFF,
  0x9F, 0x78, 0x07, 0xFF, 0xBE, 0xF0, 0x1F, 0xFF, 0x7F, 0xE0, 0x3F, 0x07,
  0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x81, 0xF0, 0x07, 0xFF, 0x03, 0xE0, 0x07,
  0xFE, 0x07, 0x80, 0x0F, 0xFC, 0x1F, 0x00, 0x1F, 0xF8, 0x3E, 0x00, 0x3F,
  0xF0, 0x7C, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0xFF, 0xC1, 0xF0, 0x01, 0xFF,
  0x83, 0xE0, 0x03, 0xFF, 0x07, 0xC0, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0xFC,
  0x1F, 0x00, 0x1F, 0xF8, 0x1E, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x7F, 0xE0,
  0x7C, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xF7, 0x80, 0xFE, 0x1F, 0xEF, 0x01,
  0xFF, 0xF7, 0xDF, 0x01, 0xFF, 0xEF, 0xBE, 0x01, 0xFF, 0x9F, 0x7C, 0x01,
  0xFE, 0x3E, 0x78, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0x8F, 0x80, 0x00, 0xFE, 0x3E, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0x8F, 0x80, 0x00,
  0x7F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0x87,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x1C, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xF0, 0xFF, 0x81, 0xF7, 0xC3, 0xFF, 0xFF,
  0xDF, 0x07, 0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0x87,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x84, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFC, 0xF8,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0xF8,
  0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0xF9,
  0xFF, 0x80, 0x00, 0xF9, 0xFF, 0x80, 0x00, 0xFB, 0xFF, 0xC0, 0x00, 0xFF,
  0xEF, 0xE0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0xF8,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xBF, 0xFB, 0xC0, 0x1F, 0x7F, 0xF7, 0xC0, 0x3E, 0xFF, 0xEF, 0x80,
  0x79, 0xFF, 0xCF, 0x81, 0xF3, 0xFF, 0x9F, 0x03, 0xC7, 0xFF, 0x1E, 0x0F,
  0x8F, 0xFE, 0x3E, 0x1F, 0x1F, 0xFC, 0x7C, 0x3C, 0x3F, 0xF8, 0x7C, 0xF8,
  0x7F, 0xF0, 0xF9, 0xE0, 0xFF, 0xE0, 0xF7, 0xC1, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x1F,
  0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0x7F, 0xF0, 0x0F, 0x00, 0xFF,
  0xE0, 0x1E, 0x01, 0xFF, 0xC0, 0x38, 0x03, 0xFF, 0x80, 0x30, 0x07, 0xFF,
  0x00, 0x40, 0x0F, 0xFE, 0x00, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0x7C, 0x00, 0x1F, 0xFB, 0xF0, 0x00, 0xFF, 0xCF,
  0x80, 0x07, 0xFE, 0x7C, 0x00, 0x3F, 0xF3, 0xF0, 0x01, 0xFF, 0x8F, 0x80,
  0x0F, 0xFC, 0x7E, 0x00, 0x7F, 0xE1, 0xF0, 0x03, 0xFF, 0x0F, 0x80, 0x1F,
  0xF8, 0x3E, 0x00, 0xFF, 0xC1, 0xF0, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0xF0,
  0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E,
  0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x3E, 0x07,
  0xFE, 0x00, 0xF8, 0x3F, 0xF0, 0x07, 0xC1, 0xFF, 0x80, 0x3F, 0x0F, 0xFC,
  0x00, 0xF8, 0x7F, 0xE0, 0x07, 0xE3, 0xFF, 0x00, 0x1F, 0x1F, 0xF8, 0x00,
  0xF8, 0xFF, 0xC0, 0x07, 0xE7, 0xFE, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0xFD,
  0xFF, 0x80, 0x03, 0xEF, 0xFC, 0x00, 0x1F, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x00, 0x3F, 0xCF,
  0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0xCF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x00, 0x3F,
  0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F,
  0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0E,
  0x0F, 0x80, 0x00, 0x02, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF1,
  0x00, 0x00, 0x01, 0xF8, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0xE0, 0x00, 0xFF,
  0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE0, 0xFF, 0x00, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x1F,
  0x80, 0x3C, 0xF8, 0x07, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0x01, 0xF1, 0xE0,
  0x1F, 0xE0, 0x3E, 0x3C, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x80, 0xF8,
  0xF8, 0x1F, 0xF0, 0x1F, 0x1F, 0x03, 0xDF, 0x03, 0xE3, 0xE0, 0x7B, 0xE0,
  0x7C, 0x7C, 0x0F, 0x3C, 0x0F, 0x8F, 0x83, 0xE7, 0x81, 0xF1, 0xF0, 0x7C,
  0xF0, 0x3C, 0x3E, 0x0F, 0x1F, 0x07, 0x87, 0xC1, 0xE3, 0xE0, 0xF0, 0xF8,
  0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x87, 0xC1, 0xE1, 0xF0, 0xF8, 0xF8,
  0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C,
  0x7C, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE7, 0x80, 0xF9, 0xF0, 0x7C, 0xF0,
  0x1F, 0x3E, 0x0F, 0x9E, 0x01, 0xE7, 0x81, 0xF7, 0xC0, 0x3C, 0xF0, 0x3E,
  0xF8, 0x07, 0x9E, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0xFB, 0xC0, 0x1F, 0x78,
  0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x03, 0xF1, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x07, 0x83, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x10, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x07, 0xE0, 0x08,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0D, 0xF0, 0x7F,
  0x80, 0x7D, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x0F, 0xFF, 0x80, 0xFC,
  0x7F, 0xFF, 0x03, 0xF3, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xF8, 0xFF, 0xE0, 0x3F, 0xE3,
  0xF7, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xC0, 0xFC,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x18, 0x7C, 0x00, 0x02, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x08, 0x7E, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x7E, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x03, 0xE0, 0x3F, 0xFC, 0x1F, 0x03,
  0xFF, 0xF8, 0xF8, 0x3F, 0xFF, 0xE7, 0xC3, 0xFF, 0xFF, 0x3E, 0x3F, 0xE0,
  0x3D, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x01, 0xEF, 0x87, 0xFF, 0xFE, 0x7C,
  0x1F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0x1F, 0x01, 0xFF, 0xE0, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x40, 0xFC, 0x00, 0x01, 0xC1,
  0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x7F, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3E, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0, 0xFC, 0x7F, 0xFE, 0x0F,
  0xCF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F, 0xDE, 0x07, 0xFC, 0xFF, 0x80,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x1F,
  0xC3, 0xE0, 0x00, 0x7F, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x00,
  0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0xFE, 0x00, 0x07,
  0xC3, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x3E,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xC0, 0x01, 0xFF,
  0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7F, 0x07, 0xC0, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00,
  0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x03, 0xF0, 0xF1, 0xFF, 0x0F, 0xFC, 0xF3, 0xFF, 0x0F, 0xFC, 0xF3,
  0xFF, 0x9F, 0xFE, 0xF7, 0xFF, 0xBF, 0xFE, 0xF6, 0x1F, 0xB8, 0x7E, 0xFC,
  0x0F, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0xC3,
  0xFF, 0xC0, 0xFC, 0x7F, 0xFE, 0x0F, 0xCF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF,
  0x8F, 0xDE, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0xFF,
  0xF8, 0x0F, 0xC7, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x3F,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x3F, 0x8F, 0xFE,
  0x03, 0xFE, 0x3F, 0x7F, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0x83, 0xF1, 0xFF,
  0xFC, 0x0F, 0xC3, 0xFF, 0xC0, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0x07, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xCF,
  0x8F, 0xF8, 0x0F, 0x7C, 0xFF, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFE, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x7B, 0xE1, 0xFF,
  0xFF, 0x9F, 0x07, 0xFF, 0xFC, 0xF8, 0x1F, 0xFF, 0xC7, 0xC0, 0x7F, 0xF8,
  0x3E, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81,
  0xFE, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x38, 0x3F,
  0x00, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x60, 0x00, 0x01,
  0xF9, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x3F,
  0x8F, 0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xF7, 0xF0, 0x01, 0xBE, 0x7F, 0x80, 0xF7, 0xCF, 0xFF, 0xFC,
  0xF8, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xE3, 0xE0, 0x7F, 0xF0, 0x7C, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1E,
  0xF8, 0x03, 0xF8, 0x01, 0xE7, 0x80, 0x3F, 0x80, 0x1E, 0x78, 0x03, 0xFC,
  0x03, 0xE7, 0x80, 0x3F, 0xC0, 0x3E, 0x7C, 0x03, 0xBC, 0x03, 0xE7, 0xC0,
  0x7B, 0xC0, 0x3C, 0x7C, 0x07, 0x9C, 0x03, 0xC7, 0xC0, 0x79, 0xE0, 0x3C,
  0x3C, 0x07, 0x9E, 0x03, 0xC3, 0xC0, 0x71, 0xE0, 0x7C, 0x3C, 0x0F, 0x1E,
  0x07, 0xC3, 0xC0, 0xF0, 0xE0, 0x7C, 0x3E, 0x0F, 0x0F, 0x07, 0x83, 0xE0,
  0xF0, 0xF0, 0x78, 0x1E, 0x0E, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x78,
  0x1E, 0x1E, 0x07, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x07,
  0x8F, 0x01, 0xF1, 0xE0, 0x78, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x00, 0xF3,
  0xC0, 0x38, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x01,
  0xDE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x01, 0xFE,
  0x00, 0x03, 0xC1, 0xFF, 0xC0, 0x01, 0xE1, 0xFF, 0xF0, 0x01, 0xF1, 0xFF,
  0xF8, 0x00, 0xF0, 0xF8, 0x7E, 0x00, 0x78, 0xF8, 0x1F, 0x80, 0x7C, 0x7C,
  0x07, 0xE0, 0x3E, 0x3C, 0x01, 0xF8, 0x3E, 0x3E, 0x00, 0xFE, 0x3F, 0x1F,
  0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xFF, 0x87,
  0xC0, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 47, 40, 15, -46 },
  { 60, 17, 18, 40, 11, -49 },
  { 99, 38, 46, 40, 1, -46 },
  { 318, 33, 62, 40, 3, -54 },
  { 574, 37, 48, 40, 1, -47 },
  { 796, 36, 48, 40, 2, -47 },
  { 1012, 5, 18, 40, 17, -49 },
  { 1024, 19, 59, 40, 14, -50 },
  { 1165, 19, 59, 40, 7, -50 },
  { 1306, 34, 33, 40, 3, -37 },
  { 1447, 32, 33, 40, 4, -37 },
  { 1579, 12, 18, 40, 13, -9 },
  { 1606, 19, 5, 40, 10, -23 },
  { 1618, 10, 9, 40, 15, -8 },
  { 1630, 28, 59, 40, 6, -50 },
  { 1837, 32, 48, 40, 4, -47 },
  { 2029, 34, 46, 40, 3, -46 },
  { 2225, 31, 47, 40, 4, -47 },
  { 2408, 31, 48, 40, 3, -47 },
  { 2594, 35, 46, 40, 2, -46 },
  { 2796, 30, 47, 40, 5, -46 },
  { 2973, 31, 47, 40, 4, -46 },
  { 3156, 31, 46, 40, 4, -46 },
  { 3335, 32, 48, 40, 4, -47 },
  { 3527, 31, 47, 40, 4, -47 },
  { 3710, 10, 35, 40, 15, -34 },
  { 3754, 12, 43, 40, 13, -34 },
  { 3819, 28, 38, 40, 6, -39 },
  { 3952, 32, 18, 40, 4, -29 },
  { 4024, 28, 38, 40, 6, -39 },
  { 4157, 29, 48, 40, 5, -47 },
  { 4331, 31, 54, 40, 4, -47 },
  { 4541, 36, 46, 40, 2, -46 },
  { 4748, 30, 46, 40, 6, -46 },
  { 4921, 31, 48, 40, 5, -47 },
  { 5107, 30, 46, 40, 6, -46 },
  { 5280, 28, 46, 40, 6, -46 },
  { 5441, 29, 46, 40, 6, -46 },
  { 5608, 30, 48, 40, 4, -47 },
  { 5788, 29, 46, 40, 5, -46 },
  { 5955, 28, 46, 40, 6, -46 },
  { 6116, 27, 47, 40, 5, -46 },
  { 6275, 32, 46, 40, 6, -46 },
  { 6459, 27, 46, 40, 8, -46 },
  { 6615, 31, 46, 40, 4, -46 },
  { 6794, 29, 46, 40, 5, -46 },
  { 6961, 32, 48, 40, 4, -47 },
  { 7153, 30, 46, 40, 6, -46 },
  { 7326, 32, 59, 40, 4, -47 },
  { 7562, 30, 46, 40, 6, -46 },
  { 7735, 33, 48, 40, 3, -47 },
  { 7933, 36, 46, 40, 2, -46 },
  { 8140, 29, 47, 40, 5, -46 },
  { 8311, 35, 46, 40, 2, -46 },
  { 8513, 35, 46, 40, 2, -46 },
  { 8715, 36, 46, 40, 2, -46 },
  { 8922, 37, 46, 40, 1, -46 },
  { 9135, 33, 46, 40, 3, -46 },
  { 9325, 18, 59, 40, 15, -50 },
  { 9458, 28, 59, 40, 6, -50 },
  { 9665, 19, 59, 40, 6, -50 },
  { 9806, 34, 27, 40, 3, -46 },
  { 9921, 32, 5, 40, 4, 6 },
  { 9941, 11, 13, 40, 12, -52 },
  { 9959, 32, 36, 40, 4, -35 },
  { 10103, 30, 50, 40, 6, -49 },
  { 10291, 28, 36, 40, 6, -35 },
  { 10417, 29, 50, 40, 4, -49 },
  { 10599, 31, 36, 40, 4, -35 },
  { 10739, 31, 49, 40, 5, -49 },
  { 10929, 33, 53, 40, 4, -39 },
  { 11148, 28, 49, 40, 6, -49 },
  { 11320, 29, 50, 40, 7, -50 },
  { 11502, 24, 63, 40, 6, -50 },
  { 11691, 31, 49, 40, 7, -49 },
  { 11881, 29, 49, 40, 5, -49 },
  { 12059, 32, 35, 40, 4, -35 },
  { 12199, 28, 35, 40, 6, -35 },
  { 12322, 31, 36, 40, 4, -35 },
  { 12462, 30, 48, 40, 6, -35 },
  { 12642, 29, 48, 40, 4, -35 },
  { 12816, 32, 34, 40, 5, -34 },
  { 12952, 31, 36, 40, 4, -35 },
  { 13092, 32, 46, 40, 3, -46 },
  { 13276, 27, 35, 40, 6, -34 },
  { 13395, 31, 34, 40, 4, -34 },
  { 13527, 36, 34, 40, 2, -34 },
  { 13680, 32, 34, 40, 4, -34 },
  { 13816, 33, 47, 40, 3, -34 },
  { 14010, 28, 34, 40, 6, -34 },
  { 14129, 26, 59, 40, 7, -50 },
  { 14321, 5, 59, 40, 17, -50 },
  { 14358, 26, 59, 40, 7, -50 },
  { 14550, 33, 15, 40, 3, -28 },
};

const GFXfont IBMPlexMono_Regular66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_REGULAR66PT7B_H_
