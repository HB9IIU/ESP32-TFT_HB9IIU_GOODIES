#ifndef _IBMPLEXMONO_REGULAR33PT7B_H_
#define _IBMPLEXMONO_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC4, 0x00,
  0x00, 0xFF, 0xFD, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC1, 0xFC, 0x7F, 0x7F, 0x1F, 0xC1, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x8E, 0x0F, 0xE3, 0xFB, 0xF0,
  0xFE, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07,
  0xF0, 0x1F, 0xFC, 0x39, 0x9E, 0x71, 0x87, 0x61, 0x82, 0xE1, 0x80, 0xE1,
  0x80, 0x61, 0x80, 0x71, 0x80, 0x7D, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x87, 0x01, 0x83, 0x01, 0x87, 0x41,
  0x87, 0xE1, 0x87, 0x79, 0x9E, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x3E, 0x00, 0xDF, 0xC0, 0x6E, 0x38, 0x3B, 0x06, 0x0C,
  0xC1, 0x87, 0x30, 0x71, 0x8C, 0x18, 0xE3, 0x06, 0x30, 0xE3, 0x9C, 0x1F,
  0xC6, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0x8F, 0xE0, 0xE7,
  0x1C, 0x31, 0x83, 0x18, 0xE0, 0xC6, 0x38, 0x33, 0x0E, 0x0D, 0xC1, 0x83,
  0x60, 0x71, 0xF8, 0x0F, 0xEC, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x01,
  0xC3, 0x80, 0xE0, 0x60, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x1F, 0x73, 0x87,
  0xD8, 0x71, 0x8E, 0x0E, 0x63, 0x83, 0x98, 0xE0, 0x7C, 0x38, 0x0F, 0x0E,
  0x01, 0xC3, 0x80, 0xF8, 0x78, 0x67, 0x0F, 0xF0, 0xE1, 0xF8, 0x3C, 0xFF,
  0xFF, 0xC0, 0x03, 0x83, 0x83, 0x83, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0xF0, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x03, 0x06, 0x0D, 0xF3, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x70, 0xE0, 0x70, 0x38, 0x10, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7D, 0xE7, 0x9C, 0x73,
  0x8E, 0x38, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xF0, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x70, 0x1C, 0x70, 0x0E,
  0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE3, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0x60, 0x06, 0x70, 0x0E, 0x70, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3D, 0xC0, 0x79, 0xC0, 0xF1, 0xC0,
  0xE1, 0xC0, 0x41, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xE0,
  0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x1C, 0xE0, 0x0E, 0x60, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xF1,
  0xE0, 0xF3, 0x80, 0xE2, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1D, 0x00, 0x3F, 0x00, 0xEF, 0x03, 0xC7,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0x70, 0x01, 0xDC, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x06, 0x1C,
  0x03, 0x87, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07,
  0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x73, 0xF0, 0x77, 0xF8, 0x78, 0x3C, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x20, 0x0E, 0xF0, 0x0E,
  0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x73, 0xF0, 0x6F, 0xF8, 0xF8, 0x3C, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x0E, 0x70, 0x0E, 0x38, 0x3C,
  0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x0E, 0x60, 0x0E,
  0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x0F, 0xF0,
  0x1F, 0xF0, 0x38, 0x1C, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0E, 0x78, 0x1E, 0x3F, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x3C, 0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0F, 0x78, 0x36,
  0x3F, 0xEE, 0x0F, 0xCE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x7F, 0xFE,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x78, 0x7B, 0xEF, 0x9E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x9E, 0x71, 0xCE, 0x38,
  0xE3, 0x00, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x30, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0xB8, 0x0E, 0xE0, 0x1D, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0,
  0xF1, 0x80, 0x67, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x73, 0xE3, 0xF7,
  0xC7, 0x1F, 0x9C, 0x1F, 0x38, 0x3E, 0x70, 0x7C, 0xE0, 0xF9, 0xC1, 0xF3,
  0x83, 0xE7, 0x07, 0xC6, 0x0F, 0x8F, 0xFB, 0x0F, 0xB6, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0x70, 0x01, 0xCC, 0x00,
  0x73, 0x80, 0x18, 0xE0, 0x0E, 0x18, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x30,
  0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x38, 0x07,
  0x0C, 0x01, 0xC7, 0x00, 0x31, 0xC0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x1C, 0xFF, 0xE1, 0xFF, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x19, 0xC0, 0x73, 0xFF, 0x87, 0xFF,
  0x8E, 0x03, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xEE, 0x03, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0xFC, 0x1C, 0x1E, 0x38, 0x0E, 0x30, 0x07, 0x70, 0x04, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x04, 0x30, 0x07,
  0x38, 0x0E, 0x1C, 0x1E, 0x0F, 0xFC, 0x07, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3,
  0x81, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x07, 0x9F,
  0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0x77, 0x00, 0xEC,
  0x01, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x1D,
  0xC0, 0x3B, 0x80, 0x73, 0xC3, 0x63, 0xFC, 0xC3, 0xF1, 0x80, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x7E, 0x01, 0xDC, 0x0E, 0x78, 0x78, 0xFF, 0xC0, 0xFC,
  0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x70, 0xE0,
  0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0xE7, 0x80, 0xE7, 0x00, 0xEF, 0x00, 0xFF,
  0x80, 0xFB, 0xC0, 0xF1, 0xC0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0,
  0x78, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xEC, 0x37, 0xEC, 0x37, 0xEE, 0x67, 0xE6, 0x67, 0xE7, 0xE7,
  0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xD8, 0x0F, 0x70,
  0x3C, 0xC0, 0xF3, 0x83, 0xCE, 0x0F, 0x18, 0x3C, 0x70, 0xF0, 0xC3, 0xC3,
  0x8F, 0x0E, 0x3C, 0x18, 0xF0, 0x73, 0xC0, 0xCF, 0x03, 0xBC, 0x0E, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3C,
  0x3C, 0x70, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x3C,
  0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00,
  0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B,
  0x80, 0xF7, 0xFF, 0xCF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x70, 0x1C, 0x70, 0x0E, 0x60,
  0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0xFF, 0xE1, 0xFF,
  0xF3, 0x80, 0xF7, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0xF7, 0xFF, 0xCF, 0xFE, 0x1C, 0x38, 0x38,
  0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC0, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x01,
  0xDC, 0x03, 0xB8, 0x03, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0x03, 0xC7,
  0x00, 0xF7, 0x00, 0x23, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xD8, 0x00, 0xFE, 0x00, 0xE7,
  0xC0, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0x70, 0x78, 0xFF,
  0xC0, 0xFC, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0x30, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x30, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x33, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1B, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x1E, 0x19, 0x87,
  0x86, 0x61, 0xE1, 0x98, 0x78, 0x66, 0x3E, 0x39, 0x8D, 0xCE, 0x73, 0x33,
  0x9C, 0xCC, 0xE7, 0x33, 0x39, 0xDC, 0xEC, 0x76, 0x1B, 0x0D, 0x86, 0xC3,
  0x61, 0xB0, 0xF8, 0x6C, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x03, 0xDC, 0x00, 0xE3, 0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x0E, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x1C, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xFC, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x1C,
  0x38, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x01,
  0xCE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xE6, 0x00, 0x73, 0x80, 0x70, 0xC0, 0x30,
  0x70, 0x38, 0x1C, 0x18, 0x0E, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0x7E,
  0x00, 0x19, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x67, 0x9C, 0x71, 0x8C,
  0x0F, 0xC0, 0x3F, 0xF0, 0x78, 0x78, 0x60, 0x18, 0x20, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x0F, 0xFC, 0x3F, 0xFC, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0x7C, 0x3F, 0xCF, 0x1F, 0x8F, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x73,
  0xF0, 0xEF, 0xF1, 0xF0, 0xF3, 0x80, 0x77, 0x00, 0xEE, 0x00, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE,
  0x01, 0xDF, 0x0F, 0x3B, 0xFC, 0x73, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0x83,
  0x9C, 0x07, 0xE0, 0x13, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x09, 0xC0, 0x73, 0x83, 0x87, 0xFC, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x87, 0xC7, 0x3F, 0xEE, 0x70, 0x7D, 0xC0, 0x7B, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3B, 0x00, 0x77, 0x01, 0xE7, 0x07, 0xCF, 0xFB, 0x87, 0xC7, 0x07, 0xE0,
  0x1F, 0xF8, 0x3C, 0x3C, 0x70, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x04,
  0x70, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x0F,
  0x81, 0xFE, 0x03, 0xFF, 0x03, 0xC3, 0xC1, 0x80, 0xE1, 0xC0, 0x30, 0xE0,
  0x18, 0x70, 0x0C, 0x38, 0x06, 0x0C, 0x07, 0x03, 0x87, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x8E, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0C, 0xE0, 0x1E, 0x7F,
  0xFE, 0x0F, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x39, 0xF0, 0xEF, 0xF3, 0xE1, 0xEE, 0x03, 0xB8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x6F, 0xFE, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x80,
  0xFF, 0x80, 0xF9, 0xC0, 0xF0, 0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xCE, 0x1C, 0xDF, 0x3E, 0xE3, 0xC7, 0xC3, 0x87, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xE7, 0xC3,
  0xBF, 0xCF, 0x87, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x70, 0x0C,
  0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x3C, 0x3C, 0x1F, 0xF8,
  0x07, 0xE0, 0xE7, 0xE1, 0xDF, 0xE3, 0xE1, 0xE7, 0x00, 0xEE, 0x01, 0xDC,
  0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xDC, 0x03, 0xBE, 0x1E, 0x77, 0xF8, 0xE7, 0xE1, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F,
  0x8E, 0x7F, 0xDC, 0xE0, 0xFB, 0x80, 0xF6, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x76, 0x00, 0xEE,
  0x03, 0xCE, 0x0F, 0x9F, 0xF7, 0x0F, 0x8E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFE, 0x3F, 0xFC, 0xFC,
  0x1B, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xF8, 0xE0, 0x7B, 0x80, 0x27,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x34, 0x00, 0x6C, 0x01, 0xFE, 0x07, 0x9F, 0xFE, 0x0F, 0xF0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF7, 0x87,
  0xCF, 0xF7, 0x1F, 0x1C, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x70, 0x0C,
  0x30, 0x0C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x38, 0x0C, 0x30,
  0x0C, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xC1, 0xC1, 0xF8, 0x78, 0x7E, 0x1E, 0x19, 0x87, 0x86, 0x61,
  0x61, 0x98, 0xC8, 0x66, 0x33, 0x19, 0x8C, 0xC6, 0x63, 0x33, 0x9C, 0xCC,
  0xC3, 0x61, 0x30, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB0,
  0xF0, 0x78, 0x1C, 0x0E, 0x00, 0xF0, 0x0F, 0x70, 0x0E, 0x38, 0x1C, 0x1C,
  0x38, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x18, 0x38, 0x38, 0x1C, 0x70,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x30,
  0x0C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0E,
  0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x3F,
  0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x01, 0xC3, 0xFC, 0x1F, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0x81, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0xE0, 0x7F, 0x07, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x03, 0x3F, 0x03, 0x63,
  0x07, 0x61, 0x86, 0xC1, 0xCE, 0xC0, 0xFC, 0xC0, 0x78,
};

const GFXglyph IBMPlexMono_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 23, 20, 7, -23 },
  { 16, 8, 9, 20, 6, -24 },
  { 25, 18, 23, 20, 1, -23 },
  { 77, 16, 29, 20, 2, -26 },
  { 135, 18, 23, 20, 1, -23 },
  { 187, 18, 23, 20, 1, -23 },
  { 239, 2, 9, 20, 9, -24 },
  { 242, 9, 30, 20, 7, -25 },
  { 276, 10, 30, 20, 3, -25 },
  { 314, 17, 16, 20, 1, -19 },
  { 348, 16, 16, 20, 2, -18 },
  { 380, 6, 9, 20, 7, -4 },
  { 387, 10, 2, 20, 5, -11 },
  { 390, 5, 4, 20, 7, -4 },
  { 393, 14, 30, 20, 3, -25 },
  { 446, 16, 23, 20, 2, -23 },
  { 492, 16, 23, 20, 2, -23 },
  { 538, 16, 23, 20, 2, -23 },
  { 584, 15, 23, 20, 2, -23 },
  { 628, 18, 23, 20, 1, -23 },
  { 680, 16, 23, 20, 2, -23 },
  { 726, 16, 23, 20, 2, -23 },
  { 772, 16, 23, 20, 2, -23 },
  { 818, 16, 23, 20, 2, -23 },
  { 864, 16, 23, 20, 2, -23 },
  { 910, 5, 17, 20, 7, -17 },
  { 921, 6, 22, 20, 7, -17 },
  { 938, 14, 19, 20, 3, -20 },
  { 972, 16, 8, 20, 2, -14 },
  { 988, 14, 19, 20, 3, -20 },
  { 1022, 14, 23, 20, 3, -23 },
  { 1063, 15, 27, 20, 2, -23 },
  { 1114, 18, 23, 20, 1, -23 },
  { 1166, 15, 23, 20, 3, -23 },
  { 1210, 16, 23, 20, 2, -23 },
  { 1256, 15, 23, 20, 3, -23 },
  { 1300, 14, 23, 20, 3, -23 },
  { 1341, 14, 23, 20, 3, -23 },
  { 1382, 15, 23, 20, 2, -23 },
  { 1426, 14, 23, 20, 3, -23 },
  { 1467, 14, 23, 20, 3, -23 },
  { 1508, 14, 23, 20, 2, -23 },
  { 1549, 16, 23, 20, 3, -23 },
  { 1595, 14, 23, 20, 4, -23 },
  { 1636, 16, 23, 20, 2, -23 },
  { 1682, 14, 23, 20, 3, -23 },
  { 1723, 16, 23, 20, 2, -23 },
  { 1769, 15, 23, 20, 3, -23 },
  { 1813, 16, 28, 20, 2, -23 },
  { 1869, 15, 23, 20, 3, -23 },
  { 1913, 17, 23, 20, 1, -23 },
  { 1962, 18, 23, 20, 1, -23 },
  { 2014, 14, 23, 20, 3, -23 },
  { 2055, 18, 23, 20, 1, -23 },
  { 2107, 18, 23, 20, 1, -23 },
  { 2159, 18, 23, 20, 1, -23 },
  { 2211, 18, 23, 20, 1, -23 },
  { 2263, 16, 23, 20, 2, -23 },
  { 2309, 10, 30, 20, 7, -25 },
  { 2347, 14, 30, 20, 3, -25 },
  { 2400, 9, 30, 20, 3, -25 },
  { 2434, 17, 14, 20, 1, -23 },
  { 2464, 16, 2, 20, 2, 3 },
  { 2468, 5, 6, 20, 6, -25 },
  { 2472, 16, 17, 20, 2, -17 },
  { 2506, 15, 24, 20, 3, -24 },
  { 2551, 14, 17, 20, 3, -17 },
  { 2581, 15, 24, 20, 2, -24 },
  { 2626, 16, 17, 20, 2, -17 },
  { 2660, 16, 24, 20, 2, -24 },
  { 2708, 17, 26, 20, 2, -19 },
  { 2764, 14, 24, 20, 3, -24 },
  { 2806, 15, 24, 20, 3, -24 },
  { 2851, 12, 31, 20, 3, -24 },
  { 2898, 16, 24, 20, 3, -24 },
  { 2946, 14, 24, 20, 3, -24 },
  { 2988, 16, 17, 20, 2, -17 },
  { 3022, 14, 17, 20, 3, -17 },
  { 3052, 16, 17, 20, 2, -17 },
  { 3086, 15, 24, 20, 3, -17 },
  { 3131, 15, 24, 20, 2, -17 },
  { 3176, 15, 17, 20, 3, -17 },
  { 3208, 15, 17, 20, 2, -17 },
  { 3240, 16, 23, 20, 1, -23 },
  { 3286, 14, 17, 20, 3, -17 },
  { 3316, 16, 17, 20, 2, -17 },
  { 3350, 18, 17, 20, 1, -17 },
  { 3389, 16, 17, 20, 2, -17 },
  { 3423, 16, 24, 20, 2, -17 },
  { 3471, 14, 17, 20, 3, -17 },
  { 3501, 13, 30, 20, 3, -25 },
  { 3550, 2, 30, 20, 9, -25 },
  { 3558, 13, 30, 20, 3, -25 },
  { 3607, 16, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Regular33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_REGULAR33PT7B_H_
