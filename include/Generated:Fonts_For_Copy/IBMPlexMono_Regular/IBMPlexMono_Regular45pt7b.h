#ifndef _IBMPLEXMONO_REGULAR45PT7B_H_
#define _IBMPLEXMONO_REGULAR45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x40, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70, 0x00, 0x78,
  0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x70, 0x70, 0x1F, 0xF8, 0x3F, 0xEF, 0xFC, 0x1F, 0xF7,
  0xFE, 0x0F, 0xF8, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x3F, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F,
  0xEF, 0xF8, 0x3F, 0xF0, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x19,
  0xFC, 0x7C, 0x30, 0xF8, 0xF0, 0x60, 0x79, 0xC0, 0xC0, 0x87, 0x81, 0x80,
  0x0F, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x3C, 0x18, 0x00,
  0x7C, 0x30, 0x00, 0x7C, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0xFC, 0x00, 0x18, 0x7C, 0x00,
  0x30, 0x78, 0x00, 0x60, 0x78, 0x00, 0xC0, 0xF0, 0x01, 0x81, 0xE0, 0x03,
  0x03, 0xC8, 0x06, 0x07, 0x98, 0x0C, 0x0F, 0x78, 0x18, 0x3D, 0xF8, 0x30,
  0xF8, 0xFC, 0x67, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xDF, 0xFC, 0x01,
  0xCF, 0x0E, 0x00, 0xEF, 0x03, 0x80, 0xE7, 0x01, 0xC0, 0x73, 0x80, 0xE0,
  0x71, 0xC0, 0x70, 0x78, 0xE0, 0x38, 0x38, 0x70, 0x1C, 0x3C, 0x38, 0x0E,
  0x1C, 0x1E, 0x07, 0x1E, 0x07, 0x87, 0x0E, 0x03, 0xFF, 0x8F, 0x00, 0xFF,
  0x87, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x70, 0xFF, 0x80, 0x78, 0xFF, 0xE0, 0x38, 0x70, 0xF0, 0x3C, 0x70, 0x3C,
  0x1C, 0x38, 0x0E, 0x1E, 0x1C, 0x07, 0x0E, 0x0E, 0x03, 0x8F, 0x07, 0x01,
  0xC7, 0x03, 0x80, 0xE7, 0x01, 0xC0, 0x73, 0x80, 0xE0, 0x7B, 0x80, 0x38,
  0x79, 0xC0, 0x1F, 0xFD, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0x3E, 0x00, 0xF0, 0x0C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0x78, 0x1F, 0x8F, 0x1E, 0x0E, 0x0F, 0x07,
  0x87, 0x07, 0x83, 0xE3, 0x87, 0x80, 0xF1, 0x83, 0xC0, 0x3D, 0xC1, 0xE0,
  0x0F, 0xE0, 0xF0, 0x03, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F,
  0x00, 0x3F, 0x07, 0x80, 0x37, 0xC1, 0xF0, 0x79, 0xE0, 0xFF, 0xF8, 0x78,
  0x1F, 0xF8, 0x1E, 0x07, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x1C, 0x06, 0xFC, 0x38, 0x7F,
  0xFF, 0x77, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x80, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E,
  0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0xF9,
  0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1E,
  0x00, 0x60, 0x3C, 0x00, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xCE,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x1F, 0x1C, 0x00, 0x78, 0x20, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xCC, 0x00, 0x1E, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x3F, 0x01, 0xF0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x8F, 0xE0,
  0x1C, 0xFF, 0xC1, 0xEF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7C, 0x01, 0xF0, 0xC0,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0x80, 0x07, 0x9C, 0x00,
  0x3D, 0xF0, 0x03, 0xC3, 0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x8F, 0xE0,
  0x39, 0xFF, 0xC1, 0xDF, 0xFF, 0x1F, 0xE0, 0xFC, 0xFC, 0x01, 0xF7, 0xC0,
  0x07, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00,
  0x3C, 0x78, 0x03, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xE0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83,
  0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xE0, 0x03, 0xC1, 0xE0,
  0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x3E, 0x03, 0xE0, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87,
  0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0x87, 0xC0, 0x1E,
  0x3C, 0x00, 0x7B, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D,
  0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x3F, 0x07, 0xF8, 0xFF, 0xFB, 0x83, 0xFF,
  0x9C, 0x07, 0xF1, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xBE, 0x3E, 0x7F, 0x7F, 0x7F,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70,
  0xF0, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0, 0x7C,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xFB, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x1E, 0x1C,
  0x00, 0x79, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x81, 0xF3,
  0xFC, 0x1F, 0xDF, 0xE1, 0xFF, 0xFE, 0x0F, 0x0F, 0xF0, 0xF0, 0x3F, 0x87,
  0x01, 0xFC, 0x38, 0x0F, 0xE1, 0xC0, 0x7F, 0x0E, 0x03, 0xF8, 0x70, 0x1F,
  0xC3, 0x80, 0xFE, 0x1C, 0x07, 0xF0, 0xE0, 0x3F, 0x87, 0x01, 0xFC, 0x3C,
  0x0F, 0xE1, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFE, 0xE0, 0x7E, 0xF7,
  0x00, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0x3E, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0x7C, 0xF0,
  0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x78,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0x3E, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xF8, 0x3F, 0x07, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0,
  0x01, 0xEF, 0x00, 0x04, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x01, 0x0F, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x07,
  0xC1, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x00, 0xF8, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0, 0x7E, 0x3C, 0x01,
  0xE3, 0xC0, 0x0F, 0x78, 0x00, 0x77, 0x80, 0x06, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x77, 0x00, 0x07, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x01,
  0xF3, 0xF0, 0x77, 0x1F, 0xFF, 0x70, 0xFF, 0xE7, 0x03, 0xF8, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x10, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE3, 0xE0, 0xF8,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xCF, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F,
  0x80, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x7F, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0x78, 0x03, 0xF9, 0xE0, 0x0F, 0xC3, 0xC0, 0x3E,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x7C,
  0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFE, 0xE0, 0xEF, 0xF7, 0x87, 0x7F, 0x9C,
  0x73, 0xFC, 0xE3, 0x9F, 0xE7, 0xBC, 0xFF, 0x1D, 0xC7, 0xF8, 0xFE, 0x3F,
  0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC, 0x1C,
  0x1F, 0xE0, 0x40, 0xFF, 0x02, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xDC, 0x01, 0xFB,
  0xC0, 0x3F, 0x78, 0x07, 0xE7, 0x00, 0xFC, 0xF0, 0x1F, 0x8E, 0x03, 0xF1,
  0xE0, 0x7E, 0x3C, 0x0F, 0xC3, 0xC1, 0xF8, 0x78, 0x3F, 0x07, 0x07, 0xE0,
  0xF0, 0xFC, 0x1E, 0x1F, 0x81, 0xE3, 0xF0, 0x3C, 0x7E, 0x03, 0x8F, 0xC0,
  0x79, 0xF8, 0x07, 0x3F, 0x00, 0xF7, 0xE0, 0x1E, 0xFC, 0x01, 0xDF, 0x80,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0, 0x1E,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xC0, 0x1E, 0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x00, 0x3E,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70,
  0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xF0, 0x7C,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0,
  0x07, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF0, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xC0, 0x7E,
  0x3E, 0x00, 0x7C, 0xF0, 0x00, 0xE7, 0x80, 0x01, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x80, 0x00,
  0xF7, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x78, 0xFC, 0x07, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F,
  0xE0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07,
  0x01, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F,
  0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xF7, 0x0E, 0xE1, 0xCE, 0x1D, 0xC3, 0x9C,
  0x3B, 0x87, 0x38, 0x77, 0x0E, 0x70, 0xC7, 0x1C, 0xE3, 0x8E, 0x39, 0xC7,
  0x1C, 0x73, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xCF, 0x70, 0x73, 0x9E, 0xE0,
  0xEF, 0x3D, 0xC1, 0xDE, 0x3B, 0x83, 0xB8, 0x77, 0x07, 0x70, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x00, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x0F, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x1E, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xC0, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0x70, 0xF8, 0x38, 0x3C, 0x1C,
  0x0E, 0x0E, 0x05, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x03, 0xC0, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xC0, 0x1E, 0x3E, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x07,
  0xE1, 0xF0, 0x37, 0xF3, 0xFF, 0xCF, 0xC7, 0xFE, 0x1F, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F,
  0xC0, 0xF3, 0xFF, 0x0F, 0x7F, 0xF8, 0xFE, 0x07, 0xCF, 0x80, 0x3E, 0xF8,
  0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF8, 0x01,
  0xEF, 0x80, 0x3E, 0xFE, 0x07, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x83, 0xE3, 0xC0,
  0x3C, 0xF0, 0x03, 0xDC, 0x00, 0x27, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x02, 0x3C, 0x00,
  0x73, 0xC0, 0x1E, 0x7E, 0x0F, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x3F, 0x0F, 0x0F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3E, 0x07, 0xF7, 0xC0, 0x1F,
  0x78, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78,
  0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x07, 0xF1, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F,
  0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x10, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0F, 0x81, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xDF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7C, 0x1F, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x78, 0x00, 0xE1,
  0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xF0, 0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE3, 0x80,
  0x07, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0x7C, 0x00, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x01,
  0xFF, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x1F, 0x83, 0xCF, 0xFC, 0x7B, 0xFF, 0xCF, 0x60, 0xFD, 0xF0, 0x07, 0xBE,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x7D, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70, 0x0F, 0x83, 0x80, 0xF8, 0x1C,
  0x0F, 0x80, 0xE0, 0xF8, 0x07, 0x0F, 0x80, 0x38, 0xF8, 0x01, 0xCF, 0x80,
  0x0E, 0xFE, 0x00, 0x7F, 0x78, 0x03, 0xF3, 0xE0, 0x1F, 0x0F, 0x80, 0xF0,
  0x3C, 0x07, 0x00, 0xF0, 0x38, 0x07, 0xC1, 0xC0, 0x1F, 0x0E, 0x00, 0x78,
  0x70, 0x01, 0xE3, 0x80, 0x0F, 0x9C, 0x00, 0x3E, 0xE0, 0x00, 0xF8, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE1, 0xF1, 0xEF, 0xE7, 0xF3,
  0xDF, 0xDF, 0xF7, 0xC3, 0xF1, 0xEF, 0x07, 0xC1, 0xDE, 0x07, 0x03, 0xBC,
  0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0,
  0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E,
  0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0,
  0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07,
  0xF8, 0x1C, 0x0F, 0x00, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0x07,
  0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0,
  0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x0F, 0x83, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7,
  0xFF, 0x8F, 0xE0, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0xE0,
  0x7C, 0xF7, 0xFF, 0x8F, 0x3F, 0xF0, 0xF0, 0xFC, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xCF, 0x1F, 0xFE,
  0xF3, 0xE0, 0x7F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x7F,
  0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x03, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xC0, 0x7B, 0x80, 0x01, 0xE8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF8, 0x7C, 0x07, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0x21,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC8, 0x00, 0x1E, 0xE0, 0x00,
  0xEF, 0x80, 0x0F, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xC0,
  0x0F, 0xBC, 0x01, 0xF7, 0xE0, 0xFE, 0x7F, 0xFB, 0xC7, 0xFE, 0x78, 0x3F,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x78, 0x03,
  0x83, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0xF0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x03, 0x9C, 0x0F, 0x81, 0xCE,
  0x07, 0xC0, 0xE7, 0x03, 0x60, 0x73, 0x83, 0xB8, 0x39, 0xC1, 0xDC, 0x1C,
  0x70, 0xEE, 0x0E, 0x38, 0x63, 0x0E, 0x1C, 0x31, 0x87, 0x0E, 0x38, 0xE3,
  0x87, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE1, 0xC6, 0x0C, 0x70, 0x63, 0x06,
  0x30, 0x3B, 0x83, 0xB8, 0x1D, 0xC1, 0xDC, 0x0E, 0xE0, 0xEE, 0x07, 0x60,
  0x37, 0x03, 0xB0, 0x1B, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78,
  0x3C, 0x07, 0x80, 0xF0, 0x78, 0x07, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x7B,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1,
  0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x3C,
  0x1E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x00, 0xE3,
  0x80, 0x01, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0x80, 0x0C, 0x3F, 0x80, 0x18, 0x7F, 0x80, 0x71, 0xE7, 0x80, 0xE3, 0x87,
  0x81, 0xCE, 0x07, 0x87, 0x1C, 0x07, 0x9E, 0x38, 0x07, 0xF8, 0xE0, 0x07,
  0xF0, 0xC0, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 31, 27, 10, -31 },
  { 29, 11, 12, 27, 8, -33 },
  { 46, 25, 31, 27, 1, -31 },
  { 143, 23, 43, 27, 2, -37 },
  { 267, 25, 33, 27, 1, -32 },
  { 371, 25, 33, 27, 1, -32 },
  { 475, 3, 12, 27, 12, -33 },
  { 480, 13, 40, 27, 9, -34 },
  { 545, 13, 40, 27, 5, -34 },
  { 610, 23, 22, 27, 2, -26 },
  { 674, 21, 21, 27, 3, -24 },
  { 730, 8, 12, 27, 9, -6 },
  { 742, 13, 3, 27, 7, -15 },
  { 747, 7, 6, 27, 10, -6 },
  { 753, 19, 40, 27, 4, -34 },
  { 848, 21, 33, 27, 3, -32 },
  { 935, 23, 31, 27, 2, -31 },
  { 1025, 21, 32, 27, 3, -32 },
  { 1109, 21, 33, 27, 2, -32 },
  { 1196, 23, 31, 27, 2, -31 },
  { 1286, 21, 32, 27, 3, -31 },
  { 1370, 21, 32, 27, 3, -31 },
  { 1454, 21, 31, 27, 3, -31 },
  { 1536, 23, 33, 27, 2, -32 },
  { 1631, 21, 32, 27, 3, -32 },
  { 1715, 7, 24, 27, 10, -24 },
  { 1736, 8, 30, 27, 9, -24 },
  { 1766, 19, 26, 27, 4, -27 },
  { 1828, 21, 12, 27, 3, -20 },
  { 1860, 19, 26, 27, 4, -27 },
  { 1922, 20, 32, 27, 3, -32 },
  { 2002, 21, 37, 27, 3, -32 },
  { 2100, 25, 31, 27, 1, -31 },
  { 2197, 20, 31, 27, 4, -31 },
  { 2275, 21, 33, 27, 3, -32 },
  { 2362, 20, 31, 27, 4, -31 },
  { 2440, 19, 31, 27, 4, -31 },
  { 2514, 20, 31, 27, 4, -31 },
  { 2592, 20, 33, 27, 3, -32 },
  { 2675, 19, 31, 27, 4, -31 },
  { 2749, 19, 31, 27, 4, -31 },
  { 2823, 19, 32, 27, 3, -31 },
  { 2899, 22, 31, 27, 4, -31 },
  { 2985, 19, 31, 27, 5, -31 },
  { 3059, 21, 31, 27, 3, -31 },
  { 3141, 19, 31, 27, 4, -31 },
  { 3215, 21, 33, 27, 3, -32 },
  { 3302, 20, 31, 27, 4, -31 },
  { 3380, 21, 39, 27, 3, -32 },
  { 3483, 21, 31, 27, 4, -31 },
  { 3565, 22, 33, 27, 2, -32 },
  { 3656, 25, 31, 27, 1, -31 },
  { 3753, 19, 32, 27, 4, -31 },
  { 3829, 23, 31, 27, 2, -31 },
  { 3919, 23, 31, 27, 2, -31 },
  { 4009, 25, 31, 27, 1, -31 },
  { 4106, 25, 31, 27, 1, -31 },
  { 4203, 23, 31, 27, 2, -31 },
  { 4293, 13, 40, 27, 10, -34 },
  { 4358, 19, 40, 27, 4, -34 },
  { 4453, 13, 40, 27, 4, -34 },
  { 4518, 23, 18, 27, 2, -31 },
  { 4570, 21, 3, 27, 3, 4 },
  { 4578, 8, 9, 27, 8, -35 },
  { 4587, 22, 25, 27, 3, -24 },
  { 4656, 20, 34, 27, 4, -33 },
  { 4741, 19, 25, 27, 4, -24 },
  { 4801, 20, 34, 27, 3, -33 },
  { 4886, 21, 25, 27, 3, -24 },
  { 4952, 21, 33, 27, 3, -33 },
  { 5039, 22, 36, 27, 3, -26 },
  { 5138, 19, 33, 27, 4, -33 },
  { 5217, 20, 33, 27, 5, -33 },
  { 5300, 16, 42, 27, 4, -33 },
  { 5384, 21, 33, 27, 5, -33 },
  { 5471, 19, 33, 27, 4, -33 },
  { 5550, 23, 24, 27, 2, -24 },
  { 5619, 19, 24, 27, 4, -24 },
  { 5676, 21, 25, 27, 3, -24 },
  { 5742, 20, 33, 27, 4, -24 },
  { 5825, 20, 33, 27, 3, -24 },
  { 5908, 22, 23, 27, 3, -23 },
  { 5972, 21, 25, 27, 3, -24 },
  { 6038, 22, 31, 27, 2, -31 },
  { 6124, 19, 24, 27, 4, -23 },
  { 6181, 21, 23, 27, 3, -23 },
  { 6242, 25, 23, 27, 1, -23 },
  { 6314, 21, 23, 27, 3, -23 },
  { 6375, 23, 32, 27, 2, -23 },
  { 6467, 19, 23, 27, 4, -23 },
  { 6522, 17, 40, 27, 5, -34 },
  { 6607, 3, 40, 27, 12, -34 },
  { 6622, 17, 40, 27, 5, -34 },
  { 6707, 23, 10, 27, 2, -19 },
};

const GFXfont IBMPlexMono_Regular45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_REGULAR45PT7B_H_
