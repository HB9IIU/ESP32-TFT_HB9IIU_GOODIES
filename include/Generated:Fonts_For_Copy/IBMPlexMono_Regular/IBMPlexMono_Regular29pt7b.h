#ifndef _IBMPLEXMONO_REGULAR29PT7B_H_
#define _IBMPLEXMONO_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x44, 0x40, 0x00, 0xEF, 0xFE, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3,
  0x00, 0x63, 0x80, 0x31, 0x80, 0x18, 0xC0, 0xFC, 0x7E, 0x7E, 0x3F, 0x06,
  0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x0F, 0xE3, 0xF7, 0xE1, 0xF8,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18, 0x03, 0x0C,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x3F, 0x01, 0xFF, 0x87, 0x33,
  0x9C, 0x63, 0xB8, 0xC0, 0x71, 0x80, 0xE3, 0x00, 0xC6, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x67, 0x00, 0xC7, 0x01, 0x86, 0x03, 0x0C, 0x86,
  0x1B, 0x8C, 0x7F, 0x99, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x3C, 0x03, 0x7E, 0x06, 0xC7, 0x0E, 0xC3, 0x0C, 0xC3, 0x18,
  0xC3, 0x18, 0xC3, 0x30, 0xC7, 0x30, 0x7E, 0x60, 0x3C, 0x00, 0x00, 0x7C,
  0x0C, 0xFE, 0x1C, 0xC6, 0x19, 0x83, 0x39, 0x83, 0x31, 0x83, 0x61, 0x83,
  0x60, 0xC6, 0xC0, 0xFE, 0xC0, 0x7C, 0x0F, 0x80, 0x1F, 0xE0, 0x38, 0xE0,
  0x30, 0x70, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x1E, 0x76, 0x1E, 0x63, 0x18, 0xE3, 0x98, 0xC1, 0xD8, 0xC0, 0xF0,
  0xC0, 0x70, 0xE0, 0x78, 0xF0, 0xDC, 0x7F, 0x8C, 0x1F, 0x0F, 0xFF, 0xFF,
  0x07, 0x0E, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0xE0, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x0C,
  0x1C, 0x18, 0x30, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x08,
  0x18, 0x2E, 0x33, 0xFF, 0xFF, 0x87, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x39,
  0x80, 0x63, 0x81, 0x83, 0x07, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7B, 0xDC, 0xE6, 0x73,
  0x98, 0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x80, 0xFF,
  0x87, 0x87, 0x18, 0x0E, 0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x1C, 0x7C, 0x79, 0xF1, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB8,
  0x06, 0x60, 0x39, 0xE1, 0xC3, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xF8, 0x1E, 0xE0, 0xF3, 0x83, 0x8E, 0x0C, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x87, 0x07,
  0x38, 0x0C, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x9C,
  0x06, 0x20, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x1F, 0x80,
  0x7E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xD0, 0x07, 0x60, 0x1F,
  0xE0, 0xE3, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x0D,
  0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x30, 0x60,
  0xC0, 0xC3, 0x81, 0x86, 0x03, 0x18, 0x06, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x7F, 0xFB, 0xFF, 0xD8, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xF8, 0x6F, 0xF3, 0x83, 0x98,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x68, 0x03, 0xE0, 0x3B, 0x83,
  0x8F, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x19, 0xF0, 0xEF, 0xF3, 0x41, 0xCE, 0x03, 0xB8,
  0x06, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB8, 0x06, 0x60, 0x39, 0xC1, 0xC3,
  0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x60,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00,
  0x1F, 0xC0, 0xFF, 0xC7, 0x07, 0xB8, 0x0E, 0xE0, 0x1B, 0x80, 0x66, 0x03,
  0x9C, 0x1C, 0x1F, 0xE0, 0x7F, 0x87, 0x07, 0x38, 0x06, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x19, 0xC1, 0xE3, 0xFF, 0x07, 0xF0, 0x0F,
  0x80, 0xFF, 0x87, 0x07, 0x18, 0x0E, 0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x07, 0xE0, 0x1F, 0x80, 0xE7, 0x07, 0x8F, 0xF6, 0x1F, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0xEF, 0xFE,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF7, 0xB9, 0xCC, 0xE7, 0x30, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x18, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x1C, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xC0, 0x7E, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3E, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0xC1, 0xFF, 0x0E, 0x1C, 0xC0, 0x76, 0x01, 0xE0, 0x0F, 0x0F,
  0x78, 0xFF, 0xC6, 0x1E, 0x70, 0xF3, 0x07, 0x98, 0x3C, 0xC1, 0xE6, 0x0F,
  0x18, 0x78, 0xFF, 0xC3, 0xDE, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06,
  0xE0, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x70, 0x1C, 0x30, 0x18, 0x30, 0x18,
  0x38, 0x18, 0x38, 0x3F, 0xF8, 0x3F, 0xFC, 0x30, 0x1C, 0x70, 0x0C, 0x60,
  0x0C, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x30, 0x39,
  0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0xE7, 0xFE, 0x3F,
  0xF9, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03,
  0xBF, 0xF9, 0xFF, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x06, 0x60,
  0x1D, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x06, 0x70, 0x1C, 0xE1, 0xE1,
  0xFF, 0x01, 0xF0, 0xFF, 0x07, 0xFE, 0x30, 0x39, 0x80, 0xEC, 0x07, 0x60,
  0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x76, 0x07, 0x3F, 0xF1, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x83, 0xFC, 0x01, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0x60, 0x3B, 0xC3, 0xCF, 0xF6, 0x1F, 0x30, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x3F, 0xC1, 0xF8, 0xE0, 0x1F, 0xC0,
  0x73, 0x80, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0x80,
  0xE7, 0x01, 0xDE, 0x03, 0xFE, 0x07, 0xCC, 0x0F, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0x77, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0x81, 0xFC,
  0x1F, 0xF0, 0xFD, 0x87, 0xEC, 0x6F, 0x33, 0x79, 0xB3, 0xCF, 0x9E, 0x3C,
  0xF1, 0xC7, 0x86, 0x3C, 0x21, 0xE1, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x30, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0xC1, 0xF6, 0x0F, 0xB0, 0x7D, 0xC3, 0xE6, 0x1F, 0x38, 0xF8, 0xC7, 0xC6,
  0x3E, 0x19, 0xF0, 0xCF, 0x87, 0x7C, 0x1B, 0xE0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xF0, 0x0F, 0x80, 0xFF, 0x87, 0x87, 0x18, 0x0E, 0xE0, 0x1B, 0x80,
  0x6C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xB8, 0x06, 0x60, 0x39, 0xE1, 0xC3, 0xFE, 0x03,
  0xE0, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x06, 0xC0, 0x77, 0xFF, 0x3F, 0xF1, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0x80,
  0xFF, 0x87, 0x87, 0x18, 0x0E, 0xE0, 0x1B, 0x80, 0x6C, 0x01, 0xB0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xB8, 0x06, 0x60, 0x39, 0xE1, 0xC3, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFC, 0x01, 0xF0, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80,
  0x6C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x77, 0xFF, 0x3F, 0xF1,
  0x86, 0x0C, 0x38, 0x60, 0xC3, 0x07, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0xB0,
  0x1D, 0x80, 0x70, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x77, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xA0, 0x07, 0xE0, 0x0C, 0xF0,
  0x78, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x60,
  0x3B, 0x83, 0x8F, 0xF8, 0x1F, 0x80, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x3B,
  0x80, 0x67, 0x00, 0xC6, 0x03, 0x8E, 0x06, 0x1C, 0x0C, 0x18, 0x38, 0x30,
  0x70, 0x70, 0xC0, 0xE1, 0x80, 0xC7, 0x01, 0xCC, 0x03, 0x98, 0x03, 0x70,
  0x06, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x70, 0xD8, 0xE1, 0xB1, 0xE3, 0x62,
  0xC6, 0xCD, 0x8D, 0x9B, 0x3B, 0x32, 0x66, 0x66, 0xCC, 0x8D, 0x9B, 0x1B,
  0x36, 0x36, 0x6C, 0x3C, 0xF8, 0x79, 0xE0, 0xF1, 0xC1, 0xE0, 0xE0, 0x0E,
  0x70, 0x0E, 0x30, 0x1C, 0x38, 0x18, 0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x60,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0,
  0x0E, 0x70, 0x1C, 0x30, 0x18, 0x38, 0x38, 0x18, 0x70, 0x1C, 0x60, 0x0E,
  0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC1, 0xC0,
  0xC0, 0x60, 0xE0, 0x38, 0x60, 0x0C, 0x70, 0x07, 0x30, 0x01, 0xB8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0x80, 0x1B, 0x00,
  0x73, 0x00, 0xC6, 0x03, 0x86, 0x06, 0x0E, 0x1C, 0x0C, 0x30, 0x1C, 0xC0,
  0x19, 0x80, 0x3E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0x1C, 0x61,
  0x8C, 0x1F, 0x80, 0xFF, 0x87, 0x0E, 0x30, 0x1C, 0x00, 0x30, 0x00, 0xC1,
  0xFF, 0x1F, 0xFC, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x38, 0x1C, 0xE0, 0xB1,
  0xFE, 0xF3, 0xF1, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x3E, 0x1B, 0xFC, 0xF0, 0xE6, 0x03, 0xB0, 0x0D, 0x80, 0x6C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x37, 0x03, 0xBC, 0x3D, 0xBF,
  0xCC, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x76, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x08, 0xE0, 0x33, 0x87,
  0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x7C, 0xE7, 0xF7, 0x70, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x1E, 0x7F,
  0x71, 0xF3, 0x80, 0x0F, 0x81, 0xFF, 0x1E, 0x1C, 0xC0, 0x7E, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x27, 0x87,
  0x9F, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0xFA, 0x0F, 0xF8,
  0x70, 0x71, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0xC1, 0xC3, 0xFE,
  0x03, 0xE0, 0x30, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFC, 0x3F, 0xF9, 0x80,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x1D, 0xFF, 0xE3, 0xFE, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D, 0xFC, 0xF0, 0xEE,
  0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xBF, 0xEF, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x03, 0xB0, 0x38, 0xC1, 0xC3, 0x0E, 0x0C, 0x70, 0x33, 0x80,
  0xDE, 0x03, 0xFC, 0x0F, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x8C, 0x07,
  0x30, 0x0C, 0xC0, 0x3C, 0xFF, 0x07, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xFF,
  0xFF, 0xFF, 0x80, 0xDC, 0x7B, 0xFB, 0xEC, 0x71, 0xF1, 0xC3, 0xC3, 0x0F,
  0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3,
  0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xC0, 0xCF, 0x8D, 0xFC, 0xF0, 0xEE, 0x06,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x7E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x06, 0xC0,
  0x77, 0x07, 0x1F, 0xF0, 0x3E, 0x00, 0xCF, 0x86, 0xFF, 0x3C, 0x39, 0x80,
  0xEC, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0D,
  0xC0, 0xEF, 0x0F, 0x6F, 0xF3, 0x3E, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0x39, 0xFD, 0xDC, 0x1F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x77, 0x07, 0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0xFE, 0x3F, 0xFB, 0xF0, 0x68, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0x9C, 0x0E,
  0xC0, 0x26, 0x00, 0x38, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x01, 0xC0,
  0x06, 0x80, 0x3F, 0x03, 0xBF, 0xF8, 0x7F, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0xF7, 0xF7, 0x3E, 0x70, 0xC0, 0x1F, 0x80, 0x66, 0x03, 0x98,
  0x0C, 0x70, 0x30, 0xC1, 0xC3, 0x06, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x00,
  0xCC, 0x03, 0x60, 0x0D, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC3, 0x87, 0xC3,
  0x86, 0xC3, 0x86, 0xC2, 0xC6, 0x62, 0xC6, 0x66, 0xC6, 0x66, 0x46, 0x66,
  0x44, 0x64, 0x6C, 0x64, 0x6C, 0x6C, 0x6C, 0x2C, 0x2C, 0x3C, 0x2C, 0x38,
  0x38, 0x38, 0x38, 0xE0, 0x3D, 0xC0, 0xC3, 0x07, 0x0E, 0x38, 0x1C, 0xC0,
  0x3E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x80, 0x37, 0x01, 0xCC, 0x0E, 0x38,
  0x30, 0x71, 0x80, 0xEE, 0x01, 0xC0, 0xC0, 0x1F, 0x80, 0x66, 0x01, 0x98,
  0x0C, 0x70, 0x30, 0xC1, 0xC3, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x73, 0x00,
  0xDC, 0x03, 0x60, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xE1, 0xFC, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x8F, 0xE1, 0xFC, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x7E, 0x0F, 0xC7, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0xFE, 0x1F, 0xC0, 0x3C, 0x0D, 0xF8, 0x3E, 0x71, 0xB0, 0xE6, 0xC1, 0xF2,
  0x03, 0x80,
};

const GFXglyph IBMPlexMono_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 7, -20 },
  { 11, 7, 8, 17, 5, -21 },
  { 18, 17, 20, 17, 0, -20 },
  { 61, 15, 26, 17, 1, -23 },
  { 110, 16, 20, 17, 1, -20 },
  { 150, 16, 20, 17, 1, -20 },
  { 190, 2, 8, 17, 8, -21 },
  { 192, 8, 26, 17, 6, -22 },
  { 218, 8, 26, 17, 3, -22 },
  { 244, 15, 14, 17, 1, -16 },
  { 271, 14, 14, 17, 2, -16 },
  { 296, 5, 8, 17, 6, -4 },
  { 301, 9, 2, 17, 4, -10 },
  { 304, 4, 4, 17, 7, -4 },
  { 306, 12, 26, 17, 3, -22 },
  { 345, 14, 20, 17, 2, -20 },
  { 380, 14, 20, 17, 2, -20 },
  { 415, 14, 20, 17, 2, -20 },
  { 450, 14, 20, 17, 1, -20 },
  { 485, 15, 20, 17, 1, -20 },
  { 523, 13, 20, 17, 2, -20 },
  { 556, 14, 20, 17, 2, -20 },
  { 591, 13, 20, 17, 2, -20 },
  { 624, 14, 20, 17, 2, -20 },
  { 659, 14, 20, 17, 2, -20 },
  { 694, 4, 15, 17, 7, -15 },
  { 702, 5, 19, 17, 6, -15 },
  { 714, 13, 17, 17, 2, -17 },
  { 742, 14, 8, 17, 2, -13 },
  { 756, 13, 17, 17, 2, -17 },
  { 784, 13, 20, 17, 2, -20 },
  { 817, 13, 23, 17, 2, -20 },
  { 855, 16, 20, 17, 1, -20 },
  { 895, 13, 20, 17, 3, -20 },
  { 928, 14, 20, 17, 2, -20 },
  { 963, 13, 20, 17, 3, -20 },
  { 996, 12, 20, 17, 3, -20 },
  { 1026, 12, 20, 17, 3, -20 },
  { 1056, 13, 20, 17, 2, -20 },
  { 1089, 13, 20, 17, 2, -20 },
  { 1122, 13, 20, 17, 2, -20 },
  { 1155, 12, 20, 17, 2, -20 },
  { 1185, 15, 20, 17, 2, -20 },
  { 1223, 13, 20, 17, 3, -20 },
  { 1256, 13, 20, 17, 2, -20 },
  { 1289, 13, 20, 17, 2, -20 },
  { 1322, 14, 20, 17, 2, -20 },
  { 1357, 13, 20, 17, 3, -20 },
  { 1390, 14, 25, 17, 2, -20 },
  { 1434, 13, 20, 17, 3, -20 },
  { 1467, 15, 20, 17, 1, -20 },
  { 1505, 16, 20, 17, 1, -20 },
  { 1545, 13, 20, 17, 2, -20 },
  { 1578, 15, 20, 17, 1, -20 },
  { 1616, 15, 20, 17, 1, -20 },
  { 1654, 16, 20, 17, 1, -20 },
  { 1694, 17, 20, 17, 0, -20 },
  { 1737, 15, 20, 17, 1, -20 },
  { 1775, 8, 26, 17, 7, -22 },
  { 1801, 12, 26, 17, 3, -22 },
  { 1840, 8, 26, 17, 3, -22 },
  { 1866, 15, 12, 17, 1, -20 },
  { 1889, 14, 2, 17, 2, 3 },
  { 1893, 5, 6, 17, 5, -23 },
  { 1897, 14, 15, 17, 2, -15 },
  { 1924, 13, 21, 17, 3, -21 },
  { 1959, 13, 15, 17, 2, -15 },
  { 1984, 13, 21, 17, 2, -21 },
  { 2019, 13, 15, 17, 2, -15 },
  { 2044, 14, 21, 17, 2, -21 },
  { 2081, 14, 23, 17, 2, -17 },
  { 2122, 12, 21, 17, 3, -21 },
  { 2154, 13, 21, 17, 3, -21 },
  { 2189, 10, 27, 17, 3, -21 },
  { 2223, 14, 21, 17, 3, -21 },
  { 2260, 13, 21, 17, 2, -21 },
  { 2295, 14, 15, 17, 2, -15 },
  { 2322, 12, 15, 17, 3, -15 },
  { 2345, 13, 15, 17, 2, -15 },
  { 2370, 13, 21, 17, 3, -15 },
  { 2405, 13, 21, 17, 2, -15 },
  { 2440, 14, 15, 17, 2, -15 },
  { 2467, 13, 15, 17, 2, -15 },
  { 2492, 14, 20, 17, 1, -20 },
  { 2527, 12, 15, 17, 3, -15 },
  { 2550, 14, 15, 17, 2, -15 },
  { 2577, 16, 15, 17, 1, -15 },
  { 2607, 14, 15, 17, 2, -15 },
  { 2634, 14, 21, 17, 2, -15 },
  { 2671, 13, 15, 17, 2, -15 },
  { 2696, 11, 26, 17, 3, -22 },
  { 2732, 2, 26, 17, 8, -22 },
  { 2739, 11, 26, 17, 3, -22 },
  { 2775, 14, 6, 17, 2, -12 },
};

const GFXfont IBMPlexMono_Regular29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_REGULAR29PT7B_H_
