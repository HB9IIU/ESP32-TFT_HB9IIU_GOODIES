#ifndef _IBMPLEXMONO_REGULAR28PT7B_H_
#define _IBMPLEXMONO_REGULAR28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x62, 0x22, 0x20, 0x00, 0x7F, 0xF7, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x03, 0x8C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x7E, 0x1F, 0x7E, 0x3F, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0xFC, 0x3E, 0xFC, 0x7E, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0xE0, 0x18, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x03, 0xF8, 0x1F, 0xF8, 0xE6, 0xF7, 0x18, 0xD8, 0x60,
  0x61, 0x81, 0xC6, 0x07, 0x18, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1B,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x34, 0x18, 0xD8, 0x63, 0xF9, 0xBC, 0xFF,
  0xE0, 0xFE, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1E, 0x03, 0x3F, 0x07,
  0x63, 0x06, 0x61, 0x8C, 0x41, 0x8C, 0x41, 0x98, 0x61, 0x98, 0x63, 0x30,
  0x3F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x0E, 0xE3, 0x0C, 0xC3,
  0x18, 0xC3, 0x18, 0xC3, 0x30, 0xC3, 0x30, 0xE3, 0x60, 0x7E, 0xE0, 0x3C,
  0x0F, 0x80, 0x3F, 0x80, 0xE3, 0x81, 0x82, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x3D, 0xF8, 0x7B, 0x38, 0xCC, 0x39,
  0x18, 0x3E, 0x30, 0x3C, 0x60, 0x38, 0xE0, 0x71, 0xE1, 0xF1, 0xFE, 0x70,
  0xF8, 0x70, 0xFF, 0xFF, 0x07, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x07, 0xE0, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06,
  0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x04, 0x30, 0x5F, 0x67, 0x9F, 0xFE, 0x87, 0xE0, 0x07, 0x80, 0x0D,
  0x80, 0x33, 0x80, 0xE3, 0x83, 0x83, 0x02, 0x05, 0x00, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x7B, 0x9C, 0xCE, 0x73,
  0x18, 0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x3C, 0xC0, 0x6E, 0x03,
  0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0x60, 0x33, 0x87, 0x8F, 0xF8, 0x1F,
  0x00, 0x07, 0x80, 0x3E, 0x01, 0xD8, 0x0E, 0x60, 0x71, 0x83, 0x86, 0x04,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x07, 0xFF, 0xDF, 0xFF,
  0x1F, 0x81, 0xFF, 0x1C, 0x39, 0xC0, 0xEC, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F,
  0xC3, 0x87, 0x1C, 0x0E, 0x20, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x3F, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x90,
  0x07, 0x60, 0x3B, 0xC1, 0xE3, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xE0,
  0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x18, 0x06, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x7F, 0xF3,
  0xFF, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xF8, 0x7F,
  0xE3, 0x87, 0x88, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE8, 0x07,
  0xE0, 0x33, 0x83, 0x8F, 0xF8, 0x3F, 0x00, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0xF8, 0xFF, 0xE6, 0x83, 0xB8,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x60, 0x33, 0x83,
  0x8F, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x6C, 0x07,
  0x60, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x00, 0x1F, 0xC3, 0xFF, 0x1C, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x80,
  0xCE, 0x0E, 0x1F, 0xC1, 0xFE, 0x1C, 0x1D, 0xC0, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x3B, 0x83, 0x9F, 0xF8, 0x3F, 0x80, 0x0F, 0x81,
  0xFF, 0x1C, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3F, 0x01, 0xDC, 0x1E, 0x7F, 0x61, 0xF3, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x70, 0x77, 0xBC, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x39,
  0x9C, 0xE6, 0x30, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x00, 0x30, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xE0, 0x08, 0x00, 0x0F, 0x83, 0xFE, 0x70, 0x76, 0x03, 0xE0, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x01, 0xE0, 0x78, 0x06, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xFF,
  0x1C, 0x1C, 0xC0, 0x66, 0x03, 0x60, 0x0F, 0x0E, 0x78, 0xFB, 0xCE, 0x3E,
  0x60, 0xF3, 0x07, 0x98, 0x3C, 0xC1, 0xE6, 0x0F, 0x38, 0xF8, 0xFB, 0xC7,
  0xDE, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0x80, 0x03,
  0x80, 0x0F, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x9C, 0x03, 0x18,
  0x06, 0x30, 0x1C, 0x70, 0x30, 0x60, 0x60, 0xC1, 0xC1, 0x83, 0xFF, 0x87,
  0xFF, 0x0C, 0x06, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x1B, 0x80, 0x3E, 0x00,
  0x70, 0xFF, 0xC7, 0xFF, 0x38, 0x1D, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80,
  0xDC, 0x06, 0xE0, 0x67, 0xFE, 0x3F, 0xF9, 0xC0, 0xEE, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xBF, 0xFD, 0xFF, 0x80, 0x0F, 0xC0,
  0xFF, 0x0E, 0x1C, 0xE0, 0x76, 0x01, 0xF0, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x03,
  0x70, 0x39, 0xC3, 0x87, 0xF8, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xC1, 0xCC,
  0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x1C, 0xFF, 0xCF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xFF, 0x87, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0x60, 0x3B, 0x83, 0xCF, 0xEE, 0x3E, 0x70, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE7, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1A, 0x03, 0xE0,
  0x6E, 0x1C, 0xFF, 0x0F, 0x80, 0xE0, 0x1F, 0x80, 0xEE, 0x07, 0x38, 0x38,
  0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0xBC, 0x0F, 0xB0,
  0x3C, 0xE0, 0xF1, 0xC3, 0x83, 0x0E, 0x0E, 0x38, 0x18, 0xE0, 0x73, 0x80,
  0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0x03, 0xFC, 0x1F, 0xE0, 0xFD, 0x8D, 0xEC, 0x6F, 0x66, 0x79, 0xB3, 0xCD,
  0x9E, 0x38, 0xF1, 0xC7, 0x8C, 0x3C, 0x21, 0xE1, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x30, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xB0, 0x7D, 0x83, 0xE6, 0x1F, 0x30, 0xF9, 0xC7, 0xC6, 0x3E, 0x31, 0xF1,
  0xCF, 0x86, 0x7C, 0x3B, 0xE0, 0xDF, 0x06, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0x81, 0xFF, 0x1C, 0x3C, 0xC0, 0x6E, 0x03,
  0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0x60, 0x33, 0x87, 0x8F, 0xF8, 0x1F,
  0x00, 0xFF, 0x8F, 0xFE, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7F, 0xFE, 0xFF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x3C,
  0xC0, 0x6E, 0x03, 0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x06, 0x60, 0x33, 0x87,
  0x8F, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xC0, 0x7E, 0xFF, 0x8F,
  0xFE, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7F,
  0xFE, 0xFF, 0x8C, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x8C, 0x1C, 0xC0, 0xCC,
  0x0E, 0xC0, 0x7C, 0x07, 0x0F, 0xE0, 0x7F, 0xE3, 0x83, 0xDC, 0x02, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xD0, 0x03, 0xE0, 0x1D, 0xE0, 0xE3,
  0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x83, 0x8F, 0xF8,
  0x3F, 0x80, 0xE0, 0x0F, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE7, 0x01, 0xC6,
  0x03, 0x0C, 0x06, 0x1C, 0x1C, 0x38, 0x30, 0x30, 0x60, 0x61, 0xC0, 0xE3,
  0x00, 0xC6, 0x01, 0x8C, 0x03, 0xB8, 0x07, 0x60, 0x06, 0xC0, 0x0D, 0x80,
  0x1E, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xD8, 0x71, 0xB8, 0xE3, 0x31, 0xC6, 0x66, 0x8C, 0xCD, 0x99, 0x9B,
  0x33, 0x36, 0x66, 0x4C, 0xCD, 0x89, 0x9B, 0x1B, 0x36, 0x36, 0x6C, 0x6C,
  0xD0, 0xD1, 0xE0, 0xE3, 0xC1, 0xC0, 0xE0, 0x0E, 0xE0, 0x38, 0xC0, 0x61,
  0xC1, 0xC1, 0x83, 0x03, 0x8E, 0x03, 0xB8, 0x03, 0x60, 0x07, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0xEE, 0x01, 0x8C, 0x07, 0x1C, 0x0C, 0x18,
  0x30, 0x38, 0xE0, 0x39, 0x80, 0x37, 0x00, 0x70, 0xE0, 0x07, 0x70, 0x07,
  0x30, 0x0E, 0x38, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x0E, 0x38, 0x06, 0x30,
  0x07, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF,
  0x03, 0x80, 0x0F, 0x00, 0x1B, 0x00, 0x67, 0x00, 0xC6, 0x03, 0x0E, 0x06,
  0x0C, 0x18, 0x1C, 0x70, 0x18, 0xC0, 0x1B, 0x80, 0x32, 0x00, 0x50, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0x0C, 0x61, 0x80, 0x1F, 0x83, 0xFE, 0x1C, 0x39,
  0x80, 0xC0, 0x06, 0x00, 0x30, 0xFF, 0x8F, 0xFC, 0xE0, 0x66, 0x03, 0x30,
  0x19, 0xC1, 0xC7, 0xF3, 0x9F, 0x1C, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xCE, 0x0E, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0xED, 0xFC,
  0xCF, 0x80, 0x0F, 0x83, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x02, 0x70, 0x33, 0x87, 0x3F, 0xE0, 0xFC, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31, 0xF3, 0x7F,
  0xB7, 0x0F, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x03, 0x70, 0xF7, 0xFB, 0x1F, 0x30, 0x0F, 0x81, 0xFF, 0x1C, 0x1C,
  0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x63, 0xFF, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0xFC, 0x0F, 0xF8,
  0x70, 0xE1, 0x81, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x70, 0xC3, 0x83, 0xFC,
  0x07, 0xE0, 0x60, 0x01, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x60, 0x1B, 0x00,
  0x3C, 0x01, 0xF8, 0x0E, 0x7F, 0xF8, 0xFF, 0x80, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C, 0xDF, 0xDC, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xF0, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0xFF, 0xBF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x0E, 0xC0, 0xE6, 0x0E, 0x30, 0xE1, 0x8C, 0x0D,
  0xC0, 0x7F, 0x03, 0xDC, 0x1C, 0x70, 0xC1, 0xC6, 0x06, 0x30, 0x39, 0x80,
  0xEC, 0x03, 0x80, 0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF,
  0xFF, 0x80, 0xDC, 0x77, 0xF7, 0xF1, 0xC7, 0x8E, 0x3C, 0x61, 0xE3, 0x0F,
  0x18, 0x78, 0xC3, 0xC6, 0x1E, 0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3,
  0x0C, 0xCF, 0x9B, 0xFB, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x0F, 0x81, 0xFF,
  0x1C, 0x1C, 0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0xFE, 0x07, 0xC0, 0xCF, 0x8D, 0xFC, 0xE0,
  0xEC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7E, 0x0E, 0xDF, 0xCC, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x1F, 0x37, 0xFB, 0x70, 0xFE, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x37, 0x0F, 0x7F, 0xB1, 0xF3, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFE, 0x7F, 0xFB, 0xF0,
  0xF8, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF,
  0x9C, 0x1C, 0xC0, 0x46, 0x00, 0x38, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x70,
  0x01, 0xD0, 0x0F, 0xE0, 0xE7, 0xFF, 0x0F, 0xE0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0xF7,
  0xF6, 0x7C, 0xC0, 0xC0, 0x1F, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x06, 0x18,
  0x30, 0xC3, 0x83, 0x18, 0x18, 0xC0, 0xCE, 0x03, 0x60, 0x1B, 0x00, 0xF0,
  0x03, 0x80, 0xC3, 0x87, 0x87, 0x0F, 0x0A, 0x1E, 0x34, 0x24, 0x6C, 0xCC,
  0xD9, 0x99, 0x33, 0x32, 0x26, 0x6C, 0x4C, 0xD8, 0xD1, 0xB1, 0xA1, 0x43,
  0xC3, 0x83, 0x87, 0x07, 0x00, 0xE0, 0x3B, 0x83, 0x8C, 0x18, 0x71, 0x81,
  0xDC, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x30, 0x60,
  0xC6, 0x07, 0x70, 0x1C, 0xE0, 0x0D, 0x80, 0x73, 0x01, 0x8C, 0x06, 0x38,
  0x30, 0x60, 0xC1, 0x87, 0x03, 0x18, 0x0C, 0x60, 0x3B, 0x00, 0x6C, 0x01,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x07,
  0xE0, 0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x1C, 0x7F, 0x0F, 0xC0, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x70, 0x07, 0xF0, 0xFE,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x87, 0xF0, 0xFC, 0x00, 0x1C, 0x04, 0xF8, 0x36, 0x30, 0xD8, 0x66,
  0x61, 0xFB, 0x01, 0xC0,
};

const GFXglyph IBMPlexMono_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 6, -20 },
  { 11, 7, 8, 17, 5, -21 },
  { 18, 16, 20, 17, 0, -20 },
  { 58, 14, 26, 17, 1, -23 },
  { 104, 16, 20, 17, 0, -20 },
  { 144, 15, 20, 17, 1, -20 },
  { 182, 2, 8, 17, 7, -21 },
  { 184, 8, 25, 17, 6, -21 },
  { 209, 8, 25, 17, 3, -21 },
  { 234, 15, 14, 17, 1, -16 },
  { 261, 13, 14, 17, 2, -16 },
  { 284, 5, 8, 17, 6, -4 },
  { 289, 8, 2, 17, 4, -10 },
  { 291, 4, 4, 17, 6, -4 },
  { 293, 11, 25, 17, 3, -21 },
  { 328, 13, 20, 17, 2, -20 },
  { 361, 14, 20, 17, 1, -20 },
  { 396, 13, 20, 17, 2, -20 },
  { 429, 14, 20, 17, 1, -20 },
  { 464, 15, 20, 17, 1, -20 },
  { 502, 13, 20, 17, 2, -20 },
  { 535, 13, 20, 17, 2, -20 },
  { 568, 13, 20, 17, 2, -20 },
  { 601, 13, 20, 17, 2, -20 },
  { 634, 13, 20, 17, 2, -20 },
  { 667, 4, 15, 17, 6, -15 },
  { 675, 5, 19, 17, 6, -15 },
  { 687, 12, 16, 17, 2, -17 },
  { 711, 13, 7, 17, 2, -12 },
  { 723, 12, 16, 17, 2, -17 },
  { 747, 12, 20, 17, 2, -20 },
  { 777, 13, 23, 17, 2, -20 },
  { 815, 15, 20, 17, 1, -20 },
  { 853, 13, 20, 17, 2, -20 },
  { 886, 13, 20, 17, 2, -20 },
  { 919, 12, 20, 17, 3, -20 },
  { 949, 12, 20, 17, 3, -20 },
  { 979, 12, 20, 17, 3, -20 },
  { 1009, 13, 20, 17, 2, -20 },
  { 1042, 13, 20, 17, 2, -20 },
  { 1075, 12, 20, 17, 2, -20 },
  { 1105, 11, 20, 17, 2, -20 },
  { 1133, 14, 20, 17, 2, -20 },
  { 1168, 12, 20, 17, 3, -20 },
  { 1198, 13, 20, 17, 2, -20 },
  { 1231, 13, 20, 17, 2, -20 },
  { 1264, 13, 20, 17, 2, -20 },
  { 1297, 12, 20, 17, 3, -20 },
  { 1327, 13, 24, 17, 2, -20 },
  { 1366, 12, 20, 17, 3, -20 },
  { 1396, 14, 20, 17, 1, -20 },
  { 1431, 15, 20, 17, 1, -20 },
  { 1469, 13, 20, 17, 2, -20 },
  { 1502, 15, 20, 17, 1, -20 },
  { 1540, 15, 20, 17, 1, -20 },
  { 1578, 15, 20, 17, 1, -20 },
  { 1616, 16, 20, 17, 0, -20 },
  { 1656, 14, 20, 17, 1, -20 },
  { 1691, 8, 25, 17, 6, -21 },
  { 1716, 11, 25, 17, 3, -21 },
  { 1751, 8, 25, 17, 3, -21 },
  { 1776, 15, 12, 17, 1, -20 },
  { 1799, 13, 2, 17, 2, 3 },
  { 1803, 5, 5, 17, 5, -21 },
  { 1807, 13, 14, 17, 2, -14 },
  { 1830, 12, 21, 17, 3, -21 },
  { 1862, 12, 14, 17, 2, -14 },
  { 1883, 12, 21, 17, 2, -21 },
  { 1915, 13, 14, 17, 2, -14 },
  { 1938, 13, 21, 17, 2, -21 },
  { 1973, 14, 22, 17, 2, -16 },
  { 2012, 11, 21, 17, 3, -21 },
  { 2041, 12, 20, 17, 3, -20 },
  { 2071, 10, 26, 17, 3, -20 },
  { 2104, 13, 21, 17, 3, -21 },
  { 2139, 13, 21, 17, 2, -21 },
  { 2174, 13, 14, 17, 2, -14 },
  { 2197, 11, 14, 17, 3, -14 },
  { 2217, 13, 14, 17, 2, -14 },
  { 2240, 12, 20, 17, 3, -14 },
  { 2270, 12, 20, 17, 2, -14 },
  { 2300, 14, 14, 17, 2, -14 },
  { 2325, 13, 14, 17, 2, -14 },
  { 2348, 14, 20, 17, 1, -20 },
  { 2383, 11, 14, 17, 3, -14 },
  { 2403, 13, 14, 17, 2, -14 },
  { 2426, 15, 14, 17, 1, -14 },
  { 2453, 13, 14, 17, 2, -14 },
  { 2476, 14, 20, 17, 1, -14 },
  { 2511, 12, 14, 17, 2, -14 },
  { 2532, 11, 25, 17, 3, -21 },
  { 2567, 2, 25, 17, 7, -21 },
  { 2574, 11, 25, 17, 3, -21 },
  { 2609, 14, 6, 17, 1, -12 },
};

const GFXfont IBMPlexMono_Regular28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_REGULAR28PT7B_H_
