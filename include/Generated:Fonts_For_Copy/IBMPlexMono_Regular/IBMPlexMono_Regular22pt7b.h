#ifndef _IBMPLEXMONO_REGULAR22PT7B_H_
#define _IBMPLEXMONO_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x92, 0x40, 0x0F, 0xF8, 0xCE, 0x73, 0x9C, 0xE4, 0x06,
  0x60, 0x22, 0x01, 0x10, 0x18, 0x87, 0xCF, 0xBE, 0x7C, 0x33, 0x01, 0x10,
  0x08, 0x87, 0xCF, 0xBE, 0x7C, 0x33, 0x01, 0x18, 0x08, 0x80, 0xCC, 0x00,
  0x06, 0x00, 0xC0, 0x7C, 0x1F, 0xE6, 0x4E, 0xC8, 0x91, 0x03, 0x20, 0x7E,
  0x07, 0xF8, 0x1F, 0x82, 0x30, 0x46, 0x88, 0xF9, 0x39, 0xFE, 0x1F, 0x80,
  0xC0, 0x18, 0x00, 0x3C, 0x1B, 0xF1, 0x91, 0x89, 0x8C, 0xC4, 0x64, 0x3F,
  0x60, 0xF2, 0x00, 0x00, 0x0C, 0xE0, 0xCF, 0x84, 0xC6, 0x66, 0x32, 0x31,
  0xB0, 0xFB, 0x03, 0x80, 0x1E, 0x03, 0xF0, 0x63, 0x06, 0x28, 0x60, 0x03,
  0x00, 0x30, 0xE7, 0x8E, 0xEC, 0xCC, 0x68, 0x83, 0x88, 0x38, 0xC1, 0xCF,
  0xEC, 0x3C, 0x70, 0xFC, 0x1C, 0x42, 0x18, 0x43, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0C, 0x10, 0x60, 0x81, 0x07, 0xE0, 0x60, 0x40, 0xC0, 0xC1,
  0x81, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x18, 0x20, 0xC7,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x42, 0x1F, 0x5E, 0x7F, 0x03, 0x80, 0xD8,
  0x19, 0x86, 0x30, 0x83, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41,
  0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x37, 0x66,
  0x6C, 0xFF, 0xFC, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x10, 0x18, 0x00, 0x1F, 0x07, 0xF1, 0xC3, 0x30, 0x64, 0x07, 0x80,
  0xF0, 0x1E, 0x73, 0xCE, 0x78, 0x0D, 0x01, 0xB0, 0x67, 0x0C, 0x7F, 0x07,
  0xC0, 0x0E, 0x03, 0xC0, 0xF8, 0x3B, 0x0E, 0x60, 0x8C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xFF, 0xDF, 0xF8, 0x1F, 0x07,
  0xF1, 0x87, 0x30, 0x6C, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x06, 0x00, 0xFF, 0xDF, 0xF8, 0x1F, 0x0F, 0xE6, 0x1D, 0x03,
  0x00, 0xC0, 0x61, 0xF0, 0x7E, 0x01, 0xC0, 0x30, 0x0D, 0x03, 0xE1, 0xDF,
  0xE1, 0xF0, 0x03, 0x80, 0xF0, 0x1E, 0x06, 0xC0, 0x98, 0x23, 0x0C, 0x61,
  0x0C, 0x41, 0x98, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x7F,
  0x9F, 0xEC, 0x03, 0x00, 0xC0, 0x37, 0x8F, 0xFB, 0x86, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0xC1, 0x9F, 0xC3, 0xE0, 0x07, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x00, 0xDE, 0x1F, 0xF2, 0x86, 0xE0, 0x78, 0x0F, 0x01, 0xB0, 0x37, 0x0C,
  0x7F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0x60, 0x6C, 0x08, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x1F, 0x0F, 0xF9, 0x83, 0x30, 0x36, 0x04, 0xC1, 0x8F, 0xE1, 0xFC, 0x60,
  0xD8, 0x0F, 0x01, 0xE0, 0x36, 0x0E, 0xFF, 0x87, 0xC0, 0x1F, 0x07, 0xF1,
  0xC3, 0x30, 0x2C, 0x07, 0x80, 0xD8, 0x1B, 0x87, 0x3F, 0xC3, 0xD8, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x77,
  0x70, 0x00, 0x00, 0x03, 0x76, 0x66, 0xC0, 0x00, 0x80, 0xC1, 0xC3, 0x83,
  0x87, 0x03, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x30, 0x08, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x02, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x08, 0x00, 0x3E, 0x3F,
  0xB8, 0x78, 0x38, 0x18, 0x0C, 0x0C, 0x3C, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x70, 0x1F, 0x07, 0xF1, 0xC3, 0x30, 0x24, 0x76, 0x9F, 0xF3,
  0x1E, 0x43, 0xC8, 0x79, 0x0F, 0x31, 0xA7, 0xF4, 0x76, 0xC0, 0x1C, 0x01,
  0xFC, 0x0F, 0x80, 0x0E, 0x00, 0xE0, 0x0B, 0x01, 0xB0, 0x1B, 0x01, 0x18,
  0x31, 0x83, 0x18, 0x20, 0xC7, 0xFC, 0x7F, 0xC6, 0x0C, 0xC0, 0x6C, 0x06,
  0xC0, 0x70, 0xFF, 0x3F, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6F, 0xF3, 0xFE,
  0xC1, 0xB0, 0x3C, 0x0F, 0x03, 0xC1, 0xFF, 0xEF, 0xF0, 0x1E, 0x1F, 0xC6,
  0x1B, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x03,
  0x61, 0x9F, 0xC1, 0xE0, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0xC3, 0xBF, 0xCF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0xFB, 0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F,
  0x0F, 0xE7, 0x0D, 0x83, 0x40, 0x30, 0x0C, 0x03, 0x0F, 0xC3, 0xF0, 0x1C,
  0x05, 0x81, 0x70, 0xCF, 0xD1, 0xE4, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0xFF,
  0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC7, 0xFF, 0xFE, 0x7F, 0xBF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x78, 0x3C, 0x33, 0xF8, 0xF0, 0xC0, 0xF8, 0x33,
  0x0C, 0x63, 0x8C, 0x61, 0x98, 0x36, 0x07, 0xE0, 0xEE, 0x18, 0xC3, 0x0C,
  0x61, 0x8C, 0x19, 0x81, 0xB0, 0x38, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFF, 0xFE, 0xE0,
  0xFE, 0x1F, 0xC7, 0xE8, 0xFD, 0xB7, 0x96, 0xF3, 0x9E, 0x73, 0xC4, 0x78,
  0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0xE0, 0xF0, 0x68, 0x36,
  0x1B, 0x0C, 0xC6, 0x63, 0x11, 0x8C, 0xC2, 0x61, 0xB0, 0xD8, 0x3C, 0x1E,
  0x06, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x64, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0xFF, 0x3F,
  0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFE, 0xFF, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x64, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x67, 0x1C, 0x7F,
  0x07, 0xC0, 0x20, 0x04, 0x00, 0xF8, 0x0F, 0x00, 0xFF, 0x3F, 0xEC, 0x1F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFE, 0xFF, 0x31, 0x8C, 0x63, 0x0C, 0xC3,
  0x30, 0x6C, 0x0C, 0x1F, 0x0F, 0xF9, 0x83, 0xA0, 0x24, 0x00, 0xC0, 0x1F,
  0x81, 0xFE, 0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x3E, 0x0E, 0xFF, 0x87, 0xC0,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x3E, 0x1B, 0xF8, 0xF8, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x66, 0x0C, 0xC1,
  0x8C, 0x21, 0x8C, 0x31, 0x83, 0x30, 0x6C, 0x0D, 0x80, 0xB0, 0x1C, 0x03,
  0x80, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0xE7, 0x9C, 0xF2, 0x9E, 0x53,
  0xCB, 0x6B, 0x6D, 0x65, 0xA8, 0xB5, 0x1C, 0xE3, 0x9C, 0x70, 0xC0, 0x76,
  0x06, 0x60, 0xC3, 0x18, 0x19, 0x81, 0xB0, 0x0E, 0x00, 0x60, 0x0E, 0x01,
  0xB0, 0x19, 0x83, 0x18, 0x60, 0xC6, 0x06, 0xC0, 0x70, 0xE0, 0x3B, 0x01,
  0x8C, 0x18, 0x70, 0xC1, 0x8C, 0x06, 0x60, 0x36, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xFF, 0xC0, 0x20,
  0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0xFF, 0xF0, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xFF,
  0x0E, 0x01, 0xC0, 0x6C, 0x08, 0xC3, 0x18, 0x41, 0x98, 0x36, 0x03, 0xC0,
  0x60, 0xFF, 0xFF, 0xFC, 0xC6, 0x63, 0x1F, 0x07, 0xF1, 0x86, 0x20, 0x60,
  0x0C, 0x7F, 0x9F, 0xF6, 0x06, 0xC1, 0xCF, 0xDC, 0xF1, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x33, 0xCF, 0xFB, 0x86, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x6F, 0xFB, 0x3C, 0x1E, 0x3F, 0x98, 0x78, 0x2C, 0x06,
  0x03, 0x01, 0x81, 0xE1, 0xBF, 0x87, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC7, 0xB7, 0xFD, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD8,
  0x37, 0xFC, 0x7B, 0x1F, 0x07, 0xF1, 0x83, 0x20, 0x27, 0xFF, 0xFF, 0xD0,
  0x03, 0x00, 0x70, 0xC7, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x80, 0x20,
  0x08, 0x3F, 0xFF, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x0F, 0xFB, 0xFE, 0x00, 0xE0, 0x1C, 0x7E, 0x1F, 0xC6, 0x0C, 0xC1, 0x98,
  0x31, 0xFC, 0x1F, 0x04, 0x01, 0x80, 0x1F, 0xE3, 0xFE, 0x80, 0x70, 0x1B,
  0xFF, 0x3F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x73, 0x7D, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFE,
  0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0, 0xC6, 0x30,
  0xCC, 0x1B, 0x83, 0xF0, 0x73, 0x0C, 0x31, 0x83, 0x30, 0x66, 0x07, 0xF8,
  0x7C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x43, 0xFF, 0xFF, 0xD9, 0xDF, 0xBF, 0x39, 0xE2, 0x3C, 0x47,
  0x88, 0xF1, 0x1E, 0x23, 0xC4, 0x78, 0x8F, 0x11, 0x80, 0xCE, 0x6F, 0xB8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x1F, 0x07,
  0xF1, 0xC3, 0x30, 0x24, 0x07, 0x80, 0xD0, 0x1B, 0x02, 0x70, 0xC7, 0xF0,
  0x7C, 0x00, 0xCF, 0x3F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xE1, 0xBF, 0xEC, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1E, 0xDF, 0xF6,
  0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xDF, 0xF1, 0xEC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0xF9, 0xFE, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x3F, 0xEF, 0xF8, 0x1F, 0x07, 0xF9, 0x83, 0x30, 0x07,
  0xE0, 0x7F, 0x80, 0xF0, 0x03, 0x60, 0xDF, 0xF8, 0x7C, 0x00, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x0F, 0xFF, 0xFF, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xC3, 0xF8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xBF, 0xCF, 0x60, 0xC0, 0x6C, 0x09, 0x83,
  0x10, 0x43, 0x18, 0x63, 0x04, 0x40, 0xD8, 0x0B, 0x01, 0xC0, 0x38, 0x00,
  0x86, 0x38, 0xE2, 0xCA, 0x2C, 0xA2, 0xCB, 0x65, 0xB6, 0x59, 0x65, 0x14,
  0x51, 0x47, 0x1C, 0x71, 0xC0, 0xE0, 0xE6, 0x18, 0xC6, 0x0D, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xD8, 0x31, 0x8C, 0x1B, 0x83, 0x80, 0xC0, 0x6C, 0x09,
  0x83, 0x10, 0x63, 0x18, 0x23, 0x06, 0x40, 0xD8, 0x0E, 0x01, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0x8F, 0xC6, 0x03, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x06, 0x7E, 0x3F, 0x00, 0xC0, 0x60, 0x20, 0x20,
  0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x18, 0x07, 0xC3, 0xE3, 0x01, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x02, 0x3F, 0x1F, 0x80, 0x38, 0x2F, 0x8D, 0x39,
  0xE3, 0xEC, 0x38,
};

const GFXglyph IBMPlexMono_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 5, 6, 13, 4, -16 },
  { 11, 13, 15, 13, 0, -15 },
  { 36, 11, 19, 13, 1, -17 },
  { 63, 13, 15, 13, 0, -15 },
  { 88, 12, 15, 13, 1, -15 },
  { 111, 1, 6, 13, 6, -16 },
  { 112, 6, 20, 13, 5, -17 },
  { 127, 7, 20, 13, 2, -17 },
  { 145, 11, 11, 13, 1, -13 },
  { 161, 11, 12, 13, 1, -13 },
  { 178, 4, 6, 13, 4, -3 },
  { 181, 7, 2, 13, 3, -8 },
  { 183, 3, 3, 13, 5, -3 },
  { 185, 9, 20, 13, 2, -17 },
  { 208, 11, 15, 13, 1, -15 },
  { 229, 11, 15, 13, 1, -15 },
  { 250, 11, 15, 13, 1, -15 },
  { 271, 10, 15, 13, 1, -15 },
  { 290, 11, 15, 13, 1, -15 },
  { 311, 10, 15, 13, 2, -15 },
  { 330, 11, 15, 13, 1, -15 },
  { 351, 11, 15, 13, 1, -15 },
  { 372, 11, 15, 13, 1, -15 },
  { 393, 11, 15, 13, 1, -15 },
  { 414, 3, 12, 13, 5, -12 },
  { 419, 4, 15, 13, 4, -12 },
  { 427, 9, 13, 13, 2, -13 },
  { 442, 11, 6, 13, 1, -10 },
  { 451, 9, 13, 13, 2, -13 },
  { 466, 9, 15, 13, 2, -15 },
  { 483, 11, 17, 13, 1, -15 },
  { 507, 12, 15, 13, 1, -15 },
  { 530, 10, 15, 13, 2, -15 },
  { 549, 10, 15, 13, 2, -15 },
  { 568, 10, 15, 13, 2, -15 },
  { 587, 9, 15, 13, 2, -15 },
  { 604, 10, 15, 13, 2, -15 },
  { 623, 10, 15, 13, 1, -15 },
  { 642, 9, 15, 13, 2, -15 },
  { 659, 9, 15, 13, 2, -15 },
  { 676, 9, 15, 13, 2, -15 },
  { 693, 11, 15, 13, 2, -15 },
  { 714, 9, 15, 13, 3, -15 },
  { 731, 11, 15, 13, 1, -15 },
  { 752, 9, 15, 13, 2, -15 },
  { 769, 11, 15, 13, 1, -15 },
  { 790, 10, 15, 13, 2, -15 },
  { 809, 11, 19, 13, 1, -15 },
  { 836, 10, 15, 13, 2, -15 },
  { 855, 11, 15, 13, 1, -15 },
  { 876, 12, 15, 13, 1, -15 },
  { 899, 9, 15, 13, 2, -15 },
  { 916, 11, 15, 13, 1, -15 },
  { 937, 11, 15, 13, 1, -15 },
  { 958, 12, 15, 13, 1, -15 },
  { 981, 13, 15, 13, 0, -15 },
  { 1006, 11, 15, 13, 1, -15 },
  { 1027, 6, 20, 13, 5, -17 },
  { 1042, 9, 20, 13, 2, -17 },
  { 1065, 6, 20, 13, 2, -17 },
  { 1080, 11, 9, 13, 1, -15 },
  { 1093, 11, 2, 13, 1, 2 },
  { 1096, 4, 4, 13, 4, -17 },
  { 1098, 11, 11, 13, 1, -11 },
  { 1114, 10, 16, 13, 2, -16 },
  { 1134, 9, 11, 13, 2, -11 },
  { 1147, 10, 16, 13, 1, -16 },
  { 1167, 11, 11, 13, 1, -11 },
  { 1183, 10, 16, 13, 2, -16 },
  { 1203, 11, 17, 13, 1, -13 },
  { 1227, 9, 16, 13, 2, -16 },
  { 1245, 10, 16, 13, 2, -16 },
  { 1265, 8, 20, 13, 2, -16 },
  { 1285, 11, 16, 13, 2, -16 },
  { 1307, 9, 16, 13, 2, -16 },
  { 1325, 11, 11, 13, 1, -11 },
  { 1341, 9, 11, 13, 2, -11 },
  { 1354, 11, 11, 13, 1, -11 },
  { 1370, 10, 15, 13, 2, -11 },
  { 1389, 10, 15, 13, 1, -11 },
  { 1408, 10, 11, 13, 2, -11 },
  { 1422, 11, 11, 13, 1, -11 },
  { 1438, 11, 15, 13, 1, -15 },
  { 1459, 9, 11, 13, 2, -11 },
  { 1472, 11, 11, 13, 1, -11 },
  { 1488, 12, 11, 13, 1, -11 },
  { 1505, 11, 11, 13, 1, -11 },
  { 1521, 11, 15, 13, 1, -11 },
  { 1542, 9, 11, 13, 2, -11 },
  { 1555, 9, 20, 13, 2, -17 },
  { 1578, 1, 20, 13, 6, -17 },
  { 1581, 9, 20, 13, 2, -17 },
  { 1604, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Regular22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_REGULAR22PT7B_H_
