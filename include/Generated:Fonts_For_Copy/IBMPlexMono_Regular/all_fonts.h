#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/IBMPlexMono_Regular
// Headers: 67

#include "IBMPlexMono_Regular6pt7b.h"
#include "IBMPlexMono_Regular7pt7b.h"
#include "IBMPlexMono_Regular8pt7b.h"
#include "IBMPlexMono_Regular9pt7b.h"
#include "IBMPlexMono_Regular10pt7b.h"
#include "IBMPlexMono_Regular11pt7b.h"
#include "IBMPlexMono_Regular12pt7b.h"
#include "IBMPlexMono_Regular13pt7b.h"
#include "IBMPlexMono_Regular14pt7b.h"
#include "IBMPlexMono_Regular15pt7b.h"
#include "IBMPlexMono_Regular16pt7b.h"
#include "IBMPlexMono_Regular17pt7b.h"
#include "IBMPlexMono_Regular18pt7b.h"
#include "IBMPlexMono_Regular19pt7b.h"
#include "IBMPlexMono_Regular20pt7b.h"
#include "IBMPlexMono_Regular21pt7b.h"
#include "IBMPlexMono_Regular22pt7b.h"
#include "IBMPlexMono_Regular23pt7b.h"
#include "IBMPlexMono_Regular24pt7b.h"
#include "IBMPlexMono_Regular25pt7b.h"
#include "IBMPlexMono_Regular26pt7b.h"
#include "IBMPlexMono_Regular27pt7b.h"
#include "IBMPlexMono_Regular28pt7b.h"
#include "IBMPlexMono_Regular29pt7b.h"
#include "IBMPlexMono_Regular30pt7b.h"
#include "IBMPlexMono_Regular31pt7b.h"
#include "IBMPlexMono_Regular32pt7b.h"
#include "IBMPlexMono_Regular33pt7b.h"
#include "IBMPlexMono_Regular34pt7b.h"
#include "IBMPlexMono_Regular35pt7b.h"
#include "IBMPlexMono_Regular36pt7b.h"
#include "IBMPlexMono_Regular37pt7b.h"
#include "IBMPlexMono_Regular38pt7b.h"
#include "IBMPlexMono_Regular39pt7b.h"
#include "IBMPlexMono_Regular40pt7b.h"
#include "IBMPlexMono_Regular41pt7b.h"
#include "IBMPlexMono_Regular42pt7b.h"
#include "IBMPlexMono_Regular43pt7b.h"
#include "IBMPlexMono_Regular44pt7b.h"
#include "IBMPlexMono_Regular45pt7b.h"
#include "IBMPlexMono_Regular46pt7b.h"
#include "IBMPlexMono_Regular47pt7b.h"
#include "IBMPlexMono_Regular48pt7b.h"
#include "IBMPlexMono_Regular49pt7b.h"
#include "IBMPlexMono_Regular50pt7b.h"
#include "IBMPlexMono_Regular51pt7b.h"
#include "IBMPlexMono_Regular52pt7b.h"
#include "IBMPlexMono_Regular53pt7b.h"
#include "IBMPlexMono_Regular54pt7b.h"
#include "IBMPlexMono_Regular55pt7b.h"
#include "IBMPlexMono_Regular56pt7b.h"
#include "IBMPlexMono_Regular57pt7b.h"
#include "IBMPlexMono_Regular58pt7b.h"
#include "IBMPlexMono_Regular59pt7b.h"
#include "IBMPlexMono_Regular60pt7b.h"
#include "IBMPlexMono_Regular61pt7b.h"
#include "IBMPlexMono_Regular62pt7b.h"
#include "IBMPlexMono_Regular63pt7b.h"
#include "IBMPlexMono_Regular64pt7b.h"
#include "IBMPlexMono_Regular65pt7b.h"
#include "IBMPlexMono_Regular66pt7b.h"
#include "IBMPlexMono_Regular67pt7b.h"
#include "IBMPlexMono_Regular68pt7b.h"
#include "IBMPlexMono_Regular69pt7b.h"
#include "IBMPlexMono_Regular70pt7b.h"
#include "IBMPlexMono_Regular71pt7b.h"
#include "IBMPlexMono_Regular72pt7b.h"
