#ifndef _IBMPLEXMONO_REGULAR46PT7B_H_
#define _IBMPLEXMONO_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF3, 0xFF, 0xFF, 0xDF, 0xBE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x3C, 0x07, 0xFE, 0x0F,
  0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xC0, 0x78, 0x38, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x3C, 0x1C, 0x03, 0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF,
  0xC0, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0x9C, 0xFC, 0x7C,
  0x38, 0x7C, 0xF0, 0x70, 0x71, 0xE0, 0xE0, 0x43, 0x81, 0xC0, 0x0F, 0x03,
  0x80, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38,
  0x00, 0x7C, 0x70, 0x00, 0xFE, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x7C, 0x00, 0x38, 0x7C,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0,
  0x07, 0x03, 0x90, 0x0E, 0x0F, 0x30, 0x1C, 0x1E, 0xF0, 0x38, 0x7F, 0xF0,
  0x71, 0xF1, 0xF8, 0xE7, 0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0xFF,
  0x00, 0x39, 0xE1, 0xE0, 0x1C, 0xF0, 0x38, 0x07, 0x38, 0x0E, 0x03, 0x8E,
  0x03, 0xC0, 0xE3, 0x80, 0xF0, 0x70, 0xE0, 0x3C, 0x3C, 0x38, 0x0F, 0x0E,
  0x0E, 0x03, 0x87, 0x83, 0xC0, 0xE1, 0xC0, 0x78, 0x78, 0xF0, 0x1F, 0xFC,
  0x38, 0x03, 0xFE, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x8F, 0xF8, 0x03, 0xC7, 0xFF,
  0x00, 0xE1, 0xE1, 0xE0, 0x78, 0xF0, 0x38, 0x1C, 0x38, 0x0E, 0x0F, 0x0E,
  0x01, 0xC3, 0x83, 0x80, 0x71, 0xE0, 0xE0, 0x1C, 0x70, 0x38, 0x07, 0x3C,
  0x0E, 0x03, 0x8E, 0x03, 0xC0, 0xE7, 0x00, 0x78, 0x79, 0xC0, 0x1F, 0xFC,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x06, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x3F,
  0x8F, 0xF8, 0x1F, 0xCF, 0x1E, 0x0F, 0xE7, 0x8F, 0x87, 0x07, 0x83, 0xC3,
  0x83, 0x80, 0xF1, 0xC3, 0xC0, 0x3C, 0xE1, 0xE0, 0x0F, 0x70, 0xF0, 0x07,
  0xB0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x1F, 0x83, 0xE0, 0x19, 0xE0, 0xF8, 0x1C, 0x78, 0x3F, 0xFC, 0x1E, 0x0F,
  0xFC, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C, 0x06, 0xFC, 0x3C, 0x3E, 0xFF,
  0xBD, 0xFE, 0x7F, 0xFF, 0xFD, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x03,
  0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x8F, 0x8F,
  0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E,
  0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x70, 0x00,
  0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x1E, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3,
  0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x1E, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x39, 0xC0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0x81, 0xF0,
  0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0,
  0x03, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1E, 0x00,
  0xE0, 0x3C, 0x00, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x00,
  0x0F, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC,
  0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xCC, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xF0, 0x03, 0xC7,
  0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x71, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE1,
  0xF8, 0x03, 0x9F, 0xF8, 0x0E, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0, 0x07,
  0xC1, 0x80, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE3, 0x00,
  0x07, 0x9E, 0x00, 0x3C, 0xFC, 0x01, 0xF0, 0xFC, 0x0F, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x7E, 0x01, 0xE7, 0xFE, 0x07, 0xBF, 0xFE, 0x3D,
  0xC0, 0xFC, 0xFC, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x39, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x3C,
  0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC,
  0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0,
  0x00, 0x79, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0xF0, 0xF0, 0x03, 0x81, 0xF0, 0x3E, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x79, 0xF0, 0x03, 0xE3,
  0xE0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x3C, 0x01,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x3E, 0x7C, 0x01, 0xB8, 0xFC, 0x0D,
  0xE1, 0xFF, 0xF7, 0x83, 0xFF, 0x9E, 0x03, 0xF8, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFF,
  0xFF, 0xDF, 0xBE, 0x3E, 0x1F, 0x9F, 0xCF, 0xE3, 0xF1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x07,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x03, 0xE7,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x0F, 0x1E, 0x00,
  0x79, 0xE0, 0x01, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0xF1, 0xFC,
  0x1F, 0xEF, 0xE0, 0xFF, 0x7E, 0x0F, 0x0F, 0xF0, 0x70, 0x3F, 0x87, 0x80,
  0xFC, 0x3C, 0x07, 0xE1, 0xC0, 0x3F, 0x0E, 0x01, 0xF8, 0x70, 0x0F, 0xC3,
  0x80, 0x7E, 0x1C, 0x03, 0xF0, 0xE0, 0x1F, 0x87, 0x80, 0xFC, 0x3C, 0x07,
  0xE1, 0xE0, 0x3F, 0x07, 0x83, 0xFC, 0x3F, 0x7E, 0xE0, 0xFF, 0x77, 0x03,
  0xF3, 0xB8, 0x04, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xCE, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x03, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x3E, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xE0, 0xFC, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xC0, 0x03,
  0xCE, 0x00, 0x0C, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x0F, 0x00, 0x0F, 0x3E, 0x00,
  0x78, 0x78, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xE0,
  0x1F, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xE0,
  0x01, 0xEF, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0x9F,
  0x00, 0xFC, 0x7C, 0x0F, 0xE3, 0xFF, 0xEF, 0x07, 0xFE, 0x78, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE2, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x01, 0xE7,
  0xC0, 0x3C, 0x7C, 0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0,
  0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x1F,
  0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xFC, 0x00, 0x7B, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFC, 0xF8, 0x03, 0xF8, 0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0x81, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC1,
  0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0E, 0xFE, 0xE0, 0x77, 0xF7, 0x87, 0x3F,
  0x9C, 0x39, 0xFC, 0xE3, 0xCF, 0xE7, 0x9C, 0x7F, 0x1C, 0xE3, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xF8, 0x3F, 0x83, 0xC1, 0xFC,
  0x1C, 0x0F, 0xE0, 0x60, 0x7F, 0x02, 0x03, 0xF8, 0x10, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFE, 0xE0, 0x0F, 0xEF, 0x00, 0xFE, 0xF0, 0x0F, 0xE7, 0x80, 0xFE, 0x78,
  0x0F, 0xE3, 0x80, 0xFE, 0x3C, 0x0F, 0xE1, 0xC0, 0xFE, 0x1E, 0x0F, 0xE1,
  0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xF0, 0xFE, 0x07, 0x0F, 0xE0, 0x78, 0xFE,
  0x07, 0x8F, 0xE0, 0x38, 0xFE, 0x03, 0xCF, 0xE0, 0x1C, 0xFE, 0x01, 0xEF,
  0xE0, 0x1E, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0x81, 0xF0, 0x7E, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xE0, 0x07, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x0F, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0x1E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E,
  0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x3E,
  0x01, 0xF0, 0x7C, 0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xE0, 0x07, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x0F, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3C, 0x1E, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x07, 0x87, 0x80, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xE3, 0xE0, 0x07, 0xE7, 0x80,
  0x03, 0x9E, 0x00, 0x04, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x80,
  0x00, 0x7B, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0xC0,
  0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x83,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xC7,
  0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x3C, 0x0E, 0xF0, 0x7C, 0x0E, 0xF0, 0x7E, 0x0E, 0x70, 0x7E,
  0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x6E, 0x0E, 0x70, 0xEE, 0x0E, 0x70, 0xE7,
  0x1E, 0x70, 0xE7, 0x1E, 0x70, 0xE7, 0x1E, 0x71, 0xC7, 0x1E, 0x71, 0xC7,
  0x1C, 0x79, 0xC3, 0x9C, 0x79, 0xC3, 0x9C, 0x79, 0xC3, 0x9C, 0x7B, 0x83,
  0x9C, 0x3B, 0x83, 0xDC, 0x3B, 0x81, 0xDC, 0x3B, 0x81, 0xDC, 0x3B, 0x81,
  0xDC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x79, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEF,
  0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x80, 0x03, 0xC3, 0x80, 0x03, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x20, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x21, 0xE3, 0xC3, 0xC7, 0x87,
  0x87, 0x0F, 0x0C, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0x83, 0xF0, 0x78, 0x03, 0xC0, 0xC0, 0x07, 0x82, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xC0, 0x1E, 0x3E, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF8, 0x02,
  0xE1, 0xF0, 0x3B, 0xF3, 0xFF, 0xCF, 0xC7, 0xFE, 0x1F, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x3F, 0x81, 0xE3, 0xFF, 0x0F, 0x7F, 0xFC, 0x7B, 0x03,
  0xF3, 0xF0, 0x07, 0x9F, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x7C, 0x00, 0xFB, 0xF0, 0x07, 0x9E, 0xC0, 0xFC,
  0xF7, 0xFF, 0xC7, 0x9F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x78,
  0x00, 0x87, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x47, 0x80, 0x0F, 0x3C, 0x01,
  0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x03, 0xF0, 0x70, 0xFF, 0xC7, 0x1F, 0xFE, 0x73, 0xF0, 0x77, 0x7C, 0x01,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x7C, 0x01, 0xF3, 0xF0, 0x77, 0x1F, 0xFE, 0x70, 0xFF, 0xC7,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1E, 0x00,
  0x1E, 0x70, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x02, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0xF8, 0x7C, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xEC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07,
  0x80, 0x1C, 0x0F, 0x00, 0x78, 0x0F, 0x81, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF1, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xF8, 0x01, 0xF9,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x1F, 0x83, 0x8F, 0xF8,
  0xE7, 0xFF, 0x3B, 0x03, 0xEE, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFE, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x07, 0xC3,
  0xC0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x78,
  0x01, 0xE7, 0x80, 0x0F, 0x7E, 0x00, 0x7F, 0xF8, 0x03, 0xFB, 0xE0, 0x1F,
  0x0F, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1F,
  0x0F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x3E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0xF9, 0xEF, 0xE3, 0xFB,
  0xDF, 0xEF, 0xF7, 0xC3, 0xF1, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x81, 0xFC,
  0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0,
  0xF0, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F,
  0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0,
  0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x03,
  0xF8, 0x1E, 0x07, 0xE1, 0xF8, 0x38, 0xFF, 0x8E, 0x7F, 0xF3, 0xB0, 0x3E,
  0xE8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x01, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x01, 0xF0, 0xE0,
  0x03, 0xC7, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0x8E, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xF0, 0xFE, 0x07, 0x8F, 0xFC, 0x3D,
  0xFF, 0xF1, 0xEC, 0x0F, 0xCF, 0xC0, 0x1E, 0x7C, 0x00, 0xFB, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0xC0,
  0x1E, 0x7B, 0x03, 0xF3, 0xDF, 0xFF, 0x1E, 0x7F, 0xF0, 0xF0, 0xFE, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x70,
  0xFF, 0xC7, 0x1F, 0xFE, 0x73, 0xF0, 0x77, 0x7C, 0x01, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C,
  0x01, 0xF3, 0xF0, 0x77, 0x1F, 0xFE, 0x70, 0xFF, 0xC7, 0x03, 0xF0, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0xF7, 0x00, 0x03, 0xD8, 0x00, 0x0F, 0x40,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7E, 0x07,
  0xE3, 0xC0, 0x07, 0x9C, 0x00, 0x11, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC8, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xBF, 0x80, 0xF8,
  0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x3E, 0x7C, 0x1F, 0xCF, 0xFF, 0x78, 0xFF, 0xCF, 0x07, 0xF0, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1C, 0x38,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80,
  0x1C, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0F,
  0x38, 0x00, 0x3C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x1E, 0x03, 0xB8, 0x0F, 0x01,
  0xDC, 0x0F, 0x80, 0xEE, 0x07, 0xE0, 0x77, 0x03, 0xF0, 0x7B, 0x81, 0xB8,
  0x39, 0xC0, 0xCC, 0x1C, 0x70, 0xE6, 0x0E, 0x38, 0x73, 0x87, 0x1C, 0x39,
  0xC3, 0x8E, 0x18, 0xE1, 0xC7, 0x0C, 0x70, 0xC3, 0x8E, 0x18, 0xE1, 0xC7,
  0x0C, 0x70, 0x73, 0x87, 0x38, 0x39, 0x83, 0x9C, 0x1C, 0xC1, 0xCE, 0x0E,
  0xE0, 0x67, 0x07, 0x70, 0x33, 0x03, 0xB8, 0x1D, 0x81, 0xD8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x7D,
  0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0xF8, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07,
  0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0xE3,
  0xC0, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x0C, 0x1F, 0xC0, 0x1C, 0x7F, 0xC0, 0x39, 0xE7, 0xC0, 0xF3,
  0x87, 0x81, 0xCE, 0x07, 0x83, 0x9C, 0x07, 0x8E, 0x38, 0x07, 0xFC, 0x70,
  0x07, 0xF1, 0xC0, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 32, 28, 10, -32 },
  { 29, 12, 13, 28, 8, -34 },
  { 49, 26, 32, 28, 1, -32 },
  { 153, 23, 44, 28, 2, -38 },
  { 280, 26, 34, 28, 1, -33 },
  { 391, 25, 34, 28, 1, -33 },
  { 498, 4, 13, 28, 12, -34 },
  { 505, 14, 41, 28, 9, -35 },
  { 577, 13, 41, 28, 5, -35 },
  { 644, 24, 23, 28, 2, -26 },
  { 713, 22, 23, 28, 3, -26 },
  { 777, 9, 12, 28, 9, -6 },
  { 791, 13, 3, 28, 7, -15 },
  { 796, 7, 6, 28, 10, -6 },
  { 802, 19, 41, 28, 4, -35 },
  { 900, 22, 34, 28, 3, -33 },
  { 994, 23, 32, 28, 2, -32 },
  { 1086, 22, 33, 28, 3, -33 },
  { 1177, 22, 34, 28, 2, -33 },
  { 1271, 24, 32, 28, 2, -32 },
  { 1367, 22, 33, 28, 3, -32 },
  { 1458, 22, 33, 28, 3, -32 },
  { 1549, 21, 32, 28, 3, -32 },
  { 1633, 22, 34, 28, 3, -33 },
  { 1727, 22, 33, 28, 3, -33 },
  { 1818, 7, 24, 28, 10, -24 },
  { 1839, 9, 30, 28, 9, -24 },
  { 1873, 20, 27, 28, 4, -28 },
  { 1941, 22, 12, 28, 3, -20 },
  { 1974, 20, 27, 28, 4, -28 },
  { 2042, 19, 33, 28, 4, -33 },
  { 2121, 21, 38, 28, 3, -33 },
  { 2221, 25, 32, 28, 1, -32 },
  { 2321, 21, 32, 28, 4, -32 },
  { 2405, 22, 34, 28, 3, -33 },
  { 2499, 21, 32, 28, 4, -32 },
  { 2583, 20, 32, 28, 4, -32 },
  { 2663, 20, 32, 28, 4, -32 },
  { 2743, 21, 34, 28, 3, -33 },
  { 2833, 20, 32, 28, 4, -32 },
  { 2913, 20, 32, 28, 4, -32 },
  { 2993, 19, 33, 28, 3, -32 },
  { 3072, 23, 32, 28, 4, -32 },
  { 3164, 19, 32, 28, 6, -32 },
  { 3240, 21, 32, 28, 3, -32 },
  { 3324, 20, 32, 28, 4, -32 },
  { 3404, 22, 34, 28, 3, -33 },
  { 3498, 21, 32, 28, 4, -32 },
  { 3582, 22, 40, 28, 3, -33 },
  { 3692, 21, 32, 28, 4, -32 },
  { 3776, 23, 34, 28, 2, -33 },
  { 3874, 25, 32, 28, 1, -32 },
  { 3974, 20, 33, 28, 4, -32 },
  { 4057, 24, 32, 28, 2, -32 },
  { 4153, 24, 32, 28, 2, -32 },
  { 4249, 25, 32, 28, 1, -32 },
  { 4349, 26, 32, 28, 1, -32 },
  { 4453, 23, 32, 28, 2, -32 },
  { 4545, 13, 41, 28, 10, -35 },
  { 4612, 19, 41, 28, 4, -35 },
  { 4710, 13, 41, 28, 4, -35 },
  { 4777, 24, 19, 28, 2, -32 },
  { 4834, 22, 3, 28, 3, 5 },
  { 4843, 7, 9, 28, 9, -36 },
  { 4851, 22, 25, 28, 3, -24 },
  { 4920, 21, 35, 28, 4, -34 },
  { 5012, 20, 25, 28, 4, -24 },
  { 5075, 20, 35, 28, 3, -34 },
  { 5163, 22, 25, 28, 3, -24 },
  { 5232, 22, 34, 28, 3, -34 },
  { 5326, 23, 37, 28, 3, -27 },
  { 5433, 18, 34, 28, 5, -34 },
  { 5510, 20, 34, 28, 5, -34 },
  { 5595, 17, 43, 28, 4, -34 },
  { 5687, 21, 34, 28, 5, -34 },
  { 5777, 20, 34, 28, 4, -34 },
  { 5862, 23, 24, 28, 2, -24 },
  { 5931, 18, 24, 28, 5, -24 },
  { 5985, 22, 25, 28, 3, -24 },
  { 6054, 21, 33, 28, 4, -24 },
  { 6141, 20, 33, 28, 3, -24 },
  { 6224, 22, 24, 28, 4, -24 },
  { 6290, 21, 25, 28, 3, -24 },
  { 6356, 22, 32, 28, 2, -32 },
  { 6444, 19, 25, 28, 4, -24 },
  { 6504, 22, 24, 28, 3, -24 },
  { 6570, 25, 24, 28, 1, -24 },
  { 6645, 22, 24, 28, 3, -24 },
  { 6711, 23, 33, 28, 2, -24 },
  { 6806, 20, 24, 28, 4, -24 },
  { 6866, 18, 41, 28, 5, -35 },
  { 6959, 3, 41, 28, 12, -35 },
  { 6975, 18, 41, 28, 5, -35 },
  { 7068, 23, 10, 28, 2, -19 },
};

const GFXfont IBMPlexMono_Regular46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_REGULAR46PT7B_H_
