#ifndef _IBMPLEXMONO_REGULAR47PT7B_H_
#define _IBMPLEXMONO_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0xDF, 0xFF, 0xFE, 0x78, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07,
  0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x07, 0xFF,
  0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0xFF, 0xC0, 0x38, 0x3C, 0x00,
  0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0,
  0x7F, 0xEF, 0xF8, 0x1F, 0xF8, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x9C, 0xFE, 0x1E, 0x1C, 0x3E, 0x3C, 0x1C, 0x1F, 0x3C,
  0x1C, 0x0C, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x1C, 0x00, 0x1F, 0x1C, 0x00, 0x1F,
  0xDC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1F, 0x00,
  0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x20,
  0x1C, 0x0F, 0x30, 0x1C, 0x0F, 0x78, 0x1C, 0x1E, 0xFE, 0x1C, 0x3E, 0x3F,
  0x9C, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x01, 0xCF, 0xF8, 0x00, 0xF7, 0xFF, 0x00, 0x39,
  0xE1, 0xE0, 0x1E, 0xF0, 0x38, 0x07, 0x38, 0x07, 0x03, 0x8E, 0x01, 0xC1,
  0xE3, 0x80, 0x70, 0x70, 0xE0, 0x1C, 0x3C, 0x38, 0x07, 0x0E, 0x0E, 0x01,
  0xC7, 0x83, 0xC0, 0xE1, 0xC0, 0x78, 0x78, 0xF0, 0x1F, 0xFC, 0x38, 0x03,
  0xFE, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF0, 0x07, 0x8F, 0xFE, 0x03, 0xC7, 0x87, 0x80, 0xE1,
  0xC0, 0xF0, 0x78, 0x70, 0x1C, 0x1C, 0x3C, 0x07, 0x0F, 0x0E, 0x01, 0xC3,
  0x83, 0x80, 0x71, 0xE0, 0xE0, 0x1C, 0x70, 0x3C, 0x07, 0x3C, 0x07, 0x01,
  0xCE, 0x01, 0xC0, 0xF7, 0x80, 0x78, 0x79, 0xC0, 0x0F, 0xFE, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x30,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0x87, 0xFC, 0x07, 0xE3, 0xE7, 0x81, 0xF8, 0xF0, 0xF0, 0x70, 0x78, 0x3E,
  0x1C, 0x1E, 0x07, 0x8F, 0x0F, 0x00, 0xF3, 0x83, 0xC0, 0x1E, 0xE0, 0xF0,
  0x03, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0xFC, 0x1F, 0x00, 0x6F, 0x83, 0xE0, 0x71, 0xF0, 0x7F, 0xFC,
  0x3E, 0x0F, 0xFC, 0x07, 0x80, 0xFC, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40,
  0x3C, 0x02, 0x78, 0x3C, 0x1F, 0xFF, 0x3C, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x07,
  0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x06, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF0, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xFB,
  0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x1E, 0x0F, 0x78, 0x7E, 0x1F, 0xF0,
  0xFC, 0x3F, 0xE1, 0xF8, 0x7F, 0xC3, 0xF0, 0xFF, 0x83, 0xC1, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3C, 0xE0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x1E, 0x00,
  0x7E, 0x1E, 0x00, 0xFC, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x30, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x9C, 0x00, 0x1E, 0x10, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC,
  0x3E, 0x00, 0xF8, 0xF0, 0x01, 0xE0, 0x80, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xCC, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xF0, 0x03, 0xE3,
  0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE1, 0xFC, 0x03, 0x9F, 0xFC, 0x0E, 0xFF, 0xF8, 0x3F, 0x03,
  0xF0, 0xF0, 0x03, 0xE1, 0x80, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xCC, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xF0, 0x03,
  0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE1, 0xFC, 0x07, 0x9F, 0xFC, 0x1E, 0xFF, 0xF8, 0xF7, 0x03, 0xF3, 0xD0,
  0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7,
  0x00, 0x03, 0xDE, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xF0, 0x03, 0xC1, 0xF0,
  0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x07, 0xC0, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFC, 0x0F, 0xC3,
  0xE0, 0x07, 0xC7, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7,
  0x80, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xFC, 0xFC, 0x0E, 0xF1, 0xFF, 0xF7, 0x83,
  0xFF, 0x9E, 0x03, 0xF8, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0xFF, 0xFE, 0x78,
  0x3C, 0x7E, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xE0, 0x7C, 0x7C, 0x01,
  0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x20, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x1E, 0x00,
  0xF0, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x7C, 0xF7, 0x03, 0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0xF8, 0x7F, 0xC3,
  0xC0, 0xFE, 0x0E, 0x03, 0xF8, 0x78, 0x0F, 0xE1, 0xE0, 0x3F, 0x87, 0x80,
  0xFE, 0x1E, 0x03, 0xF8, 0x78, 0x0F, 0xE1, 0xE0, 0x3F, 0x87, 0x80, 0xFE,
  0x1E, 0x03, 0xF8, 0x78, 0x0F, 0xF0, 0xE0, 0x3F, 0xC3, 0xC1, 0xFF, 0x0F,
  0xDF, 0xDC, 0x1F, 0xEF, 0x70, 0x3F, 0xBD, 0xC0, 0x10, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xC0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0x00, 0x3F,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x03,
  0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x06, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x01, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x7C, 0x7C,
  0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x03, 0xF0,
  0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x3F, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBC, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E, 0x00, 0xF0,
  0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x0D, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x1F, 0x3C, 0x00, 0xFC, 0xF8, 0x07, 0xF1, 0xF0, 0x3B, 0xC3,
  0xFF, 0xCF, 0x07, 0xFE, 0x3C, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x10,
  0x01, 0xEF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3C, 0x3E, 0x07, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFB, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x00, 0x3E, 0x1E, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03,
  0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3C,
  0xFC, 0x00, 0x7B, 0xF8, 0x00, 0xF7, 0xF8, 0x01, 0xFE, 0xF8, 0x03, 0xF8,
  0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0xC1, 0xE0, 0x1F, 0x01, 0xE0, 0x3C, 0x03,
  0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFD, 0xC0, 0xEF, 0xF7,
  0x83, 0xBF, 0xCE, 0x1E, 0xFF, 0x38, 0x73, 0xFC, 0xF1, 0xCF, 0xF1, 0xCE,
  0x3F, 0xC7, 0xB8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x0E, 0x0F, 0xF0, 0x30, 0x3F, 0xC0,
  0xC0, 0xFF, 0x02, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0xF0, 0x07, 0xEF,
  0x00, 0x7E, 0x70, 0x07, 0xE7, 0x80, 0x7E, 0x78, 0x07, 0xE3, 0xC0, 0x7E,
  0x3C, 0x07, 0xE1, 0xC0, 0x7E, 0x1E, 0x07, 0xE1, 0xE0, 0x7E, 0x0F, 0x07,
  0xE0, 0xF0, 0x7E, 0x07, 0x07, 0xE0, 0x78, 0x7E, 0x07, 0x87, 0xE0, 0x3C,
  0x7E, 0x03, 0xC7, 0xE0, 0x1C, 0x7E, 0x01, 0xE7, 0xE0, 0x1E, 0x7E, 0x00,
  0xF7, 0xE0, 0x0F, 0x7E, 0x00, 0x77, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1E,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x79, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x07,
  0xC3, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3C, 0x00, 0x7C, 0xF0, 0x00,
  0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFC, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x03, 0x9F,
  0x00, 0x02, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x7B,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x0F, 0x8F, 0xE0, 0x7E, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3E,
  0x07, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x78, 0x1E, 0x07,
  0xBC, 0x0F, 0x83, 0xCE, 0x0F, 0xC1, 0xE7, 0x07, 0xE0, 0xF3, 0x83, 0xF0,
  0x79, 0xC1, 0xFC, 0x38, 0xE0, 0xEE, 0x1C, 0x70, 0xE7, 0x0E, 0x38, 0x73,
  0x87, 0x1C, 0x39, 0xC3, 0x8F, 0x1C, 0xF1, 0xC7, 0x9E, 0x38, 0xE3, 0xCE,
  0x1C, 0x71, 0xE7, 0x0E, 0x38, 0xF3, 0x87, 0xBC, 0x39, 0xC1, 0xDE, 0x1D,
  0xC0, 0xEF, 0x0E, 0xE0, 0x77, 0x07, 0x70, 0x3B, 0x83, 0xB8, 0x1F, 0xC1,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x1E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF8, 0x01, 0xE0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x31, 0xE3, 0xE3, 0xC3, 0xC7, 0x87,
  0x87, 0x0C, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xF0,
  0x3E, 0x07, 0x80, 0x3E, 0x06, 0x00, 0x3C, 0x08, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x80, 0x38, 0x3C, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x03, 0xBF, 0x9F, 0xFE, 0x3F, 0x1F,
  0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x81, 0xE3, 0xFF,
  0x0F, 0x3F, 0xFC, 0x7B, 0x83, 0xF3, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7B,
  0xE0, 0x03, 0xDF, 0x80, 0x3E, 0xF7, 0x07, 0xE7, 0x9F, 0xFE, 0x3C, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x78, 0x00, 0x47, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x06, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x1F,
  0x03, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0xFC, 0x1E, 0x1F, 0xF8, 0xF1, 0xFF, 0xF7, 0x9F, 0x83, 0xBC, 0xF0, 0x07,
  0xEF, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xE7, 0x80, 0x3F, 0x3F, 0x03, 0x78,
  0xFF, 0xFB, 0xC3, 0xFF, 0x1E, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0xF8, 0x1E, 0x00, 0xF0, 0xF0, 0x03,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x02,
  0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xC1, 0xF8, 0x3F, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xC0, 0x01, 0xF7, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x83, 0xF0, 0x71, 0xFF, 0x8E, 0x7F, 0xF9, 0xDC, 0x1F, 0x3A, 0x01, 0xF7,
  0x80, 0x1E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x3E, 0xF0, 0x01, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C,
  0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7C,
  0x00, 0xF3, 0xE0, 0x03, 0xDF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x9E, 0x00,
  0xFC, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC1, 0xF1, 0xCF, 0xC7, 0xF3, 0xBF, 0xDF, 0xF7, 0xC7, 0xA1, 0xEF, 0x07,
  0x81, 0xDC, 0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78,
  0x1F, 0xC0, 0xF0, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81,
  0xFC, 0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F,
  0xC0, 0xF0, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC,
  0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1E, 0x00,
  0xFC, 0x1C, 0x7F, 0xE3, 0x9F, 0xFE, 0x77, 0x07, 0xCE, 0x80, 0x7D, 0xE0,
  0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0xF0, 0xF0, 0x01, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF8, 0x03, 0xC1,
  0xF0, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEE, 0x0F, 0xCF, 0xC0, 0x1F,
  0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7E, 0x00, 0xFB, 0xDC, 0x1F, 0x9E,
  0x7F, 0xF8, 0xF1, 0xFF, 0x87, 0x83, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE3, 0xC7, 0xFF,
  0xDE, 0x7E, 0x0E, 0xF3, 0xC0, 0x1F, 0xBC, 0x00, 0x7D, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0x9E, 0x00, 0xFC, 0xFC, 0x0D, 0xE3, 0xFF, 0xEF, 0x0F, 0xFC, 0x78, 0x1F,
  0x83, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xC0, 0x73, 0x80, 0x01, 0xD8,
  0x00, 0x07, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xC0, 0x7E, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xC3, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC8, 0x00, 0x0F,
  0x70, 0x00, 0x7B, 0xF0, 0x01, 0xE7, 0xF0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x1F, 0xFE, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF3, 0xE0, 0x6F, 0x1F,
  0xFE, 0xF0, 0xFF, 0xCF, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xC3,
  0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x78,
  0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00,
  0x7B, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0xF0, 0x1E, 0x03, 0xDC, 0x07, 0xC0, 0xF7, 0x01, 0xF0, 0x39, 0xC0,
  0xFC, 0x0E, 0x70, 0x3F, 0x03, 0x9C, 0x0E, 0xC0, 0xE7, 0x83, 0x30, 0x38,
  0xE0, 0xCE, 0x0E, 0x38, 0x73, 0x87, 0x0E, 0x1C, 0xE1, 0xC3, 0x87, 0x18,
  0x70, 0xE1, 0x86, 0x1C, 0x38, 0x61, 0xC7, 0x0F, 0x38, 0x71, 0xC1, 0xCE,
  0x1C, 0x70, 0x73, 0x83, 0x38, 0x1C, 0xE0, 0xCE, 0x07, 0x30, 0x3B, 0x81,
  0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0x00,
  0x78, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0x78, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0x81,
  0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x07,
  0xC0, 0x06, 0x0F, 0xE0, 0x07, 0x1F, 0xF0, 0x0E, 0x3C, 0x78, 0x0E, 0x38,
  0x3C, 0x0E, 0x78, 0x1E, 0x1C, 0x70, 0x1F, 0x3C, 0x70, 0x0F, 0xF8, 0x70,
  0x07, 0xF8, 0xE0, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 33, 28, 11, -33 },
  { 30, 12, 13, 28, 8, -35 },
  { 50, 26, 33, 28, 1, -33 },
  { 158, 24, 44, 28, 2, -38 },
  { 290, 26, 34, 28, 1, -33 },
  { 401, 26, 34, 28, 1, -33 },
  { 512, 4, 13, 28, 12, -35 },
  { 519, 13, 42, 28, 10, -36 },
  { 588, 14, 42, 28, 5, -36 },
  { 662, 24, 23, 28, 2, -27 },
  { 731, 22, 23, 28, 3, -26 },
  { 795, 8, 13, 28, 10, -6 },
  { 808, 14, 3, 28, 7, -16 },
  { 814, 7, 6, 28, 11, -6 },
  { 820, 20, 42, 28, 4, -36 },
  { 925, 23, 34, 28, 3, -33 },
  { 1023, 24, 33, 28, 2, -33 },
  { 1122, 22, 33, 28, 3, -33 },
  { 1213, 22, 34, 28, 2, -33 },
  { 1307, 24, 33, 28, 2, -33 },
  { 1406, 22, 34, 28, 3, -33 },
  { 1500, 22, 34, 28, 3, -33 },
  { 1594, 22, 33, 28, 3, -33 },
  { 1685, 23, 34, 28, 3, -33 },
  { 1783, 22, 33, 28, 3, -33 },
  { 1874, 7, 25, 28, 11, -25 },
  { 1896, 8, 32, 28, 10, -25 },
  { 1928, 20, 27, 28, 4, -28 },
  { 1996, 22, 13, 28, 3, -21 },
  { 2032, 20, 27, 28, 4, -28 },
  { 2100, 20, 33, 28, 4, -33 },
  { 2183, 22, 38, 28, 3, -33 },
  { 2288, 26, 33, 28, 1, -33 },
  { 2396, 22, 33, 28, 4, -33 },
  { 2487, 22, 34, 28, 3, -33 },
  { 2581, 22, 33, 28, 4, -33 },
  { 2672, 20, 33, 28, 4, -33 },
  { 2755, 21, 33, 28, 4, -33 },
  { 2842, 22, 34, 28, 3, -33 },
  { 2936, 20, 33, 28, 4, -33 },
  { 3019, 20, 33, 28, 4, -33 },
  { 3102, 20, 34, 28, 3, -33 },
  { 3187, 23, 33, 28, 4, -33 },
  { 3282, 19, 33, 28, 6, -33 },
  { 3361, 22, 33, 28, 3, -33 },
  { 3452, 20, 33, 28, 4, -33 },
  { 3535, 23, 34, 28, 3, -33 },
  { 3633, 22, 33, 28, 4, -33 },
  { 3724, 23, 40, 28, 3, -33 },
  { 3839, 22, 33, 28, 4, -33 },
  { 3930, 23, 34, 28, 2, -33 },
  { 4028, 26, 33, 28, 1, -33 },
  { 4136, 20, 34, 28, 4, -33 },
  { 4221, 25, 33, 28, 2, -33 },
  { 4325, 25, 33, 28, 2, -33 },
  { 4429, 26, 33, 28, 1, -33 },
  { 4537, 26, 33, 28, 1, -33 },
  { 4645, 24, 33, 28, 2, -33 },
  { 4744, 13, 42, 28, 11, -36 },
  { 4813, 20, 42, 28, 4, -36 },
  { 4918, 14, 42, 28, 4, -36 },
  { 4992, 24, 19, 28, 2, -33 },
  { 5049, 22, 3, 28, 3, 5 },
  { 5058, 7, 9, 28, 9, -37 },
  { 5066, 23, 26, 28, 3, -25 },
  { 5141, 21, 36, 28, 4, -35 },
  { 5236, 20, 26, 28, 4, -25 },
  { 5301, 21, 36, 28, 3, -35 },
  { 5396, 22, 26, 28, 3, -25 },
  { 5468, 23, 35, 28, 3, -35 },
  { 5569, 23, 37, 28, 3, -27 },
  { 5676, 19, 35, 28, 5, -35 },
  { 5760, 21, 35, 28, 5, -35 },
  { 5852, 17, 44, 28, 4, -35 },
  { 5946, 22, 35, 28, 5, -35 },
  { 6043, 20, 35, 28, 4, -35 },
  { 6131, 23, 25, 28, 3, -25 },
  { 6203, 19, 25, 28, 5, -25 },
  { 6263, 22, 26, 28, 3, -25 },
  { 6335, 21, 34, 28, 4, -25 },
  { 6425, 21, 34, 28, 3, -25 },
  { 6515, 22, 24, 28, 4, -24 },
  { 6581, 22, 26, 28, 3, -25 },
  { 6653, 23, 33, 28, 2, -33 },
  { 6748, 20, 25, 28, 4, -24 },
  { 6811, 22, 24, 28, 3, -24 },
  { 6877, 26, 24, 28, 1, -24 },
  { 6955, 22, 24, 28, 3, -24 },
  { 7021, 24, 33, 28, 2, -24 },
  { 7120, 20, 24, 28, 4, -24 },
  { 7180, 18, 42, 28, 5, -36 },
  { 7275, 4, 42, 28, 12, -36 },
  { 7296, 18, 42, 28, 5, -36 },
  { 7391, 24, 10, 28, 2, -19 },
};

const GFXfont IBMPlexMono_Regular47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_REGULAR47PT7B_H_
