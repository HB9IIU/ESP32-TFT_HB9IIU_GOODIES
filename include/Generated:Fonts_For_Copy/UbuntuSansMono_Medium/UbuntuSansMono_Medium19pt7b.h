#ifndef _UBUNTUSANSMONO_MEDIUM19PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x03, 0x7E, 0xCF, 0x3C, 0xD3, 0x44, 0x0D, 0x86,
  0x61, 0x9B, 0xFF, 0xFF, 0xC4, 0x43, 0x30, 0xCC, 0xFF, 0xFF, 0xF2, 0x21,
  0x98, 0x66, 0x00, 0x18, 0x0C, 0x07, 0x8F, 0xE6, 0x17, 0x03, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xE0, 0x78, 0x37, 0xF8, 0xF0, 0x30, 0x18, 0x00, 0x70,
  0xF6, 0x2C, 0x9B, 0x6C, 0x5A, 0x1D, 0x80, 0xC0, 0x2F, 0x1A, 0x44, 0x93,
  0x25, 0x89, 0xC3, 0xC0, 0x7C, 0x33, 0x31, 0x88, 0xC6, 0xC3, 0xC1, 0xE5,
  0xB2, 0xCF, 0x63, 0xB1, 0xDF, 0xE7, 0x98, 0xFF, 0x50, 0x04, 0x31, 0x8C,
  0x71, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x83, 0x0E, 0x1C, 0x30, 0x40,
  0x43, 0x87, 0x0E, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x8E,
  0x73, 0x84, 0x00, 0x18, 0x0C, 0x3A, 0xDF, 0xF1, 0xC1, 0xB1, 0xDC, 0x48,
  0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x77,
  0x73, 0x6C, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0xC0, 0x3E, 0x3B, 0xB8, 0xD8, 0x6C, 0x1E, 0xCF, 0x77, 0x93, 0xC1, 0xE1,
  0x98, 0xCF, 0xE3, 0xE0, 0x0C, 0x1E, 0x3F, 0x0D, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF7, 0xF8, 0x7E, 0x73, 0x90, 0xC0, 0x60,
  0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0xFE, 0x67,
  0x03, 0x03, 0x07, 0x3E, 0x3E, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFE, 0x07,
  0x07, 0x87, 0xC3, 0xE3, 0x73, 0x39, 0x9D, 0x8E, 0xFF, 0xFF, 0xC1, 0xC0,
  0xE0, 0x70, 0x7F, 0x7F, 0x60, 0x60, 0x60, 0x7C, 0x1F, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFE, 0x0F, 0x1F, 0x8C, 0x0C, 0x06, 0x07, 0xF3, 0xFD, 0x86,
  0xC3, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x7E, 0x33, 0xB0,
  0xD8, 0x6E, 0x33, 0xF0, 0xF8, 0xCE, 0xC3, 0xE0, 0xF0, 0xFE, 0xE7, 0xE0,
  0x7E, 0x33, 0xB0, 0xD8, 0x6C, 0x3F, 0x1D, 0xFE, 0x7E, 0x03, 0x03, 0x83,
  0x8F, 0x87, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x77, 0x70, 0x00, 0x07, 0x77,
  0x3E, 0xC0, 0x01, 0x03, 0xC7, 0x9F, 0x0C, 0x07, 0xC0, 0xF8, 0x0F, 0x01,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x78, 0x1F, 0x01,
  0xE0, 0x38, 0x7C, 0xF1, 0xE0, 0xC0, 0x00, 0xFD, 0x9C, 0x18, 0x30, 0xC3,
  0x0C, 0x18, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x3F, 0x31, 0x90, 0x78, 0x3C,
  0xFE, 0xEE, 0x67, 0x33, 0x99, 0xEC, 0xF7, 0xF9, 0xF6, 0x03, 0x80, 0xFC,
  0x1E, 0x0E, 0x03, 0x81, 0xB0, 0x6C, 0x13, 0x0C, 0xC3, 0x18, 0xC6, 0x7F,
  0x9F, 0xF6, 0x0D, 0x83, 0xC0, 0xC0, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x37,
  0xF3, 0xF9, 0x86, 0xC1, 0xE0, 0xF0, 0xFF, 0xEF, 0xE0, 0x3F, 0xBC, 0x98,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0F, 0xF3, 0xF8,
  0xFC, 0x7F, 0x30, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xB1,
  0xDF, 0xCF, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x00, 0x3F, 0xBC, 0x98, 0x18, 0x0C, 0x06, 0x03, 0x07,
  0x83, 0xC1, 0xE0, 0xD8, 0x6F, 0xF3, 0xF8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0xFF, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0xFC,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0xFF, 0xE0, 0x3F, 0x3F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x83, 0xFE, 0x7E, 0xC3,
  0xE3, 0xB1, 0x99, 0x8D, 0xC7, 0xC3, 0xE1, 0xB8, 0xCE, 0x63, 0xB0, 0xD8,
  0x7C, 0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xE3, 0x71, 0xB9, 0xDE, 0xFF, 0x5E, 0xEF, 0x77, 0xB3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xC1, 0xF0, 0xF8, 0x7E, 0x3D, 0x9E,
  0xCF, 0x27, 0x9B, 0xC5, 0xE3, 0xF0, 0xF8, 0x7C, 0x38, 0x3E, 0x33, 0xB0,
  0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3, 0xE0,
  0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x1F, 0xFD, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x00, 0x3E, 0x3B, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0xCF, 0xE3, 0xE0, 0xC0, 0x38, 0x0F, 0x00, 0x80, 0xFE,
  0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0xF9, 0xF8, 0xC6, 0x63, 0x30, 0xD8,
  0x6C, 0x18, 0x7F, 0x39, 0xB0, 0x18, 0x06, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0x01, 0xC0, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xCF, 0xE7, 0xE0, 0xE0,
  0xD8, 0x36, 0x0D, 0x86, 0x71, 0x8C, 0x63, 0x18, 0xCC, 0x1B, 0x06, 0xC1,
  0xA0, 0x38, 0x0E, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0xCF, 0x77,
  0xAB, 0xF5, 0xF3, 0xF8, 0xDC, 0x6C, 0x30, 0x61, 0xCC, 0x63, 0x38, 0x6C,
  0x1E, 0x03, 0x80, 0xE0, 0x7C, 0x1B, 0x0C, 0xE3, 0x19, 0x87, 0xE0, 0xC0,
  0xE0, 0xD8, 0x37, 0x18, 0xC6, 0x33, 0x06, 0xC1, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0x81, 0xC0, 0xC0, 0xC0, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x18, 0x1F, 0xFF, 0xF8, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE0, 0x60, 0x60, 0x70,
  0x30, 0x30, 0x38, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0x03, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x1C, 0x1E, 0x0D, 0x8E, 0xC6, 0x36,
  0x1F, 0x06, 0xFF, 0xFF, 0xF0, 0x4E, 0x71, 0x7E, 0x7F, 0x03, 0x03, 0x3F,
  0xFF, 0xC3, 0xC3, 0xFF, 0x7F, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3,
  0xFD, 0xC6, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x37, 0xFB, 0xF8, 0x1F, 0xBF,
  0x98, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x7F, 0x9F, 0xC0, 0x01, 0x03,
  0x03, 0x03, 0x03, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F,
  0x3F, 0x3E, 0x3F, 0xB8, 0xD8, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x7F, 0x1F,
  0x80, 0x07, 0x0F, 0xCE, 0x26, 0x03, 0x07, 0xFB, 0xFC, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7F, 0x13, 0x03, 0x87, 0xFE, 0x38, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x10,
  0x1C, 0x0E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xFC, 0x3E, 0x04, 0x1C, 0x38, 0x00, 0x0F, 0xDF, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x4F, 0xF8, 0xE0, 0x60, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x1F, 0x9D, 0xDC, 0xFC, 0x7C, 0x3F, 0x1D, 0xCE, 0x67,
  0x1B, 0x8E, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFC, 0x3E, 0xF7, 0x7F, 0xF6, 0x7B, 0x3D,
  0x9E, 0xCF, 0x07, 0x83, 0xC1, 0xE0, 0xC0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3E, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F,
  0x07, 0xC6, 0x7F, 0x1F, 0x00, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E, 0x1F, 0x0F,
  0x87, 0xC6, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0x7F, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x7F,
  0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x7F, 0x60,
  0x60, 0x7C, 0x1F, 0x03, 0x03, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x1F, 0xFF,
  0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0xF1, 0xF8, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x63, 0x7F, 0x3F, 0xE0, 0xD8, 0x36, 0x18,
  0xC6, 0x31, 0x8C, 0xC1, 0xB0, 0x78, 0x0E, 0x03, 0x00, 0xC0, 0xF0, 0x34,
  0x4D, 0x33, 0x6E, 0xDB, 0xB7, 0xA9, 0xCE, 0x31, 0x8C, 0x60, 0xC3, 0xB1,
  0x9D, 0x87, 0x81, 0xC0, 0xE0, 0xD8, 0xCE, 0xE3, 0x60, 0xC0, 0xC1, 0xF1,
  0xD8, 0xCC, 0x66, 0x31, 0xB0, 0xD8, 0x3C, 0x1C, 0x06, 0x06, 0x13, 0x0F,
  0x02, 0x00, 0x7F, 0x7F, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0x7F, 0xFF,
  0x1E, 0x7C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xE1, 0xC1, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF8,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0xF8, 0xE0, 0x79, 0xFF, 0xE3, 0xC0,
};

const GFXglyph UbuntuSansMono_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 6, 5, 11, 2, -14 },
  { 10, 10, 13, 11, 0, -13 },
  { 27, 9, 17, 11, 1, -15 },
  { 47, 10, 13, 11, 0, -13 },
  { 64, 9, 13, 11, 1, -13 },
  { 79, 2, 6, 11, 4, -14 },
  { 81, 6, 19, 11, 2, -15 },
  { 96, 6, 19, 11, 2, -15 },
  { 111, 9, 8, 11, 1, -13 },
  { 120, 9, 9, 11, 1, -10 },
  { 131, 4, 6, 11, 3, -3 },
  { 134, 5, 2, 11, 3, -6 },
  { 136, 3, 3, 11, 4, -3 },
  { 138, 8, 19, 11, 1, -15 },
  { 157, 9, 13, 11, 1, -13 },
  { 172, 9, 13, 11, 1, -13 },
  { 187, 9, 13, 11, 1, -13 },
  { 202, 8, 13, 11, 1, -13 },
  { 215, 9, 13, 11, 1, -13 },
  { 230, 8, 13, 11, 1, -13 },
  { 243, 9, 13, 11, 1, -13 },
  { 258, 9, 13, 11, 1, -13 },
  { 273, 9, 13, 11, 1, -13 },
  { 288, 9, 13, 11, 1, -13 },
  { 303, 3, 10, 11, 4, -10 },
  { 307, 4, 13, 11, 3, -10 },
  { 314, 9, 9, 11, 1, -10 },
  { 325, 9, 6, 11, 1, -9 },
  { 332, 9, 9, 11, 1, -10 },
  { 343, 7, 13, 11, 2, -13 },
  { 355, 9, 16, 11, 1, -13 },
  { 373, 10, 13, 11, 0, -13 },
  { 390, 9, 13, 11, 1, -13 },
  { 405, 9, 13, 11, 1, -13 },
  { 420, 9, 13, 11, 1, -13 },
  { 435, 8, 13, 11, 2, -13 },
  { 448, 7, 13, 11, 2, -13 },
  { 460, 9, 13, 11, 1, -13 },
  { 475, 9, 13, 11, 1, -13 },
  { 490, 7, 13, 11, 2, -13 },
  { 502, 8, 13, 11, 1, -13 },
  { 515, 9, 13, 11, 1, -13 },
  { 530, 8, 13, 11, 2, -13 },
  { 543, 9, 13, 11, 1, -13 },
  { 558, 9, 13, 11, 1, -13 },
  { 573, 9, 13, 11, 1, -13 },
  { 588, 9, 13, 11, 1, -13 },
  { 603, 9, 17, 11, 1, -13 },
  { 623, 9, 13, 11, 1, -13 },
  { 638, 9, 13, 11, 1, -13 },
  { 653, 9, 13, 11, 1, -13 },
  { 668, 9, 13, 11, 1, -13 },
  { 683, 10, 13, 11, 0, -13 },
  { 700, 9, 13, 11, 1, -13 },
  { 715, 10, 13, 11, 0, -13 },
  { 732, 10, 13, 11, 0, -13 },
  { 749, 9, 13, 11, 1, -13 },
  { 764, 5, 19, 11, 3, -15 },
  { 776, 8, 19, 11, 1, -15 },
  { 795, 6, 19, 11, 2, -15 },
  { 810, 9, 7, 11, 1, -13 },
  { 818, 10, 2, 11, 0, 2 },
  { 821, 4, 4, 11, 3, -15 },
  { 823, 8, 10, 11, 1, -10 },
  { 833, 9, 15, 11, 1, -15 },
  { 850, 9, 10, 11, 1, -10 },
  { 862, 8, 15, 11, 1, -15 },
  { 877, 9, 10, 11, 1, -10 },
  { 889, 9, 15, 11, 1, -15 },
  { 906, 8, 14, 11, 1, -10 },
  { 920, 8, 15, 11, 1, -15 },
  { 935, 9, 15, 11, 1, -15 },
  { 952, 7, 19, 11, 1, -15 },
  { 969, 9, 15, 11, 1, -15 },
  { 986, 9, 15, 11, 1, -15 },
  { 1003, 9, 10, 11, 1, -10 },
  { 1015, 8, 10, 11, 1, -10 },
  { 1025, 9, 10, 11, 1, -10 },
  { 1037, 9, 14, 11, 1, -10 },
  { 1053, 8, 14, 11, 1, -10 },
  { 1067, 8, 10, 11, 2, -10 },
  { 1077, 8, 10, 11, 1, -10 },
  { 1087, 9, 13, 11, 1, -13 },
  { 1102, 8, 10, 11, 1, -10 },
  { 1112, 10, 10, 11, 0, -10 },
  { 1125, 10, 10, 11, 0, -10 },
  { 1138, 9, 10, 11, 1, -10 },
  { 1150, 9, 14, 11, 1, -10 },
  { 1166, 8, 10, 11, 1, -10 },
  { 1176, 7, 19, 11, 2, -15 },
  { 1193, 2, 19, 11, 4, -15 },
  { 1198, 8, 19, 11, 1, -15 },
  { 1217, 9, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_Medium19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_MEDIUM19PT7B_H_
