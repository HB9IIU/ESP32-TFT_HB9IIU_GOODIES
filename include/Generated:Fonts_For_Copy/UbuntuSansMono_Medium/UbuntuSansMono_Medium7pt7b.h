#ifndef _UBUNTUSANSMONO_MEDIUM7PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium7pt7bBitmaps[] PROGMEM = {
  0x00, 0xA8, 0xC0, 0xF0, 0x5F, 0x6F, 0xA0, 0x68, 0x61, 0xE4, 0xDE, 0x47,
  0xB0, 0x6A, 0x5A, 0xF0, 0xC0, 0x5A, 0xA4, 0xA5, 0x58, 0x4F, 0x60, 0x4F,
  0x44, 0xE0, 0xC0, 0xC0, 0x24, 0xA5, 0x80, 0x69, 0xD9, 0x60, 0x2E, 0x22,
  0x70, 0xE2, 0x24, 0xF0, 0xE2, 0x61, 0xE0, 0x26, 0xAF, 0x20, 0x69, 0x9E,
  0x24, 0xE9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0x72, 0x60,
  0xCC, 0xCE, 0x1E, 0x61, 0xFF, 0x86, 0x78, 0xDC, 0x80, 0x6B, 0xDD, 0xB6,
  0x66, 0x6E, 0x90, 0xEA, 0xE9, 0xE0, 0x78, 0x88, 0x70, 0xE9, 0x99, 0xE0,
  0xD3, 0x4E, 0xEE, 0x80, 0x78, 0x89, 0x70, 0x99, 0xF9, 0x90, 0xEA, 0xC0,
  0x64, 0x9E, 0x9A, 0xCA, 0x90, 0x92, 0x4E, 0xAF, 0xD9, 0x90, 0x9D, 0xBB,
  0x90, 0x69, 0x99, 0x60, 0xD7, 0x48, 0x69, 0x99, 0x63, 0xE9, 0xEA, 0x90,
  0x68, 0x61, 0xE0, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99, 0x66, 0x60,
  0x99, 0xDF, 0xA0, 0x96, 0x46, 0x90, 0x96, 0x64, 0x40, 0xF2, 0x44, 0xF0,
  0xEA, 0xB0, 0xC9, 0x12, 0x40, 0xD5, 0x70, 0x66, 0x90, 0xF0, 0xC0, 0x67,
  0xB0, 0x9A, 0xDC, 0x78, 0x87, 0x2E, 0xD6, 0x69, 0xE6, 0x7E, 0x44, 0x40,
  0x76, 0xBE, 0xBF, 0xC0, 0x4C, 0x44, 0x30, 0x2C, 0x93, 0xC0, 0x97, 0x6E,
  0xC4, 0x44, 0x30, 0xED, 0xD9, 0xFF, 0x69, 0x96, 0xD6, 0xE8, 0x76, 0xB2,
  0xF2, 0x40, 0x78, 0xF0, 0x4F, 0x44, 0x70, 0xB6, 0xB0, 0x9A, 0x66, 0x9D,
  0xF6, 0x96, 0x69, 0x96, 0x62, 0xC0, 0xDB, 0xEA, 0xB0, 0xFC, 0xD5, 0x70,
  0x5A,
};

const GFXglyph UbuntuSansMono_Medium7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 6, 4, 0, -5 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 1, -5 },
  { 17, 2, 7, 4, 1, -6 },
  { 19, 2, 7, 4, 1, -6 },
  { 21, 4, 3, 4, 0, -5 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 3, 6, 4, 0, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 2, 3, 4, 1, -3 },
  { 61, 2, 4, 4, 1, -3 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 2, 4, 0, -3 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 2, 5, 4, 1, -5 },
  { 69, 4, 6, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 2, 5, 4, 1, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 2, 5, 4, 1, -5 },
  { 96, 3, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 6, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 2, 6, 4, 1, -5 },
  { 146, 3, 6, 4, 0, -5 },
  { 149, 2, 6, 4, 1, -5 },
  { 151, 4, 3, 4, 0, -5 },
  { 153, 4, 1, 4, 0, 0 },
  { 154, 2, 1, 4, 1, -5 },
  { 155, 3, 4, 4, 0, -4 },
  { 157, 3, 5, 4, 1, -5 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 3, 5, 4, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 3, 5, 4, 0, -4 },
  { 170, 2, 5, 4, 1, -5 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 3, 6, 4, 0, -5 },
  { 178, 3, 5, 4, 1, -5 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 2, 4, 4, 1, -4 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 3, 5, 4, 1, -4 },
  { 190, 3, 5, 4, 0, -4 },
  { 192, 3, 4, 4, 1, -4 },
  { 194, 3, 4, 4, 0, -4 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 3, 4, 4, 0, -4 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 5, 4, 0, -4 },
  { 210, 2, 4, 4, 1, -4 },
  { 211, 2, 6, 4, 1, -5 },
  { 213, 1, 6, 4, 1, -5 },
  { 214, 2, 6, 4, 1, -5 },
  { 216, 4, 2, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Medium7pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium7pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUSANSMONO_MEDIUM7PT7B_H_
