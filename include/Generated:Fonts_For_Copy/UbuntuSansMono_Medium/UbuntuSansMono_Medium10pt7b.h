#ifndef _UBUNTUSANSMONO_MEDIUM10PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAC, 0xB6, 0x80, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x46, 0x98,
  0xE1, 0x9E, 0x40, 0xCD, 0x6C, 0xC3, 0xAE, 0x60, 0x72, 0x94, 0xDB, 0xCD,
  0xE0, 0xF0, 0x2D, 0x49, 0x22, 0x64, 0x88, 0x92, 0x49, 0x50, 0x4F, 0x4B,
  0x21, 0x3E, 0x42, 0x00, 0xF6, 0xE0, 0xB0, 0x13, 0x22, 0x64, 0x4C, 0x88,
  0x72, 0x53, 0xD4, 0xA5, 0xC0, 0x6E, 0x22, 0x22, 0xF0, 0xE9, 0x32, 0x48,
  0xF0, 0xE1, 0x36, 0x11, 0xE0, 0x11, 0x8C, 0xAF, 0x88, 0x40, 0xF8, 0x8E,
  0x11, 0xE0, 0x7C, 0x8F, 0x99, 0xE0, 0xF3, 0x22, 0x44, 0x40, 0xE9, 0x96,
  0x99, 0xF0, 0xE9, 0x9F, 0x12, 0xC0, 0xB0, 0xB0, 0x4C, 0x04, 0xD4, 0x3C,
  0xC3, 0xF8, 0x3E, 0x87, 0x3C, 0xE1, 0x24, 0x44, 0x40, 0x3A, 0x67, 0x5A,
  0xD5, 0x6C, 0x18, 0x30, 0xC5, 0x12, 0x7B, 0x28, 0xC0, 0xE9, 0x9E, 0x99,
  0xE0, 0x3A, 0x11, 0x84, 0x21, 0xE0, 0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8F,
  0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x3A, 0x11, 0x94, 0xA5, 0xE0, 0xCE,
  0x73, 0xFC, 0xE7, 0x20, 0xF4, 0x44, 0x44, 0xF0, 0xF1, 0x11, 0x11, 0xE0,
  0x9A, 0xEC, 0xAB, 0x90, 0x88, 0x88, 0x88, 0xF0, 0x4A, 0xEF, 0x78, 0xC6,
  0x20, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0x73, 0x1C, 0xA5, 0xC0, 0xE9, 0x9B,
  0xC8, 0x80, 0x72, 0x73, 0x1C, 0xA5, 0xC6, 0x18, 0xE9, 0x9E, 0xAB, 0x90,
  0xF8, 0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0xCE, 0x73, 0x9C,
  0xA5, 0xE0, 0x8E, 0x52, 0x95, 0x18, 0xC0, 0x8C, 0x63, 0x7B, 0xAD, 0x20,
  0xCA, 0x8C, 0x67, 0x27, 0x20, 0xCA, 0x54, 0x62, 0x10, 0x80, 0xF3, 0x24,
  0x48, 0xF0, 0xFB, 0x6D, 0xB6, 0xDC, 0x88, 0xC4, 0x46, 0x22, 0x31, 0xE4,
  0x92, 0x49, 0x3C, 0x33, 0x97, 0x90, 0xFC, 0xB0, 0xF1, 0xF9, 0xF0, 0x88,
  0x8F, 0x99, 0x9E, 0xF8, 0x88, 0xF0, 0x08, 0x42, 0xFC, 0xE5, 0x2F, 0x7A,
  0x7E, 0x87, 0x80, 0x34, 0x4F, 0x44, 0x44, 0x7E, 0x72, 0x93, 0x85, 0xC0,
  0x88, 0x8F, 0x99, 0x99, 0x44, 0x0C, 0x44, 0x47, 0x24, 0x72, 0x49, 0x3C,
  0x88, 0x8B, 0xEC, 0xA9, 0xC4, 0x44, 0x44, 0x47, 0xFD, 0x6B, 0x18, 0x80,
  0xF9, 0x99, 0x90, 0x7A, 0x72, 0x97, 0x00, 0xF9, 0x99, 0xF8, 0x80, 0x7A,
  0x72, 0x97, 0x84, 0x20, 0xF8, 0x88, 0x80, 0xF8, 0x61, 0xF0, 0x44, 0xF4,
  0x44, 0x70, 0x99, 0x99, 0xF0, 0xCA, 0x54, 0x62, 0x00, 0x8D, 0x6E, 0xB4,
  0x80, 0xC9, 0x8C, 0xAC, 0x80, 0xCA, 0x5C, 0x63, 0x13, 0x80, 0xF2, 0x48,
  0xF0, 0x34, 0x44, 0x4C, 0x44, 0x43, 0xFF, 0xC0, 0xC6, 0x22, 0x23, 0x22,
  0x6C, 0x6C, 0xC0,
};

const GFXglyph UbuntuSansMono_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 1, -8 },
  { 5, 5, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 5, 7, 6, 0, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 1, 4, 6, 2, -8 },
  { 26, 3, 10, 6, 1, -8 },
  { 30, 3, 10, 6, 1, -8 },
  { 34, 4, 4, 6, 1, -7 },
  { 36, 5, 5, 6, 0, -5 },
  { 40, 2, 4, 6, 2, -2 },
  { 41, 3, 1, 6, 1, -3 },
  { 42, 2, 2, 6, 2, -2 },
  { 43, 4, 10, 6, 1, -8 },
  { 48, 5, 7, 6, 0, -7 },
  { 53, 4, 7, 6, 1, -7 },
  { 57, 4, 7, 6, 1, -7 },
  { 61, 4, 7, 6, 1, -7 },
  { 65, 5, 7, 6, 0, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 2, 6, 6, 2, -6 },
  { 92, 3, 8, 6, 1, -6 },
  { 95, 4, 4, 6, 1, -5 },
  { 97, 5, 3, 6, 0, -4 },
  { 99, 4, 4, 6, 1, -5 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 5, 9, 6, 0, -7 },
  { 111, 6, 7, 6, 0, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 5, 7, 6, 0, -7 },
  { 126, 4, 7, 6, 1, -7 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 4, 7, 6, 1, -7 },
  { 138, 5, 7, 6, 0, -7 },
  { 143, 5, 7, 6, 0, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 4, 7, 6, 1, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 4, 7, 6, 1, -7 },
  { 164, 5, 7, 6, 0, -7 },
  { 169, 4, 7, 6, 1, -7 },
  { 173, 5, 7, 6, 0, -7 },
  { 178, 4, 7, 6, 1, -7 },
  { 182, 5, 9, 6, 0, -7 },
  { 188, 4, 7, 6, 1, -7 },
  { 192, 4, 7, 6, 1, -7 },
  { 196, 5, 7, 6, 0, -7 },
  { 201, 5, 7, 6, 0, -7 },
  { 206, 5, 7, 6, 0, -7 },
  { 211, 5, 7, 6, 0, -7 },
  { 216, 5, 7, 6, 0, -7 },
  { 221, 5, 7, 6, 0, -7 },
  { 226, 4, 7, 6, 1, -7 },
  { 230, 3, 10, 6, 1, -8 },
  { 234, 4, 10, 6, 1, -8 },
  { 239, 3, 10, 6, 1, -8 },
  { 243, 5, 4, 6, 0, -7 },
  { 246, 6, 1, 6, 0, 1 },
  { 247, 2, 2, 6, 2, -8 },
  { 248, 4, 5, 6, 1, -5 },
  { 251, 4, 8, 6, 1, -8 },
  { 255, 4, 5, 6, 1, -5 },
  { 258, 5, 8, 6, 0, -8 },
  { 263, 5, 5, 6, 0, -5 },
  { 267, 4, 8, 6, 1, -8 },
  { 271, 5, 7, 6, 0, -5 },
  { 276, 4, 8, 6, 1, -8 },
  { 280, 4, 8, 6, 1, -8 },
  { 284, 3, 10, 6, 1, -8 },
  { 288, 4, 8, 6, 1, -8 },
  { 292, 4, 8, 6, 1, -8 },
  { 296, 5, 5, 6, 0, -5 },
  { 300, 4, 5, 6, 1, -5 },
  { 303, 5, 5, 6, 0, -5 },
  { 307, 4, 7, 6, 1, -5 },
  { 311, 5, 7, 6, 0, -5 },
  { 316, 4, 5, 6, 1, -5 },
  { 319, 4, 5, 6, 1, -5 },
  { 322, 4, 7, 6, 1, -7 },
  { 326, 4, 5, 6, 1, -5 },
  { 329, 5, 5, 6, 0, -5 },
  { 333, 5, 5, 6, 0, -5 },
  { 337, 5, 5, 6, 0, -5 },
  { 341, 5, 7, 6, 0, -5 },
  { 346, 4, 5, 6, 1, -5 },
  { 349, 4, 10, 6, 1, -8 },
  { 354, 1, 10, 6, 2, -8 },
  { 356, 4, 10, 6, 1, -8 },
  { 361, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Medium10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_MEDIUM10PT7B_H_
