#ifndef _UBUNTUSANSMONO_MEDIUM25PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE6, 0x66, 0x60, 0x06, 0xFF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0x42, 0x0C, 0x60, 0xC6, 0x1C, 0xE1, 0xCE, 0xFF,
  0xFF, 0xFF, 0x18, 0xC3, 0x9C, 0x39, 0xC3, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0x38, 0x63, 0x86, 0x30, 0x63, 0x00, 0x06, 0x00, 0x60, 0x0F, 0x83,
  0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0xE0, 0x07, 0x00, 0x74, 0x0F, 0x7F, 0xEF, 0xFC, 0x0F, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x38, 0x05, 0xF0, 0x66, 0xC3, 0x31, 0x0C, 0xC6,
  0x63, 0x1B, 0x86, 0xCC, 0x1F, 0x60, 0x3B, 0x80, 0x0C, 0x00, 0x67, 0x01,
  0xB6, 0x0C, 0xD8, 0x66, 0x31, 0x98, 0xCC, 0x26, 0x70, 0xDB, 0x83, 0xE0,
  0x0C, 0x03, 0xF0, 0x7B, 0x87, 0x18, 0x61, 0x87, 0x38, 0x73, 0x83, 0xF0,
  0x3E, 0x03, 0xC6, 0x7E, 0x6E, 0x76, 0xC3, 0xEC, 0x1C, 0xE1, 0xCE, 0x3E,
  0x7F, 0x73, 0xE7, 0xFF, 0xFF, 0x02, 0x07, 0x0F, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x02, 0x40, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E,
  0x0E, 0x1C, 0x1C, 0x38, 0xF0, 0xE0, 0x40, 0x06, 0x00, 0x60, 0x66, 0x27,
  0x6E, 0xFF, 0xF0, 0x60, 0x0F, 0x01, 0xD8, 0x39, 0xC1, 0x88, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x39, 0xF7, 0xCF, 0x18, 0xEF, 0x38,
  0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0x01, 0xF8, 0x3F, 0xC7, 0x0E, 0x70, 0xE6, 0x06, 0xE0, 0x7E, 0x67,
  0xEF, 0x7E, 0x77, 0xE6, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70, 0xE7, 0x9E,
  0x3F, 0xC1, 0xF8, 0x0E, 0x03, 0xC1, 0xF8, 0x7F, 0x0E, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x83,
  0xFF, 0x7F, 0xE0, 0x0E, 0x03, 0xF8, 0xFF, 0xC6, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x7F, 0xF7, 0xFF, 0x1E, 0x0F, 0xF1, 0xFF, 0x20, 0xF0,
  0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x3A, 0x0F, 0x7F, 0xDF, 0xF0, 0x01, 0xC0, 0x3C, 0x07, 0xC0,
  0xFC, 0x0D, 0xC1, 0xDC, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xE7, 0xFC,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0x3C, 0x03,
  0x80, 0x30, 0x06, 0x01, 0xD0, 0x7B, 0xFE, 0xFF, 0x80, 0x03, 0xE0, 0xFE,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x87, 0xFC, 0xFF, 0xEE, 0x0E,
  0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0E, 0x78, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x60, 0x66, 0x06, 0x70, 0xE7, 0x8C, 0x3F,
  0xC3, 0xFC, 0x73, 0xE6, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x7F,
  0xE3, 0xFC, 0x0E, 0x03, 0xF8, 0x7F, 0xC7, 0x0E, 0x60, 0xEE, 0x06, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0xFF, 0x3F, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0xC1, 0xF8, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3C, 0x31, 0xBE,
  0x60, 0x00, 0x20, 0x0F, 0x07, 0xF1, 0xF8, 0x7E, 0x0F, 0x00, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xE0, 0x02, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x07, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0x01, 0xF0, 0x7E, 0x3F, 0x8F, 0xC0, 0x70, 0x04,
  0x00, 0x1C, 0x3F, 0xE7, 0xF9, 0x0F, 0x01, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x81, 0xC0, 0x60, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x07, 0x00,
  0x07, 0x01, 0xFC, 0x3D, 0xE7, 0x07, 0x60, 0x76, 0x03, 0xE3, 0xFC, 0x7F,
  0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xE7, 0x3E, 0x7F,
  0x61, 0xE7, 0x00, 0x38, 0x01, 0xE2, 0x0F, 0xE0, 0x3E, 0x07, 0x80, 0x1E,
  0x00, 0xFC, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0xCE, 0x06, 0x18, 0x18,
  0x60, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF9, 0xC0, 0xE7, 0x03, 0x98,
  0x0E, 0xE0, 0x1C, 0x08, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x1C, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x1E, 0xFF, 0xEF, 0xF8, 0x03, 0x81, 0xFF, 0x3F, 0xF3, 0x82,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0xC2, 0x3F, 0xF0, 0xFE, 0x18, 0x0F, 0xF8,
  0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x3C, 0xFF, 0x8F, 0xF0,
  0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFC, 0xFF,
  0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC1,
  0xFF, 0x3F, 0xE3, 0x82, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0x73, 0x87, 0x3F, 0xF0,
  0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xD8, 0x77, 0xFE, 0x7F,
  0x80, 0xC1, 0xEC, 0x1C, 0xC3, 0x8C, 0x78, 0xC7, 0x0C, 0xE0, 0xDC, 0x0F,
  0x80, 0xFC, 0x0D, 0xE0, 0xCF, 0x0C, 0x78, 0xC3, 0x8C, 0x1C, 0xC1, 0xEC,
  0x0E, 0xC0, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xFF, 0xFF, 0xE0, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x9E, 0xF9, 0xFF, 0x9F,
  0xEF, 0x7E, 0xF3, 0xCF, 0x3C, 0x63, 0xC6, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC,
  0x7E, 0xC7, 0xEE, 0x7E, 0x67, 0xE7, 0x7E, 0x37, 0xE3, 0x7E, 0x1F, 0xE1,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x70, 0x0F, 0x03, 0xFC, 0x7F, 0xE7,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0x18, 0x1F,
  0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFF, 0xFB,
  0xFE, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x3F,
  0xC1, 0xF8, 0x06, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0x00, 0x20, 0x10, 0x1F,
  0xE3, 0xFE, 0x61, 0xEC, 0x1D, 0x83, 0xB0, 0x76, 0x0E, 0xC3, 0xDF, 0xF3,
  0xFC, 0x63, 0x8C, 0x31, 0x87, 0x30, 0x76, 0x0E, 0xC0, 0xF8, 0x1C, 0x0F,
  0x83, 0xFE, 0x7F, 0xE7, 0x02, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x76, 0x0E, 0xFF,
  0xE7, 0xF8, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76,
  0x06, 0x70, 0xE7, 0xFE, 0x3F, 0xC0, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x30, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x60, 0x73, 0x81,
  0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC6, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF7, 0xC9, 0x7F, 0x9F, 0xF9, 0xE7, 0x1E, 0x70, 0xE7, 0x0E,
  0x70, 0xE0, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x9C, 0x39, 0xC1, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0x9C, 0x39, 0xC7, 0x0E, 0x70,
  0xEE, 0x07, 0xE0, 0x70, 0xF0, 0x3D, 0xC0, 0xE3, 0x03, 0x8E, 0x1C, 0x38,
  0x70, 0x73, 0x81, 0xCE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xFE, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC7,
  0x0E, 0x70, 0xEE, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x63, 0xC3, 0x87, 0x08, 0x3F, 0x87, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x3F,
  0xDF, 0xFB, 0x87, 0xE0, 0xFC, 0x1D, 0xC3, 0xBF, 0xF3, 0xFE, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xC7, 0xFE, 0xE1, 0xDC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE3, 0xDF, 0xF3, 0xFC,
  0x00, 0x0F, 0xF3, 0xFE, 0x78, 0x27, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x7C, 0x13, 0xFF, 0x0F, 0xF0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0xFB, 0xFF, 0x70, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0x78, 0xE7, 0xFC, 0x7F, 0x80,
  0x1F, 0x83, 0xFE, 0x70, 0xE6, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x23, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x83,
  0x84, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xFF, 0x9F, 0xFC, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0xE7, 0xFD, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xEE, 0x1D, 0xFF, 0x9F, 0xF0, 0x0E, 0x01, 0xC0, 0x3B,
  0xFE, 0x7F, 0x83, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xF3, 0xFE, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1C, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x10, 0x7F, 0x03, 0xF0, 0x07, 0x03, 0xC1,
  0xC0, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3F, 0xFB, 0xFC, 0x70,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0x1E, 0xE7,
  0x9C, 0xE3, 0xF8, 0x7E, 0x0F, 0xC1, 0xDC, 0x39, 0xC7, 0x1C, 0xE3, 0xDC,
  0x3F, 0x83, 0x80, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x10, 0x7F, 0x03, 0xF0, 0xFF, 0xEF, 0xFF, 0xCE,
  0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x30, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x83, 0xFC,
  0x70, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F,
  0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x8F, 0x7F, 0xCF, 0xF1, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xE7, 0xFD, 0xE3, 0xB8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xE3, 0xBF, 0xF1, 0xFE,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0xFF, 0xEE, 0x0B, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x3F, 0xDF, 0xEE, 0x0B, 0x80, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xC0,
  0x7C, 0x1F, 0xFF, 0xFF, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x10, 0xFF, 0x07, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1D, 0xFF, 0x3F, 0xC0,
  0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x0C, 0x39, 0xC3, 0x9C,
  0x1B, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1D, 0x80, 0x66,
  0x01, 0x98, 0xC6, 0x63, 0x99, 0x9E, 0x66, 0x79, 0x9D, 0xEE, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x77, 0x0E, 0x39, 0xC3,
  0xDC, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0xC3, 0x9C, 0x70, 0xE6,
  0x0E, 0xE0, 0x70, 0xE0, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x8E,
  0x39, 0xC1, 0xDC, 0x1D, 0xC0, 0xD8, 0x0F, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x0F, 0xC0, 0xFC, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x1E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x83, 0xE0, 0xF0, 0x3E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xFC, 0x3F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x3F, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0x1F, 0x01, 0xC1, 0xF0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xE3, 0xF0, 0xE0, 0x00, 0x10, 0x27,
  0xC3, 0xFF, 0xFC, 0x7E, 0x41, 0xC0,
};

const GFXglyph UbuntuSansMono_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 7, 14, 3, -19 },
  { 17, 12, 17, 14, 1, -17 },
  { 43, 12, 22, 14, 1, -19 },
  { 76, 14, 18, 14, 0, -18 },
  { 108, 12, 18, 14, 1, -18 },
  { 135, 2, 8, 14, 6, -19 },
  { 137, 8, 25, 14, 3, -20 },
  { 162, 8, 25, 14, 3, -20 },
  { 187, 12, 10, 14, 1, -17 },
  { 202, 12, 13, 14, 1, -14 },
  { 222, 6, 8, 14, 4, -4 },
  { 228, 6, 2, 14, 4, -8 },
  { 230, 4, 4, 14, 5, -4 },
  { 232, 10, 25, 14, 2, -20 },
  { 264, 12, 18, 14, 1, -18 },
  { 291, 11, 17, 14, 2, -17 },
  { 315, 12, 18, 14, 1, -18 },
  { 342, 11, 18, 14, 1, -18 },
  { 367, 12, 17, 14, 1, -17 },
  { 393, 11, 17, 14, 1, -17 },
  { 417, 12, 17, 14, 1, -17 },
  { 443, 11, 17, 14, 2, -17 },
  { 467, 12, 18, 14, 1, -18 },
  { 494, 12, 18, 14, 1, -18 },
  { 521, 4, 13, 14, 5, -13 },
  { 528, 6, 17, 14, 3, -13 },
  { 541, 12, 12, 14, 1, -13 },
  { 559, 12, 8, 14, 1, -11 },
  { 571, 12, 12, 14, 1, -13 },
  { 589, 10, 18, 14, 2, -18 },
  { 612, 12, 22, 14, 1, -18 },
  { 645, 14, 17, 14, 0, -17 },
  { 675, 12, 18, 14, 1, -18 },
  { 702, 12, 18, 14, 1, -18 },
  { 729, 12, 18, 14, 1, -18 },
  { 756, 11, 17, 14, 2, -17 },
  { 780, 10, 17, 14, 2, -17 },
  { 802, 12, 18, 14, 1, -18 },
  { 829, 12, 17, 14, 1, -17 },
  { 855, 10, 17, 14, 2, -17 },
  { 877, 11, 17, 14, 1, -17 },
  { 901, 12, 17, 14, 2, -17 },
  { 927, 11, 17, 14, 2, -17 },
  { 951, 12, 17, 14, 1, -17 },
  { 977, 12, 17, 14, 1, -17 },
  { 1003, 12, 18, 14, 1, -18 },
  { 1030, 11, 18, 14, 2, -18 },
  { 1055, 12, 23, 14, 1, -18 },
  { 1090, 11, 18, 14, 2, -18 },
  { 1115, 12, 18, 14, 1, -18 },
  { 1142, 12, 17, 14, 1, -17 },
  { 1168, 12, 17, 14, 1, -17 },
  { 1194, 14, 17, 14, 0, -17 },
  { 1224, 12, 17, 14, 1, -17 },
  { 1250, 12, 17, 14, 1, -17 },
  { 1276, 14, 17, 14, 0, -17 },
  { 1306, 12, 17, 14, 1, -17 },
  { 1332, 7, 25, 14, 4, -20 },
  { 1354, 10, 25, 14, 2, -20 },
  { 1386, 7, 25, 14, 3, -20 },
  { 1408, 12, 9, 14, 1, -17 },
  { 1422, 14, 3, 14, 0, 2 },
  { 1428, 6, 5, 14, 4, -19 },
  { 1432, 11, 13, 14, 1, -13 },
  { 1450, 11, 19, 14, 2, -19 },
  { 1477, 12, 13, 14, 1, -13 },
  { 1497, 11, 19, 14, 1, -19 },
  { 1524, 12, 13, 14, 1, -13 },
  { 1544, 13, 19, 14, 1, -19 },
  { 1575, 11, 18, 14, 1, -13 },
  { 1600, 10, 19, 14, 2, -19 },
  { 1624, 12, 19, 14, 1, -19 },
  { 1653, 9, 24, 14, 2, -19 },
  { 1680, 11, 19, 14, 2, -19 },
  { 1707, 12, 19, 14, 1, -19 },
  { 1736, 12, 13, 14, 1, -13 },
  { 1756, 10, 13, 14, 2, -13 },
  { 1773, 12, 13, 14, 1, -13 },
  { 1793, 11, 18, 14, 2, -13 },
  { 1818, 11, 18, 14, 1, -13 },
  { 1843, 10, 13, 14, 3, -13 },
  { 1860, 10, 13, 14, 2, -13 },
  { 1877, 12, 17, 14, 1, -17 },
  { 1903, 10, 13, 14, 2, -13 },
  { 1920, 12, 13, 14, 1, -13 },
  { 1940, 14, 13, 14, 0, -13 },
  { 1963, 12, 13, 14, 1, -13 },
  { 1983, 12, 18, 14, 1, -13 },
  { 2010, 10, 13, 14, 2, -13 },
  { 2027, 10, 25, 14, 2, -20 },
  { 2059, 2, 25, 14, 6, -20 },
  { 2066, 10, 25, 14, 2, -20 },
  { 2098, 12, 5, 14, 1, -10 },
};

const GFXfont UbuntuSansMono_Medium25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_MEDIUM25PT7B_H_
