#ifndef _UBUNTUSANSMONO_MEDIUM34PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xDC, 0x7B, 0x8E, 0x60, 0xCC, 0x18, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0,
  0x70, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1F, 0x01, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x3C, 0x02,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x03, 0x9F, 0x80, 0xEE, 0xE0,
  0x73, 0x1C, 0x38, 0xC7, 0x0E, 0x31, 0xC7, 0x0C, 0x71, 0xC3, 0x1C, 0xE0,
  0xE7, 0x70, 0x3F, 0x9C, 0x07, 0xEE, 0x00, 0x67, 0x00, 0x01, 0xC0, 0x00,
  0xE7, 0xC0, 0x3B, 0xF8, 0x1C, 0xCE, 0x0E, 0x71, 0x83, 0x9C, 0x61, 0xC7,
  0x1C, 0xE1, 0xC6, 0x38, 0x71, 0x9C, 0x1C, 0xE6, 0x03, 0xFB, 0x80, 0x7C,
  0x00, 0x04, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0x8F, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xF0, 0xC3, 0xF8, 0x71, 0xFE, 0x39, 0xEF, 0xBD, 0xE3,
  0xFC, 0xF0, 0xFE, 0x78, 0x3F, 0x3C, 0x0F, 0x1E, 0x07, 0xCF, 0x87, 0xE3,
  0xFF, 0xF8, 0xFF, 0x9E, 0x3F, 0x8F, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0,
  0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xC0, 0x40, 0x0E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x07, 0x80, 0x60, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x06, 0x38, 0xCF, 0x77, 0xFF, 0xFF, 0xBF, 0xFF, 0x03,
  0x80, 0x0F, 0xC0, 0x3B, 0xC0, 0xF7, 0xC3, 0xC7, 0x83, 0x8E, 0x02, 0x08,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F,
  0x1F, 0x07, 0x0E, 0x3E, 0xFC, 0x70, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0xF9, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC3, 0x1F, 0x8E, 0x3F, 0x3E, 0x7E, 0x7C, 0xFC, 0x71, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xE7, 0x83, 0xC7,
  0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xF8, 0x1E, 0x70, 0x38, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x0F, 0xE0, 0x7F, 0xE3, 0xFF, 0xE7, 0xC7, 0xE6,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xC1, 0xFF, 0xE1, 0xFF, 0xE3, 0xC7, 0xC4, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF4, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0E, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x0F, 0x07,
  0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF4, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0,
  0x02, 0x00, 0x00, 0x0C, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xF8, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE7, 0x83, 0xFF, 0xC7, 0xFF,
  0xEF, 0xEF, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7B, 0xC0, 0xF7, 0x83, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0x78, 0x1C, 0xF8, 0x78, 0xFD, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xBF,
  0x9E, 0x1F, 0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF,
  0x83, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xF8, 0x01, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE3, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0xC3,
  0xF7, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x38, 0xF9, 0xFF, 0xF7, 0xCF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x9F, 0xFF, 0x7C, 0xF8, 0x1C, 0x3E,
  0x3F, 0x7F, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3E,
  0x3E, 0x7F, 0x3F, 0x3E, 0x0E, 0x1E, 0x7C, 0xF8, 0xF0, 0x80, 0x00, 0x02,
  0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1E, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x87,
  0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x20, 0x00, 0x3F, 0xC7, 0xFF, 0x1F, 0xFC,
  0xC1, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x03, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0,
  0x1E, 0xE0, 0x3F, 0x70, 0xFF, 0xB8, 0xFF, 0xFC, 0x7F, 0xFE, 0x78, 0xFE,
  0x3C, 0x7F, 0x1C, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF9, 0xE3,
  0xFC, 0xF1, 0xEE, 0x3F, 0xF7, 0x1F, 0xFB, 0xC3, 0xFC, 0xE0, 0x20, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80,
  0x07, 0x78, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0xC0,
  0x38, 0x78, 0x07, 0x07, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x01, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xE0, 0x1E, 0x1C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x0F, 0x3F, 0x81, 0xFF,
  0xE3, 0xFF, 0xE7, 0xCF, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0E,
  0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9E, 0x1F, 0xBC,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x07,
  0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0xC3, 0xF0, 0xE3, 0xE0, 0x11, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x30, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x60, 0x00,
  0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xF3, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x87, 0x3E,
  0x01, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x78,
  0x07, 0x78, 0x07, 0x7C, 0x07, 0x3C, 0x07, 0x3F, 0x07, 0x1F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x20, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xD0, 0x0F, 0x60, 0x7F, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x06,
  0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87,
  0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x81, 0xE3, 0xE0, 0xF0,
  0xF0, 0x78, 0x7C, 0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xFB,
  0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0x0E, 0x1C, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3,
  0xF1, 0xF9, 0xF8, 0xFC, 0xEC, 0x6E, 0x77, 0x77, 0x3B, 0xBB, 0x9C, 0xDD,
  0xCE, 0x6C, 0xE7, 0x3E, 0x73, 0x9F, 0x39, 0xC7, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xF7, 0x07, 0xEF, 0x0F, 0xCE, 0x1F, 0x9E,
  0x3F, 0x1C, 0x7E, 0x3C, 0xFC, 0x39, 0xF8, 0x7B, 0xF0, 0x77, 0xE0, 0xEF,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xC7, 0xC7, 0xC1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xB8, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0xF9, 0xFE, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xCF,
  0x01, 0xE3, 0xC1, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x7F,
  0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFB, 0xFC, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0x0F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xF3, 0xE0, 0xC7, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF6, 0x03, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF8, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x83, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x03, 0x00,
  0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x9E,
  0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x1C, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x38, 0xF0,
  0x0E, 0x38, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0xE3, 0xFC, 0x71, 0xCE, 0x7C, 0xE7, 0x3E, 0x73, 0x9B, 0x39,
  0xDD, 0xDC, 0xEE, 0xEE, 0x76, 0x37, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0x70, 0x1C, 0xF0, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0,
  0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x1E, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F,
  0x07, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x0F,
  0x03, 0x83, 0xC1, 0xE0, 0x70, 0x78, 0x1E, 0x3C, 0x03, 0x8F, 0x00, 0xF7,
  0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x7C, 0xF0, 0x3C, 0x78, 0x3C, 0x1E,
  0x1E, 0x0F, 0x1E, 0x03, 0xDF, 0x00, 0xF7, 0x00, 0x70, 0x80, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0xE3, 0xE1, 0xE1, 0xE1,
  0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xEF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCE, 0x03, 0xDC,
  0x07, 0xB8, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x3E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80,
  0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xF0, 0x27, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x80, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x07, 0xEE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF1, 0xF7, 0x80, 0xEF, 0x01,
  0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77,
  0x80, 0xEF, 0x01, 0xCF, 0x83, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFC, 0x07,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xC7, 0x80, 0xF3, 0xC0, 0x79,
  0xC0, 0x1D, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x08, 0x7F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1, 0xF0, 0x20, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC,
  0x3F, 0xFC, 0xFF, 0xF9, 0xF0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0xC3,
  0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xEE, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF2,
  0x03, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0x3C, 0x3E, 0xE0, 0x7B, 0x81, 0xEE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF6, 0x0F, 0x3F, 0xFB, 0xFF, 0x8F, 0xF8, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x3F, 0xC0, 0xFB, 0x83, 0xE7, 0x0F, 0x8E, 0x3E, 0x1C, 0xF8,
  0x3B, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0x9E, 0x07, 0x1E, 0x0E,
  0x1E, 0x1C, 0x1E, 0x38, 0x3E, 0x70, 0x3E, 0xE0, 0x3D, 0xC0, 0x3C, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x7F, 0x3C, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0x78, 0xEF, 0x1C, 0x7F, 0x8E,
  0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xC0, 0x7F, 0xC3, 0xFF, 0xCF, 0xFF, 0x38, 0x3E, 0xE0, 0x7B,
  0x81, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x07,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0x79,
  0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEE, 0x00,
  0xE7, 0x80, 0xF3, 0xC0, 0x78, 0xF0, 0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xC3, 0xFF, 0xE7, 0x07, 0xCE, 0x07, 0xDC,
  0x07, 0xB8, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xEE, 0x03, 0xDC, 0x07, 0xBC, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0x77, 0xC0, 0xEF, 0x01, 0xDE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x80, 0xEF,
  0x01, 0xDF, 0x07, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x6F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xE3, 0xC0, 0x47, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xD8, 0x0F, 0xBF, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x10, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x78, 0x1D, 0xE0, 0x77, 0xC1, 0xCF, 0xFF,
  0x3F, 0xFC, 0x7F, 0xF0, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xCF, 0x01,
  0xE7, 0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x3C, 0x0F,
  0x1E, 0x07, 0x8E, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x8F, 0xE7, 0xCF,
  0x73, 0xE7, 0x39, 0xB3, 0x9D, 0xDD, 0xCE, 0xEE, 0xE7, 0x63, 0x73, 0xF1,
  0xF8, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x07, 0x00, 0xF0, 0x07,
  0xBC, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x00,
  0xF3, 0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03,
  0xC0, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x70, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x00, 0x7B, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8,
  0x1F, 0xC1, 0xFE, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xE0, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC3, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0x1E,
  0x03, 0x1F, 0xC1, 0xDF, 0xFD, 0xEE, 0x7F, 0xEE, 0x0F, 0xE3, 0x01, 0xE0,
};

const GFXglyph UbuntuSansMono_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 24, 19, 7, -24 },
  { 16, 11, 10, 19, 4, -26 },
  { 30, 17, 24, 19, 1, -24 },
  { 81, 15, 30, 19, 2, -26 },
  { 138, 18, 25, 19, 1, -24 },
  { 195, 17, 24, 19, 1, -24 },
  { 246, 4, 11, 19, 8, -26 },
  { 252, 11, 33, 19, 4, -27 },
  { 298, 11, 33, 19, 4, -27 },
  { 344, 15, 15, 19, 2, -24 },
  { 373, 15, 16, 19, 2, -18 },
  { 403, 8, 12, 19, 5, -6 },
  { 415, 9, 4, 19, 5, -12 },
  { 420, 7, 6, 19, 6, -6 },
  { 426, 15, 33, 19, 2, -27 },
  { 488, 15, 25, 19, 2, -24 },
  { 535, 15, 24, 19, 2, -24 },
  { 580, 15, 24, 19, 2, -24 },
  { 625, 15, 25, 19, 2, -24 },
  { 672, 17, 24, 19, 1, -24 },
  { 723, 15, 25, 19, 2, -24 },
  { 770, 15, 25, 19, 2, -24 },
  { 817, 15, 24, 19, 2, -24 },
  { 862, 15, 25, 19, 2, -24 },
  { 909, 15, 24, 19, 2, -24 },
  { 954, 7, 18, 19, 6, -18 },
  { 970, 8, 24, 19, 5, -18 },
  { 994, 16, 16, 19, 2, -18 },
  { 1026, 15, 10, 19, 2, -15 },
  { 1045, 15, 16, 19, 2, -18 },
  { 1075, 13, 24, 19, 3, -24 },
  { 1114, 17, 29, 19, 1, -24 },
  { 1176, 19, 24, 19, 0, -24 },
  { 1233, 15, 24, 19, 2, -24 },
  { 1278, 17, 25, 19, 1, -24 },
  { 1332, 16, 24, 19, 2, -24 },
  { 1380, 15, 24, 19, 3, -24 },
  { 1425, 14, 24, 19, 3, -24 },
  { 1467, 16, 25, 19, 1, -24 },
  { 1517, 15, 24, 19, 2, -24 },
  { 1562, 13, 24, 19, 3, -24 },
  { 1601, 14, 25, 19, 2, -24 },
  { 1645, 17, 24, 19, 2, -24 },
  { 1696, 15, 24, 19, 3, -24 },
  { 1741, 17, 24, 19, 1, -24 },
  { 1792, 15, 24, 19, 2, -24 },
  { 1837, 17, 25, 19, 1, -24 },
  { 1891, 16, 24, 19, 2, -24 },
  { 1939, 17, 30, 19, 1, -24 },
  { 2003, 16, 24, 19, 2, -24 },
  { 2051, 15, 25, 19, 2, -24 },
  { 2098, 17, 24, 19, 1, -24 },
  { 2149, 15, 25, 19, 2, -24 },
  { 2196, 18, 24, 19, 1, -24 },
  { 2250, 17, 24, 19, 1, -24 },
  { 2301, 17, 24, 19, 1, -24 },
  { 2352, 18, 24, 19, 1, -24 },
  { 2406, 15, 24, 19, 2, -24 },
  { 2451, 10, 33, 19, 5, -27 },
  { 2493, 15, 33, 19, 2, -27 },
  { 2555, 10, 33, 19, 4, -27 },
  { 2597, 17, 14, 19, 1, -24 },
  { 2627, 19, 3, 19, 0, 3 },
  { 2635, 7, 6, 19, 6, -26 },
  { 2641, 15, 18, 19, 2, -18 },
  { 2675, 15, 26, 19, 3, -26 },
  { 2724, 15, 18, 19, 2, -18 },
  { 2758, 15, 26, 19, 1, -26 },
  { 2807, 17, 18, 19, 1, -18 },
  { 2846, 17, 26, 19, 2, -26 },
  { 2902, 15, 24, 19, 1, -18 },
  { 2947, 14, 26, 19, 3, -26 },
  { 2993, 15, 26, 19, 2, -26 },
  { 3042, 13, 32, 19, 2, -26 },
  { 3094, 15, 26, 19, 3, -26 },
  { 3143, 15, 26, 19, 2, -26 },
  { 3192, 17, 18, 19, 1, -18 },
  { 3231, 14, 18, 19, 3, -18 },
  { 3263, 17, 18, 19, 1, -18 },
  { 3302, 15, 24, 19, 3, -18 },
  { 3347, 15, 24, 19, 1, -18 },
  { 3392, 13, 18, 19, 4, -18 },
  { 3422, 15, 18, 19, 2, -18 },
  { 3456, 15, 23, 19, 2, -23 },
  { 3500, 14, 18, 19, 2, -18 },
  { 3532, 17, 18, 19, 1, -18 },
  { 3571, 17, 18, 19, 1, -18 },
  { 3610, 17, 18, 19, 1, -18 },
  { 3649, 17, 24, 19, 1, -18 },
  { 3700, 13, 18, 19, 3, -18 },
  { 3730, 13, 33, 19, 3, -27 },
  { 3784, 3, 33, 19, 8, -27 },
  { 3797, 13, 33, 19, 3, -27 },
  { 3851, 17, 6, 19, 1, -13 },
};

const GFXfont UbuntuSansMono_Medium34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_MEDIUM34PT7B_H_
