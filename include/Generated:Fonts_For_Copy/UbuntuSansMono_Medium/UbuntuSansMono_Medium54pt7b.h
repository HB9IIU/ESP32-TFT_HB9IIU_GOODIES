#ifndef _UBUNTUSANSMONO_MEDIUM54PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFD,
  0xFE, 0xFF, 0x7F, 0xFF, 0xDF, 0xE7, 0xE0, 0xC0, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xE7, 0x81, 0xF3,
  0xC0, 0x79, 0xE0, 0x38, 0xE0, 0x1C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0,
  0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xF8, 0x07, 0x87, 0xF0, 0x00, 0x43, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x98, 0x00, 0x1F, 0xCF, 0x80, 0x1F, 0xE7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0x7F, 0xF0, 0x03, 0xE7, 0xFF, 0x00, 0x3C,
  0xF8, 0xF8, 0x07, 0xCF, 0x07, 0x80, 0xF8, 0xF0, 0x78, 0x0F, 0x8F, 0x07,
  0x81, 0xF0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x7C,
  0x0F, 0x07, 0x87, 0x80, 0xF0, 0x78, 0xF8, 0x0F, 0x8F, 0x9F, 0x00, 0x7D,
  0xF1, 0xE0, 0x07, 0xFF, 0x3E, 0x00, 0x3F, 0xE7, 0xC0, 0x01, 0xFC, 0x7C,
  0x00, 0x02, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xFC, 0x00, 0x3C, 0x7F, 0xE0, 0x07, 0xCF, 0xFE, 0x00, 0xF8,
  0xF1, 0xF0, 0x0F, 0x9F, 0x0F, 0x01, 0xF1, 0xE0, 0xF0, 0x1E, 0x1E, 0x0F,
  0x03, 0xE1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0xF8,
  0x1E, 0x0F, 0x1F, 0x01, 0xF0, 0xF1, 0xE0, 0x1F, 0x1F, 0x3E, 0x00, 0xF9,
  0xF7, 0xC0, 0x0F, 0xFE, 0x7C, 0x00, 0x7F, 0xCF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xC1, 0xFF,
  0xE0, 0xF8, 0x7E, 0xFC, 0x1F, 0x1F, 0x9F, 0xC7, 0xC3, 0xF1, 0xFC, 0xF8,
  0xFC, 0x1F, 0xDF, 0x1F, 0x81, 0xFF, 0xE3, 0xE0, 0x1F, 0xF8, 0x7C, 0x01,
  0xFF, 0x0F, 0x80, 0x1F, 0xE1, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87,
  0xE0, 0x0F, 0xF0, 0xFE, 0x03, 0xFF, 0x0F, 0xF1, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE7, 0xE1, 0xFF, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xE7, 0x9E,
  0x78, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x30, 0x3E, 0x06, 0x7C, 0x3C, 0x3E, 0x7F, 0x3C,
  0xFE, 0x7F, 0xDD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xF7,
  0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0x81, 0xE0, 0x01, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x83,
  0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x7F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7C, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x03, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x1F,
  0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x78, 0x3F, 0xF8, 0x7E, 0x1F, 0xFC,
  0x3F, 0x0F, 0xFE, 0x1F, 0xC7, 0xFF, 0x0F, 0xC3, 0xFF, 0x87, 0xE1, 0xFF,
  0xC1, 0xE0, 0xFF, 0xE0, 0x20, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xC0, 0x03,
  0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xBF, 0x00, 0xFC, 0x7E,
  0x01, 0xF0, 0xFC, 0x01, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0x07,
  0xFC, 0x3C, 0x01, 0xFC, 0x30, 0x00, 0xFC, 0x10, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3E, 0x07, 0xFC, 0x10, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x60, 0x01, 0xFE, 0x7F, 0x9F, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x60, 0x01, 0xFE, 0x7F,
  0x1F, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0xE3, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x80, 0xFC, 0x3F, 0xC1,
  0xFC, 0x1F, 0xF3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x8F, 0xFC, 0x3F, 0x03, 0xFE, 0x7E, 0x00,
  0xFE, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF7, 0xF8, 0xFC, 0x0C, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0xFF, 0xC3, 0xFC,
  0x1F, 0xC0, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x80,
  0xFF, 0x40, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xF8, 0xFF, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x7C, 0x03, 0xFF, 0xDF, 0x01, 0xFF, 0xF7, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0x87,
  0xE0, 0x7F, 0xE1, 0xF8, 0x1F, 0xF8, 0x7E, 0x07, 0xFE, 0x1F, 0x01, 0xFF,
  0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x01,
  0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF8, 0x1F, 0xF8, 0x7E, 0x07, 0xFF, 0x0F,
  0xC1, 0xF7, 0xC3, 0xF8, 0x7D, 0xF0, 0x7F, 0xFF, 0x7C, 0x1F, 0xFF, 0xDF,
  0x83, 0xFF, 0xF3, 0xE0, 0x3F, 0xFC, 0xFC, 0x01, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xE7, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xF0, 0xFF, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0xFE, 0xFC, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0x03, 0xE0, 0xFF, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF1, 0xFF, 0xC3, 0xF0, 0x0F,
  0xF1, 0xF8, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFE, 0x03, 0xE0, 0xFE, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x0F, 0xC3, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x88, 0x00, 0x7F, 0x3C, 0x01, 0xFE, 0x7F, 0x3F, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xCF, 0xF0,
  0x01, 0xF8, 0xFF, 0x00, 0x3F, 0x0F, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x7F,
  0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x07, 0xBC, 0x7F, 0xC0, 0xF7,
  0x8F, 0xBC, 0x1E, 0xF1, 0xF7, 0x87, 0x9E, 0x3E, 0xF0, 0xF3, 0xC7, 0xDF,
  0x1E, 0x78, 0xF9, 0xE7, 0xCF, 0x1F, 0x3C, 0xF1, 0xE3, 0xE7, 0xDE, 0x3C,
  0x7C, 0x7F, 0xC7, 0xCF, 0x8F, 0xF0, 0xF9, 0xF1, 0xFE, 0x1F, 0x3E, 0x1F,
  0xC3, 0xEF, 0xC3, 0xF0, 0x7D, 0xF8, 0x7E, 0x0F, 0xBF, 0x07, 0xC1, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF0, 0x1F, 0xFD,
  0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7C, 0x1F, 0xFC,
  0x7C, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x1F, 0x1F, 0xFC,
  0x1F, 0x1F, 0xFC, 0x0F, 0x9F, 0xFC, 0x0F, 0x9F, 0xFC, 0x07, 0xDF, 0xFC,
  0x07, 0xDF, 0xFC, 0x03, 0xDF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0xFC, 0xFC, 0x01, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x38, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F,
  0x0F, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x80, 0x3C,
  0x7F, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x40, 0x00, 0x7F, 0x78, 0x00, 0xFF, 0x7F, 0x07, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0,
  0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0xE7, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x3E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF7, 0xE1, 0xF8, 0x3E,
  0xFC, 0x3F, 0x07, 0xCF, 0x8F, 0xF0, 0xF9, 0xF1, 0xFE, 0x1F, 0x3E, 0x3F,
  0xC3, 0xE7, 0xCF, 0xBC, 0x78, 0xF9, 0xE7, 0x8F, 0x1F, 0x3C, 0xF1, 0xE3,
  0xE7, 0x8F, 0x3C, 0x7D, 0xE1, 0xE7, 0x8F, 0xBC, 0x3C, 0xF1, 0xF7, 0x87,
  0xDE, 0x3F, 0xE0, 0x7B, 0xC7, 0xFC, 0x0F, 0x78, 0xFF, 0x81, 0xEF, 0x1F,
  0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x7F,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x81,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xDF, 0xC0,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x8E, 0x00, 0x03, 0x80, 0x80, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x06, 0x01, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xC0, 0x30, 0x02, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC1, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xE0, 0xFE,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7F, 0xC0, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFC, 0xFE,
  0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x01, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x02, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x7C, 0x3F, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x3F,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8,
  0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x08,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC1, 0xF0, 0x1F, 0xC0, 0x04, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0x3F, 0x80, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0x00, 0x38,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x20, 0x00, 0xFE, 0x3C, 0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFD, 0xFF, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x20, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x60, 0x0F, 0xE7, 0xC1,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03,
  0xFD, 0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x01,
  0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xE1, 0xFC, 0x03, 0xF1,
  0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xF0, 0x03,
  0xF3, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x10, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x78, 0x1F, 0xFC, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x1F, 0xE7,
  0xFF, 0x83, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07,
  0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE,
  0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07,
  0xFE, 0x07, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFC, 0xFC, 0x03, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFF,
  0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFD, 0xFF, 0x80, 0xFC, 0x18, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0x3F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x7F, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xBF, 0x00, 0x1C, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xF0, 0x00, 0x5F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFE, 0x03, 0xC7, 0xE0, 0x01, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x02, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xF0, 0x0F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8,
  0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0xC3, 0xE7,
  0xC1, 0xFC, 0x3E, 0x7C, 0x3F, 0xC3, 0xE3, 0xC3, 0xFE, 0x3E, 0x3E, 0x3F,
  0xE3, 0xC3, 0xE7, 0xDE, 0x3C, 0x3E, 0x79, 0xE7, 0xC3, 0xE7, 0x9F, 0x7C,
  0x3E, 0xF8, 0xF7, 0xC1, 0xEF, 0x0F, 0x7C, 0x1E, 0xF0, 0xFF, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81,
  0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x41, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x02, 0x01,
  0xFE, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x1F, 0xFF, 0x83, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xF8, 0xF8,
  0x03, 0xFE, 0x02, 0x00, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_Medium54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 9, 38, 30, 11, -37 },
  { 44, 17, 16, 30, 7, -41 },
  { 78, 28, 37, 30, 1, -37 },
  { 208, 25, 48, 30, 3, -42 },
  { 358, 28, 39, 30, 1, -38 },
  { 495, 27, 38, 30, 2, -38 },
  { 624, 6, 17, 30, 12, -41 },
  { 637, 18, 53, 30, 6, -43 },
  { 757, 18, 53, 30, 6, -43 },
  { 877, 24, 22, 30, 3, -37 },
  { 943, 25, 27, 30, 3, -29 },
  { 1028, 13, 18, 30, 8, -9 },
  { 1058, 14, 5, 30, 8, -18 },
  { 1067, 10, 10, 30, 10, -9 },
  { 1080, 23, 52, 30, 4, -42 },
  { 1230, 25, 39, 30, 3, -38 },
  { 1352, 23, 37, 30, 4, -37 },
  { 1459, 24, 38, 30, 3, -38 },
  { 1573, 24, 39, 30, 3, -38 },
  { 1690, 26, 37, 30, 2, -37 },
  { 1811, 24, 38, 30, 3, -37 },
  { 1925, 24, 39, 30, 3, -38 },
  { 2042, 23, 37, 30, 4, -37 },
  { 2149, 24, 39, 30, 3, -38 },
  { 2266, 24, 38, 30, 3, -38 },
  { 2380, 10, 29, 30, 10, -28 },
  { 2417, 13, 37, 30, 7, -28 },
  { 2478, 25, 25, 30, 3, -28 },
  { 2557, 25, 16, 30, 3, -24 },
  { 2607, 25, 25, 30, 3, -28 },
  { 2686, 20, 39, 30, 5, -38 },
  { 2784, 26, 46, 30, 2, -38 },
  { 2934, 29, 37, 30, 1, -37 },
  { 3069, 25, 38, 30, 3, -38 },
  { 3188, 26, 39, 30, 2, -38 },
  { 3315, 25, 38, 30, 3, -38 },
  { 3434, 23, 37, 30, 5, -37 },
  { 3541, 22, 37, 30, 5, -37 },
  { 3643, 26, 39, 30, 2, -38 },
  { 3770, 25, 37, 30, 3, -37 },
  { 3886, 21, 37, 30, 5, -37 },
  { 3984, 23, 38, 30, 3, -37 },
  { 4094, 27, 37, 30, 3, -37 },
  { 4219, 23, 37, 30, 5, -37 },
  { 4326, 27, 37, 30, 2, -37 },
  { 4451, 24, 37, 30, 3, -37 },
  { 4562, 27, 39, 30, 2, -38 },
  { 4694, 24, 38, 30, 4, -38 },
  { 4808, 27, 48, 30, 2, -38 },
  { 4970, 26, 38, 30, 3, -38 },
  { 5094, 24, 39, 30, 3, -38 },
  { 5211, 26, 37, 30, 2, -37 },
  { 5332, 25, 38, 30, 3, -37 },
  { 5451, 29, 37, 30, 1, -37 },
  { 5586, 27, 37, 30, 2, -37 },
  { 5711, 28, 37, 30, 1, -37 },
  { 5841, 29, 37, 30, 1, -37 },
  { 5976, 24, 37, 30, 3, -37 },
  { 6087, 15, 52, 30, 8, -42 },
  { 6185, 23, 52, 30, 4, -42 },
  { 6335, 15, 52, 30, 7, -42 },
  { 6433, 27, 21, 30, 2, -37 },
  { 6504, 30, 5, 30, 0, 5 },
  { 6523, 11, 11, 30, 10, -42 },
  { 6539, 23, 30, 30, 3, -29 },
  { 6626, 24, 43, 30, 4, -42 },
  { 6755, 25, 30, 30, 3, -29 },
  { 6849, 24, 43, 30, 2, -42 },
  { 6978, 26, 30, 30, 2, -29 },
  { 7076, 26, 42, 30, 3, -42 },
  { 7213, 24, 39, 30, 2, -29 },
  { 7330, 22, 42, 30, 4, -42 },
  { 7446, 25, 42, 30, 3, -41 },
  { 7578, 20, 51, 30, 4, -41 },
  { 7706, 25, 42, 30, 4, -42 },
  { 7838, 25, 43, 30, 3, -42 },
  { 7973, 26, 29, 30, 2, -29 },
  { 8068, 22, 29, 30, 4, -29 },
  { 8148, 26, 30, 30, 2, -29 },
  { 8246, 24, 39, 30, 4, -29 },
  { 8363, 24, 39, 30, 2, -29 },
  { 8480, 21, 29, 30, 6, -29 },
  { 8557, 22, 30, 30, 4, -29 },
  { 8640, 25, 38, 30, 3, -37 },
  { 8759, 22, 29, 30, 4, -28 },
  { 8839, 28, 28, 30, 1, -28 },
  { 8937, 28, 28, 30, 1, -28 },
  { 9035, 27, 28, 30, 2, -28 },
  { 9130, 26, 38, 30, 2, -28 },
  { 9254, 22, 28, 30, 4, -28 },
  { 9331, 22, 52, 30, 4, -42 },
  { 9474, 6, 52, 30, 12, -42 },
  { 9513, 22, 52, 30, 4, -42 },
  { 9656, 27, 10, 30, 2, -21 },
};

const GFXfont UbuntuSansMono_Medium54pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium54pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium54pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUSANSMONO_MEDIUM54PT7B_H_
