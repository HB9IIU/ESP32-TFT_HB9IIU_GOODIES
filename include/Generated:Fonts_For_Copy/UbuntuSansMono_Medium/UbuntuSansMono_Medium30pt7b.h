#ifndef _UBUNTUSANSMONO_MEDIUM30PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x27,
  0xBF, 0xFF, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xC3, 0x00, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x60, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x83, 0x87, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xE0, 0x61, 0xC1,
  0xC3, 0x03, 0x8E, 0x07, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x3F,
  0xC3, 0xFF, 0x3F, 0xFB, 0xC0, 0x5E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x1F, 0xE1, 0xFF, 0xFF, 0x7F, 0xF0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x3C, 0x07, 0x7E, 0x06, 0x67, 0x0E, 0x67, 0x0C, 0xE7, 0x1C, 0xE3,
  0x38, 0x67, 0x30, 0x67, 0x70, 0x7E, 0xE0, 0x3C, 0xC0, 0x01, 0xC0, 0x03,
  0x9C, 0x03, 0xBE, 0x07, 0x77, 0x06, 0x63, 0x0E, 0x63, 0x1C, 0x63, 0x18,
  0x63, 0x38, 0x73, 0x70, 0x3F, 0x60, 0x3E, 0x0F, 0x80, 0x3F, 0x80, 0xF7,
  0x81, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x3F, 0x80,
  0x3E, 0x00, 0xFC, 0x73, 0xF8, 0xE7, 0x79, 0xDC, 0x7B, 0x38, 0x7E, 0x70,
  0x7C, 0xE0, 0x79, 0xE1, 0xF1, 0xEF, 0xF3, 0xFE, 0xE3, 0xF9, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0x01, 0xC1, 0xE1, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x08, 0x20, 0x1C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC3, 0xE0,
  0x70, 0x08, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x2F, 0x77, 0xFF,
  0xFD, 0xFF, 0xC0, 0xE0, 0x1D, 0x81, 0xEE, 0x1E, 0x7C, 0x71, 0xC1, 0x08,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x3C, 0x79, 0xFB, 0xF3, 0xE1, 0x87, 0x7C, 0xF1,
  0x80, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x8E, 0x1E, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0xF3, 0x9F,
  0xCE, 0x7F, 0x39, 0xFC, 0xE7, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0x78, 0x3C, 0xE0, 0xE3, 0xEF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x80, 0x3C,
  0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x3D, 0xC1, 0x8E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0x3F,
  0xFC, 0xC1, 0xE4, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x87, 0xFF, 0x1F, 0xF8,
  0x81, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0xE0, 0xFE, 0x07,
  0xF8, 0x07, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x03,
  0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x70,
  0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F,
  0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xF0, 0x3F,
  0x83, 0xFC, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFD, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x7B, 0x83, 0xDF, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD,
  0xE0, 0xEE, 0x07, 0xF0, 0x1F, 0x81, 0xFE, 0x0E, 0x78, 0xF1, 0xFF, 0x07,
  0xF0, 0xFF, 0xE7, 0x0F, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xFF, 0x7E, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xE0,
  0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xDF, 0xFE,
  0xFF, 0xF1, 0xFF, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x1F,
  0xE0, 0xFE, 0x07, 0x80, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xFF, 0xFE, 0x1C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE3, 0xE7, 0xCF, 0x9F, 0x0E, 0x3B, 0xF7, 0x86, 0x00, 0x00, 0x08,
  0x01, 0xC0, 0x3E, 0x0F, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0x1E, 0x00, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x0F, 0x80, 0x70, 0x00,
  0x7F, 0x9F, 0xFB, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x08, 0x03,
  0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x79, 0xF1, 0xC0,
  0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0x1F,
  0x9C, 0x3F, 0x38, 0x7E, 0x70, 0xFC, 0xE1, 0xF9, 0xC3, 0xF3, 0x87, 0xE3,
  0x8E, 0xC7, 0xFD, 0xC7, 0xFB, 0x83, 0xC3, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x39, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0E, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x78, 0x0E, 0x38, 0x07, 0x9C, 0x03, 0xCE, 0x00,
  0xEF, 0x00, 0x78, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0E, 0xE1, 0xE7, 0xFE, 0x3F, 0xF9, 0xFF, 0xEE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFD, 0xFF, 0xEF,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0x23, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x08,
  0x7E, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x38,
  0x7C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x7B,
  0x83, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x01, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77,
  0x01, 0xDE, 0x07, 0x78, 0x1C, 0xF0, 0x73, 0xFF, 0xC7, 0xFF, 0x07, 0xFC,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x74, 0x0F, 0xF7, 0xEF, 0xFE,
  0x7F, 0x80, 0xE0, 0x3F, 0x81, 0xEE, 0x0F, 0x38, 0x3C, 0xE1, 0xE3, 0x8F,
  0x0E, 0x78, 0x39, 0xE0, 0xEF, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC0, 0xE7,
  0x83, 0x8F, 0x0E, 0x1E, 0x38, 0x78, 0xE0, 0xF3, 0x81, 0xEE, 0x07, 0xB8,
  0x0F, 0xE0, 0x3C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xC6, 0xCD, 0x8D, 0x9B, 0x3B,
  0x37, 0x76, 0x66, 0xCC, 0xCD, 0x9B, 0x9F, 0x37, 0x1C, 0x6E, 0x38, 0xDC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xE0, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0xF0, 0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B,
  0xF0, 0xDF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x03, 0xCE,
  0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x70, 0x3C, 0xF0, 0x78,
  0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C,
  0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF,
  0x1F, 0xBF, 0xFC, 0xFF, 0xC3, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xC1, 0xE7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0E, 0x70, 0x1C, 0xF0, 0x78, 0xFB, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x10, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x07, 0xB8, 0x1E,
  0xE0, 0x73, 0x83, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0x8F, 0x0E, 0x1E,
  0x38, 0x38, 0xE0, 0xF3, 0x81, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x3C, 0x1F,
  0xE1, 0xFF, 0x9F, 0xFD, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x03, 0xFE, 0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF7, 0xEF, 0x8F,
  0xFE, 0x1F, 0xE0, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE3, 0x8D, 0xC7, 0x1B, 0x9F, 0x37, 0x36, 0x66, 0x6C, 0xCD, 0xD9, 0x9B,
  0x3B, 0x36, 0x36, 0x7C, 0x6C, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xE7, 0x03,
  0xC0, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7, 0x03, 0x9E,
  0x07, 0xB8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFE, 0x03, 0xDE, 0x07, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0xF0, 0x79, 0xC0,
  0xF7, 0x80, 0xFE, 0x01, 0xE0, 0xF0, 0x07, 0x78, 0x0F, 0x78, 0x0F, 0x38,
  0x0E, 0x3C, 0x1E, 0x1C, 0x1C, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x07,
  0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x01, 0xEE, 0x03, 0xDE, 0x0F,
  0x1E, 0x1C, 0x1C, 0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x79, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0xE3, 0xE1, 0xE0, 0xE0, 0x80,
  0x3F, 0xC3, 0xFF, 0x0F, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x0D, 0xE7,
  0xFF, 0x7F, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFE, 0x3D, 0xFF,
  0xE7, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0x07, 0xBC, 0x1E, 0xF0,
  0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC,
  0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE,
  0xF8, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE1, 0xF7, 0x1F, 0xF9,
  0xFF, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xDC, 0x0E, 0xF0, 0x73, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x07,
  0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x1D, 0xC0, 0x7F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xF3,
  0xFF, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE6, 0x0F, 0x9F, 0xFC, 0x7F, 0xE0, 0x38, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF0,
  0xFF, 0xE7, 0xFF, 0xBC, 0x3D, 0xE0, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xE0, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xEE, 0x7F, 0xFF, 0x7F, 0xC0, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xF0, 0x7B, 0xC3,
  0xCF, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7,
  0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x03, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0x7E, 0x71, 0xFF, 0xFB, 0xFF, 0xF7, 0x1C, 0xEE, 0x38, 0xFC,
  0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x3F, 0x87, 0xFF, 0x3F,
  0xFD, 0xE1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xE7, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0x80, 0xE7, 0x83, 0xC7, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0,
  0x7B, 0xC0, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC,
  0x0E, 0xF0, 0x7B, 0xFF, 0xCF, 0xFF, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF,
  0xDF, 0x0F, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x3C, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xE1,
  0xFF, 0x9F, 0xFC, 0xE0, 0x2F, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0xFF, 0xFB, 0xFF, 0xCF, 0xF8,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0x80, 0xE7, 0x83, 0xCF, 0x07, 0x0E, 0x0E,
  0x1E, 0x3C, 0x1C, 0x70, 0x39, 0xE0, 0x7B, 0x80, 0x77, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x38, 0xFC, 0x71, 0xF9, 0xE3, 0xF3, 0xE6, 0x67, 0xCC, 0xCD, 0xB9,
  0xBB, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x0E, 0x0E, 0x1C, 0x1C, 0xF0,
  0x1E, 0xE0, 0x78, 0xE0, 0xE1, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0xE3, 0x83, 0xC7, 0x8F,
  0x07, 0x9C, 0x07, 0x78, 0x0F, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0x73, 0xC1,
  0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x3C, 0x1E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x02, 0x3C, 0x07, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x7F, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0xFF, 0x0F, 0xE0,
  0xF8, 0x00, 0x08, 0x00, 0x7C, 0x1D, 0xFE, 0x3F, 0xBF, 0xEE, 0x1F, 0x84,
  0x0E, 0x00,
};

const GFXglyph UbuntuSansMono_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 9, 9, 17, 4, -23 },
  { 26, 15, 21, 17, 1, -21 },
  { 66, 13, 26, 17, 2, -23 },
  { 109, 16, 21, 17, 0, -21 },
  { 151, 15, 21, 17, 1, -21 },
  { 191, 3, 10, 17, 7, -23 },
  { 195, 9, 30, 17, 4, -24 },
  { 229, 10, 30, 17, 3, -24 },
  { 267, 13, 13, 17, 2, -21 },
  { 289, 14, 15, 17, 1, -16 },
  { 316, 7, 10, 17, 5, -5 },
  { 325, 8, 3, 17, 4, -10 },
  { 328, 5, 5, 17, 6, -5 },
  { 332, 13, 29, 17, 2, -23 },
  { 380, 14, 21, 17, 1, -21 },
  { 417, 13, 21, 17, 2, -21 },
  { 452, 13, 21, 17, 2, -21 },
  { 487, 13, 21, 17, 2, -21 },
  { 522, 15, 21, 17, 1, -21 },
  { 562, 13, 21, 17, 2, -21 },
  { 597, 13, 21, 17, 2, -21 },
  { 632, 13, 21, 17, 2, -21 },
  { 667, 13, 21, 17, 2, -21 },
  { 702, 13, 21, 17, 2, -21 },
  { 737, 5, 16, 17, 6, -16 },
  { 747, 7, 21, 17, 4, -16 },
  { 766, 13, 14, 17, 2, -16 },
  { 789, 14, 9, 17, 1, -13 },
  { 805, 13, 14, 17, 2, -16 },
  { 828, 11, 21, 17, 3, -21 },
  { 857, 15, 26, 17, 1, -21 },
  { 906, 17, 21, 17, 0, -21 },
  { 951, 13, 21, 17, 2, -21 },
  { 986, 15, 21, 17, 1, -21 },
  { 1026, 14, 21, 17, 2, -21 },
  { 1063, 12, 21, 17, 3, -21 },
  { 1095, 12, 21, 17, 3, -21 },
  { 1127, 14, 21, 17, 1, -21 },
  { 1164, 14, 21, 17, 1, -21 },
  { 1201, 11, 21, 17, 3, -21 },
  { 1230, 12, 21, 17, 2, -21 },
  { 1262, 14, 21, 17, 2, -21 },
  { 1299, 12, 21, 17, 3, -21 },
  { 1331, 15, 21, 17, 1, -21 },
  { 1371, 13, 21, 17, 2, -21 },
  { 1406, 15, 21, 17, 1, -21 },
  { 1446, 14, 21, 17, 2, -21 },
  { 1483, 15, 27, 17, 1, -21 },
  { 1534, 14, 21, 17, 2, -21 },
  { 1571, 13, 21, 17, 2, -21 },
  { 1606, 15, 21, 17, 1, -21 },
  { 1646, 14, 21, 17, 1, -21 },
  { 1683, 16, 21, 17, 0, -21 },
  { 1725, 15, 21, 17, 1, -21 },
  { 1765, 15, 21, 17, 1, -21 },
  { 1805, 16, 21, 17, 0, -21 },
  { 1847, 13, 21, 17, 2, -21 },
  { 1882, 9, 29, 17, 4, -23 },
  { 1915, 13, 29, 17, 2, -23 },
  { 1963, 8, 29, 17, 4, -23 },
  { 1992, 15, 12, 17, 1, -21 },
  { 2015, 17, 3, 17, 0, 3 },
  { 2022, 7, 6, 17, 5, -23 },
  { 2028, 13, 16, 17, 2, -16 },
  { 2054, 14, 23, 17, 2, -23 },
  { 2095, 13, 16, 17, 2, -16 },
  { 2121, 13, 23, 17, 1, -23 },
  { 2159, 14, 16, 17, 1, -16 },
  { 2187, 14, 23, 17, 2, -23 },
  { 2228, 14, 22, 17, 1, -16 },
  { 2267, 13, 23, 17, 2, -23 },
  { 2305, 13, 23, 17, 2, -23 },
  { 2343, 11, 29, 17, 2, -23 },
  { 2383, 14, 23, 17, 2, -23 },
  { 2424, 13, 23, 17, 2, -23 },
  { 2462, 15, 16, 17, 1, -16 },
  { 2492, 13, 16, 17, 2, -16 },
  { 2518, 15, 16, 17, 1, -16 },
  { 2548, 14, 22, 17, 2, -16 },
  { 2587, 14, 22, 17, 1, -16 },
  { 2626, 12, 16, 17, 3, -16 },
  { 2650, 13, 16, 17, 2, -16 },
  { 2676, 13, 20, 17, 2, -20 },
  { 2709, 13, 16, 17, 2, -16 },
  { 2735, 15, 16, 17, 1, -16 },
  { 2765, 15, 16, 17, 1, -16 },
  { 2795, 15, 16, 17, 1, -16 },
  { 2825, 15, 22, 17, 1, -16 },
  { 2867, 12, 16, 17, 2, -16 },
  { 2891, 12, 29, 17, 2, -23 },
  { 2935, 3, 29, 17, 7, -23 },
  { 2946, 12, 29, 17, 2, -23 },
  { 2990, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_Medium30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_MEDIUM30PT7B_H_
