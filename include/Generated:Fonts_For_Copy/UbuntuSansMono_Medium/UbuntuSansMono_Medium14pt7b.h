#ifndef _UBUNTUSANSMONO_MEDIUM14PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0x99, 0x99, 0x12, 0x2C, 0xDF, 0xF2, 0x44, 0xBF,
  0xFF, 0x68, 0x90, 0x30, 0xC7, 0xF0, 0xC3, 0x83, 0x83, 0x0F, 0xF7, 0x8C,
  0x30, 0x63, 0xB2, 0x94, 0xBC, 0x68, 0x16, 0x3E, 0x29, 0x4B, 0xC6, 0x38,
  0xD9, 0xB3, 0x43, 0x8E, 0x57, 0xE6, 0x4E, 0xF4, 0xFF, 0x80, 0x13, 0x6C,
  0x88, 0x88, 0x8C, 0x46, 0x31, 0x8C, 0x62, 0x31, 0x11, 0x13, 0x26, 0xC8,
  0x30, 0xCE, 0xCC, 0x79, 0x20, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x00, 0x6C,
  0xE0, 0xFF, 0xF0, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x0C, 0x21, 0x86, 0x10,
  0xC3, 0x00, 0x73, 0x6C, 0xE1, 0xB6, 0xD8, 0x63, 0xCD, 0xE0, 0x10, 0xCF,
  0x24, 0x10, 0x41, 0x04, 0x11, 0xF0, 0x7B, 0x60, 0xC3, 0x18, 0xC6, 0x10,
  0xC3, 0xF0, 0x73, 0x60, 0xC2, 0x38, 0xE0, 0xC3, 0x8F, 0xE0, 0x04, 0x18,
  0x51, 0xA2, 0x48, 0xBF, 0xFF, 0x04, 0x08, 0x7D, 0xF4, 0x10, 0x72, 0x70,
  0xC3, 0x8F, 0xE0, 0x18, 0xF6, 0x30, 0xFA, 0x38, 0xF3, 0xCD, 0xE0, 0xFF,
  0xF0, 0x86, 0x10, 0xC3, 0x08, 0x61, 0x80, 0x7B, 0x38, 0xF3, 0x79, 0xE8,
  0xE1, 0xCD, 0xE0, 0x7B, 0x68, 0xE1, 0xC5, 0xF0, 0xC2, 0x3B, 0x80, 0xF0,
  0x3C, 0x6C, 0x00, 0xD9, 0xC0, 0x0C, 0xEE, 0x38, 0x38, 0x30, 0xFC, 0x00,
  0x3F, 0xC1, 0xC1, 0xC7, 0x73, 0x00, 0xF9, 0x60, 0xC2, 0x10, 0xC2, 0x00,
  0x31, 0xC0, 0x1C, 0x4D, 0x0A, 0x75, 0xBA, 0x74, 0xA9, 0x5E, 0xC0, 0xC0,
  0xF0, 0x18, 0x18, 0x3C, 0x2C, 0x24, 0x66, 0x7E, 0x7E, 0x42, 0xC3, 0xF3,
  0xE8, 0xE3, 0xFB, 0xF8, 0x61, 0x8F, 0xE0, 0x3D, 0xBC, 0x20, 0x82, 0x08,
  0x30, 0xE5, 0xF0, 0xF3, 0xE8, 0xE1, 0x86, 0x18, 0x63, 0x9B, 0xC0, 0xFF,
  0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0xF0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC,
  0x30, 0xC3, 0x00, 0x3D, 0x9C, 0x20, 0x82, 0x18, 0x71, 0xC5, 0xF0, 0x86,
  0x18, 0x61, 0xFF, 0xF8, 0x61, 0x86, 0x10, 0xFF, 0xF3, 0x0C, 0x30, 0xC3,
  0x0C, 0x33, 0xF0, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x8B, 0xE0, 0x8D,
  0x1A, 0x65, 0x8E, 0x16, 0x26, 0x4C, 0x8D, 0x0C, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0xF0, 0x66, 0xCD, 0x9B, 0x55, 0xAB, 0x50, 0xA1, 0x43,
  0x84, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8E, 0x30, 0x3C, 0xDD, 0x1A,
  0x1C, 0x38, 0x50, 0xA1, 0x66, 0x78, 0xFB, 0xFC, 0x71, 0xCF, 0xFE, 0x30,
  0xC3, 0x00, 0x3C, 0xDD, 0x1A, 0x1C, 0x38, 0x50, 0xA1, 0x66, 0x78, 0x60,
  0x70, 0x20, 0xF3, 0xE8, 0xE3, 0x8F, 0xE9, 0xA2, 0x8E, 0x10, 0x7F, 0x2C,
  0x30, 0x70, 0xE0, 0xC1, 0x8F, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xE0, 0xC3, 0xC2,
  0x42, 0x66, 0x66, 0x24, 0x24, 0x3C, 0x18, 0x18, 0xC3, 0x85, 0x0A, 0x15,
  0xAB, 0x5E, 0xB3, 0x66, 0xCC, 0xC2, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x3C,
  0x24, 0x66, 0xC3, 0xC3, 0x42, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xF0, 0x86, 0x30, 0x86, 0x10, 0xC3, 0xF0, 0xFC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xFF, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x61,
  0x82, 0x0C, 0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x30,
  0xF3, 0x26, 0x78, 0x40, 0xFF, 0xFF, 0x5C, 0x80, 0x78, 0x30, 0xFF, 0x8F,
  0x37, 0xC0, 0xC3, 0x0C, 0x30, 0xFB, 0x3C, 0x71, 0xC7, 0x3F, 0x80, 0x7F,
  0x08, 0x20, 0xC3, 0x97, 0xC0, 0x0C, 0x30, 0xC3, 0xFF, 0x38, 0xE3, 0x8F,
  0x37, 0xC0, 0x7B, 0x38, 0x7F, 0x83, 0x17, 0xC0, 0x1E, 0x69, 0x83, 0x0F,
  0xCC, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x7F, 0x38, 0xE3, 0x8F, 0xF3, 0xC3,
  0xF9, 0xC0, 0xC3, 0x0C, 0x30, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x21,
  0x82, 0x00, 0xE0, 0x82, 0x08, 0x20, 0xD3, 0xC0, 0x18, 0xC4, 0x07, 0x84,
  0x21, 0x08, 0x42, 0x3F, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0xDB, 0x3C, 0x78,
  0xD9, 0x9B, 0x38, 0xE3, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xD3, 0xC0,
  0xFE, 0xDB, 0x6D, 0x86, 0x18, 0x40, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0,
  0x7B, 0x38, 0x61, 0x87, 0x37, 0x80, 0xFB, 0x3C, 0x71, 0xC7, 0x3F, 0xB0,
  0xC3, 0x00, 0x7F, 0x38, 0xE3, 0x8F, 0x37, 0xC3, 0x0C, 0x30, 0xFC, 0x21,
  0x08, 0x42, 0x00, 0xFF, 0x0E, 0x1E, 0x0E, 0x3F, 0x80, 0x21, 0x86, 0x3F,
  0x61, 0x86, 0x18, 0x24, 0xF0, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0xC0, 0xC2,
  0xCD, 0x99, 0x23, 0xC7, 0x06, 0x00, 0xC3, 0xDA, 0x5A, 0x5A, 0x7A, 0x66,
  0x66, 0xE6, 0x78, 0x60, 0xC3, 0xCC, 0xF0, 0x80, 0x62, 0xCC, 0x99, 0xA3,
  0xC3, 0x86, 0x0C, 0x71, 0xC0, 0xFC, 0x63, 0x08, 0x63, 0x0F, 0xC0, 0x1C,
  0xC2, 0x08, 0x20, 0x8E, 0x18, 0x20, 0x82, 0x08, 0x3C, 0x70, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0xC1, 0x04, 0x10, 0x41, 0xC6, 0x10, 0x41, 0x04, 0xF3,
  0x00, 0x7B, 0x9C,
};

const GFXglyph UbuntuSansMono_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 7, 10, 8, 0, -10 },
  { 15, 6, 13, 8, 1, -11 },
  { 25, 8, 10, 8, 0, -10 },
  { 35, 7, 10, 8, 0, -10 },
  { 44, 2, 5, 8, 3, -11 },
  { 46, 4, 14, 8, 2, -11 },
  { 53, 4, 14, 8, 2, -11 },
  { 60, 6, 6, 8, 1, -10 },
  { 65, 6, 7, 8, 1, -8 },
  { 71, 3, 4, 8, 2, -2 },
  { 73, 4, 2, 8, 2, -5 },
  { 74, 2, 2, 8, 3, -2 },
  { 75, 6, 14, 8, 1, -11 },
  { 86, 6, 10, 8, 1, -10 },
  { 94, 6, 10, 8, 1, -10 },
  { 102, 6, 10, 8, 1, -10 },
  { 110, 6, 10, 8, 1, -10 },
  { 118, 7, 10, 8, 0, -10 },
  { 127, 6, 10, 8, 1, -10 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 6, 10, 8, 1, -10 },
  { 151, 6, 10, 8, 1, -10 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 2, 7, 8, 3, -7 },
  { 169, 3, 9, 8, 2, -7 },
  { 173, 6, 6, 8, 1, -7 },
  { 178, 6, 4, 8, 1, -6 },
  { 181, 6, 6, 8, 1, -7 },
  { 186, 6, 10, 8, 1, -10 },
  { 194, 7, 12, 8, 0, -10 },
  { 205, 8, 10, 8, 0, -10 },
  { 215, 6, 10, 8, 1, -10 },
  { 223, 6, 10, 8, 1, -10 },
  { 231, 6, 10, 8, 1, -10 },
  { 239, 6, 10, 8, 1, -10 },
  { 247, 6, 10, 8, 1, -10 },
  { 255, 6, 10, 8, 1, -10 },
  { 263, 6, 10, 8, 1, -10 },
  { 271, 6, 10, 8, 1, -10 },
  { 279, 6, 10, 8, 1, -10 },
  { 287, 7, 10, 8, 1, -10 },
  { 296, 6, 10, 8, 1, -10 },
  { 304, 7, 10, 8, 0, -10 },
  { 313, 6, 10, 8, 1, -10 },
  { 321, 7, 10, 8, 0, -10 },
  { 330, 6, 10, 8, 1, -10 },
  { 338, 7, 13, 8, 0, -10 },
  { 350, 6, 10, 8, 1, -10 },
  { 358, 6, 10, 8, 1, -10 },
  { 366, 6, 10, 8, 1, -10 },
  { 374, 6, 10, 8, 1, -10 },
  { 382, 8, 10, 8, 0, -10 },
  { 392, 7, 10, 8, 0, -10 },
  { 401, 8, 10, 8, 0, -10 },
  { 411, 8, 10, 8, 0, -10 },
  { 421, 6, 10, 8, 1, -10 },
  { 429, 4, 14, 8, 2, -11 },
  { 436, 6, 14, 8, 1, -11 },
  { 447, 4, 14, 8, 2, -11 },
  { 454, 7, 6, 8, 0, -10 },
  { 460, 8, 2, 8, 0, 1 },
  { 462, 3, 3, 8, 2, -11 },
  { 464, 6, 7, 8, 1, -7 },
  { 470, 6, 11, 8, 1, -11 },
  { 479, 6, 7, 8, 1, -7 },
  { 485, 6, 11, 8, 1, -11 },
  { 494, 6, 7, 8, 1, -7 },
  { 500, 7, 11, 8, 1, -11 },
  { 510, 6, 10, 8, 1, -7 },
  { 518, 6, 11, 8, 1, -11 },
  { 527, 6, 11, 8, 1, -11 },
  { 536, 5, 14, 8, 1, -11 },
  { 545, 7, 11, 8, 1, -11 },
  { 555, 6, 11, 8, 1, -11 },
  { 564, 6, 7, 8, 1, -7 },
  { 570, 6, 7, 8, 1, -7 },
  { 576, 6, 7, 8, 1, -7 },
  { 582, 6, 10, 8, 1, -7 },
  { 590, 6, 10, 8, 1, -7 },
  { 598, 5, 7, 8, 2, -7 },
  { 603, 6, 7, 8, 1, -7 },
  { 609, 6, 10, 8, 1, -10 },
  { 617, 6, 7, 8, 1, -7 },
  { 623, 7, 7, 8, 0, -7 },
  { 630, 8, 7, 8, 0, -7 },
  { 637, 7, 7, 8, 0, -7 },
  { 644, 7, 10, 8, 0, -7 },
  { 653, 6, 7, 8, 1, -7 },
  { 659, 6, 14, 8, 1, -11 },
  { 670, 2, 14, 8, 3, -11 },
  { 674, 6, 14, 8, 1, -11 },
  { 685, 7, 2, 8, 0, -5 },
};

const GFXfont UbuntuSansMono_Medium14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_MEDIUM14PT7B_H_
