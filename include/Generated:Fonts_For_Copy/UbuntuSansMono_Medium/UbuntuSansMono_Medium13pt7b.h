#ifndef _UBUNTUSANSMONO_MEDIUM13PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA3, 0xC0, 0xBB, 0xBA, 0x34, 0x6B, 0xF9, 0x22, 0xDF, 0xFF,
  0xA4, 0x58, 0x20, 0xCF, 0xA0, 0xC1, 0xC1, 0x83, 0x9B, 0xC2, 0x00, 0x63,
  0x4A, 0xA7, 0x41, 0x07, 0xCA, 0xA5, 0xCE, 0x38, 0x91, 0x23, 0xC7, 0x4B,
  0xB3, 0x26, 0x7E, 0xF0, 0x36, 0xC8, 0x88, 0x88, 0x8C, 0x63, 0xC3, 0x0C,
  0x21, 0x8C, 0x63, 0x11, 0x88, 0x80, 0x22, 0xAF, 0xDC, 0xD8, 0x20, 0x82,
  0x3F, 0x20, 0x80, 0x6C, 0xE0, 0xE0, 0xEC, 0x08, 0xC6, 0x23, 0x18, 0x8C,
  0x62, 0x31, 0x80, 0x73, 0x28, 0xAB, 0xAE, 0x38, 0xB2, 0x70, 0x31, 0xCF,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0xFA, 0x60, 0x86, 0x31, 0x84, 0x30, 0xFC,
  0xF4, 0xC2, 0x37, 0x84, 0x31, 0xF8, 0x0C, 0x38, 0xF1, 0x64, 0xC9, 0xBF,
  0x86, 0x0C, 0x7A, 0x10, 0xCF, 0x84, 0x31, 0xF8, 0x39, 0x8C, 0x2C, 0xFA,
  0x38, 0xF2, 0x78, 0xFC, 0x21, 0x84, 0x30, 0x82, 0x18, 0x60, 0x7A, 0x28,
  0xB6, 0x72, 0x28, 0xE2, 0xF8, 0x7A, 0x28, 0xA3, 0xFC, 0xA1, 0x8C, 0xE0,
  0xEC, 0x01, 0xD8, 0xEC, 0x00, 0xFB, 0xC0, 0x04, 0xFE, 0x30, 0x70, 0x70,
  0xFC, 0x00, 0x3F, 0x83, 0x83, 0x87, 0x73, 0x00, 0xF8, 0xC2, 0x22, 0x10,
  0x0C, 0x60, 0x3C, 0xCD, 0x0A, 0xFD, 0x3A, 0x54, 0xAF, 0x40, 0x40, 0x70,
  0x18, 0x70, 0xA1, 0x66, 0x48, 0x9F, 0xA3, 0xC2, 0xF2, 0x68, 0xA6, 0xFA,
  0x38, 0xE2, 0xF8, 0x7F, 0x18, 0x20, 0x82, 0x08, 0x31, 0x7C, 0xF2, 0x68,
  0xE3, 0x8E, 0x38, 0xE6, 0xF0, 0xFB, 0x0C, 0x30, 0xFB, 0x0C, 0x30, 0xFC,
  0xFE, 0x31, 0x8F, 0xE3, 0x18, 0xC0, 0x7F, 0x18, 0x20, 0x8E, 0x38, 0xF3,
  0x7C, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0xF8, 0x78, 0x42, 0x10, 0x84, 0x33, 0xF0, 0x8E, 0x6B, 0x28, 0xE2,
  0xC9, 0xA2, 0x8C, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x44, 0xC9,
  0xBB, 0x75, 0xEA, 0xD1, 0xE3, 0xC2, 0x8F, 0x3C, 0xEB, 0xAE, 0x79, 0xE3,
  0x8C, 0x3C, 0xC9, 0x1E, 0x3C, 0x78, 0xD1, 0xB2, 0x3C, 0xFA, 0x38, 0xE3,
  0x9B, 0xC8, 0x20, 0x80, 0x3C, 0xC9, 0x1E, 0x3C, 0x78, 0xD1, 0xB2, 0x3C,
  0x20, 0x38, 0xF2, 0x68, 0xA2, 0xFB, 0xC9, 0xA2, 0x8C, 0x7B, 0x28, 0x30,
  0x78, 0x60, 0xE2, 0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF2, 0x78, 0xC2, 0x8D, 0x1A, 0x26, 0x45,
  0x8A, 0x1C, 0x18, 0xC7, 0x8D, 0x1A, 0xB5, 0xED, 0xDB, 0xB2, 0x44, 0xC6,
  0xC8, 0xA1, 0xC1, 0x87, 0x1B, 0x32, 0xC6, 0xC6, 0x89, 0x91, 0x63, 0x82,
  0x04, 0x08, 0x10, 0xFC, 0x21, 0x8C, 0x21, 0x84, 0x30, 0xFC, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x8F, 0xC6, 0x10, 0xC6, 0x10, 0xC6, 0x10, 0x86, 0x10,
  0xE4, 0x92, 0x49, 0x24, 0xF0, 0x18, 0x70, 0xB3, 0x2C, 0x60, 0xFE, 0xCC,
  0xF4, 0xC3, 0xF8, 0xC7, 0xE0, 0x82, 0x08, 0x3C, 0xDA, 0x38, 0xE3, 0x8B,
  0xE0, 0x7F, 0x18, 0x20, 0x83, 0x07, 0xC0, 0x04, 0x10, 0x4F, 0x6D, 0x1C,
  0x51, 0x64, 0xF0, 0x73, 0x28, 0xFF, 0x83, 0x07, 0x80, 0x3D, 0x96, 0x3E,
  0x61, 0x86, 0x18, 0x61, 0x80, 0x7E, 0x63, 0x18, 0xFD, 0xA1, 0xF8, 0x84,
  0x21, 0xED, 0xC6, 0x31, 0x8C, 0x40, 0x61, 0x80, 0x38, 0x20, 0x82, 0x08,
  0x20, 0xF0, 0x11, 0xC1, 0xF1, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x82, 0x08,
  0x23, 0x9A, 0xCE, 0x2C, 0x9A, 0x30, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xF0, 0xFA, 0xBA, 0x69, 0x86, 0x18, 0x40, 0xF4, 0xE3, 0x18, 0xC6,
  0x20, 0x73, 0x68, 0xE3, 0x8F, 0x27, 0x80, 0xF2, 0x68, 0xE3, 0x8E, 0x2F,
  0xA0, 0x80, 0x7E, 0x63, 0x18, 0xE5, 0xE1, 0x08, 0x7F, 0x1C, 0x30, 0xC3,
  0x0C, 0x00, 0x7E, 0x70, 0xE1, 0xC7, 0xE0, 0x61, 0x8F, 0xD8, 0x61, 0x86,
  0x18, 0x3C, 0x8C, 0x63, 0x18, 0xE5, 0xE0, 0xC6, 0x8D, 0x93, 0x62, 0x87,
  0x04, 0x00, 0xC3, 0x87, 0x4A, 0xF6, 0xCD, 0x99, 0x00, 0xC6, 0xD8, 0xE0,
  0xC3, 0x8D, 0xB1, 0x80, 0x46, 0xC9, 0x91, 0x63, 0xC3, 0x06, 0x08, 0xF0,
  0xF8, 0xCC, 0x46, 0x63, 0xE0, 0x39, 0x08, 0x42, 0x33, 0x04, 0x21, 0x08,
  0x70, 0xFF, 0xF0, 0xE1, 0x8C, 0x63, 0x08, 0x66, 0x31, 0x8D, 0xC0, 0x73,
  0xB8,
};

const GFXglyph UbuntuSansMono_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 4, 4, 7, 2, -10 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 11, 7, 1, -10 },
  { 23, 7, 9, 7, 0, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 1, 4, 7, 3, -10 },
  { 40, 4, 12, 7, 2, -10 },
  { 46, 5, 12, 7, 1, -10 },
  { 54, 6, 5, 7, 1, -9 },
  { 58, 6, 6, 7, 1, -7 },
  { 63, 3, 4, 7, 2, -2 },
  { 65, 3, 1, 7, 2, -4 },
  { 66, 3, 2, 7, 2, -2 },
  { 67, 5, 12, 7, 1, -10 },
  { 75, 6, 9, 7, 1, -9 },
  { 82, 6, 9, 7, 1, -9 },
  { 89, 6, 9, 7, 1, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 7, 9, 7, 0, -9 },
  { 110, 5, 9, 7, 1, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 6, 9, 7, 1, -9 },
  { 130, 6, 9, 7, 1, -9 },
  { 137, 6, 9, 7, 1, -9 },
  { 144, 3, 7, 7, 2, -7 },
  { 147, 3, 9, 7, 2, -7 },
  { 151, 6, 6, 7, 1, -7 },
  { 156, 6, 4, 7, 1, -6 },
  { 159, 6, 6, 7, 1, -7 },
  { 164, 5, 9, 7, 1, -9 },
  { 170, 7, 11, 7, 0, -9 },
  { 180, 7, 9, 7, 0, -9 },
  { 188, 6, 9, 7, 1, -9 },
  { 195, 6, 9, 7, 1, -9 },
  { 202, 6, 9, 7, 1, -9 },
  { 209, 6, 9, 7, 1, -9 },
  { 216, 5, 9, 7, 1, -9 },
  { 222, 6, 9, 7, 1, -9 },
  { 229, 6, 9, 7, 1, -9 },
  { 236, 5, 9, 7, 1, -9 },
  { 242, 5, 9, 7, 1, -9 },
  { 248, 6, 9, 7, 1, -9 },
  { 255, 6, 9, 7, 1, -9 },
  { 262, 7, 9, 7, 0, -9 },
  { 270, 6, 9, 7, 1, -9 },
  { 277, 7, 9, 7, 0, -9 },
  { 285, 6, 9, 7, 1, -9 },
  { 292, 7, 11, 7, 0, -9 },
  { 302, 6, 9, 7, 1, -9 },
  { 309, 6, 9, 7, 1, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 6, 9, 7, 1, -9 },
  { 331, 7, 9, 7, 0, -9 },
  { 339, 7, 9, 7, 0, -9 },
  { 347, 7, 9, 7, 0, -9 },
  { 355, 7, 9, 7, 0, -9 },
  { 363, 6, 9, 7, 1, -9 },
  { 370, 4, 12, 7, 2, -10 },
  { 376, 5, 12, 7, 1, -10 },
  { 384, 3, 12, 7, 2, -10 },
  { 389, 7, 5, 7, 0, -9 },
  { 394, 7, 1, 7, 0, 1 },
  { 395, 3, 2, 7, 2, -10 },
  { 396, 5, 7, 7, 1, -7 },
  { 401, 6, 10, 7, 1, -10 },
  { 409, 6, 7, 7, 1, -7 },
  { 415, 6, 10, 7, 0, -10 },
  { 423, 6, 7, 7, 1, -7 },
  { 429, 6, 10, 7, 1, -10 },
  { 437, 5, 9, 7, 1, -7 },
  { 443, 5, 10, 7, 1, -10 },
  { 450, 6, 10, 7, 1, -10 },
  { 458, 5, 12, 7, 1, -10 },
  { 466, 6, 10, 7, 1, -10 },
  { 474, 6, 10, 7, 1, -10 },
  { 482, 6, 7, 7, 1, -7 },
  { 488, 5, 7, 7, 1, -7 },
  { 493, 6, 7, 7, 1, -7 },
  { 499, 6, 9, 7, 1, -7 },
  { 506, 5, 9, 7, 1, -7 },
  { 512, 6, 7, 7, 1, -7 },
  { 518, 5, 7, 7, 1, -7 },
  { 523, 6, 9, 7, 1, -9 },
  { 530, 5, 7, 7, 1, -7 },
  { 535, 7, 7, 7, 0, -7 },
  { 542, 7, 7, 7, 0, -7 },
  { 549, 7, 7, 7, 0, -7 },
  { 556, 7, 9, 7, 0, -7 },
  { 564, 5, 7, 7, 1, -7 },
  { 569, 5, 12, 7, 1, -10 },
  { 577, 1, 12, 7, 3, -10 },
  { 579, 5, 12, 7, 1, -10 },
  { 587, 7, 2, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_Medium13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_MEDIUM13PT7B_H_
