#ifndef _UBUNTUSANSMONO_MEDIUM58PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x9F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF7, 0xF8, 0xFC, 0x0E, 0x00, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0x7C,
  0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x07, 0xDF, 0x01,
  0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x38, 0x07, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFC, 0x00, 0xF0, 0xFF, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE2, 0x00,
  0x01, 0xFC, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0xFF, 0xC0,
  0x03, 0xE3, 0xFF, 0xC0, 0x07, 0xC7, 0xCF, 0x80, 0x1F, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x3C, 0x0F,
  0xC1, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0xF8,
  0x0F, 0x83, 0xC3, 0xE0, 0x1F, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x1F, 0x00,
  0x3E, 0x7C, 0x7C, 0x00, 0x7F, 0xF9, 0xF8, 0x00, 0x7F, 0xE3, 0xE0, 0x00,
  0x7F, 0x8F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x0F, 0x8F, 0xF8, 0x00,
  0x3E, 0x3F, 0xF8, 0x00, 0x7C, 0xFF, 0xF0, 0x01, 0xF1, 0xF1, 0xF0, 0x07,
  0xE3, 0xC3, 0xE0, 0x0F, 0x8F, 0x83, 0xC0, 0x3E, 0x1F, 0x07, 0x80, 0x7C,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81,
  0xF0, 0x78, 0x3E, 0x03, 0xE0, 0xF0, 0xFC, 0x03, 0xC1, 0xE1, 0xF0, 0x07,
  0xC7, 0xC7, 0xC0, 0x0F, 0xDF, 0x8F, 0x80, 0x0F, 0xFE, 0x3E, 0x00, 0x1F,
  0xF8, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x7F, 0xC0,
  0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0xFC,
  0x7F, 0x3F, 0xC7, 0xC3, 0xF0, 0xFF, 0x3E, 0x1F, 0x83, 0xFD, 0xF1, 0xF8,
  0x0F, 0xFF, 0x8F, 0xC0, 0x3F, 0xF8, 0x7E, 0x00, 0xFF, 0xC3, 0xF0, 0x03,
  0xFE, 0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xF0, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x9F, 0xC1, 0xFF, 0xF0, 0x7E, 0x03, 0xFF,
  0x03, 0xF8, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x08, 0x07,
  0xC0, 0x23, 0xC1, 0xF0, 0x78, 0xFC, 0x7C, 0x7E, 0x7F, 0x9E, 0x3F, 0x9F,
  0xFB, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3C, 0x07, 0x80, 0x06, 0x01, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0xC3,
  0xFE, 0x3F, 0xF0, 0xFF, 0x81, 0xF8, 0x07, 0x80, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F,
  0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x1E, 0x0F, 0xFF, 0x87, 0xE1, 0xFF,
  0xF0, 0xFE, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F,
  0x0F, 0xFF, 0x0F, 0xC1, 0xFF, 0xE0, 0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xEF, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0x83, 0xF0, 0x03, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xF0, 0x0F,
  0xF0, 0xF0, 0x01, 0xFC, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xC0, 0x0F, 0xF0, 0x40, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE4, 0x00, 0x07, 0xF9, 0xE0, 0x07,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x90, 0x00, 0x1F,
  0xE7, 0x80, 0x1F, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x1F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x1F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xF8, 0x3F, 0x80, 0xFF,
  0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xC0,
  0x3F, 0xE7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD,
  0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0xC0, 0x07, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F,
  0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x1F, 0xF7, 0xFE, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xE7, 0xFC, 0x7F, 0x03, 0x00, 0x03, 0xC0, 0x1F, 0xC0, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x83, 0xFE, 0x3F, 0xF0, 0xFF, 0x83,
  0xF8, 0x07, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFC, 0x7F, 0xE3, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xF7, 0xC0,
  0x7F, 0xFF, 0x7C, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFF, 0xC3, 0xF8, 0x1F, 0xFC, 0x3F, 0x01, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC,
  0x3F, 0x01, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0xC7, 0xE0,
  0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC, 0x3F, 0x01, 0xFF,
  0xC3, 0xF0, 0x1F, 0xFC, 0x3F, 0x01, 0xFF, 0xC3, 0xF8, 0x1F, 0x7C, 0x1F,
  0xC1, 0xF7, 0xC1, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0x3E, 0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFE, 0x3F, 0x00, 0x08, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x01, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xE0, 0xFF, 0x00, 0x04, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0xFF, 0xC0,
  0x1E, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0x87, 0xF0, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0x7F, 0x07, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFE, 0x0F, 0xF8, 0x01, 0xC0, 0xFF,
  0x00, 0x04, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x20, 0x00, 0x7F, 0x1C, 0x00, 0x7F, 0x8F, 0x80, 0x7F,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0xFF, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xDF, 0xF0,
  0x00, 0xFC, 0xFF, 0x80, 0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0x3F, 0xC0, 0x0F,
  0xC1, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x07,
  0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x3D, 0xE0, 0x7F, 0xE1, 0xEF, 0x03, 0xFF, 0x1F, 0x7C, 0x1E,
  0xF8, 0xFB, 0xE0, 0xF7, 0xC7, 0xCF, 0x0F, 0xBE, 0x3E, 0x7C, 0x79, 0xF1,
  0xF3, 0xE3, 0xCF, 0x8F, 0x8F, 0x3E, 0x7C, 0x7C, 0x79, 0xE3, 0xE3, 0xE3,
  0xEF, 0x1F, 0x9F, 0x0F, 0xF8, 0xFC, 0xF8, 0x7F, 0xC7, 0xE7, 0xC3, 0xFC,
  0x3F, 0x3E, 0x0F, 0xE1, 0xF9, 0xF0, 0x7F, 0x0F, 0xCF, 0x83, 0xF0, 0x7E,
  0x7C, 0x1F, 0x83, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xE0,
  0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xF1,
  0xF8, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC1, 0xF0, 0xFF,
  0xF0, 0x7E, 0x3F, 0xFC, 0x0F, 0x8F, 0xFF, 0x03, 0xE3, 0xFF, 0xC0, 0xFC,
  0xFF, 0xF0, 0x1F, 0x3F, 0xFC, 0x07, 0xEF, 0xFF, 0x00, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xE0, 0x1F, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x01,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0x00, 0xFF, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E, 0x01, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xC3, 0xFC, 0x00, 0xE0, 0xFC, 0x00,
  0x08, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF3, 0x00, 0x03, 0xFD, 0xF0, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F,
  0xCF, 0x83, 0xF0, 0x7E, 0x7C, 0x1F, 0x83, 0xF3, 0xE0, 0xFE, 0x1F, 0x9F,
  0x0F, 0xF0, 0xFC, 0xF8, 0x7F, 0x87, 0xE7, 0xC3, 0xFE, 0x3F, 0x3E, 0x3F,
  0xF1, 0xF9, 0xF1, 0xF7, 0x8F, 0x8F, 0x8F, 0x3E, 0x7C, 0x7C, 0x79, 0xF3,
  0xE3, 0xE7, 0xC7, 0x9F, 0x1F, 0x3C, 0x3C, 0xF8, 0xF9, 0xE1, 0xF7, 0xC7,
  0xDF, 0x07, 0xBE, 0x3E, 0xF0, 0x3D, 0xF0, 0xF7, 0x81, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x3E,
  0x06, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0x00, 0x38, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0x1F, 0xF8, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0xC1, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xDF, 0xE0, 0x07, 0xEF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0xC0, 0x0F, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0x80,
  0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x21, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x38,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF9, 0xFC, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xE0, 0x07, 0xF7, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xFC, 0x01, 0xFC, 0x7F, 0xC0, 0x7F, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x1F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x38, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xC0, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0xE0,
  0x03, 0xF3, 0xFC, 0x00, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xCF,
  0xC0, 0x07, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x60, 0x03, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x70, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE4, 0x00, 0x7F,
  0x78, 0x07, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0x7F,
  0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC7,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x0E, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x07, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0,
  0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81,
  0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC,
  0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x8F, 0xE0, 0x1F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x3F, 0xE0, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xEF, 0xFE, 0x03, 0xF8, 0x7C,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0xC0, 0x1F, 0xCF, 0xF8, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0xFC, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE0, 0x03, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xE1, 0xFC, 0x7F, 0x00, 0x0C, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x3F,
  0x7C, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x08, 0x03, 0xFC, 0x07, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x80, 0x3F, 0x7F, 0xC0, 0x3F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x1F, 0x9F, 0x01, 0xF0, 0x3F, 0x3E, 0x03, 0xE0, 0x7E, 0x7C, 0x0F, 0xC0,
  0xF8, 0xFC, 0x1F, 0xC1, 0xF1, 0xF8, 0x3F, 0x83, 0xE3, 0xF0, 0x7F, 0x07,
  0xC3, 0xE1, 0xFE, 0x0F, 0x87, 0xC3, 0xFE, 0x1F, 0x0F, 0x87, 0xFC, 0x7E,
  0x1F, 0x1F, 0xF8, 0xF8, 0x3E, 0x3E, 0xF9, 0xF0, 0x7C, 0x79, 0xF3, 0xE0,
  0xFD, 0xF3, 0xE7, 0xC0, 0xFB, 0xE3, 0xEF, 0x81, 0xF7, 0x87, 0xDF, 0x03,
  0xFF, 0x0F, 0xBC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0xFF, 0xE0, 0x07, 0xC7, 0xFF, 0xC0,
  0x7C, 0x7F, 0xFF, 0x07, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xF1,
  0xF0, 0x3F, 0xFF, 0x9F, 0x00, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0x80, 0xC0,
  0x03, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 41, 32, 11, -40 },
  { 53, 18, 17, 32, 7, -44 },
  { 92, 29, 40, 32, 2, -40 },
  { 237, 27, 51, 32, 3, -45 },
  { 410, 31, 42, 32, 1, -41 },
  { 573, 29, 42, 32, 2, -41 },
  { 726, 7, 18, 32, 13, -44 },
  { 742, 19, 57, 32, 7, -46 },
  { 878, 19, 57, 32, 7, -46 },
  { 1014, 26, 24, 32, 3, -40 },
  { 1092, 27, 28, 32, 3, -31 },
  { 1187, 14, 20, 32, 9, -10 },
  { 1222, 16, 7, 32, 8, -20 },
  { 1236, 11, 11, 32, 11, -10 },
  { 1252, 25, 56, 32, 4, -45 },
  { 1427, 27, 42, 32, 3, -41 },
  { 1569, 25, 40, 32, 4, -40 },
  { 1694, 26, 41, 32, 3, -41 },
  { 1828, 26, 42, 32, 3, -41 },
  { 1965, 29, 40, 32, 2, -40 },
  { 2110, 26, 41, 32, 3, -40 },
  { 2244, 26, 41, 32, 3, -40 },
  { 2378, 26, 40, 32, 4, -40 },
  { 2508, 27, 42, 32, 3, -41 },
  { 2650, 26, 41, 32, 3, -41 },
  { 2784, 11, 31, 32, 11, -30 },
  { 2827, 14, 40, 32, 8, -30 },
  { 2897, 27, 27, 32, 3, -30 },
  { 2989, 27, 18, 32, 3, -26 },
  { 3050, 27, 27, 32, 3, -30 },
  { 3142, 22, 42, 32, 5, -41 },
  { 3258, 28, 50, 32, 2, -41 },
  { 3433, 31, 40, 32, 1, -40 },
  { 3588, 27, 41, 32, 3, -41 },
  { 3727, 28, 42, 32, 2, -41 },
  { 3874, 27, 41, 32, 3, -41 },
  { 4013, 25, 40, 32, 5, -40 },
  { 4138, 24, 40, 32, 5, -40 },
  { 4258, 28, 42, 32, 2, -41 },
  { 4405, 27, 40, 32, 3, -40 },
  { 4540, 23, 40, 32, 5, -40 },
  { 4655, 25, 41, 32, 3, -40 },
  { 4784, 28, 40, 32, 4, -40 },
  { 4924, 25, 40, 32, 5, -40 },
  { 5049, 29, 40, 32, 2, -40 },
  { 5194, 26, 40, 32, 3, -40 },
  { 5324, 29, 42, 32, 2, -41 },
  { 5477, 26, 41, 32, 4, -41 },
  { 5611, 29, 52, 32, 2, -41 },
  { 5800, 27, 41, 32, 4, -41 },
  { 5939, 26, 42, 32, 3, -41 },
  { 6076, 28, 40, 32, 2, -40 },
  { 6216, 27, 41, 32, 3, -40 },
  { 6355, 31, 40, 32, 1, -40 },
  { 6510, 29, 40, 32, 2, -40 },
  { 6655, 30, 40, 32, 1, -40 },
  { 6805, 31, 40, 32, 1, -40 },
  { 6960, 27, 40, 32, 3, -40 },
  { 7095, 17, 56, 32, 8, -45 },
  { 7214, 25, 56, 32, 4, -45 },
  { 7389, 17, 56, 32, 7, -45 },
  { 7508, 29, 22, 32, 2, -40 },
  { 7588, 31, 6, 32, 1, 5 },
  { 7612, 13, 11, 32, 10, -45 },
  { 7630, 25, 32, 32, 3, -31 },
  { 7730, 26, 46, 32, 4, -45 },
  { 7880, 27, 32, 32, 3, -31 },
  { 7988, 26, 46, 32, 2, -45 },
  { 8138, 28, 32, 32, 2, -31 },
  { 8250, 29, 45, 32, 3, -45 },
  { 8414, 26, 42, 32, 2, -31 },
  { 8551, 24, 45, 32, 4, -45 },
  { 8686, 27, 45, 32, 3, -44 },
  { 8838, 21, 55, 32, 4, -44 },
  { 8983, 27, 45, 32, 4, -45 },
  { 9135, 27, 46, 32, 3, -45 },
  { 9291, 28, 31, 32, 2, -31 },
  { 9400, 24, 31, 32, 4, -31 },
  { 9493, 28, 32, 32, 2, -31 },
  { 9605, 26, 42, 32, 4, -31 },
  { 9742, 26, 42, 32, 2, -31 },
  { 9879, 23, 31, 32, 6, -31 },
  { 9969, 24, 32, 32, 4, -31 },
  { 10065, 27, 41, 32, 3, -40 },
  { 10204, 24, 31, 32, 4, -30 },
  { 10297, 29, 30, 32, 2, -30 },
  { 10406, 31, 30, 32, 1, -30 },
  { 10523, 29, 30, 32, 2, -30 },
  { 10632, 28, 41, 32, 2, -30 },
  { 10776, 23, 30, 32, 5, -30 },
  { 10863, 23, 56, 32, 5, -45 },
  { 11024, 6, 56, 32, 13, -45 },
  { 11066, 24, 56, 32, 4, -45 },
  { 11234, 29, 10, 32, 2, -22 },
};

const GFXfont UbuntuSansMono_Medium58pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium58pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium58pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _UBUNTUSANSMONO_MEDIUM58PT7B_H_
