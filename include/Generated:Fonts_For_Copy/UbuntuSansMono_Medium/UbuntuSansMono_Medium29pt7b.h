#ifndef _UBUNTUSANSMONO_MEDIUM29PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x60, 0x00, 0xFF, 0xFF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x37, 0x1B, 0x0D, 0x86, 0x06, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x70, 0x38, 0xE0, 0x61, 0x81, 0xC7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x98, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0xF8, 0xFF, 0xE3, 0xC7, 0x1E, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xDC, 0x1E, 0x7F, 0xFB, 0xFF,
  0xC0, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x3C, 0x07,
  0x7E, 0x0E, 0x66, 0x0C, 0xE7, 0x18, 0xE7, 0x38, 0xE7, 0x30, 0x66, 0x70,
  0x7E, 0xE0, 0x3C, 0xC0, 0x19, 0xC0, 0x03, 0x98, 0x03, 0x3E, 0x07, 0x7E,
  0x06, 0x67, 0x0E, 0x67, 0x1C, 0x63, 0x18, 0x67, 0x38, 0x67, 0x70, 0x7E,
  0xE0, 0x3C, 0x02, 0x00, 0x7E, 0x03, 0xFC, 0x0E, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x0E, 0x70, 0x3B, 0xC0, 0x7E, 0x01, 0xE1, 0x8F, 0xC6, 0x77,
  0x9B, 0x8F, 0xEE, 0x1F, 0xB8, 0x3C, 0xE0, 0xF3, 0x83, 0xEF, 0xBF, 0x9F,
  0xF7, 0x3F, 0x1C, 0xFF, 0xFF, 0x77, 0x66, 0x60, 0x00, 0x80, 0xE0, 0x7C,
  0x3C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x20, 0x1C, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x1C, 0x1F, 0x0F, 0x81, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xCC,
  0x6F, 0xEF, 0x7F, 0xFC, 0x3E, 0x01, 0xF0, 0x1D, 0xC1, 0xCF, 0x1E, 0x78,
  0x21, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x39, 0xF7, 0xDF, 0x3C, 0x73, 0xBE, 0xF2,
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF, 0x00, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0x01, 0x00, 0x3F, 0x81, 0xFF, 0x0F, 0x3C, 0x78, 0x79, 0xC0,
  0xE7, 0x03, 0x9C, 0x07, 0xF1, 0x1F, 0xCE, 0x7E, 0x79, 0xF8, 0xE7, 0xF3,
  0x1F, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x39, 0xE1, 0xE3, 0xCF, 0x07,
  0xFC, 0x0F, 0xC0, 0x03, 0x80, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0x3B,
  0xC1, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0,
  0x04, 0x01, 0xFE, 0x3F, 0xF9, 0xE3, 0xC4, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x04,
  0x07, 0xFC, 0xFF, 0xE7, 0x1E, 0x40, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x01,
  0xE1, 0xFC, 0x1F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0xF3, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x07, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x1C, 0x38, 0x70, 0xE1,
  0xC7, 0x07, 0x1C, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x87, 0xFE, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0x7F, 0xFF, 0xEF, 0xF8,
  0x01, 0xE0, 0x3F, 0x87, 0xFC, 0x7C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x40, 0xFF, 0xC7, 0xFF, 0x3C, 0x3D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0E, 0xF0, 0x73, 0xCF, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x0E,
  0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x78, 0x78, 0xFB, 0xC1,
  0xFE, 0x07, 0xFC, 0x38, 0xF9, 0xC0, 0xE7, 0x03, 0xFC, 0x07, 0xF0, 0x1D,
  0xC0, 0xF7, 0xCF, 0x8F, 0xFC, 0x1F, 0xE0, 0x06, 0x01, 0xFE, 0x1F, 0xF9,
  0xE3, 0xCE, 0x0F, 0x70, 0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xFE,
  0x3E, 0xFF, 0xE3, 0xFF, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x3E,
  0x1F, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x77, 0xBF, 0xFF, 0x00, 0x00, 0x00,
  0x1D, 0xEF, 0xFF, 0xC0, 0x1C, 0x78, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x71, 0xE3, 0xE7, 0xCF, 0x86, 0x1D, 0xF3, 0xC6, 0x00, 0x00, 0x10,
  0x07, 0xC0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x03, 0xC0, 0x1F, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x60, 0x01, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xC0, 0x3F, 0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x08,
  0x1F, 0xF3, 0xFF, 0x61, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xF8, 0x1F, 0x01, 0xC0, 0x01, 0x00, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38,
  0x1D, 0xC0, 0x77, 0x01, 0xD8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0x71, 0xF9,
  0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x9F, 0x8F, 0xF7,
  0x1F, 0xDC, 0x3E, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x83, 0xFE, 0x07, 0xF8,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x3D, 0xF9, 0xC1, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x77, 0xFF, 0xBF, 0xF9, 0xFF,
  0x00, 0x00, 0xC0, 0x1F, 0xE1, 0xFF, 0xCF, 0xCE, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xF3, 0xC7, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x1E, 0xE1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xCF, 0xFC, 0xFF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x80, 0x1F,
  0xE1, 0xFF, 0xCF, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x78, 0x1C, 0xF0, 0x73, 0xF3, 0xC7, 0xFF, 0x07, 0xFC, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x40, 0xEF, 0x3E, 0xFF, 0xC7, 0xF8, 0xE0, 0x7B, 0x81,
  0xCE, 0x0F, 0x38, 0x78, 0xE3, 0xC3, 0x8E, 0x0E, 0x78, 0x3B, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x3B, 0xC0, 0xE7, 0x83, 0x8F, 0x0E, 0x1E, 0x38,
  0x3C, 0xE0, 0xF3, 0x81, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x39, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x7C, 0x79, 0xB3,
  0xF6, 0xCD, 0xDB, 0xB7, 0xE7, 0xDF, 0x9E, 0x7E, 0x79, 0xF8, 0xE7, 0xE3,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xDF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xF0, 0x01, 0x00,
  0x7F, 0x83, 0xFF, 0x0F, 0x3E, 0x78, 0x39, 0xC0, 0xFF, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x07, 0x70, 0x3D, 0xE0, 0xE3, 0xCF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x3E, 0xFD, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xF0, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0x83,
  0xFF, 0x0F, 0x3E, 0x78, 0x39, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0x70, 0x3D, 0xE0, 0xE3, 0xCF, 0x8F, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xE0, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xC1,
  0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x3F, 0x3F, 0xF1,
  0xFF, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xB8,
  0x1F, 0xC0, 0x70, 0x02, 0x01, 0xFF, 0x1F, 0xFC, 0xF0, 0xCF, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xBC, 0x7D, 0xFF, 0xC7,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x03, 0xDC, 0x0F, 0x70, 0x39, 0xF3, 0xE3, 0xFF, 0x07, 0xF8,
  0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x0E, 0x38, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xC7, 0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xF9,
  0xF7, 0x6C, 0xDD, 0xB3, 0x76, 0xCF, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE7,
  0x83, 0x9C, 0x0E, 0xF0, 0x1C, 0xE0, 0x71, 0xE0, 0xE1, 0xC3, 0x83, 0xCF,
  0x03, 0x9C, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xEE, 0x03, 0x9E, 0x0F, 0x1C, 0x1C, 0x3C, 0x78, 0x38, 0xE0,
  0x7B, 0xC0, 0xF7, 0x00, 0xF0, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38,
  0x1C, 0x3C, 0x1C, 0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x70, 0x0F, 0x70, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F,
  0xFF, 0xF0, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x1E, 0xE0, 0xF3, 0xC3, 0x87,
  0x1E, 0x1E, 0x70, 0x3F, 0xC0, 0x76, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x63, 0xC7, 0x8F, 0x0C, 0x06, 0x07, 0xFC, 0x7F, 0xE2, 0x1F, 0x00, 0x70,
  0x07, 0x00, 0x73, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x87, 0x7F, 0xF3, 0xFF, 0x10, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xC7, 0xFF, 0x3E, 0x7D, 0xC0, 0xEE,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1,
  0xEF, 0xBF, 0x7F, 0xF3, 0xFE, 0x00, 0x00, 0x80, 0xFF, 0xCF, 0xFC, 0xFC,
  0x6F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x80, 0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0x08, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x1F, 0xF9, 0xFF,
  0xDF, 0x3E, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xDC, 0x0E, 0xF0, 0x77, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x01, 0x00,
  0x3F, 0x83, 0xFF, 0x0F, 0x1E, 0x78, 0x39, 0xC0, 0x7F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xE1, 0xFF,
  0x83, 0xFE, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0xC7, 0xC6, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0xDF, 0x0E,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDE,
  0x0E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x7B, 0x8F,
  0x9F, 0xFC, 0xFF, 0x80, 0x10, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xCF, 0xFE, 0xFB, 0xEE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xF0,
  0x7F, 0x81, 0xFC, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x73, 0xDF, 0xFB, 0xFE, 0x02, 0x00, 0x10, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7B, 0x83, 0xCE,
  0x1E, 0x38, 0xF0, 0xE7, 0x83, 0xBC, 0x0F, 0xC0, 0x3F, 0x80, 0xEF, 0x03,
  0x9E, 0x0E, 0x3C, 0x38, 0x78, 0xE0, 0xF3, 0x81, 0xEE, 0x03, 0xC0, 0xFE,
  0x07, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0xFF,
  0xFB, 0xFF, 0xEE, 0x79, 0xF8, 0xC7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8,
  0xE7, 0xE3, 0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xC0, 0xFF, 0xCF, 0xFE, 0xF3, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0x01, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x39, 0xC0, 0xFF,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xDC, 0x0F, 0x78, 0x38,
  0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0xFF, 0xC7, 0xFF, 0x3C, 0x7D, 0xC0, 0xEE,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0xDF, 0x9E, 0xF0, 0x77, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x0E, 0xF0, 0x77, 0xFF, 0x9F,
  0xFC, 0x7F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x02, 0x03,
  0xFE, 0x7F, 0xE7, 0x86, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xBF, 0xFF, 0xE7, 0xFC, 0x04, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0x7F, 0xF7, 0xFF, 0x1F, 0xF0, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0xDC,
  0x0E, 0x78, 0x38, 0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0xE0, 0x73, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x70,
  0x07, 0x70, 0x06, 0x71, 0x86, 0x71, 0xC6, 0x73, 0xCE, 0x73, 0xCE, 0x73,
  0xEE, 0x37, 0xEE, 0x36, 0x6C, 0x36, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x1C,
  0x3C, 0x1C, 0x18, 0xF0, 0x3D, 0xE0, 0xE3, 0x87, 0x07, 0x3C, 0x1E, 0xE0,
  0x3F, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xCF, 0x0E, 0x1C,
  0x78, 0x79, 0xC0, 0xFE, 0x01, 0xC0, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0x9E,
  0x0E, 0x38, 0x38, 0xE1, 0xE1, 0xC7, 0x07, 0x1C, 0x1E, 0x70, 0x3B, 0x80,
  0xEE, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x02,
  0x3C, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xE0,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0xFF, 0x0F, 0xE0, 0x3E, 0x0D, 0xFC, 0x77, 0xFF, 0xF8, 0xFE, 0x40, 0xF0,
};

const GFXglyph UbuntuSansMono_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 9, 8, 16, 4, -22 },
  { 20, 15, 20, 16, 1, -20 },
  { 58, 14, 26, 16, 1, -23 },
  { 104, 16, 21, 16, 0, -21 },
  { 146, 14, 21, 16, 1, -21 },
  { 183, 4, 9, 16, 6, -22 },
  { 188, 10, 28, 16, 3, -23 },
  { 223, 10, 28, 16, 3, -23 },
  { 258, 13, 12, 16, 2, -20 },
  { 278, 14, 15, 16, 1, -16 },
  { 305, 6, 10, 16, 5, -5 },
  { 313, 8, 3, 16, 4, -10 },
  { 316, 5, 5, 16, 6, -5 },
  { 320, 12, 28, 16, 2, -23 },
  { 362, 14, 21, 16, 1, -21 },
  { 399, 13, 20, 16, 2, -20 },
  { 432, 13, 21, 16, 2, -21 },
  { 467, 12, 21, 16, 2, -21 },
  { 499, 14, 20, 16, 1, -20 },
  { 534, 12, 20, 16, 2, -20 },
  { 564, 13, 20, 16, 2, -20 },
  { 597, 13, 20, 16, 2, -20 },
  { 630, 14, 21, 16, 1, -21 },
  { 667, 13, 21, 16, 2, -21 },
  { 702, 5, 15, 16, 6, -15 },
  { 712, 7, 20, 16, 4, -15 },
  { 730, 13, 13, 16, 2, -15 },
  { 752, 14, 9, 16, 1, -13 },
  { 768, 14, 13, 16, 1, -15 },
  { 791, 11, 21, 16, 3, -21 },
  { 820, 14, 25, 16, 1, -21 },
  { 864, 16, 20, 16, 0, -20 },
  { 904, 13, 20, 16, 2, -20 },
  { 937, 14, 21, 16, 1, -21 },
  { 974, 13, 20, 16, 2, -20 },
  { 1007, 12, 20, 16, 3, -20 },
  { 1037, 11, 20, 16, 3, -20 },
  { 1065, 14, 21, 16, 1, -21 },
  { 1102, 14, 20, 16, 1, -20 },
  { 1137, 12, 20, 16, 2, -20 },
  { 1167, 12, 20, 16, 2, -20 },
  { 1197, 14, 20, 16, 2, -20 },
  { 1232, 12, 20, 16, 3, -20 },
  { 1262, 14, 20, 16, 1, -20 },
  { 1297, 13, 20, 16, 2, -20 },
  { 1330, 14, 21, 16, 1, -21 },
  { 1367, 13, 20, 16, 2, -20 },
  { 1400, 14, 26, 16, 1, -21 },
  { 1446, 13, 20, 16, 2, -20 },
  { 1479, 13, 21, 16, 2, -21 },
  { 1514, 14, 20, 16, 1, -20 },
  { 1549, 14, 20, 16, 1, -20 },
  { 1584, 16, 20, 16, 0, -20 },
  { 1624, 14, 20, 16, 1, -20 },
  { 1659, 15, 20, 16, 1, -20 },
  { 1697, 16, 20, 16, 0, -20 },
  { 1737, 13, 20, 16, 2, -20 },
  { 1770, 9, 28, 16, 4, -23 },
  { 1802, 12, 28, 16, 2, -23 },
  { 1844, 8, 28, 16, 4, -23 },
  { 1872, 14, 11, 16, 1, -20 },
  { 1892, 16, 2, 16, 0, 3 },
  { 1896, 6, 5, 16, 5, -22 },
  { 1900, 12, 16, 16, 2, -16 },
  { 1924, 13, 23, 16, 2, -23 },
  { 1962, 13, 16, 16, 2, -16 },
  { 1988, 13, 23, 16, 1, -23 },
  { 2026, 14, 16, 16, 1, -16 },
  { 2054, 14, 23, 16, 2, -23 },
  { 2095, 13, 20, 16, 1, -15 },
  { 2128, 12, 23, 16, 2, -23 },
  { 2163, 13, 22, 16, 2, -22 },
  { 2199, 11, 28, 16, 2, -22 },
  { 2238, 14, 23, 16, 2, -23 },
  { 2279, 13, 22, 16, 2, -22 },
  { 2315, 14, 15, 16, 1, -15 },
  { 2342, 12, 15, 16, 2, -15 },
  { 2365, 14, 16, 16, 1, -16 },
  { 2393, 13, 20, 16, 2, -15 },
  { 2426, 13, 20, 16, 1, -15 },
  { 2459, 12, 15, 16, 3, -15 },
  { 2482, 12, 16, 16, 2, -16 },
  { 2506, 13, 20, 16, 2, -20 },
  { 2539, 12, 15, 16, 2, -15 },
  { 2562, 14, 15, 16, 1, -15 },
  { 2589, 16, 15, 16, 0, -15 },
  { 2619, 14, 15, 16, 1, -15 },
  { 2646, 14, 20, 16, 1, -15 },
  { 2681, 12, 15, 16, 2, -15 },
  { 2704, 12, 28, 16, 2, -23 },
  { 2746, 3, 28, 16, 7, -23 },
  { 2757, 12, 28, 16, 2, -23 },
  { 2799, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_Medium29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_MEDIUM29PT7B_H_
