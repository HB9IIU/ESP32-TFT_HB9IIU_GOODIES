#ifndef _NOTOSANS_LIGHTITALIC13PT7B_H_
#define _NOTOSANS_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0xC0, 0x55, 0xA0, 0x0A, 0x12, 0x7B, 0x14, 0x24,
  0xFF, 0x24, 0x28, 0x48, 0x10, 0xF5, 0x14, 0x60, 0xC2, 0x8A, 0xB1, 0x04,
  0x00, 0x71, 0x49, 0x25, 0x13, 0x6A, 0xCA, 0xA4, 0x94, 0x92, 0x46, 0x00,
  0x3C, 0x89, 0x21, 0x85, 0x12, 0x63, 0x46, 0xF6, 0x58, 0x12, 0x24, 0x48,
  0x88, 0x84, 0x40, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x12, 0x47, 0xCC,
  0x50, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x80, 0x29, 0x40, 0xF0, 0xC0, 0x04,
  0x10, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x39, 0x18, 0x61, 0x86, 0x18, 0xA2,
  0x70, 0x3E, 0x22, 0x24, 0x44, 0x40, 0x3C, 0x04, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xFC, 0x3E, 0x04, 0x08, 0x23, 0x80, 0x81, 0x02, 0xF8, 0x06, 0x18,
  0x51, 0x22, 0x48, 0xBF, 0x84, 0x08, 0x3E, 0x40, 0x81, 0xC0, 0x40, 0x81,
  0x02, 0xF8, 0x3D, 0x04, 0x2C, 0xCA, 0x18, 0xA2, 0x70, 0x7C, 0x10, 0x84,
  0x10, 0x82, 0x10, 0x80, 0x3D, 0x14, 0x4A, 0x72, 0x28, 0xA2, 0xF0, 0x7A,
  0x18, 0x61, 0x5C, 0xA0, 0x84, 0xE0, 0x20, 0x00, 0x30, 0x10, 0x00, 0x02,
  0x44, 0x80, 0x04, 0x66, 0x30, 0x30, 0x30, 0xFC, 0x0F, 0xC0, 0x81, 0x81,
  0x83, 0x33, 0x00, 0xF0, 0x42, 0x22, 0x22, 0x00, 0x80, 0x3F, 0x10, 0x28,
  0xE6, 0x49, 0xA2, 0x69, 0x2A, 0x4A, 0x6C, 0x80, 0x1F, 0x80, 0x04, 0x0A,
  0x0A, 0x12, 0x12, 0x3E, 0x22, 0x42, 0x81, 0x7C, 0x85, 0x0A, 0x2B, 0x90,
  0xA1, 0x42, 0xF8, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x7C, 0x7C,
  0x85, 0x0A, 0x18, 0x30, 0x60, 0xC6, 0xF0, 0x7D, 0x04, 0x10, 0xBA, 0x08,
  0x20, 0xF0, 0x7D, 0x04, 0x10, 0x7A, 0x08, 0x20, 0x80, 0x3F, 0x40, 0x40,
  0x80, 0x8E, 0x82, 0x82, 0x82, 0x7C, 0x41, 0x41, 0x42, 0x42, 0xBE, 0x82,
  0x82, 0x84, 0x84, 0x39, 0x08, 0x42, 0x21, 0x08, 0xE0, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x38, 0x46, 0x91, 0x43, 0x05, 0x12, 0x24, 0x44, 0x88,
  0x44, 0x44, 0x88, 0x88, 0xF0, 0x60, 0xD8, 0x66, 0x19, 0x8A, 0xA2, 0xA5,
  0x29, 0x92, 0x64, 0x91, 0x00, 0x61, 0x61, 0x51, 0x52, 0x92, 0x8A, 0x8A,
  0x84, 0x84, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x7D,
  0x14, 0x51, 0xFA, 0x08, 0x20, 0x80, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x7C, 0x08, 0x0C, 0x7D, 0x14, 0x51, 0x7A, 0x48, 0xA2, 0x88,
  0x3E, 0x81, 0x01, 0x01, 0x80, 0x81, 0x02, 0xF8, 0xFE, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x84,
  0x78, 0x83, 0x0A, 0x12, 0x44, 0x8A, 0x14, 0x30, 0x40, 0x88, 0x66, 0x29,
  0x8A, 0xA4, 0xA5, 0x31, 0x8C, 0x62, 0x10, 0x84, 0x00, 0x31, 0x89, 0x05,
  0x01, 0x80, 0x80, 0xA0, 0x90, 0x88, 0xC2, 0x00, 0x86, 0x91, 0x22, 0x86,
  0x04, 0x08, 0x20, 0x40, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0xFC,
  0x39, 0x08, 0x84, 0x21, 0x10, 0x84, 0x38, 0x91, 0x24, 0x92, 0x20, 0x38,
  0x42, 0x21, 0x08, 0x44, 0x21, 0x38, 0x30, 0xC4, 0x92, 0x84, 0xF8, 0x90,
  0x76, 0x38, 0xA2, 0x8A, 0x6E, 0x80, 0x20, 0x40, 0x81, 0xE2, 0x28, 0x50,
  0xA1, 0x45, 0x70, 0x7C, 0x21, 0x08, 0x43, 0xC0, 0x02, 0x08, 0x13, 0xE8,
  0x50, 0xA2, 0x44, 0x99, 0xD0, 0x7C, 0x63, 0xE8, 0x43, 0xC0, 0x07, 0x08,
  0x08, 0x1C, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xE0, 0x3E,
  0x85, 0x0A, 0x24, 0x49, 0x9D, 0x02, 0x09, 0xE0, 0x20, 0x40, 0x81, 0xE2,
  0x28, 0x51, 0x22, 0x45, 0x08, 0x20, 0xA4, 0x92, 0x80, 0x08, 0x02, 0x21,
  0x08, 0x42, 0x21, 0x09, 0x80, 0x20, 0x40, 0x81, 0x34, 0x8A, 0x1C, 0x28,
  0x49, 0x10, 0x24, 0x94, 0x92, 0x50, 0x3D, 0xC8, 0x94, 0x45, 0x11, 0x44,
  0x51, 0x18, 0x84, 0x3C, 0x45, 0x0A, 0x24, 0x48, 0xA1, 0x00, 0x7A, 0x18,
  0x61, 0x8A, 0x2F, 0x00, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0xAE, 0x40, 0x81,
  0x00, 0x7E, 0x18, 0x62, 0x8A, 0x6E, 0x82, 0x10, 0x40, 0x39, 0x10, 0x84,
  0x22, 0x00, 0x3A, 0x10, 0x60, 0x87, 0xC0, 0x44, 0xF8, 0x88, 0x88, 0xC0,
  0x46, 0x18, 0x62, 0x8A, 0x6E, 0x80, 0x8C, 0x65, 0x2A, 0x61, 0x00, 0x91,
  0x99, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x44, 0xA3, 0x08, 0x31, 0x48, 0x80,
  0x22, 0x44, 0x91, 0x22, 0x86, 0x04, 0x10, 0x21, 0x80, 0x7C, 0x21, 0x08,
  0x41, 0x0F, 0x80, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8,
  0x10, 0x44, 0x21, 0x04, 0x44, 0x21, 0x30, 0xFC,
};

const GFXglyph NotoSans_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 5, 1, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 11, 7, 1, -10 },
  { 25, 9, 9, 10, 1, -9 },
  { 36, 7, 9, 9, 1, -9 },
  { 44, 2, 3, 3, 1, -9 },
  { 45, 4, 11, 3, 0, -9 },
  { 51, 4, 11, 3, -1, -9 },
  { 57, 6, 6, 7, 1, -10 },
  { 62, 6, 6, 7, 1, -8 },
  { 67, 3, 4, 3, -1, -2 },
  { 69, 4, 1, 4, 0, -4 },
  { 70, 2, 1, 3, 0, -1 },
  { 71, 6, 9, 4, -1, -9 },
  { 78, 6, 9, 7, 1, -9 },
  { 85, 4, 9, 7, 2, -9 },
  { 90, 7, 9, 7, 0, -9 },
  { 98, 7, 9, 7, 0, -9 },
  { 106, 7, 9, 7, 0, -9 },
  { 114, 7, 9, 7, 0, -9 },
  { 122, 6, 9, 7, 1, -9 },
  { 129, 6, 9, 7, 1, -9 },
  { 136, 6, 9, 7, 1, -9 },
  { 143, 6, 9, 7, 1, -9 },
  { 150, 3, 7, 3, 0, -7 },
  { 153, 4, 9, 3, -1, -7 },
  { 158, 6, 6, 7, 1, -8 },
  { 163, 6, 3, 7, 1, -6 },
  { 166, 6, 6, 7, 1, -8 },
  { 171, 5, 9, 5, 1, -9 },
  { 177, 10, 10, 11, 1, -9 },
  { 190, 8, 9, 7, -1, -9 },
  { 199, 7, 9, 8, 1, -9 },
  { 207, 7, 9, 8, 1, -9 },
  { 215, 7, 9, 9, 1, -9 },
  { 223, 6, 9, 7, 1, -9 },
  { 230, 6, 9, 6, 1, -9 },
  { 237, 8, 9, 9, 1, -9 },
  { 246, 8, 9, 9, 1, -9 },
  { 255, 5, 9, 4, 0, -9 },
  { 261, 5, 11, 3, -2, -9 },
  { 268, 7, 9, 7, 1, -9 },
  { 276, 4, 9, 6, 1, -9 },
  { 281, 10, 9, 11, 1, -9 },
  { 293, 8, 9, 9, 1, -9 },
  { 302, 8, 9, 9, 1, -9 },
  { 311, 6, 9, 7, 1, -9 },
  { 318, 8, 11, 9, 1, -9 },
  { 329, 6, 9, 7, 1, -9 },
  { 336, 7, 9, 7, 0, -9 },
  { 344, 7, 9, 6, 1, -9 },
  { 352, 8, 9, 9, 1, -9 },
  { 361, 7, 9, 7, 1, -9 },
  { 369, 10, 9, 11, 2, -9 },
  { 381, 9, 9, 7, -1, -9 },
  { 392, 7, 9, 6, 1, -9 },
  { 400, 7, 9, 7, 0, -9 },
  { 408, 5, 11, 4, 0, -9 },
  { 415, 3, 9, 4, 1, -9 },
  { 419, 5, 11, 4, -1, -9 },
  { 426, 6, 5, 7, 1, -9 },
  { 430, 5, 1, 5, -1, 1 },
  { 431, 2, 2, 3, 2, -10 },
  { 432, 6, 7, 7, 1, -7 },
  { 438, 7, 10, 7, 0, -10 },
  { 447, 5, 7, 6, 1, -7 },
  { 452, 7, 10, 7, 1, -10 },
  { 461, 5, 7, 6, 1, -7 },
  { 466, 8, 13, 4, -2, -10 },
  { 479, 7, 10, 7, 0, -7 },
  { 488, 7, 10, 7, 0, -10 },
  { 497, 3, 9, 3, 0, -9 },
  { 501, 5, 12, 3, -2, -9 },
  { 509, 7, 10, 6, 0, -10 },
  { 518, 3, 10, 3, 0, -10 },
  { 522, 10, 7, 11, 0, -7 },
  { 531, 7, 7, 7, 0, -7 },
  { 538, 6, 7, 7, 1, -7 },
  { 544, 7, 10, 7, 0, -7 },
  { 553, 6, 10, 7, 1, -7 },
  { 561, 5, 7, 5, 0, -7 },
  { 566, 5, 7, 6, 0, -7 },
  { 571, 4, 9, 4, 1, -9 },
  { 576, 6, 7, 7, 1, -7 },
  { 582, 5, 7, 6, 1, -7 },
  { 587, 8, 7, 9, 1, -7 },
  { 594, 6, 7, 6, 0, -7 },
  { 600, 7, 10, 6, -1, -7 },
  { 609, 6, 7, 6, 0, -7 },
  { 615, 5, 11, 4, 0, -9 },
  { 622, 1, 13, 7, 3, -10 },
  { 624, 5, 11, 4, -1, -9 },
  { 631, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_LIGHTITALIC13PT7B_H_
