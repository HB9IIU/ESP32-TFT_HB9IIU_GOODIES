#ifndef _NOTOSANS_LIGHTITALIC61PT7B_H_
#define _NOTOSANS_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x06, 0x00, 0x00, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38,
  0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xF8, 0x61, 0xF0, 0x0F, 0x07, 0x01, 0x80,
  0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x3E, 0x38, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xDF,
  0x80, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80,
  0xF0, 0x00, 0x0C, 0x0F, 0x03, 0x00, 0xE0, 0xF8, 0x1F, 0x87, 0x3F, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x07,
  0xFF, 0x80, 0x00, 0x70, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x03, 0xC0,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x07, 0x07, 0x07, 0xF8,
  0xE0, 0x07, 0x0F, 0x1F, 0xFC, 0xE0, 0x0E, 0x0E, 0x3E, 0x1E, 0xE0, 0x0E,
  0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x70, 0x0E, 0x78, 0x38, 0x78, 0xF0,
  0x0F, 0x7F, 0xF8, 0x70, 0xE0, 0x07, 0x3F, 0xF0, 0xE0, 0xE0, 0x07, 0x0F,
  0xC1, 0xC1, 0xC0, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x0F, 0x00, 0x03, 0x81,
  0xC0, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E,
  0x00, 0x1E, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x03, 0x80, 0x78, 0x07, 0x80, 0x03, 0x80, 0x70, 0x07, 0x00, 0x03,
  0xC0, 0xE0, 0x0E, 0x00, 0x01, 0xE3, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xC0,
  0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x00, 0x7E, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x7C, 0x03, 0xC0, 0x03, 0x87, 0x80,
  0x0F, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0x1E,
  0x3C, 0x00, 0x07, 0x80, 0xE1, 0xE0, 0x00, 0x1E, 0x0E, 0x0E, 0x00, 0x00,
  0xF0, 0xF0, 0x70, 0x00, 0x03, 0xCF, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x3C,
  0x00, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0x80,
  0x01, 0xF3, 0xC0, 0x3E, 0x00, 0x3F, 0x0F, 0x00, 0xFF, 0x1F, 0xE0, 0x78,
  0x03, 0xFF, 0xFC, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0xF3, 0xCE, 0x39, 0xE7, 0x9C, 0x71, 0xC7, 0x38,
  0xE3, 0x8C, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x70,
  0x01, 0xE0, 0x18, 0x00, 0xFC, 0x06, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0xFC,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x1C, 0x00, 0x20, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x3C,
  0x3F, 0x1C, 0x7E, 0x0E, 0x7E, 0x0F, 0x1C, 0x07, 0x84, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x1C,
  0x00, 0x07, 0x80, 0x10, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x60, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xBF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x0F, 0xFF, 0x00, 0x71, 0xFF,
  0xFC, 0x03, 0x9E, 0x01, 0xF0, 0x3D, 0xC0, 0x07, 0xC1, 0xDC, 0x00, 0x1E,
  0x0F, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0E, 0x3E,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F,
  0x07, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x3F, 0xC0, 0xF0, 0x03, 0xDC, 0x07,
  0xF1, 0xFC, 0xE0, 0x1F, 0xFF, 0x8F, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x08,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x1F, 0x83, 0xE0, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x10, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x3F,
  0xF0, 0x01, 0xC1, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0x83, 0x80, 0x07, 0xF3,
  0xF8, 0x07, 0x0E, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xF0, 0x01,
  0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x39, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x77, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xEE, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x9C, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x38, 0x07, 0x80, 0x03, 0x80, 0x0E, 0xF0, 0x0E, 0x00, 0x07, 0x00,
  0x1D, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0x7B, 0xC0, 0x38, 0x00, 0x38, 0x00,
  0xE7, 0x00, 0x70, 0x00, 0x70, 0x01, 0xCE, 0x00, 0xE0, 0x01, 0xE0, 0x07,
  0x1E, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x3C, 0x03, 0x80, 0x0F, 0x80, 0x38,
  0x78, 0x07, 0x80, 0x3F, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0xE7, 0x03, 0xC0,
  0xE0, 0x0F, 0x87, 0x8F, 0x1F, 0x01, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x00, 0xF8,
  0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x81,
  0xC0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x3E, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x03, 0xFC,
  0x00, 0x70, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xE0,
  0x07, 0xC0, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x01, 0xFF,
  0xF8, 0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x40, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0x07,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x1F, 0x00, 0x00,
  0x03, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x07, 0x3F, 0x80, 0x00, 0x00, 0x77,
  0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x00,
  0x0F, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0xF7, 0x00, 0x00, 0x01, 0xDE, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xBC,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x07, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x0E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x00, 0x01, 0xC7, 0x80,
  0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x00, 0x3C, 0x38, 0x03, 0x87, 0x00, 0x00, 0x70, 0xF0, 0x0F,
  0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x78, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x70, 0x03, 0xC0, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x00, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x1C,
  0x00, 0x78, 0x07, 0x80, 0x0E, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x38, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0x00, 0x01, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x00, 0x0F,
  0x00, 0xF7, 0x00, 0x00, 0x1E, 0x01, 0xCF, 0x00, 0x00, 0x38, 0x03, 0x8E,
  0x00, 0x00, 0x70, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x3C, 0x00, 0x03,
  0xC0, 0x3C, 0x38, 0x00, 0x07, 0x80, 0x78, 0x78, 0x00, 0x0E, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x70, 0x00, 0x07, 0x8E, 0x00,
  0xE0, 0x00, 0x07, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0xF0, 0x0F, 0x00, 0x00, 0x1D, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0x80,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x1F, 0x00, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x20, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x77, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x01, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x70,
  0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0xF0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00,
  0x78, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x07, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x03, 0x87, 0x80,
  0x01, 0xE3, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xC1, 0xC0, 0x3F, 0xFF, 0x0E, 0x03, 0xF0, 0x3C, 0x70,
  0x3E, 0x00, 0x73, 0x83, 0xE0, 0x01, 0xB8, 0x1E, 0x00, 0x0F, 0xC1, 0xE0,
  0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF8, 0x3C, 0x00, 0x1D, 0xC0, 0xF0,
  0x00, 0xCE, 0x07, 0x80, 0x1E, 0xE0, 0x1E, 0x01, 0xE7, 0x00, 0xFE, 0x7C,
  0x38, 0x03, 0xFF, 0xC1, 0xC0, 0x07, 0xFC, 0x0E, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0xF1, 0xFF,
  0xF8, 0x03, 0x8F, 0x83, 0xF0, 0x0E, 0x78, 0x03, 0xC0, 0x3B, 0x80, 0x07,
  0x81, 0xFC, 0x00, 0x1E, 0x07, 0x60, 0x00, 0x38, 0x1F, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x3C, 0x1F, 0x80, 0x01, 0xF0, 0x76, 0x00, 0x07, 0x81, 0xDC,
  0x00, 0x7C, 0x07, 0x38, 0x03, 0xE0, 0x38, 0xFC, 0xFF, 0x00, 0xE1, 0xFF,
  0xF8, 0x03, 0x81, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0x80, 0x3F, 0x8F, 0xC0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0xFF, 0xF0, 0xF0, 0x01,
  0xFF, 0xFC, 0x78, 0x01, 0xF8, 0x0F, 0x38, 0x01, 0xF0, 0x03, 0x9C, 0x01,
  0xF0, 0x00, 0xEE, 0x00, 0xF0, 0x00, 0x37, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x77, 0x00, 0x3C, 0x00,
  0x73, 0x80, 0x0F, 0x00, 0xF1, 0xC0, 0x07, 0xF3, 0xF0, 0xE0, 0x01, 0xFF,
  0xF0, 0xE0, 0x00, 0x7F, 0xE0, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xE0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE7, 0x80, 0x01,
  0xE3, 0x80, 0x01, 0xF3, 0xC0, 0x03, 0xF1, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x80, 0xF8, 0x01, 0xC0, 0x3F, 0x8F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x33, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x1C, 0x01, 0xFF,
  0xFC, 0x38, 0x07, 0xE0, 0x3C, 0xE0, 0x1F, 0x00, 0x39, 0xC0, 0x7C, 0x00,
  0x3B, 0x80, 0xF0, 0x00, 0x37, 0x03, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7E, 0x01, 0xE0,
  0x01, 0xDC, 0x03, 0xC0, 0x07, 0x38, 0x03, 0xC0, 0x3C, 0xF0, 0x07, 0xF3,
  0xF1, 0xE0, 0x07, 0xFF, 0xC3, 0x80, 0x03, 0xFE, 0x07, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x03, 0xE0,
  0x07, 0x00, 0x1F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0x0F,
  0x07, 0xFF, 0x00, 0x78, 0xFF, 0xFC, 0x03, 0x8F, 0x81, 0xF0, 0x1C, 0xF0,
  0x07, 0x80, 0xEE, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0xF0, 0x76, 0x00, 0x07,
  0x83, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x63, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x04,
  0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x1C,
  0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0x77, 0xBC,
  0x00, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x40, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0E,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1C, 0x78, 0x1E, 0x0F, 0x03, 0xE0, 0x39,
  0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x77, 0x00, 0x3C, 0xE0, 0x03, 0xC1, 0xFC,
  0x00, 0x3B, 0x80, 0x07, 0x83, 0xB0, 0x00, 0x76, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0x7F, 0x80, 0x1E, 0x0F, 0xFE, 0x00, 0xE1, 0xFF, 0xF8,
  0x07, 0x1F, 0x03, 0xE0, 0x39, 0xE0, 0x0F, 0x81, 0xDE, 0x00, 0x3C, 0x1F,
  0xC0, 0x01, 0xE0, 0xFC, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x78, 0x3E, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x0F, 0xE0, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x1C, 0x3F, 0xFF,
  0x00, 0x0E, 0x3E, 0x0F, 0xC0, 0x07, 0x3C, 0x01, 0xE0, 0x03, 0xB8, 0x00,
  0x78, 0x03, 0xF8, 0x00, 0x3C, 0x01, 0xD8, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x03,
  0xF0, 0x00, 0x3E, 0x01, 0xD8, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0x3E, 0x00,
  0x73, 0x80, 0x3E, 0x00, 0x79, 0xF9, 0xFE, 0x00, 0x3C, 0x7F, 0xFE, 0x00,
  0x1C, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x70, 0x0F, 0xFF,
  0xE1, 0xC0, 0x7E, 0x03, 0xCE, 0x03, 0xE0, 0x07, 0x38, 0x1F, 0x00, 0x0E,
  0xE0, 0x78, 0x00, 0x1B, 0x83, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x1D, 0xC0, 0x78,
  0x00, 0xE7, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xF9, 0xF8, 0xF0, 0x07, 0xFF,
  0xC3, 0x80, 0x07, 0xFC, 0x0E, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x40, 0x7E, 0x03, 0x07, 0xFC, 0x0E, 0x1F, 0xF8, 0x1C, 0x7C, 0x10, 0x39,
  0xE0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x1E, 0x07, 0x80,
  0x02, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x80, 0x01,
  0xF0, 0xE0, 0x03, 0xE0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x9C, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0xDC, 0x0F, 0x00, 0x06, 0x70, 0x1E, 0x00, 0x7B, 0xC0, 0x7C, 0x03,
  0xCE, 0x00, 0xFE, 0xFE, 0x38, 0x03, 0xFF, 0xE0, 0xE0, 0x03, 0xFF, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xB8, 0x00,
  0x1E, 0x00, 0x07, 0x9C, 0x00, 0x1F, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0xC0,
  0x03, 0xC7, 0x00, 0x0E, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0x70, 0x03,
  0xCE, 0x00, 0x78, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x1C, 0x01, 0xE3, 0x80,
  0x3C, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x07, 0x00, 0xF0, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x70, 0x0E, 0x01, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xF0, 0x38,
  0x0E, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x07, 0x80, 0x3C, 0x1C, 0x03, 0x83,
  0xC0, 0x1E, 0x1E, 0x01, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0x80,
  0x1C, 0x70, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x07,
  0xE0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x08,
  0xFF, 0xE0, 0x00, 0x5F, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00,
  0x7F, 0xFF, 0x60, 0x00, 0x7F, 0xE2, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 45, 14, 2, -44 },
  { 75, 16, 16, 21, 7, -44 },
  { 107, 37, 44, 38, 2, -44 },
  { 311, 29, 50, 34, 3, -46 },
  { 493, 40, 45, 48, 5, -44 },
  { 718, 37, 45, 41, 2, -44 },
  { 927, 6, 16, 12, 7, -44 },
  { 939, 19, 54, 16, 2, -44 },
  { 1068, 18, 54, 16, -4, -44 },
  { 1190, 26, 27, 33, 7, -46 },
  { 1278, 29, 29, 35, 4, -36 },
  { 1384, 10, 15, 13, -3, -7 },
  { 1403, 15, 3, 19, 2, -18 },
  { 1409, 5, 6, 14, 2, -5 },
  { 1413, 28, 44, 20, -3, -44 },
  { 1567, 28, 45, 34, 4, -44 },
  { 1725, 17, 44, 34, 9, -44 },
  { 1819, 32, 44, 34, 0, -44 },
  { 1995, 31, 45, 34, 1, -44 },
  { 2170, 32, 44, 34, 1, -44 },
  { 2346, 31, 45, 34, 2, -44 },
  { 2521, 29, 45, 34, 4, -44 },
  { 2685, 28, 44, 34, 6, -44 },
  { 2839, 30, 45, 34, 3, -44 },
  { 3008, 29, 45, 34, 3, -44 },
  { 3172, 11, 34, 14, 2, -33 },
  { 3219, 16, 41, 14, -3, -33 },
  { 3301, 29, 28, 35, 4, -36 },
  { 3403, 28, 15, 35, 5, -29 },
  { 3456, 29, 28, 35, 4, -36 },
  { 3558, 22, 45, 25, 5, -44 },
  { 3682, 47, 48, 51, 3, -43 },
  { 3964, 34, 44, 34, -3, -44 },
  { 4151, 33, 44, 37, 3, -44 },
  { 4333, 34, 45, 36, 5, -44 },
  { 4525, 36, 44, 41, 3, -44 },
  { 4723, 31, 44, 32, 3, -44 },
  { 4894, 31, 44, 29, 3, -44 },
  { 5065, 36, 45, 42, 5, -44 },
  { 5268, 38, 44, 42, 3, -44 },
  { 5477, 21, 44, 18, 0, -44 },
  { 5593, 26, 55, 15, -10, -44 },
  { 5772, 36, 44, 34, 3, -44 },
  { 5970, 22, 44, 30, 3, -44 },
  { 6091, 47, 44, 50, 3, -44 },
  { 6350, 39, 44, 42, 3, -44 },
  { 6565, 37, 45, 44, 5, -44 },
  { 6774, 31, 44, 34, 3, -44 },
  { 6945, 37, 54, 44, 5, -44 },
  { 7195, 31, 44, 35, 3, -44 },
  { 7366, 30, 45, 31, 1, -44 },
  { 7535, 30, 44, 30, 6, -44 },
  { 7700, 37, 45, 42, 5, -44 },
  { 7909, 32, 44, 33, 6, -44 },
  { 8085, 49, 44, 51, 7, -44 },
  { 8355, 39, 44, 31, -3, -44 },
  { 8570, 30, 44, 30, 6, -44 },
  { 8735, 36, 44, 33, -1, -44 },
  { 8933, 24, 54, 18, -1, -44 },
  { 9095, 11, 44, 20, 6, -44 },
  { 9156, 23, 54, 18, -4, -44 },
  { 9312, 29, 27, 34, 3, -44 },
  { 9410, 24, 3, 23, -5, 6 },
  { 9419, 8, 10, 15, 9, -47 },
  { 9429, 29, 34, 34, 3, -33 },
  { 9553, 30, 47, 35, 2, -46 },
  { 9730, 25, 34, 28, 3, -33 },
  { 9837, 33, 47, 35, 3, -46 },
  { 10031, 25, 34, 30, 3, -33 },
  { 10138, 33, 62, 18, -7, -47 },
  { 10394, 31, 48, 35, 2, -33 },
  { 10580, 29, 46, 35, 2, -46 },
  { 10747, 13, 44, 14, 2, -44 },
  { 10819, 23, 59, 14, -8, -44 },
  { 10989, 29, 46, 28, 2, -46 },
  { 11156, 13, 46, 14, 2, -46 },
  { 11231, 47, 33, 52, 2, -33 },
  { 11425, 29, 33, 35, 2, -33 },
  { 11545, 28, 34, 34, 3, -33 },
  { 11664, 33, 47, 35, -1, -33 },
  { 11858, 30, 47, 35, 3, -33 },
  { 12035, 23, 33, 23, 2, -33 },
  { 12130, 24, 34, 26, 1, -33 },
  { 12232, 18, 41, 20, 3, -40 },
  { 12325, 30, 33, 35, 3, -32 },
  { 12449, 27, 32, 27, 3, -32 },
  { 12557, 41, 32, 42, 3, -32 },
  { 12721, 32, 32, 29, -2, -32 },
  { 12849, 36, 47, 27, -6, -32 },
  { 13061, 28, 32, 27, -1, -32 },
  { 13173, 23, 54, 21, 1, -44 },
  { 13329, 3, 61, 33, 17, -46 },
  { 13352, 23, 54, 21, -3, -44 },
  { 13508, 29, 7, 35, 4, -25 },
};

const GFXfont NotoSans_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_LIGHTITALIC61PT7B_H_
