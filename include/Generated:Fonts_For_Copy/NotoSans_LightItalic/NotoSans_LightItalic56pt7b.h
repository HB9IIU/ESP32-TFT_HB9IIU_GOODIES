#ifndef _NOTOSANS_LIGHTITALIC56PT7B_H_
#define _NOTOSANS_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x20, 0x00, 0x3C, 0x1E, 0x78, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x61, 0x81, 0xC3, 0x03, 0x8E, 0x06, 0x1C, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xC7, 0x1F, 0x01, 0xE0, 0xC0, 0x40, 0x78, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78,
  0x60, 0x00, 0x0F, 0x8C, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E,
  0x7C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x07, 0x80,
  0x00, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x03, 0xC2, 0x00, 0xE0, 0xF0, 0x70,
  0x1C, 0x7C, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x07, 0xFE, 0x00, 0x03, 0x80, 0xF0,
  0xE0, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x06, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x0E, 0x0E,
  0x00, 0x0C, 0x00, 0xC1, 0xC3, 0xF8, 0xC0, 0x1C, 0x38, 0x7F, 0xEE, 0x01,
  0xC7, 0x0F, 0x1E, 0xE0, 0x38, 0x71, 0xC0, 0xFE, 0x07, 0x0E, 0x38, 0x07,
  0x70, 0xF1, 0xC3, 0x80, 0x77, 0xFE, 0x3C, 0x70, 0x07, 0x3F, 0x83, 0x87,
  0x00, 0x70, 0x40, 0x70, 0x70, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0xE0, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x38,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70,
  0x1C, 0x00, 0x0F, 0x0F, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7C, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x1C, 0x3C, 0x07, 0x80, 0x0E,
  0x1E, 0x00, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x01, 0xC3, 0x80, 0x07, 0x80,
  0x71, 0xC0, 0x00, 0xF0, 0x38, 0x70, 0x00, 0x1C, 0x1E, 0x3C, 0x00, 0x07,
  0x87, 0x0F, 0x00, 0x00, 0xF3, 0x83, 0x80, 0x00, 0x1D, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x3F, 0x80, 0x78, 0x00, 0x1E, 0xF0, 0x0F, 0x00, 0x1F, 0x1E, 0x03,
  0xF8, 0x3F, 0x03, 0xC0, 0x7F, 0xFF, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x1E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71,
  0xC6, 0x18, 0xE3, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xFC,
  0x0C, 0x00, 0x1F, 0x86, 0x00, 0x03, 0xF3, 0x00, 0x00, 0x3D, 0x07, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0x60,
  0x03, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x20, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xE0,
  0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x80, 0x3B, 0xDF, 0xF7, 0x90, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00,
  0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xE3, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7D, 0xC3, 0xF7, 0x8F, 0x8E,
  0x7E, 0x1C, 0xF0, 0x38, 0xC0, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0xFC, 0x01, 0xF0, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC0, 0xFE, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x20, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x08, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF0,
  0x60, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x1F, 0x80, 0x07, 0x0F, 0xFE, 0x01,
  0xE7, 0xFF, 0xE0, 0x39, 0xE0, 0x3E, 0x07, 0x70, 0x03, 0xE0, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xF8, 0x3C,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0,
  0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x0E, 0xE0, 0xF8, 0x0F, 0x38, 0x1F, 0xFF, 0x9E, 0x03,
  0xFF, 0xC7, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x0F, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xF0, 0x08, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x0F, 0xC1, 0x80, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xFF, 0xE0, 0x1C, 0x38,
  0x00, 0xFF, 0xFE, 0x01, 0x87, 0x00, 0x3C, 0x03, 0x80, 0x39, 0xC0, 0x0F,
  0x00, 0x70, 0x07, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xEE, 0x00, 0xE0, 0x01,
  0xC0, 0x1D, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xB8, 0x07, 0x00, 0x0E, 0x00,
  0x77, 0x00, 0xE0, 0x01, 0xC0, 0x0D, 0xC0, 0x38, 0x00, 0x30, 0x03, 0xB8,
  0x07, 0x00, 0x0E, 0x00, 0x77, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0xE0, 0x1C,
  0x00, 0x38, 0x01, 0x9C, 0x03, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x60, 0x01,
  0xC0, 0x0E, 0x70, 0x0E, 0x00, 0x78, 0x03, 0x8E, 0x01, 0xC0, 0x1F, 0x00,
  0xF1, 0xC0, 0x38, 0x03, 0x60, 0x1C, 0x38, 0x07, 0x81, 0xCE, 0x0F, 0x03,
  0x80, 0x7D, 0xF1, 0xFF, 0xC0, 0x70, 0x07, 0xFC, 0x1F, 0xF0, 0x0E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0xF8, 0x07, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0E, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xC7, 0xF0,
  0x03, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x15, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x0E, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x1C,
  0x00, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xF0, 0x00,
  0x70, 0x03, 0xE0, 0x00, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF1, 0xC0,
  0x00, 0xFF, 0xF9, 0xE0, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x03,
  0x9F, 0x80, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x00,
  0xFC, 0x38, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x03, 0xB0, 0x00, 0x00, 0x3B, 0x80, 0x77, 0x00, 0x00, 0x0F, 0x70,
  0x1C, 0xE0, 0x00, 0x01, 0xDE, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x73,
  0x80, 0x00, 0x0E, 0x70, 0x0E, 0x70, 0x00, 0x03, 0x8E, 0x01, 0xCE, 0x00,
  0x00, 0xF3, 0xC0, 0x70, 0xC0, 0x00, 0x1C, 0x70, 0x0E, 0x1C, 0x00, 0x07,
  0x8E, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x00, 0x38, 0x38,
  0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x38,
  0x38, 0x00, 0x78, 0x38, 0x07, 0x03, 0x00, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x00, 0x70, 0x3C, 0x07, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x3C, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x00, 0xF0, 0x1C,
  0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x70,
  0x03, 0x80, 0x70, 0x01, 0x9E, 0x00, 0x70, 0x0E, 0x00, 0x3B, 0x80, 0x0E,
  0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x0E,
  0x00, 0x1F, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x78, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x1F,
  0x80, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x1E,
  0x01, 0xDC, 0x00, 0x01, 0xC0, 0x39, 0xC0, 0x00, 0x1C, 0x03, 0x9E, 0x00,
  0x01, 0xC0, 0x38, 0xE0, 0x00, 0x1C, 0x03, 0x8E, 0x00, 0x03, 0x80, 0x38,
  0x70, 0x00, 0x38, 0x07, 0x07, 0x00, 0x03, 0x80, 0x70, 0x78, 0x00, 0x38,
  0x07, 0x03, 0x80, 0x07, 0x80, 0x70, 0x38, 0x00, 0x70, 0x0F, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x38,
  0x1E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x3C, 0x00, 0x1C, 0x1C, 0x03, 0x80,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0x1E, 0x1C, 0x03, 0x80, 0x00, 0xE3, 0x80,
  0x38, 0x00, 0x0E, 0x38, 0x07, 0x00, 0x00, 0x73, 0x80, 0x70, 0x00, 0x07,
  0x38, 0x07, 0x00, 0x00, 0x7B, 0x80, 0x70, 0x00, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1C,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x1F, 0x00, 0xE0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x1E, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x7C, 0x0E, 0x00, 0x1F, 0x80,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x78, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x38, 0x00,
  0x0F, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x73, 0x80, 0x03, 0xC3, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x01, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x80,
  0x70, 0x07, 0x81, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70,
  0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x78, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00, 0x01,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xE0,
  0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0x3F, 0xC0,
  0xE0, 0x1F, 0xFE, 0x18, 0x07, 0xF3, 0xE3, 0x01, 0xF0, 0x1C, 0xE0, 0x78,
  0x01, 0xDC, 0x1E, 0x00, 0x1B, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x78, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x1F, 0x07, 0x00, 0x07, 0xE0, 0xF0, 0x01, 0xDC, 0x0E, 0x00, 0x73,
  0x01, 0xE0, 0x1C, 0xE0, 0x1F, 0x0F, 0x1C, 0x01, 0xFF, 0xC3, 0x80, 0x1F,
  0xE0, 0x70, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x03, 0xFC, 0x00, 0xE1, 0xFF, 0xC0, 0x1C, 0xFC, 0xFC,
  0x07, 0x3C, 0x07, 0xC0, 0xEE, 0x00, 0x78, 0x1D, 0x80, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x0E, 0x1F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38,
  0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0x87, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x1B, 0x80, 0x0F, 0x07, 0x38, 0x03, 0xC0, 0xE3, 0xC3, 0xF0,
  0x1C, 0x7F, 0xFC, 0x03, 0x03, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xF9, 0xF0, 0x1F, 0x00, 0x20, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0x00, 0xFC, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x83, 0x80, 0x0F, 0xFF,
  0x0E, 0x00, 0x7F, 0x3E, 0x38, 0x03, 0xE0, 0x1D, 0xE0, 0x1E, 0x00, 0x37,
  0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78,
  0x0E, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x7C, 0x03,
  0xC0, 0x03, 0x70, 0x07, 0x00, 0x19, 0xC0, 0x1E, 0x01, 0xE7, 0x00, 0x3E,
  0x1F, 0x1C, 0x00, 0x7F, 0xF0, 0x60, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xF3, 0xF0, 0x1F,
  0x01, 0xE0, 0x78, 0x01, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xC7, 0x00, 0x3F, 0x0E, 0x0F, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0x80, 0xFC, 0x1F, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x20,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x19, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x18, 0x01, 0xFF, 0xE1, 0xC0, 0x1F, 0xCF, 0x8E, 0x01, 0xF0, 0x0E, 0x70,
  0x1E, 0x00, 0x33, 0x01, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x7E, 0x07, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x37, 0x00, 0xE0, 0x03, 0x38, 0x07, 0x80, 0x79, 0xC0, 0x1F,
  0x0F, 0x1C, 0x00, 0x7F, 0xF0, 0xE0, 0x01, 0xFF, 0x07, 0x00, 0x00, 0x80,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x02, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x7C, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x7F, 0x80, 0x38, 0x7F, 0xF0, 0x0E, 0x3E,
  0x7E, 0x07, 0x3C, 0x03, 0xC1, 0xCC, 0x00, 0x70, 0x76, 0x00, 0x1C, 0x1F,
  0x00, 0x07, 0x0F, 0xC0, 0x01, 0xC3, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x1E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x31, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x78, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x77, 0xE0, 0x00, 0x1F, 0xDC, 0x00, 0x07, 0xE7,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0x61, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0C, 0x7C, 0xFC, 0x1F, 0x3F, 0x03, 0x9C, 0x07, 0x87, 0x01, 0xE0, 0x77,
  0x00, 0x71, 0xC0, 0x1E, 0x0E, 0xC0, 0x07, 0x70, 0x03, 0xC1, 0xF0, 0x00,
  0xFC, 0x00, 0x38, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xE1, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC3, 0x80, 0x01, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x70,
  0xFF, 0xF0, 0x1C, 0x7F, 0xFE, 0x03, 0x9E, 0x01, 0xE0, 0x77, 0x80, 0x1C,
  0x0E, 0xC0, 0x03, 0x81, 0xF0, 0x00, 0x78, 0x7E, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x78, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0x80, 0x7C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x70, 0x3F, 0xC0, 0x01, 0x83,
  0xFF, 0x80, 0x06, 0x1F, 0x3F, 0x00, 0x39, 0xE0, 0x3E, 0x00, 0xE6, 0x00,
  0x78, 0x03, 0xB0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x7E, 0x00, 0x07,
  0x01, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x78,
  0x0F, 0x80, 0x03, 0xC0, 0x3F, 0x00, 0x1E, 0x01, 0xEE, 0x00, 0xF0, 0x07,
  0x1E, 0x1F, 0x80, 0x1C, 0x3F, 0xFC, 0x00, 0x70, 0x7F, 0xC0, 0x01, 0xC0,
  0x18, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x60, 0x1F, 0xFE, 0x1C, 0x07, 0xF3, 0xE3, 0x81, 0xF0,
  0x0E, 0x70, 0x78, 0x00, 0xCC, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x7C, 0x38, 0x00, 0x1F, 0x87, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xDC,
  0x0E, 0x00, 0x3B, 0x81, 0xE0, 0x1E, 0x70, 0x1F, 0x0F, 0x9E, 0x01, 0xFF,
  0xC3, 0x80, 0x1F, 0xF0, 0x70, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x83, 0xF8, 0x18, 0x3F, 0xC0, 0xC7, 0xFE, 0x0E, 0x78,
  0x00, 0x77, 0x00, 0x03, 0xB0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x3E, 0x00, 0x60, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE1, 0x00, 0x03, 0xC3,
  0x80, 0x0F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x60, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x1F,
  0x07, 0x00, 0x07, 0xE0, 0xF0, 0x01, 0xDC, 0x1E, 0x00, 0x73, 0x01, 0xE0,
  0x1C, 0xE0, 0x3E, 0x1F, 0x1C, 0x03, 0xFF, 0xC3, 0x80, 0x3F, 0xE0, 0x70,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x38, 0x07, 0x80, 0x38, 0x07,
  0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0,
  0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1D,
  0xC0, 0x03, 0xF0, 0x01, 0xEE, 0x00, 0x1F, 0x80, 0x0E, 0x78, 0x01, 0xDC,
  0x00, 0x73, 0xC0, 0x0E, 0xE0, 0x07, 0x0E, 0x00, 0xE7, 0x00, 0x38, 0x70,
  0x07, 0x38, 0x03, 0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x1C, 0x03, 0x8E, 0x01,
  0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x07, 0x01, 0xC3, 0x80, 0xF0, 0x38, 0x1C,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x60, 0x78, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0xEE, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x4F,
  0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x9F, 0xC0, 0x07, 0xFF,
  0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 41, 13, 1, -40 },
  { 68, 15, 14, 20, 6, -40 },
  { 95, 34, 40, 35, 2, -40 },
  { 265, 27, 45, 31, 2, -42 },
  { 417, 36, 42, 44, 5, -41 },
  { 606, 34, 42, 38, 2, -41 },
  { 785, 6, 14, 11, 6, -40 },
  { 796, 17, 49, 15, 2, -40 },
  { 901, 17, 49, 15, -4, -40 },
  { 1006, 25, 25, 30, 6, -43 },
  { 1085, 26, 26, 32, 4, -33 },
  { 1170, 9, 14, 12, -2, -7 },
  { 1186, 14, 3, 18, 2, -17 },
  { 1192, 5, 6, 13, 1, -5 },
  { 1196, 25, 40, 19, -2, -40 },
  { 1321, 27, 42, 31, 3, -41 },
  { 1463, 15, 40, 31, 9, -40 },
  { 1538, 29, 41, 31, 0, -41 },
  { 1687, 28, 42, 31, 1, -41 },
  { 1834, 29, 40, 31, 1, -40 },
  { 1979, 28, 41, 31, 2, -40 },
  { 2123, 27, 42, 31, 4, -41 },
  { 2265, 26, 40, 31, 5, -40 },
  { 2395, 27, 42, 31, 3, -41 },
  { 2537, 26, 42, 31, 3, -41 },
  { 2674, 11, 31, 13, 1, -30 },
  { 2717, 14, 37, 13, -3, -30 },
  { 2782, 26, 26, 32, 4, -33 },
  { 2867, 26, 14, 32, 4, -27 },
  { 2913, 26, 26, 32, 4, -33 },
  { 2998, 21, 42, 23, 4, -41 },
  { 3109, 43, 45, 47, 3, -40 },
  { 3351, 31, 40, 31, -3, -40 },
  { 3506, 30, 40, 34, 3, -40 },
  { 3656, 31, 42, 33, 4, -41 },
  { 3819, 33, 40, 38, 3, -40 },
  { 3984, 28, 40, 29, 3, -40 },
  { 4124, 28, 40, 27, 3, -40 },
  { 4264, 33, 42, 38, 4, -41 },
  { 4438, 35, 40, 38, 3, -40 },
  { 4613, 20, 40, 17, 0, -40 },
  { 4713, 23, 50, 14, -9, -40 },
  { 4857, 33, 40, 31, 3, -40 },
  { 5022, 20, 40, 27, 3, -40 },
  { 5122, 43, 40, 46, 3, -40 },
  { 5337, 36, 40, 39, 3, -40 },
  { 5517, 34, 42, 40, 4, -41 },
  { 5696, 29, 40, 32, 3, -40 },
  { 5841, 34, 51, 40, 4, -41 },
  { 6058, 29, 40, 32, 3, -40 },
  { 6203, 28, 42, 28, 1, -41 },
  { 6350, 28, 40, 28, 5, -40 },
  { 6490, 34, 41, 38, 5, -40 },
  { 6665, 29, 40, 30, 6, -40 },
  { 6810, 45, 40, 47, 6, -40 },
  { 7035, 36, 40, 28, -3, -40 },
  { 7215, 28, 40, 28, 5, -40 },
  { 7355, 33, 40, 30, -1, -40 },
  { 7520, 22, 49, 17, -1, -40 },
  { 7655, 9, 40, 19, 6, -40 },
  { 7700, 21, 49, 17, -4, -40 },
  { 7829, 27, 25, 31, 2, -40 },
  { 7914, 22, 2, 21, -5, 6 },
  { 7920, 8, 9, 14, 8, -43 },
  { 7929, 27, 31, 31, 3, -30 },
  { 8034, 27, 44, 32, 2, -43 },
  { 8183, 23, 31, 25, 3, -30 },
  { 8273, 30, 44, 32, 3, -43 },
  { 8438, 23, 31, 28, 3, -30 },
  { 8528, 31, 56, 16, -7, -43 },
  { 8745, 29, 43, 32, 1, -30 },
  { 8901, 26, 43, 32, 2, -43 },
  { 9041, 12, 41, 13, 2, -41 },
  { 9103, 22, 54, 13, -8, -41 },
  { 9252, 26, 43, 26, 2, -43 },
  { 9392, 12, 43, 13, 2, -43 },
  { 9457, 43, 30, 48, 2, -30 },
  { 9619, 27, 30, 32, 2, -30 },
  { 9721, 26, 31, 32, 3, -30 },
  { 9822, 30, 43, 32, -1, -30 },
  { 9984, 27, 43, 32, 3, -30 },
  { 10130, 21, 30, 22, 2, -30 },
  { 10209, 23, 31, 24, 0, -30 },
  { 10299, 16, 38, 18, 3, -37 },
  { 10375, 27, 31, 32, 3, -30 },
  { 10480, 24, 30, 25, 3, -30 },
  { 10570, 37, 30, 38, 3, -30 },
  { 10709, 29, 30, 26, -2, -30 },
  { 10818, 33, 44, 25, -6, -30 },
  { 11000, 26, 30, 25, -1, -30 },
  { 11098, 21, 49, 19, 1, -40 },
  { 11227, 3, 57, 30, 15, -43 },
  { 11249, 20, 49, 19, -2, -40 },
  { 11372, 26, 6, 32, 4, -23 },
};

const GFXfont NotoSans_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_LIGHTITALIC56PT7B_H_
