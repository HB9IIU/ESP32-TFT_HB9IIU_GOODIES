#ifndef _NOTOSANS_LIGHTITALIC6PT7B_H_
#define _NOTOSANS_LIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x56, 0xEA, 0x29, 0x3C, 0xFD, 0x77, 0x64, 0xBF, 0x80,
  0x6A, 0x80, 0xF8, 0x6C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40, 0x76,
  0xF0, 0xEA, 0x65, 0x70, 0x6C, 0xF0, 0x2F, 0x90, 0x68, 0xF0, 0x6E, 0xF0,
  0xDA, 0x6E, 0xF0, 0xF5, 0xF0, 0x20, 0x30, 0x39, 0x80, 0xFC, 0x8F, 0x00,
  0x6A, 0x40, 0x7F, 0xF7, 0x47, 0x00, 0x2D, 0xD0, 0x7E, 0x9E, 0x78, 0x86,
  0x79, 0x9E, 0x7E, 0x70, 0x7E, 0x40, 0x7A, 0x97, 0x5F, 0x99, 0x5A, 0x29,
  0x2C, 0x74, 0xAA, 0x52, 0x70, 0x4E, 0xFB, 0x60, 0x5B, 0xB9, 0x79, 0x97,
  0x77, 0x40, 0x79, 0x95, 0x20, 0x77, 0xD0, 0xE8, 0xF0, 0xF2, 0x40, 0x59,
  0x9E, 0xBA, 0x40, 0xDD, 0xA9, 0x40, 0x74, 0x4A, 0xF2, 0x40, 0x69, 0x70,
  0x6A, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80, 0xF7, 0x80, 0x4A, 0xDE,
  0xF3, 0x00, 0x15, 0xAA, 0xE0, 0xFB, 0x00, 0x12, 0x44, 0x4C, 0xF6, 0xF0,
  0x4A, 0xDA, 0x70, 0x15, 0xC0, 0x4A, 0xAA, 0xF8, 0xFD, 0x6A, 0xF6, 0x80,
  0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0x6A, 0xB7, 0x80, 0xBA,
  0x00, 0xBF, 0xA0, 0xAB, 0x00, 0x56, 0x4C, 0x6B, 0x00, 0x5A, 0x80, 0xFC,
  0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_LightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 3, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 3, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 2, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 2, 4, 3, 1, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 3, 3, 3, 0, -4 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 5, 5, 5, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 4, 4, 4, 0, -4 },
  { 58, 4, 4, 4, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 3, 5, 2, -1, -4 },
  { 73, 4, 4, 3, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 5, 4, 5, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 4, 5, 4, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 1, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 3, 4, 3, 1, -4 },
  { 99, 5, 4, 5, 1, -4 },
  { 102, 4, 4, 3, 0, -4 },
  { 104, 3, 4, 3, 1, -4 },
  { 106, 3, 4, 3, 0, -4 },
  { 108, 2, 5, 2, 0, -4 },
  { 110, 1, 4, 2, 1, -4 },
  { 111, 2, 5, 2, 0, -4 },
  { 113, 3, 2, 3, 0, -4 },
  { 114, 3, 1, 2, -1, 0 },
  { 115, 1, 1, 2, 1, -5 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 4, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 4, 6, 2, -1, -5 },
  { 130, 3, 4, 3, 0, -3 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 1, 4, 1, 0, -4 },
  { 135, 2, 5, 1, -1, -4 },
  { 137, 3, 5, 3, 0, -5 },
  { 139, 1, 5, 1, 0, -5 },
  { 140, 5, 3, 5, 0, -3 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 4, 3, 0, -3 },
  { 148, 3, 4, 3, 0, -3 },
  { 150, 2, 3, 2, 0, -3 },
  { 151, 2, 3, 3, 0, -3 },
  { 152, 2, 4, 2, 0, -4 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 3, 3, 0, -3 },
  { 157, 4, 3, 4, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 4, 4, 3, -1, -3 },
  { 163, 3, 3, 3, 0, -3 },
  { 165, 2, 5, 2, 0, -4 },
  { 167, 1, 6, 3, 1, -5 },
  { 168, 2, 5, 2, 0, -4 },
  { 170, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_LightItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_LIGHTITALIC6PT7B_H_
