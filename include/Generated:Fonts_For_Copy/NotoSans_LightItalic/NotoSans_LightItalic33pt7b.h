#ifndef _NOTOSANS_LIGHTITALIC33PT7B_H_
#define _NOTOSANS_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1,
  0x06, 0x0C, 0x18, 0x20, 0x40, 0x00, 0x00, 0x1C, 0x38, 0x60, 0x63, 0x63,
  0x63, 0x42, 0xC6, 0xC6, 0xC6, 0x84, 0x84, 0x00, 0x60, 0xC0, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x10, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x3F, 0xFF, 0xF0, 0x10, 0x20, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x10, 0x20, 0x03, 0x06, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xFE, 0x07, 0xAF, 0x0C, 0x61, 0x0C, 0x60, 0x18, 0x60, 0x18,
  0x40, 0x18, 0x40, 0x0C, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xB8, 0x01, 0x9C, 0x01, 0x8C, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x0C, 0x83,
  0x18, 0xF3, 0x70, 0x7F, 0xE0, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0F, 0x00, 0x30, 0xFC, 0x03, 0x0C, 0x60, 0x18, 0xC1, 0x01, 0x86,
  0x08, 0x18, 0x60, 0x40, 0x83, 0x02, 0x0C, 0x18, 0x10, 0xC0, 0xC1, 0x8C,
  0x04, 0x0C, 0x40, 0x20, 0x46, 0x7D, 0x06, 0x66, 0x3C, 0x66, 0x61, 0xFE,
  0x22, 0x0C, 0xE3, 0x30, 0x60, 0x31, 0x83, 0x03, 0x08, 0x18, 0x10, 0x40,
  0xC1, 0x86, 0x04, 0x18, 0x30, 0x61, 0x81, 0x83, 0x0C, 0x04, 0x30, 0xC0,
  0x33, 0x8C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0x87, 0x00,
  0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x03, 0x0C, 0x00, 0x33, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0xC0,
  0x01, 0x86, 0x03, 0x30, 0x30, 0x36, 0x03, 0x86, 0x60, 0x18, 0xCC, 0x00,
  0xCC, 0xC0, 0x07, 0x8C, 0x00, 0x70, 0xE0, 0x0F, 0x06, 0x01, 0xD8, 0x3C,
  0xF1, 0xC1, 0xFC, 0x0E, 0x6D, 0xAD, 0xB4, 0x80, 0x00, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x00, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x20, 0x40, 0xE1, 0x01, 0xEC, 0x00, 0xE7, 0xC0, 0xFF,
  0x0D, 0x00, 0x64, 0x03, 0x18, 0x18, 0x20, 0x60, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x19, 0xCC, 0x66, 0x33, 0x18, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01,
  0xF0, 0x03, 0xFC, 0x0E, 0x0C, 0x0C, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30,
  0x02, 0x30, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x18, 0x60, 0x30, 0x60, 0x60, 0x39, 0xE0, 0x1F, 0x80, 0x01,
  0x81, 0xC3, 0xE3, 0xA7, 0x37, 0x19, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x00, 0x7C, 0x01, 0xFF, 0x81, 0xC0, 0xC0, 0x80, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x0E, 0x07, 0x08,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x3C, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x80,
  0x38, 0xF9, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x34, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x03, 0x8F,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC4, 0x01, 0xC3, 0xE7, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0xC0, 0x67, 0xF0,
  0x6C, 0x18, 0x70, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0x60, 0x30, 0x3C, 0xE0,
  0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x0C, 0x06, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x0C, 0x0E, 0x0C, 0x1C, 0x07, 0x70,
  0x03, 0xC0, 0x0F, 0xE0, 0x38, 0x30, 0x60, 0x18, 0xC0, 0x1C, 0xC0, 0x0C,
  0xC0, 0x0C, 0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xE0, 0x38, 0x78, 0xF0,
  0x3F, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x73, 0x00, 0x66,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x00,
  0x73, 0x03, 0x63, 0xFD, 0x83, 0xF3, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x38, 0x31, 0xE0, 0x7F, 0x00, 0x08,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3,
  0x00, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0x0F, 0xF9,
  0x03, 0x80, 0x30, 0x06, 0x00, 0x40, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0xC0, 0x3E, 0x06, 0x40, 0x7F, 0x83, 0x60, 0x60, 0xC1, 0xA0, 0x60,
  0x60, 0xF0, 0x60, 0x30, 0x78, 0x20, 0x10, 0x3C, 0x30, 0x18, 0x1E, 0x18,
  0x0C, 0x0B, 0x0C, 0x06, 0x0D, 0x86, 0x06, 0x06, 0xC3, 0x07, 0x06, 0x61,
  0xC6, 0xC6, 0x30, 0x7E, 0x3E, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x01, 0x88, 0x00,
  0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06,
  0x03, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x1F, 0x00,
  0x03, 0x0F, 0xE0, 0x07, 0xFF, 0x03, 0x01, 0xC1, 0x80, 0x30, 0xC0, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x8C, 0x07,
  0x87, 0xFE, 0x03, 0x07, 0xC1, 0x80, 0x70, 0x80, 0x18, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0xE3,
  0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x78, 0x08, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xE7, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x01, 0xFF, 0xC0, 0x30, 0x3C, 0x06, 0x01, 0xC0, 0xC0, 0x1C, 0x30, 0x01,
  0x86, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0xE1,
  0x80, 0x78, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x04, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x1E, 0x03, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x03, 0xFD, 0x80, 0x7F, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98,
  0x00, 0x63, 0x00, 0x0C, 0x70, 0x01, 0x86, 0x00, 0x30, 0xE0, 0x06, 0x0F,
  0x9F, 0x80, 0x7F, 0xE0, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x07, 0xF0, 0x7E, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x0F, 0xC0, 0x7C, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06,
  0x06, 0x03, 0x80, 0xC0, 0xE0, 0x30, 0x38, 0x06, 0x0E, 0x00, 0xC3, 0x80,
  0x18, 0xE0, 0x02, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0xC0, 0x03, 0xD8, 0x00,
  0x71, 0x80, 0x08, 0x30, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x80, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x03, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFE, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x1E, 0x00, 0x1B, 0x05, 0x80, 0x07, 0x83, 0x60, 0x03, 0x60, 0xD8, 0x00,
  0xD8, 0x32, 0x00, 0x66, 0x0C, 0x80, 0x11, 0x02, 0x30, 0x0C, 0xC1, 0x8C,
  0x06, 0x30, 0x63, 0x01, 0x8C, 0x18, 0xC0, 0xC3, 0x06, 0x30, 0x30, 0x83,
  0x04, 0x18, 0x60, 0xC1, 0x04, 0x18, 0x30, 0x63, 0x06, 0x0C, 0x19, 0x81,
  0x82, 0x06, 0x60, 0xC1, 0x81, 0xB0, 0x30, 0x60, 0x6C, 0x0C, 0x18, 0x0E,
  0x03, 0x06, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x30, 0x70, 0x00, 0x81, 0xE0, 0x06, 0x05, 0x80, 0x18, 0x36, 0x00,
  0x60, 0xCC, 0x01, 0x83, 0x30, 0x0C, 0x0C, 0x60, 0x30, 0x21, 0x80, 0xC1,
  0x86, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x60, 0x61, 0x83, 0x01,
  0x86, 0x0C, 0x06, 0x18, 0x30, 0x0C, 0x40, 0xC0, 0x33, 0x03, 0x00, 0x6C,
  0x18, 0x01, 0xB0, 0x60, 0x06, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x30,
  0x00, 0x60, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0x03, 0x81, 0xC0, 0x0C,
  0x18, 0x00, 0xE3, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0x8E, 0x00, 0x38, 0x60, 0x07, 0x07, 0x00, 0xE0, 0x3E, 0x7C, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0xC0,
  0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x8C,
  0x01, 0xC6, 0x01, 0xC3, 0x03, 0xC1, 0xFF, 0x80, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0x03,
  0x81, 0xC0, 0x0C, 0x18, 0x00, 0xE3, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x07, 0x07, 0x00, 0xE0,
  0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x07, 0xFE,
  0x03, 0x03, 0x81, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x01, 0x86, 0x03, 0x83, 0xFF, 0x81,
  0xFE, 0x00, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0x00,
  0xFC, 0x07, 0xFF, 0x0E, 0x03, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x80, 0x30, 0xF3, 0xE0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x60, 0xC0, 0x0E, 0x06, 0x01, 0xC0, 0x7C, 0xF8, 0x01, 0xFE, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x64, 0x00, 0x39, 0x00, 0x0C, 0x60, 0x07, 0x18, 0x01,
  0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x18, 0x06, 0x06, 0x03, 0x00,
  0x80, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x05, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C,
  0x01, 0xC0, 0x1B, 0x00, 0x50, 0x06, 0xC0, 0x34, 0x03, 0x30, 0x0D, 0x00,
  0xCC, 0x06, 0x40, 0x33, 0x01, 0x90, 0x18, 0xC0, 0xC4, 0x06, 0x30, 0x31,
  0x83, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x01, 0x18, 0x18, 0x80, 0x4C, 0x06, 0x60,
  0x13, 0x01, 0x98, 0x04, 0x80, 0x6C, 0x01, 0x60, 0x1B, 0x00, 0x50, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x18, 0x01, 0xC0, 0x40, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x03,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0x60, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x81,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x1C,
  0x00, 0x30, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x1C,
  0x20, 0x18, 0x30, 0x30, 0x30, 0x70, 0x30, 0x60, 0x18, 0xC0, 0x19, 0x80,
  0x19, 0x80, 0x0B, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x03,
  0xF0, 0x3F, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x00, 0xC1, 0x04, 0x18, 0x61, 0x86,
  0x08, 0x20, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x61, 0x82, 0x08, 0x30,
  0xC3, 0x03, 0xF0, 0x7F, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xB0, 0x01, 0x30, 0x03, 0x10, 0x06, 0x18, 0x06,
  0x08, 0x0C, 0x0C, 0x08, 0x0C, 0x18, 0x04, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xC6, 0x63, 0x10, 0x03, 0xC3,
  0x0F, 0xF2, 0x1C, 0x16, 0x38, 0x0E, 0x30, 0x0E, 0x60, 0x0C, 0x60, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x38, 0xC0, 0x78, 0xC0, 0xD0, 0x73, 0x90, 0x3E, 0x30, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x78, 0x19, 0xFE, 0x1B, 0x06, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x03,
  0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x50, 0x18, 0xDC, 0x70, 0xCF, 0xE0,
  0x03, 0xF0, 0x7F, 0xC7, 0x02, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x78, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x07, 0x86, 0x0F,
  0xF3, 0x0E, 0x0D, 0x0E, 0x03, 0x86, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x73,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18, 0x03,
  0x0C, 0x03, 0x86, 0x03, 0xC3, 0x03, 0x60, 0xE7, 0x20, 0x3F, 0x10, 0x00,
  0x03, 0xE0, 0x7F, 0x87, 0x06, 0x70, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0xF8,
  0x0E, 0xFF, 0xC7, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x02, 0x78, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x10, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0xF8,
  0x03, 0xFE, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF1, 0x83,
  0xFC, 0xC3, 0x83, 0x43, 0x80, 0xE1, 0x80, 0x71, 0x80, 0x38, 0xC0, 0x1C,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xC6, 0x00,
  0xC3, 0x00, 0xE1, 0x80, 0xF0, 0xC0, 0xD8, 0x39, 0xC8, 0x0F, 0xCC, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x01, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x78, 0x19, 0xFE, 0x1B,
  0x06, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x06, 0x1C, 0x10, 0x00, 0x00,
  0x03, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x30, 0x60, 0x00, 0x30, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0xF8, 0x0F, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x07, 0x18, 0x0C, 0x18, 0x18,
  0x18, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x37, 0x00,
  0x3F, 0x00, 0x39, 0x80, 0x71, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x60,
  0x40, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0xC0, 0x08, 0x78, 0x1E, 0x0C, 0xFE, 0x3F, 0xC6, 0xC3,
  0x30, 0x63, 0xC0, 0xD0, 0x31, 0xC0, 0x70, 0x08, 0xC0, 0x38, 0x0C, 0xE0,
  0x18, 0x06, 0x60, 0x0C, 0x03, 0x30, 0x0C, 0x01, 0x98, 0x06, 0x00, 0xC8,
  0x03, 0x00, 0xCC, 0x01, 0x80, 0x66, 0x00, 0x80, 0x33, 0x00, 0xC0, 0x19,
  0x80, 0x60, 0x0C, 0x80, 0x30, 0x0C, 0xC0, 0x18, 0x06, 0x60, 0x18, 0x03,
  0x00, 0x08, 0x7C, 0x19, 0xFE, 0x1B, 0x06, 0x1E, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0,
  0x18, 0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x67, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x6C,
  0x00, 0xD8, 0x03, 0x30, 0x06, 0x30, 0x18, 0x79, 0xE0, 0x3F, 0x80, 0x02,
  0x1E, 0x01, 0x9F, 0xE0, 0x6C, 0x18, 0x1E, 0x03, 0x07, 0x00, 0xC1, 0x80,
  0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C,
  0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x30, 0x50, 0x18, 0x37,
  0x1C, 0x0C, 0xFE, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE3,
  0x0F, 0xF3, 0x1C, 0x1A, 0x38, 0x0E, 0x30, 0x0E, 0x60, 0x0E, 0x60, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18,
  0xC0, 0x38, 0xC0, 0x78, 0xC0, 0xD8, 0x73, 0x90, 0x3F, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x08, 0x78, 0xCF, 0x86, 0xC0, 0x3C, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xC6,
  0x02, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xD0, 0x0C, 0xF1, 0xE3,
  0xFC, 0x00, 0x08, 0x04, 0x06, 0x03, 0x03, 0xFF, 0xFC, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x43, 0xE0, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x78, 0xC0, 0xD0, 0xE3,
  0x90, 0x7E, 0x30, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xB0, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x10, 0x30, 0x60, 0xC1, 0x86, 0x06, 0x30, 0x18, 0xC0,
  0x66, 0x01, 0x98, 0x02, 0xC0, 0x0B, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0,
  0x30, 0x0F, 0x01, 0xC0, 0x6C, 0x07, 0x01, 0xB0, 0x3C, 0x0C, 0xC0, 0xB0,
  0x33, 0x06, 0xC1, 0x8C, 0x19, 0x06, 0x30, 0xC4, 0x18, 0xC3, 0x10, 0xC3,
  0x18, 0x43, 0x0C, 0x61, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x1B, 0x01, 0x60,
  0x6C, 0x05, 0x81, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x1C, 0x01, 0x80, 0x70,
  0x00, 0x0C, 0x01, 0x86, 0x01, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x21, 0xC0,
  0x18, 0xC0, 0x04, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x60, 0x30, 0x60,
  0x18, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x13, 0x00, 0x02,
  0x60, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x00, 0x30, 0x0F, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0xE0,
  0x0F, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x78, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0xF0, 0x1E, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0F,
  0x80, 0xE0, 0x00, 0x7F, 0x01, 0xE3, 0xEF, 0x80, 0x7C,
};

const GFXglyph NotoSans_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 24, 8, 1, -24 },
  { 22, 8, 9, 12, 4, -24 },
  { 31, 20, 24, 21, 1, -24 },
  { 91, 16, 27, 18, 1, -25 },
  { 145, 21, 24, 26, 3, -24 },
  { 208, 20, 24, 22, 1, -24 },
  { 268, 3, 9, 6, 4, -24 },
  { 272, 10, 29, 9, 1, -24 },
  { 309, 10, 29, 9, -2, -24 },
  { 346, 14, 14, 18, 4, -25 },
  { 371, 16, 15, 19, 2, -19 },
  { 401, 5, 8, 7, -1, -4 },
  { 406, 8, 2, 10, 1, -10 },
  { 408, 3, 3, 8, 1, -3 },
  { 410, 15, 24, 11, -1, -24 },
  { 455, 16, 24, 18, 2, -24 },
  { 503, 9, 24, 18, 5, -24 },
  { 530, 17, 24, 18, 0, -24 },
  { 581, 16, 24, 18, 1, -24 },
  { 629, 18, 24, 18, 0, -24 },
  { 683, 17, 24, 18, 1, -24 },
  { 734, 16, 24, 18, 2, -24 },
  { 782, 16, 24, 18, 3, -24 },
  { 830, 16, 24, 18, 2, -24 },
  { 878, 15, 24, 18, 2, -24 },
  { 923, 6, 18, 8, 1, -18 },
  { 937, 9, 22, 8, -2, -18 },
  { 962, 16, 16, 19, 2, -20 },
  { 994, 15, 8, 19, 3, -16 },
  { 1009, 16, 16, 19, 2, -20 },
  { 1041, 11, 24, 14, 3, -24 },
  { 1074, 25, 26, 28, 2, -23 },
  { 1156, 19, 24, 18, -2, -24 },
  { 1213, 17, 24, 20, 2, -24 },
  { 1264, 18, 24, 20, 3, -24 },
  { 1318, 19, 24, 22, 2, -24 },
  { 1375, 16, 24, 17, 2, -24 },
  { 1423, 16, 24, 16, 2, -24 },
  { 1471, 19, 24, 23, 3, -24 },
  { 1528, 20, 24, 22, 2, -24 },
  { 1588, 12, 24, 10, 0, -24 },
  { 1624, 13, 30, 8, -5, -24 },
  { 1673, 19, 24, 18, 2, -24 },
  { 1730, 12, 24, 16, 2, -24 },
  { 1766, 26, 24, 27, 1, -24 },
  { 1844, 22, 24, 23, 1, -24 },
  { 1910, 20, 24, 24, 3, -24 },
  { 1970, 17, 24, 19, 2, -24 },
  { 2021, 20, 30, 24, 3, -24 },
  { 2096, 17, 24, 19, 2, -24 },
  { 2147, 16, 24, 17, 1, -24 },
  { 2195, 16, 24, 16, 3, -24 },
  { 2243, 20, 24, 23, 3, -24 },
  { 2303, 18, 24, 18, 3, -24 },
  { 2357, 26, 24, 28, 4, -24 },
  { 2435, 21, 24, 17, -2, -24 },
  { 2498, 16, 24, 16, 3, -24 },
  { 2546, 19, 24, 18, 0, -24 },
  { 2603, 12, 29, 10, 0, -24 },
  { 2647, 6, 24, 11, 3, -24 },
  { 2665, 12, 29, 10, -2, -24 },
  { 2709, 16, 15, 19, 1, -24 },
  { 2739, 13, 2, 13, -3, 3 },
  { 2743, 4, 5, 8, 5, -25 },
  { 2746, 16, 18, 18, 2, -18 },
  { 2782, 16, 25, 19, 1, -25 },
  { 2832, 13, 18, 15, 2, -18 },
  { 2862, 17, 25, 19, 2, -25 },
  { 2916, 13, 18, 16, 2, -18 },
  { 2946, 18, 33, 10, -4, -25 },
  { 3021, 17, 26, 19, 1, -18 },
  { 3077, 16, 25, 19, 1, -25 },
  { 3127, 7, 24, 8, 1, -24 },
  { 3148, 12, 32, 8, -4, -24 },
  { 3196, 16, 25, 15, 1, -25 },
  { 3246, 7, 25, 8, 1, -25 },
  { 3268, 25, 18, 28, 1, -18 },
  { 3325, 16, 18, 19, 1, -18 },
  { 3361, 15, 18, 19, 2, -18 },
  { 3395, 18, 26, 19, -1, -18 },
  { 3454, 16, 26, 19, 2, -18 },
  { 3506, 13, 18, 13, 1, -18 },
  { 3536, 13, 18, 14, 0, -18 },
  { 3566, 9, 22, 11, 2, -22 },
  { 3591, 16, 18, 19, 2, -18 },
  { 3627, 14, 18, 14, 2, -18 },
  { 3659, 22, 18, 23, 2, -18 },
  { 3709, 17, 18, 15, -1, -18 },
  { 3748, 19, 26, 14, -3, -18 },
  { 3810, 14, 18, 15, 0, -18 },
  { 3842, 12, 29, 11, 1, -24 },
  { 3886, 2, 33, 18, 9, -25 },
  { 3895, 12, 29, 11, -1, -24 },
  { 3939, 16, 3, 19, 2, -13 },
};

const GFXfont NotoSans_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_LIGHTITALIC33PT7B_H_
