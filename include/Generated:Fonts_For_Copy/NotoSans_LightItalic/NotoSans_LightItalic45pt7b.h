#ifndef _NOTOSANS_LIGHTITALIC45PT7B_H_
#define _NOTOSANS_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x40, 0x00, 0x38, 0x73, 0x06, 0x70, 0xE7,
  0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0xC1, 0x8C, 0x18, 0xC1, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x83, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0x38, 0xE0, 0xE1,
  0x80, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x07, 0x0C, 0x00, 0x3C, 0x60, 0x00, 0xF3, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0x3C, 0x00,
  0x30, 0xE0, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x06, 0x06,
  0x00, 0x30, 0x70, 0x01, 0x83, 0x8C, 0x0C, 0x78, 0x7F, 0x7F, 0x83, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0x07, 0xFC, 0x00, 0x30, 0x30, 0x70, 0x03, 0x83, 0x81, 0x80, 0x38,
  0x18, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x1C, 0x07, 0x00, 0xC0, 0xC0, 0x30, 0x0E, 0x0C, 0x01, 0x80, 0x60,
  0xE0, 0x0C, 0x03, 0x0E, 0x00, 0x60, 0x18, 0x61, 0xC3, 0x01, 0xC6, 0x3F,
  0x98, 0x0C, 0x73, 0xCE, 0xC0, 0xE7, 0x38, 0x3F, 0x0E, 0x31, 0x81, 0xDF,
  0xE3, 0x1C, 0x06, 0xFE, 0x38, 0xC0, 0x30, 0x81, 0x86, 0x01, 0x80, 0x18,
  0x70, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0x1C, 0x18, 0x06, 0x00, 0xC0, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x01, 0x80, 0xC0,
  0x60, 0x0C, 0x06, 0x06, 0x00, 0x60, 0x60, 0x70, 0x03, 0x87, 0x07, 0x00,
  0x0F, 0xF0, 0x70, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x80, 0x18, 0x00, 0x30, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78,
  0x70, 0x03, 0x9E, 0x07, 0x00, 0x67, 0x00, 0x70, 0x1C, 0xE0, 0x06, 0x03,
  0x38, 0x00, 0xE0, 0xE7, 0x00, 0x0E, 0x38, 0xC0, 0x00, 0xEE, 0x18, 0x00,
  0x1F, 0x83, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0xC0,
  0xE0, 0x07, 0xB8, 0x1E, 0x03, 0xE3, 0x81, 0xFF, 0xF0, 0x38, 0x0F, 0xF8,
  0x07, 0x80, 0x39, 0x9C, 0xE6, 0x31, 0x8C, 0xC6, 0x30, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x40, 0x30, 0x06, 0x03, 0x00, 0xF8, 0x60, 0x03, 0xE6,
  0x00, 0x07, 0xE0, 0xF0, 0x1F, 0xFF, 0x00, 0xEF, 0xF0, 0x1A, 0x00, 0x07,
  0x30, 0x00, 0xE3, 0x00, 0x1C, 0x18, 0x03, 0x81, 0x80, 0x70, 0x1C, 0x01,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x18,
  0x60, 0xC3, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0x40, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xC0, 0x70, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x60, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0x80, 0x00,
  0xEC, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x1C,
  0xC0, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x06, 0x00,
  0x70, 0x38, 0x07, 0x00, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x70, 0x1F, 0x03, 0xF0, 0xF6, 0x1E, 0x67, 0x8E, 0xF0, 0xE4, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x10, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3E, 0x01, 0xE0, 0x30,
  0x01, 0xC0, 0x40, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x10, 0x00,
  0x38, 0x3C, 0x01, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x38, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF8, 0x02, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x80, 0x07, 0x83, 0x80, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xE4, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC1, 0xF8, 0x07, 0x1F, 0xF8, 0x1D, 0xE1, 0xF0, 0x6E, 0x01,
  0xC1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x18, 0xE0, 0x00, 0x63,
  0x80, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x1C,
  0x03, 0x80, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x70, 0x1E, 0x03, 0x80, 0x1C, 0x0C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x07, 0x80,
  0x0E, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xBC, 0x00, 0xF0,
  0x38, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00, 0x06,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38,
  0x00, 0x38, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0xC0, 0x78, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xF0, 0x3C, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x86, 0x00, 0x1E,
  0x1C, 0x00, 0xF8, 0x78, 0x06, 0xE0, 0xF8, 0xF3, 0x01, 0xFF, 0x9C, 0x01,
  0xF0, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x08, 0x07, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x40,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xF8, 0x7F, 0xFC, 0x70, 0x1E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x0F, 0xE0, 0x18, 0x70, 0x07, 0xFF, 0x03, 0x0C,
  0x03, 0xC0, 0xE0, 0x73, 0x80, 0xE0, 0x18, 0x0E, 0x60, 0x38, 0x03, 0x01,
  0xDC, 0x06, 0x00, 0xE0, 0x3B, 0x01, 0xC0, 0x1C, 0x07, 0x60, 0x30, 0x03,
  0x00, 0xCC, 0x0E, 0x00, 0x60, 0x19, 0x81, 0x80, 0x1C, 0x03, 0x70, 0x30,
  0x03, 0x00, 0xEE, 0x06, 0x00, 0x60, 0x19, 0xC0, 0xC0, 0x1C, 0x07, 0x38,
  0x18, 0x07, 0x80, 0xC3, 0x03, 0x80, 0xF0, 0x38, 0x60, 0x30, 0x77, 0x0E,
  0x0C, 0x07, 0xFC, 0x7F, 0x81, 0xC0, 0x7E, 0x07, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x0E, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x30,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x18, 0x00, 0x30, 0x1C, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0x80, 0x3E, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1C, 0x03, 0xF0, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x78, 0x60, 0x00, 0xF0, 0x60, 0x0F, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0x01, 0xF8, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x0E, 0x03, 0xF8, 0x01, 0xC0, 0x0F, 0x80, 0x38, 0x00,
  0x78, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x38, 0x00, 0x7C, 0x06, 0x00, 0x3E, 0x00, 0xC0, 0x7F,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x07, 0xC0,
  0x0E, 0x03, 0xC0, 0x00, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xCC, 0x00,
  0x7F, 0xF3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x0F, 0x00,
  0x06, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0x0F, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0x80, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x18, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x3C,
  0x00, 0x00, 0x6F, 0xC0, 0x00, 0x1F, 0x98, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xB0, 0x00, 0x03,
  0x60, 0x36, 0x00, 0x00, 0xEC, 0x06, 0xC0, 0x00, 0x1B, 0x81, 0xDC, 0x00,
  0x07, 0x70, 0x3B, 0x80, 0x00, 0xCC, 0x06, 0x30, 0x00, 0x39, 0x80, 0xC6,
  0x00, 0x0E, 0x70, 0x18, 0xC0, 0x01, 0x8E, 0x07, 0x18, 0x00, 0x71, 0xC0,
  0xE3, 0x00, 0x0C, 0x30, 0x18, 0x70, 0x03, 0x86, 0x03, 0x0E, 0x00, 0x61,
  0xC0, 0x60, 0xC0, 0x1C, 0x38, 0x1C, 0x18, 0x07, 0x07, 0x03, 0x83, 0x00,
  0xC0, 0xC0, 0x60, 0x60, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x30, 0x1C, 0x0E, 0x03, 0x0E, 0x03, 0x01,
  0x80, 0x63, 0x80, 0xE0, 0x30, 0x0C, 0x60, 0x1C, 0x0E, 0x01, 0x9C, 0x03,
  0x81, 0xC0, 0x3B, 0x00, 0x60, 0x38, 0x07, 0xE0, 0x0C, 0x06, 0x00, 0x78,
  0x03, 0x80, 0xC0, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x0E, 0x07, 0xC0, 0x00, 0x60, 0x36, 0x00, 0x03, 0x01, 0xB8, 0x00,
  0x38, 0x1D, 0xC0, 0x01, 0xC0, 0xE6, 0x00, 0x0E, 0x06, 0x38, 0x00, 0x60,
  0x30, 0xC0, 0x03, 0x01, 0x87, 0x00, 0x38, 0x1C, 0x38, 0x01, 0xC0, 0xE0,
  0xC0, 0x0C, 0x06, 0x07, 0x00, 0x60, 0x30, 0x18, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x18, 0x0C, 0x06, 0x00, 0xE0, 0x60,
  0x30, 0x03, 0x07, 0x03, 0x80, 0x1C, 0x38, 0x1C, 0x00, 0xE1, 0xC0, 0xE0,
  0x03, 0x0C, 0x06, 0x00, 0x1C, 0x60, 0x30, 0x00, 0x67, 0x03, 0x80, 0x03,
  0xB8, 0x1C, 0x00, 0x1D, 0x80, 0xE0, 0x00, 0x6C, 0x06, 0x00, 0x03, 0xE0,
  0x30, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0E, 0x03, 0xF0,
  0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x06, 0x00,
  0x78, 0x1C, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x0E, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC1,
  0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00,
  0x1E, 0x06, 0x00, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x18, 0x01, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xF8,
  0x07, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC2, 0x00, 0x1E,
  0x0E, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x01,
  0xC0, 0x30, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x1C,
  0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x0E, 0xE0, 0x01, 0xB0, 0x01, 0xCE,
  0x00, 0x3B, 0x00, 0x1C, 0x60, 0x03, 0x30, 0x01, 0x86, 0x00, 0x73, 0x00,
  0x38, 0x60, 0x06, 0x30, 0x03, 0x06, 0x00, 0xE3, 0x00, 0x70, 0x60, 0x0C,
  0x30, 0x06, 0x06, 0x01, 0xC3, 0x00, 0xE0, 0x60, 0x18, 0x30, 0x0E, 0x06,
  0x03, 0x83, 0x01, 0xC0, 0x60, 0x38, 0x30, 0x1C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0x60, 0x70, 0x38, 0x38, 0x07, 0x06, 0x03, 0x83, 0x00, 0x70, 0xE0,
  0x38, 0x70, 0x07, 0x0C, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07,
  0x18, 0x01, 0x8C, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x07, 0x30, 0x01, 0x9C,
  0x00, 0x77, 0x00, 0x19, 0x80, 0x07, 0x60, 0x01, 0xB8, 0x00, 0x7E, 0x00,
  0x1B, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x83, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0E, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x38,
  0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xC1, 0x83, 0x07, 0x0E,
  0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30,
  0x60, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE0, 0xC1, 0x83,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60,
  0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x70, 0x01, 0x81, 0x80, 0x18,
  0x0C, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xE0, 0x0E, 0x06, 0x00, 0x30,
  0x70, 0x01, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x33, 0x80, 0x01, 0x98, 0x00,
  0x07, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3,
  0x87, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0xFF, 0x0C, 0x0F, 0xFE, 0x70, 0x78,
  0x19, 0x83, 0xC0, 0x36, 0x0E, 0x00, 0x58, 0x70, 0x01, 0xE3, 0x80, 0x07,
  0x8E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x18, 0x01, 0xF0,
  0x70, 0x0D, 0xC1, 0xE0, 0xE6, 0x03, 0xFF, 0x18, 0x07, 0xF0, 0x60, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0xFE, 0x01, 0xCF, 0xFC, 0x06, 0x70, 0x38, 0x1B,
  0x80, 0x70, 0xF8, 0x01, 0xC3, 0xE0, 0x03, 0x0F, 0x00, 0x0C, 0x38, 0x00,
  0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31,
  0x80, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xF0, 0x03, 0x86, 0xC0, 0x1C,
  0x19, 0x81, 0xE0, 0x63, 0xFF, 0x03, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0x01, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x0C, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0xC3, 0x00, 0x7F, 0xF3, 0x80, 0x78, 0x1D, 0xC0, 0x78,
  0x06, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x03, 0x00, 0x36, 0x01, 0xC0, 0x33, 0x00, 0xF0, 0x71, 0x80, 0x3F, 0xF1,
  0xC0, 0x0F, 0xF0, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0x07,
  0x03, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x06,
  0x30, 0x01, 0xCE, 0x00, 0xF1, 0xC1, 0xFC, 0x3F, 0xFE, 0x07, 0xFC, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x07, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x9E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x86, 0x03, 0xFF, 0x8C, 0x0F,
  0x03, 0x98, 0x3C, 0x01, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x81,
  0x80, 0x1B, 0x03, 0x80, 0x66, 0x07, 0x83, 0x9C, 0x07, 0xFE, 0x38, 0x07,
  0xF8, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x60, 0x07,
  0x00, 0xFC, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0xFE, 0x01, 0xCF, 0xFE, 0x06, 0x70, 0x38, 0x1B, 0x80,
  0x70, 0xF8, 0x01, 0xC3, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0x80,
  0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x00, 0x01, 0x80, 0x70, 0x3C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x6F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x03, 0xC1, 0xC0, 0x1C, 0x06, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x30,
  0x70, 0x00, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x67, 0x80,
  0x01, 0xB7, 0x00, 0x07, 0x8C, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0x60, 0x03,
  0x01, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x83, 0x80, 0x0F, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x00, 0x07, 0x0F, 0xC0, 0x3F, 0x80, 0xC7, 0xFC,
  0x1F, 0xF8, 0x19, 0xC1, 0xC7, 0x07, 0x03, 0x60, 0x19, 0x80, 0x70, 0xF8,
  0x03, 0x60, 0x0E, 0x1E, 0x00, 0x7C, 0x01, 0xC3, 0xC0, 0x0F, 0x00, 0x38,
  0x70, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x00, 0xE3, 0x80, 0x06, 0x00,
  0x18, 0x70, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x00, 0x61, 0x80, 0x07,
  0x00, 0x1C, 0x30, 0x00, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x00, 0x61, 0xC0,
  0x07, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x00, 0x0E, 0x38, 0x00, 0x60, 0x01, 0x87, 0x00, 0x1C, 0x00,
  0x30, 0xC0, 0x03, 0x80, 0x0E, 0x18, 0x00, 0x60, 0x01, 0xC7, 0x00, 0x0C,
  0x00, 0x38, 0x07, 0x0F, 0xF0, 0x18, 0xFF, 0xE0, 0x67, 0x83, 0x81, 0xB8,
  0x07, 0x0F, 0xC0, 0x1C, 0x3E, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x73, 0x00, 0x07, 0x18, 0x00, 0x38, 0xE0, 0x03,
  0x83, 0x80, 0x38, 0x1E, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xC3, 0xF8, 0x01, 0x8F, 0xFC, 0x01, 0x9C, 0x0E, 0x01, 0xB8, 0x07, 0x03,
  0xE0, 0x07, 0x03, 0xE0, 0x03, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03,
  0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1F, 0x00, 0x38, 0x1F,
  0x00, 0x70, 0x19, 0x81, 0xF0, 0x18, 0xFF, 0xC0, 0x38, 0x7F, 0x80, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x0C, 0x0F,
  0xFE, 0x30, 0x78, 0x1C, 0xC3, 0xC0, 0x37, 0x0E, 0x00, 0x78, 0x70, 0x01,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xC7,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3C,
  0x18, 0x01, 0xB0, 0x70, 0x0C, 0xC1, 0xE0, 0xE7, 0x03, 0xFF, 0x1C, 0x07,
  0xF8, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x0F, 0xC1,
  0x8F, 0xE0, 0x67, 0x00, 0x1B, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x0C, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x80, 0x0E, 0x38, 0x07, 0x8F, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFE, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00,
  0x06, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x86, 0x00, 0x0C,
  0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x70,
  0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x60, 0x01,
  0xE3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x18, 0x01, 0xB0, 0x70, 0x0D, 0xC1,
  0xC0, 0xE6, 0x03, 0xFF, 0x18, 0x07, 0xF8, 0x60, 0xE0, 0x00, 0x7E, 0x00,
  0x0E, 0x60, 0x00, 0xE6, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x70,
  0x03, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x1C, 0x03,
  0x01, 0xC0, 0x30, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x01, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xB8, 0x00, 0x1B, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x3E, 0x00, 0xEC, 0x01,
  0xB0, 0x06, 0x60, 0x1D, 0x80, 0x73, 0x00, 0xCC, 0x03, 0x18, 0x0E, 0x60,
  0x38, 0xC0, 0x63, 0x01, 0xC6, 0x07, 0x18, 0x1C, 0x38, 0x30, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x0E, 0x18, 0x38, 0x70, 0x71, 0xC1, 0xC3, 0x03, 0x8C,
  0x06, 0x38, 0x1C, 0xE0, 0x31, 0x80, 0xE6, 0x01, 0x9C, 0x07, 0x70, 0x0C,
  0xC0, 0x3B, 0x00, 0x6E, 0x01, 0xD8, 0x03, 0x60, 0x07, 0x80, 0x1B, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x00,
  0xC0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xC7, 0x00, 0x03, 0x83, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x60, 0x01,
  0xC0, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x07,
  0x00, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x8F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x3F,
  0xC0, 0x0B, 0xFF, 0x80, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x18,
  0x00,
};

const GFXglyph NotoSans_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 33, 11, 1, -32 },
  { 43, 12, 11, 16, 5, -32 },
  { 60, 28, 32, 28, 1, -32 },
  { 172, 21, 37, 25, 2, -34 },
  { 270, 29, 34, 35, 4, -33 },
  { 394, 27, 33, 31, 2, -33 },
  { 506, 5, 11, 9, 5, -32 },
  { 513, 13, 39, 12, 2, -32 },
  { 577, 13, 39, 12, -3, -32 },
  { 641, 20, 20, 24, 5, -34 },
  { 691, 21, 22, 26, 3, -27 },
  { 749, 7, 11, 10, -2, -5 },
  { 759, 11, 2, 14, 1, -13 },
  { 762, 4, 5, 10, 1, -4 },
  { 765, 21, 32, 15, -2, -32 },
  { 849, 21, 33, 25, 3, -33 },
  { 936, 12, 32, 25, 7, -32 },
  { 984, 23, 33, 25, 0, -33 },
  { 1079, 23, 33, 25, 1, -33 },
  { 1174, 24, 32, 25, 0, -32 },
  { 1270, 22, 32, 25, 2, -32 },
  { 1358, 22, 33, 25, 3, -33 },
  { 1449, 21, 32, 25, 4, -32 },
  { 1533, 22, 33, 25, 2, -33 },
  { 1624, 22, 33, 25, 2, -33 },
  { 1715, 8, 25, 10, 1, -24 },
  { 1740, 11, 30, 10, -2, -24 },
  { 1782, 21, 21, 26, 3, -27 },
  { 1838, 21, 11, 26, 3, -21 },
  { 1867, 21, 21, 26, 3, -27 },
  { 1923, 16, 34, 19, 4, -33 },
  { 1991, 35, 36, 38, 2, -32 },
  { 2149, 25, 32, 25, -2, -32 },
  { 2249, 24, 32, 27, 2, -32 },
  { 2345, 24, 33, 27, 4, -33 },
  { 2444, 27, 32, 30, 2, -32 },
  { 2552, 23, 32, 24, 2, -32 },
  { 2644, 23, 32, 22, 2, -32 },
  { 2736, 26, 33, 31, 4, -33 },
  { 2844, 29, 32, 31, 2, -32 },
  { 2960, 16, 32, 14, 0, -32 },
  { 3024, 19, 40, 11, -7, -32 },
  { 3119, 27, 32, 25, 2, -32 },
  { 3227, 17, 32, 22, 2, -32 },
  { 3295, 35, 32, 37, 2, -32 },
  { 3435, 29, 32, 31, 2, -32 },
  { 3551, 27, 33, 32, 4, -33 },
  { 3663, 23, 32, 25, 2, -32 },
  { 3755, 27, 41, 32, 4, -33 },
  { 3894, 23, 32, 26, 2, -32 },
  { 3986, 22, 33, 23, 1, -33 },
  { 4077, 22, 32, 22, 4, -32 },
  { 4165, 27, 32, 31, 4, -32 },
  { 4273, 24, 32, 24, 4, -32 },
  { 4369, 36, 32, 38, 5, -32 },
  { 4513, 28, 32, 23, -2, -32 },
  { 4625, 23, 32, 22, 4, -32 },
  { 4717, 26, 32, 24, 0, -32 },
  { 4821, 17, 39, 13, 0, -32 },
  { 4904, 7, 32, 15, 5, -32 },
  { 4932, 17, 39, 13, -3, -32 },
  { 5015, 21, 20, 25, 2, -32 },
  { 5068, 18, 3, 17, -4, 4 },
  { 5075, 6, 7, 11, 7, -34 },
  { 5081, 22, 24, 25, 2, -24 },
  { 5147, 22, 34, 26, 1, -34 },
  { 5241, 19, 24, 20, 2, -24 },
  { 5298, 25, 34, 26, 2, -34 },
  { 5405, 19, 24, 22, 2, -24 },
  { 5462, 24, 45, 13, -5, -34 },
  { 5597, 23, 35, 26, 1, -24 },
  { 5698, 22, 34, 25, 1, -34 },
  { 5792, 10, 33, 10, 1, -33 },
  { 5834, 17, 44, 10, -6, -33 },
  { 5928, 22, 34, 21, 1, -34 },
  { 6022, 10, 34, 10, 1, -34 },
  { 6065, 35, 24, 39, 1, -24 },
  { 6170, 22, 24, 25, 1, -24 },
  { 6236, 21, 24, 25, 2, -24 },
  { 6299, 24, 35, 26, -1, -24 },
  { 6404, 22, 35, 26, 2, -24 },
  { 6501, 18, 24, 17, 1, -24 },
  { 6555, 18, 24, 19, 0, -24 },
  { 6609, 14, 30, 14, 2, -30 },
  { 6662, 22, 24, 25, 2, -24 },
  { 6728, 20, 24, 20, 2, -24 },
  { 6788, 29, 24, 31, 3, -24 },
  { 6875, 24, 24, 21, -2, -24 },
  { 6947, 27, 35, 20, -5, -24 },
  { 7066, 21, 24, 20, -1, -24 },
  { 7129, 17, 39, 15, 1, -32 },
  { 7212, 2, 45, 24, 12, -34 },
  { 7224, 17, 39, 15, -2, -32 },
  { 7307, 21, 5, 26, 3, -18 },
};

const GFXfont NotoSans_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_LIGHTITALIC45PT7B_H_
