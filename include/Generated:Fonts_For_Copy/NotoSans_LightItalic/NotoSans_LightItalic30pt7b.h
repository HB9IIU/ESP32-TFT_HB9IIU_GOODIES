#ifndef _NOTOSANS_LIGHTITALIC30PT7B_H_
#define _NOTOSANS_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x86,
  0x00, 0x00, 0x04, 0x30, 0xC0, 0x63, 0x63, 0x62, 0x42, 0x46, 0x46, 0xC4,
  0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00,
  0x41, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x02, 0x08, 0x01, 0x82, 0x00, 0x61,
  0x80, 0x10, 0x60, 0x0C, 0x10, 0x3F, 0xFF, 0xC0, 0x83, 0x00, 0x20, 0xC0,
  0x18, 0x20, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x1F, 0xF0, 0xE4, 0xC3, 0x18, 0x06,
  0x30, 0x08, 0x40, 0x10, 0x80, 0x31, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x2E, 0x00, 0x4C, 0x01, 0x8C, 0x02, 0x18, 0x04, 0x30, 0x08, 0xC6,
  0x33, 0x0F, 0xFC, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x21, 0xF8, 0x04, 0x31, 0x80, 0xC2, 0x08, 0x18, 0x60, 0x83, 0x06,
  0x08, 0x20, 0x40, 0x86, 0x04, 0x18, 0xC0, 0x41, 0x98, 0x0C, 0x11, 0x1E,
  0x43, 0x37, 0x24, 0x26, 0x43, 0x7E, 0x4C, 0x31, 0x88, 0x83, 0x01, 0x88,
  0x30, 0x31, 0x83, 0x02, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x18, 0x61, 0x81,
  0x84, 0x10, 0x18, 0xC3, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x30,
  0xC0, 0x18, 0x18, 0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x18, 0x60,
  0x06, 0x30, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x38, 0xC0, 0xD8,
  0x18, 0x36, 0x02, 0x1B, 0x00, 0xC4, 0xC0, 0x1B, 0x30, 0x03, 0x8C, 0x00,
  0xC1, 0x80, 0xF8, 0x70, 0xE3, 0x0F, 0xF0, 0xE0, 0x6D, 0xA4, 0xB0, 0x01,
  0x81, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x82, 0x0E, 0x10, 0x1D, 0x80, 0x1F, 0xE0, 0xE0,
  0x0D, 0x00, 0xCC, 0x0C, 0x20, 0xC1, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x39, 0x88,
  0xC4, 0x62, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xC1,
  0x86, 0x02, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x33, 0x00, 0xCC, 0x06, 0x18, 0x30, 0x71, 0xC0, 0xFC, 0x00, 0x07, 0x1E,
  0x36, 0xE6, 0x86, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x00, 0x70, 0x03, 0xFC, 0x0E,
  0x06, 0x04, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x01, 0xE0, 0x0F, 0xF0, 0x70, 0x30, 0x80, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x3F, 0x80,
  0x7F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x44, 0x01, 0x8E, 0x1E, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x0A, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x64, 0x00, 0xC4, 0x01, 0x8C, 0x03,
  0x0C, 0x02, 0x0C, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x60,
  0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x62, 0x01, 0xC7, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x70,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x9F,
  0x85, 0x87, 0x3C, 0x0C, 0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x71, 0xC0, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x07, 0xF8, 0x18, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC2, 0x01,
  0x86, 0x06, 0x0C, 0x1C, 0x0E, 0x60, 0x07, 0x00, 0x7F, 0x01, 0x83, 0x06,
  0x03, 0x18, 0x06, 0x20, 0x04, 0xC0, 0x09, 0x80, 0x11, 0x00, 0x63, 0x01,
  0x83, 0x8F, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x70, 0xC0,
  0x61, 0x80, 0x46, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x18,
  0xC0, 0x31, 0xC1, 0xE1, 0xFE, 0xC0, 0xF1, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x0C, 0x38, 0x1F, 0xE0, 0x00, 0x18,
  0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0x18, 0x06, 0x1C, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x86, 0x0C, 0x30, 0x60,
  0x83, 0x04, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x10, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x0F, 0x0F, 0xF8, 0x83, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x03, 0x80, 0x60, 0x03, 0x03, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x07, 0xF8, 0x58, 0x30, 0x41, 0x41,
  0x81, 0x07, 0x0C, 0x0C, 0x1C, 0x20, 0x30, 0x60, 0x80, 0x81, 0x86, 0x06,
  0x0E, 0x18, 0x18, 0x38, 0x60, 0xE1, 0xA1, 0x83, 0x8C, 0xC3, 0xF3, 0xF3,
  0x07, 0x07, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x04, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01, 0x08, 0x01, 0x84,
  0x01, 0x82, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x7F, 0xF0, 0x3F,
  0xF8, 0x30, 0x04, 0x30, 0x02, 0x18, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0x18, 0x07, 0xFE, 0x06, 0x03, 0x83, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x0E, 0x0F,
  0xFC, 0x07, 0xFE, 0x06, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x40, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x07, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xC1, 0xE0, 0x41, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xE3, 0x80, 0x7F, 0xC0,
  0x07, 0xFC, 0x03, 0x03, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x00, 0xC2,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x62, 0x00, 0x18, 0x80, 0x0C,
  0x60, 0x06, 0x18, 0x03, 0x86, 0x03, 0x81, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x78, 0x0C, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0xFE, 0xC0, 0x3F, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C,
  0x40, 0x03, 0x18, 0x00, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x1C, 0x1E, 0x03,
  0xFE, 0x00, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x04, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x0C,
  0x00, 0x41, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x20,
  0x03, 0x0C, 0x00, 0x60, 0x0F, 0xC0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x07,
  0xE0, 0x00, 0x06, 0x01, 0xC3, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x0C,
  0x18, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x1B, 0x80, 0x07, 0xE0,
  0x01, 0xD8, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x02, 0x06, 0x00,
  0x80, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x81, 0x00, 0x60, 0xC0,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFE, 0x06, 0x00, 0x0F, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x16, 0x09, 0x00, 0x36, 0x09, 0x00,
  0x24, 0x19, 0x00, 0x64, 0x19, 0x80, 0xCC, 0x19, 0x80, 0xCC, 0x11, 0x81,
  0x8C, 0x11, 0x81, 0x08, 0x30, 0x83, 0x18, 0x30, 0x82, 0x18, 0x30, 0x86,
  0x18, 0x20, 0xCC, 0x18, 0x60, 0xCC, 0x10, 0x60, 0xD8, 0x30, 0x60, 0xD0,
  0x30, 0x60, 0x70, 0x30, 0x40, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x06, 0x00,
  0x30, 0xE0, 0x02, 0x0F, 0x00, 0x60, 0xF0, 0x06, 0x09, 0x80, 0x60, 0x98,
  0x06, 0x18, 0x80, 0x41, 0x8C, 0x0C, 0x18, 0xC0, 0xC1, 0x06, 0x0C, 0x10,
  0x60, 0x83, 0x02, 0x08, 0x30, 0x31, 0x83, 0x03, 0x18, 0x20, 0x19, 0x86,
  0x01, 0x90, 0x60, 0x0B, 0x06, 0x00, 0xF0, 0x60, 0x0F, 0x04, 0x00, 0x70,
  0xC0, 0x06, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x70, 0x38, 0x30, 0x06,
  0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x01, 0x60, 0x00, 0x58,
  0x00, 0x14, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x06, 0x40, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x70, 0xC0, 0x38,
  0x1C, 0x3C, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0C, 0x0E, 0x0C, 0x06, 0x0C,
  0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18,
  0x0C, 0x10, 0x38, 0x3F, 0xF0, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0x80, 0x70, 0x38, 0x30, 0x06, 0x18, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0D, 0x80, 0x01, 0x60, 0x00, 0x58, 0x00, 0x14, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0x40,
  0x01, 0x98, 0x00, 0xC6, 0x00, 0x70, 0xC0, 0x38, 0x1C, 0x3C, 0x03, 0xFC,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x07, 0xFC, 0x0C, 0x0E, 0x0C, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03,
  0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18, 0x1C, 0x1F, 0xF8, 0x3F, 0xC0,
  0x30, 0x60, 0x30, 0x60, 0x30, 0x20, 0x20, 0x30, 0x60, 0x30, 0x60, 0x10,
  0x60, 0x18, 0x40, 0x18, 0xC0, 0x0C, 0x00, 0xE0, 0x1F, 0xF0, 0xC0, 0x46,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0xE1, 0xC3, 0xFE, 0x00, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x98, 0x00, 0x46,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x23, 0x00,
  0x18, 0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x30, 0x80, 0x0C,
  0x30, 0x06, 0x0C, 0x03, 0x81, 0xC3, 0xC0, 0x3F, 0xC0, 0x00, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x40, 0x18, 0x40, 0x18, 0x40, 0x30,
  0x60, 0x30, 0x60, 0x60, 0x60, 0x40, 0x60, 0xC0, 0x60, 0x80, 0x61, 0x80,
  0x21, 0x00, 0x23, 0x00, 0x26, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0xC0, 0x18, 0x03, 0xA0, 0x0C, 0x01, 0x90, 0x0F,
  0x01, 0x88, 0x05, 0x80, 0xC4, 0x06, 0xC0, 0xC2, 0x02, 0x60, 0x61, 0x03,
  0x30, 0x20, 0xC1, 0x98, 0x30, 0x61, 0x8C, 0x10, 0x30, 0xC6, 0x18, 0x18,
  0xC3, 0x0C, 0x0C, 0x60, 0x8C, 0x06, 0x60, 0x46, 0x03, 0x30, 0x26, 0x01,
  0x90, 0x13, 0x00, 0xD8, 0x09, 0x00, 0x68, 0x05, 0x80, 0x3C, 0x02, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x70, 0x30, 0x0C, 0x01, 0x01, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00, 0x08,
  0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0x90, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00,
  0x60, 0x80, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60,
  0xE0, 0x03, 0x00, 0xC0, 0x0F, 0x80, 0x31, 0x00, 0x63, 0x01, 0x86, 0x06,
  0x0C, 0x0C, 0x08, 0x30, 0x18, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xFC, 0x1F, 0x80, 0xC6, 0x10, 0x84, 0x31, 0x8C, 0x21, 0x08, 0x63,
  0x18, 0x42, 0x10, 0xC6, 0x30, 0x80, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x00, 0x80, 0x01, 0x80, 0x07, 0x00,
  0x1B, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x0C, 0x06, 0x08, 0x18, 0x10, 0x30,
  0x30, 0xC0, 0x21, 0x00, 0x66, 0x00, 0x58, 0x00, 0xC0, 0xFF, 0xF0, 0xC3,
  0x08, 0x61, 0x80, 0x07, 0xE6, 0x1C, 0x6C, 0x60, 0x51, 0x80, 0x63, 0x00,
  0xCC, 0x01, 0x98, 0x03, 0x30, 0x04, 0x40, 0x18, 0x80, 0x33, 0x00, 0x62,
  0x01, 0xC4, 0x07, 0x0C, 0x1A, 0x1C, 0x6C, 0x1F, 0x98, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0xFC,
  0x1B, 0x1C, 0x28, 0x18, 0x70, 0x11, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xC8,
  0x01, 0x30, 0x02, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0xCF, 0x03,
  0x1B, 0x1C, 0x23, 0xF0, 0x00, 0x07, 0xF1, 0xC2, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x83, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x0F, 0xCC, 0x0E, 0x36,
  0x0C, 0x0F, 0x0C, 0x03, 0x86, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0x80, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x10, 0x0E, 0x08, 0x07, 0x06,
  0x05, 0x03, 0x8C, 0x80, 0xFC, 0xC0, 0x07, 0xE1, 0xC6, 0x30, 0x32, 0x03,
  0x60, 0x3C, 0x06, 0xC0, 0xCF, 0xF8, 0xF0, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x70, 0xC3, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x09, 0x80, 0x07, 0x80, 0x00, 0x07, 0xE2,
  0x1C, 0x6C, 0x60, 0x79, 0x80, 0x73, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x40, 0x08, 0x80, 0x33, 0x00, 0x62, 0x01, 0xC4, 0x03, 0x8C, 0x0A,
  0x1C, 0x6C, 0x1F, 0x98, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x18, 0x70, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x7E, 0x1B, 0x1C, 0x58, 0x31,
  0xC0, 0x4E, 0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xD8, 0x02, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x90, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x00, 0x0C,
  0x30, 0xC0, 0x00, 0x01, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x86, 0x18, 0x61,
  0x84, 0x30, 0xC3, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x4C, 0x0F, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x03, 0x18, 0x38,
  0x41, 0xC1, 0x0C, 0x0C, 0x60, 0x33, 0x00, 0xD8, 0x02, 0xE0, 0x1E, 0xC0,
  0x73, 0x01, 0x86, 0x06, 0x18, 0x10, 0x30, 0xC0, 0xC3, 0x01, 0x8C, 0x06,
  0x00, 0x04, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC2,
  0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x00, 0x19, 0xF0, 0x7C, 0x26, 0x33,
  0x1C, 0x50, 0x6C, 0x18, 0xC0, 0x50, 0x33, 0x80, 0xC0, 0x66, 0x01, 0x80,
  0xCC, 0x06, 0x01, 0x90, 0x0C, 0x02, 0x60, 0x18, 0x0C, 0xC0, 0x20, 0x19,
  0x80, 0x40, 0x33, 0x01, 0x80, 0x64, 0x03, 0x00, 0x98, 0x06, 0x03, 0x30,
  0x08, 0x06, 0x60, 0x30, 0x0C, 0x19, 0xF8, 0x6C, 0x71, 0x60, 0xC7, 0x03,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x09, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x40, 0x1B, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0x07, 0xE0, 0xE3,
  0x8C, 0x06, 0xC0, 0x36, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x6C, 0x03, 0x60, 0x31, 0xC7, 0x07, 0xF0, 0x06,
  0x7E, 0x02, 0x63, 0x81, 0x60, 0xC0, 0xE0, 0x20, 0xE0, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0xC1, 0x80, 0x61, 0xE0, 0x60, 0xD8, 0xE0, 0x67, 0xE0, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xE2, 0x1C, 0x6C, 0x60, 0x79, 0x80, 0x73, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x40, 0x08, 0x80, 0x33, 0x00, 0x62, 0x01, 0xC4, 0x03,
  0x8C, 0x0A, 0x1C, 0x6C, 0x1F, 0x98, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x19, 0xE2, 0x64, 0x58,
  0x0E, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x0F, 0xF1, 0xC3, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x0C, 0xE1, 0xC7, 0xF0, 0x08, 0x18, 0x10, 0x30, 0xFF, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80,
  0xC4, 0xF8, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0x98, 0x02, 0x60, 0x19, 0x80,
  0x64, 0x01, 0xB0, 0x04, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x1C, 0x80,
  0xE3, 0x06, 0x8E, 0x36, 0x1F, 0x98, 0xC0, 0x0D, 0x00, 0x66, 0x03, 0x18,
  0x0C, 0x60, 0x61, 0x81, 0x86, 0x0C, 0x18, 0x20, 0x21, 0x80, 0x8C, 0x03,
  0x30, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x80, 0xC0,
  0x38, 0x0E, 0x06, 0x81, 0xE0, 0x4C, 0x1E, 0x0C, 0xC3, 0x60, 0xCC, 0x36,
  0x18, 0xC6, 0x61, 0x8C, 0x62, 0x30, 0xC4, 0x23, 0x0C, 0xC2, 0x60, 0xC8,
  0x26, 0x0D, 0x82, 0x40, 0xD0, 0x2C, 0x0F, 0x02, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x00, 0x18, 0x07, 0x0C, 0x0C, 0x04, 0x0C, 0x06, 0x18, 0x02, 0x30,
  0x03, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x06, 0xC0,
  0x0C, 0x60, 0x18, 0x60, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x18, 0x0C, 0x00,
  0xC1, 0x00, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80,
  0x20, 0xC0, 0x08, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C,
  0x80, 0x03, 0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x26, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x60, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x0C, 0x01, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x3C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x30, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0E, 0x07, 0x80, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0xF0, 0x10, 0x00,
  0x7E, 0x07, 0x9F, 0x78, 0x0F, 0x80,
};

const GFXglyph NotoSans_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 8, 7, 11, 3, -21 },
  { 24, 18, 21, 19, 1, -21 },
  { 72, 15, 25, 17, 1, -23 },
  { 119, 20, 22, 23, 2, -22 },
  { 174, 18, 22, 20, 1, -22 },
  { 224, 3, 7, 6, 3, -21 },
  { 227, 9, 26, 8, 1, -21 },
  { 257, 9, 26, 8, -2, -21 },
  { 287, 13, 13, 16, 3, -23 },
  { 309, 14, 14, 17, 2, -18 },
  { 334, 5, 7, 7, -1, -3 },
  { 339, 7, 2, 9, 1, -9 },
  { 341, 2, 3, 7, 1, -3 },
  { 342, 14, 21, 10, -1, -21 },
  { 379, 14, 22, 17, 2, -22 },
  { 418, 8, 21, 17, 5, -21 },
  { 439, 16, 22, 17, 0, -22 },
  { 483, 15, 22, 17, 1, -22 },
  { 525, 16, 21, 17, 0, -21 },
  { 567, 15, 21, 17, 1, -21 },
  { 607, 14, 22, 17, 2, -22 },
  { 646, 14, 21, 17, 3, -21 },
  { 683, 15, 22, 17, 1, -22 },
  { 725, 15, 22, 17, 1, -22 },
  { 767, 5, 16, 7, 1, -16 },
  { 777, 7, 20, 7, -1, -16 },
  { 795, 14, 14, 17, 2, -18 },
  { 820, 14, 7, 17, 2, -14 },
  { 833, 14, 14, 17, 2, -18 },
  { 858, 11, 22, 13, 2, -22 },
  { 889, 22, 24, 25, 2, -21 },
  { 955, 17, 21, 17, -2, -21 },
  { 1000, 17, 21, 18, 1, -21 },
  { 1045, 17, 22, 18, 2, -22 },
  { 1092, 18, 21, 20, 1, -21 },
  { 1140, 16, 21, 16, 1, -21 },
  { 1182, 16, 21, 14, 1, -21 },
  { 1224, 18, 22, 21, 2, -22 },
  { 1274, 19, 21, 20, 1, -21 },
  { 1324, 10, 21, 9, 0, -21 },
  { 1351, 13, 26, 8, -5, -21 },
  { 1394, 18, 21, 17, 1, -21 },
  { 1442, 11, 21, 15, 1, -21 },
  { 1471, 24, 21, 25, 1, -21 },
  { 1534, 20, 21, 21, 1, -21 },
  { 1587, 18, 22, 22, 2, -22 },
  { 1637, 16, 21, 17, 1, -21 },
  { 1679, 18, 27, 22, 2, -22 },
  { 1740, 16, 21, 17, 1, -21 },
  { 1782, 14, 22, 15, 1, -22 },
  { 1821, 14, 21, 15, 3, -21 },
  { 1858, 18, 21, 21, 3, -21 },
  { 1906, 16, 21, 16, 3, -21 },
  { 1948, 25, 21, 25, 3, -21 },
  { 2014, 20, 21, 15, -2, -21 },
  { 2067, 15, 21, 15, 3, -21 },
  { 2107, 17, 21, 16, 0, -21 },
  { 2152, 11, 26, 9, 0, -21 },
  { 2188, 5, 21, 10, 3, -21 },
  { 2202, 11, 26, 9, -2, -21 },
  { 2238, 15, 14, 17, 1, -22 },
  { 2265, 12, 1, 11, -3, 3 },
  { 2267, 5, 5, 8, 4, -23 },
  { 2271, 15, 16, 17, 1, -16 },
  { 2301, 15, 23, 17, 1, -23 },
  { 2345, 12, 16, 14, 2, -16 },
  { 2369, 17, 23, 17, 1, -23 },
  { 2418, 12, 16, 15, 2, -16 },
  { 2442, 17, 30, 9, -4, -23 },
  { 2506, 15, 23, 17, 1, -16 },
  { 2550, 14, 23, 17, 1, -23 },
  { 2591, 6, 22, 7, 1, -22 },
  { 2608, 11, 29, 7, -4, -22 },
  { 2648, 14, 23, 14, 1, -23 },
  { 2689, 6, 23, 7, 1, -23 },
  { 2707, 23, 16, 26, 1, -16 },
  { 2753, 14, 16, 17, 1, -16 },
  { 2781, 13, 16, 17, 2, -16 },
  { 2807, 17, 23, 17, -1, -16 },
  { 2856, 15, 23, 17, 1, -16 },
  { 2900, 11, 16, 12, 1, -16 },
  { 2922, 12, 16, 13, 0, -16 },
  { 2946, 8, 20, 10, 2, -20 },
  { 2966, 14, 16, 17, 2, -16 },
  { 2994, 14, 16, 13, 1, -16 },
  { 3022, 20, 16, 21, 2, -16 },
  { 3062, 16, 16, 14, -1, -16 },
  { 3094, 18, 23, 13, -3, -16 },
  { 3146, 13, 16, 13, 0, -16 },
  { 3172, 11, 26, 10, 1, -21 },
  { 3208, 2, 30, 16, 8, -23 },
  { 3216, 11, 26, 10, -1, -21 },
  { 3252, 14, 3, 17, 2, -12 },
};

const GFXfont NotoSans_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_LIGHTITALIC30PT7B_H_
