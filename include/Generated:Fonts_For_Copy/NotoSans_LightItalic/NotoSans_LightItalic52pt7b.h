#ifndef _NOTOSANS_LIGHTITALIC52PT7B_H_
#define _NOTOSANS_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x38, 0x39,
  0xC1, 0xDE, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xCC, 0x0C, 0xE0,
  0x67, 0x07, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xC3, 0x06, 0x03, 0x83, 0x80,
  0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x86,
  0x00, 0x01, 0xF3, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x37, 0xC0, 0x00, 0x38, 0xF0, 0x00,
  0x18, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xF0,
  0xC0, 0x70, 0xF0, 0x7E, 0x3B, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0xE0, 0x38, 0x38, 0x00,
  0x30, 0x1C, 0x06, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x70, 0x07, 0x00, 0x60, 0x38, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60,
  0x0E, 0x07, 0x00, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x00, 0xE1, 0xC0, 0x03,
  0x80, 0x30, 0x70, 0x70, 0xE0, 0x1C, 0x38, 0xFF, 0x38, 0x07, 0x1C, 0x7F,
  0xEE, 0x03, 0x8E, 0x3C, 0x39, 0x80, 0xC3, 0x8E, 0x07, 0x70, 0xF1, 0xC7,
  0x01, 0xCF, 0xF8, 0xE1, 0x80, 0x73, 0xFC, 0x30, 0xE0, 0x1C, 0x3C, 0x1C,
  0x38, 0x07, 0x00, 0x0E, 0x0C, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x01,
  0x81, 0xC0, 0x1C, 0x00, 0xE0, 0x70, 0x06, 0x00, 0x70, 0x18, 0x01, 0x80,
  0x38, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x18, 0x07, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0xE0, 0x38, 0x00, 0x78, 0x70, 0x1C, 0x00, 0x0F, 0xF8, 0x0E, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7C, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x01, 0xC7, 0x80, 0xF0, 0x03, 0x9E,
  0x00, 0xE0, 0x0E, 0x78, 0x00, 0xE0, 0x38, 0xE0, 0x00, 0xE0, 0x71, 0xC0,
  0x01, 0xE1, 0xC7, 0x00, 0x01, 0xC7, 0x8E, 0x00, 0x01, 0xDE, 0x1C, 0x00,
  0x03, 0xF8, 0x38, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1F, 0x80, 0xE0, 0x00, 0x7F, 0x81, 0xE0, 0x03, 0xE7, 0x01, 0xF0, 0x3F,
  0x07, 0x01, 0xFF, 0xF8, 0x0F, 0x00, 0xFF, 0xE0, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x39, 0xDE, 0xE7, 0x39, 0x8C, 0xE7, 0x31, 0x8C, 0x00, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x18, 0x06, 0x00, 0x78, 0x0C, 0x00, 0xFC, 0x18,
  0x00, 0x3E, 0x60, 0x00, 0x1F, 0xC0, 0x78, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x01, 0xCE, 0x00, 0x0F, 0x0C, 0x00,
  0x3C, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x30, 0x01, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0x0F, 0x0E,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFF, 0x13, 0xFF, 0xF7, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xE0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0xC0, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xC1, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xF0, 0x1F, 0xC0, 0xF6, 0x0F, 0xB8, 0x7C, 0xE7, 0xC3, 0xBE, 0x1E,
  0x60, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x03, 0x80, 0x60, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x20,
  0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x83, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x80, 0x00, 0xF0, 0x30,
  0x00, 0x78, 0x0F, 0x80, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xE0, 0x10, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x38, 0xFF, 0xE0, 0x1C, 0xFD, 0xFC,
  0x0E, 0xE0, 0x1E, 0x0E, 0xC0, 0x07, 0x87, 0xC0, 0x01, 0xC3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xF1, 0xE0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0x80,
  0xF0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x03,
  0xC0, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x07,
  0xC7, 0x80, 0x07, 0xC1, 0xC0, 0x07, 0xE0, 0xF8, 0x07, 0x70, 0x3F, 0xFF,
  0x38, 0x0F, 0xFE, 0x38, 0x01, 0xFC, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1C, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x78, 0x3E, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1E, 0x03, 0xC1, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x03,
  0xFF, 0xC0, 0x71, 0xC0, 0x0F, 0xFF, 0x80, 0xE7, 0x00, 0x78, 0x07, 0x00,
  0xCE, 0x01, 0xE0, 0x0E, 0x01, 0xB8, 0x07, 0x80, 0x18, 0x03, 0x70, 0x0E,
  0x00, 0x70, 0x06, 0xC0, 0x38, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x01, 0x80,
  0x1F, 0x01, 0xC0, 0x03, 0x00, 0x7E, 0x03, 0x80, 0x0E, 0x00, 0xFC, 0x07,
  0x00, 0x1C, 0x01, 0xF8, 0x0C, 0x00, 0x30, 0x03, 0x70, 0x18, 0x00, 0xE0,
  0x0E, 0xE0, 0x30, 0x01, 0xC0, 0x1D, 0xC0, 0x60, 0x07, 0x80, 0x73, 0x80,
  0xE0, 0x1F, 0x01, 0xC7, 0x01, 0xC0, 0x76, 0x03, 0x8E, 0x03, 0xC1, 0xCE,
  0x1E, 0x1C, 0x03, 0xFF, 0x1F, 0xF8, 0x18, 0x03, 0xFC, 0x1F, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xE0, 0x0F, 0xC0, 0x01,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3E, 0x00,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x8E, 0x00, 0x0F, 0xFF, 0x1C,
  0x00, 0x1F, 0xFE, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x07, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x01,
  0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x3E,
  0x00, 0x00, 0x0C, 0xFC, 0x00, 0x00, 0x3B, 0xB8, 0x00, 0x00, 0x7E, 0x38,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x0E, 0xC0, 0x00, 0x03, 0xB8,
  0x07, 0x60, 0x00, 0x03, 0xB8, 0x03, 0x38, 0x00, 0x01, 0xDC, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x71, 0x80, 0x00, 0xE3, 0x80, 0x30, 0xC0, 0x00, 0x71, 0xC0,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x0E, 0x1C,
  0x00, 0x38, 0x38, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x03, 0x81, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0xC0, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x83, 0x80, 0x70, 0x06, 0x00, 0xC1, 0xC0, 0x38, 0x07,
  0x00, 0x71, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x70, 0x03,
  0x80, 0x70, 0x01, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x1C,
  0x00, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x7E, 0x00, 0x00, 0xE0, 0x1D, 0xC0, 0x00, 0x38, 0x06, 0x70, 0x00,
  0x1C, 0x03, 0x8E, 0x00, 0x07, 0x00, 0xE3, 0x80, 0x01, 0xC0, 0x38, 0xE0,
  0x00, 0x70, 0x0E, 0x1C, 0x00, 0x18, 0x03, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x38, 0x07,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x0E,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x70, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x38,
  0x38, 0x07, 0x00, 0x0E, 0x0E, 0x01, 0x80, 0x01, 0xC7, 0x00, 0xE0, 0x00,
  0x71, 0xC0, 0x38, 0x00, 0x0E, 0x70, 0x0E, 0x00, 0x03, 0x9C, 0x03, 0x80,
  0x00, 0xE6, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xE0, 0x1C,
  0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x3E,
  0x01, 0xE0, 0x01, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x0C, 0x00, 0x1F, 0x03, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x14, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x18, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x38, 0x00,
  0x1B, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xB8,
  0x00, 0x70, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x38, 0x00, 0x73, 0x80, 0x0E,
  0x06, 0x00, 0x38, 0xE0, 0x03, 0x81, 0x80, 0x0E, 0x38, 0x01, 0xC0, 0x60,
  0x07, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC1, 0x80, 0x3C, 0x07, 0x00, 0xE0,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x06, 0x01,
  0xC0, 0x1C, 0x07, 0x01, 0x80, 0x70, 0x07, 0x01, 0x80, 0x60, 0x38, 0x01,
  0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0x70, 0x30, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x1B, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x30, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x38, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x07, 0x00, 0x3F,
  0x83, 0x80, 0x7F, 0xE1, 0x80, 0xFC, 0xF8, 0xC0, 0xF8, 0x0E, 0xE0, 0xF0,
  0x03, 0x70, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x83, 0x80, 0x0F, 0xC1, 0xE0, 0x0E,
  0xE0, 0x70, 0x0E, 0x60, 0x3E, 0x1E, 0x30, 0x0F, 0xFE, 0x18, 0x03, 0xFC,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x3F, 0x80, 0x38, 0x7F,
  0xE0, 0x1C, 0xF9, 0xF8, 0x0E, 0xE0, 0x1E, 0x06, 0x60, 0x07, 0x07, 0x60,
  0x03, 0xC3, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0D, 0x80, 0x0F, 0x0E, 0xE0, 0x0F,
  0x07, 0x38, 0x1F, 0x03, 0x0F, 0xFF, 0x01, 0x83, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFE, 0x7C, 0x0F, 0x80,
  0x20, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x81, 0xF0, 0x1C, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0x83, 0x80, 0x1F, 0xFE, 0x38, 0x03, 0xF3, 0xF3, 0x80,
  0x78, 0x03, 0x30, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x1C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0xF8, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xB0, 0x0F, 0x00, 0x33,
  0x00, 0x70, 0x0E, 0x70, 0x07, 0xC3, 0xC7, 0x00, 0x3F, 0xF8, 0x70, 0x01,
  0xFF, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0xFE, 0x7C, 0x0F, 0x80, 0xF0, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x70,
  0x00, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x03, 0x9C, 0x00, 0x3C,
  0xE0, 0x07, 0xCF, 0x03, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0xC1, 0xF0, 0x1E, 0x07, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x08, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x60, 0x0F, 0xFF, 0x1C, 0x03, 0xF9, 0xF3,
  0x80, 0xF0, 0x06, 0x60, 0x3C, 0x00, 0x6C, 0x0F, 0x00, 0x0F, 0x81, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xE0, 0x70, 0x00, 0x7C, 0x0E, 0x00, 0x1B, 0x01, 0xE0, 0x06, 0xE0, 0x1C,
  0x03, 0x9C, 0x03, 0xE1, 0xE3, 0x80, 0x3F, 0xF8, 0x70, 0x03, 0xFE, 0x1C,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x0C, 0x00, 0x3C, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x03, 0xF8, 0x07, 0x0F, 0xFC, 0x07,
  0x1F, 0x3E, 0x07, 0x78, 0x0F, 0x06, 0x60, 0x07, 0x0E, 0xC0, 0x07, 0x0F,
  0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x08, 0x78, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x3C,
  0x07, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x0E, 0x03, 0xC0,
  0x0E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x19, 0xF0, 0x00, 0x3B, 0xB8, 0x00,
  0x3F, 0x38, 0x00, 0x3E, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x60, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x07, 0x07,
  0xF0, 0x03, 0xF0, 0x07, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0x3E, 0x7C, 0x3E,
  0x7E, 0x06, 0x70, 0x1C, 0x78, 0x1E, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x0E,
  0xC0, 0x0E, 0xC0, 0x07, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x00, 0x0E,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x81, 0xFC, 0x00, 0xE1, 0xFF,
  0xC0, 0x39, 0xFB, 0xF0, 0x0C, 0xF0, 0x1E, 0x07, 0x70, 0x03, 0x81, 0xD8,
  0x00, 0xE0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x07, 0xC0,
  0x3C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xE0, 0x7F, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0xE3, 0xCF, 0xC0,
  0x0C, 0xF0, 0x1E, 0x00, 0xCC, 0x00, 0xE0, 0x1D, 0x80, 0x0F, 0x01, 0xF0,
  0x00, 0x70, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x80, 0xD8, 0x00,
  0xF0, 0x1D, 0xC0, 0x1E, 0x01, 0xCE, 0x07, 0xC0, 0x1C, 0x7F, 0xF8, 0x01,
  0xC3, 0xFE, 0x00, 0x38, 0x02, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81,
  0x80, 0xFF, 0xF1, 0xC0, 0xFE, 0xFC, 0xE0, 0xF0, 0x0E, 0x60, 0xF0, 0x03,
  0xB0, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x87, 0x00, 0x07, 0xC3, 0x80, 0x06, 0xC1, 0xE0, 0x06, 0xE0,
  0x70, 0x0E, 0x70, 0x3E, 0x1E, 0x38, 0x0F, 0xFE, 0x1C, 0x03, 0xFE, 0x1C,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x07, 0xE0, 0xE1, 0xFC, 0x1C, 0xFF, 0x83, 0x3C, 0x00,
  0x6E, 0x00, 0x1D, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xC0, 0xFC, 0x7E, 0x0F, 0x00, 0x20, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0xC0, 0x03, 0x87, 0xC0, 0x7C, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x20, 0x7F, 0xC0, 0x7F, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x83, 0x80, 0x07, 0xC1, 0xC0, 0x06, 0xE0, 0xF0,
  0x0E, 0x70, 0x3C, 0x1E, 0x30, 0x1F, 0xFE, 0x18, 0x03, 0xFC, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xB8,
  0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x18, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0,
  0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0,
  0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x0F, 0x80,
  0x0E, 0xE0, 0x07, 0x60, 0x07, 0xB8, 0x01, 0xD8, 0x01, 0xCE, 0x00, 0xE6,
  0x00, 0xF3, 0x80, 0x39, 0x80, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x38, 0x07,
  0x18, 0x07, 0x0E, 0x01, 0x86, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0x60,
  0x30, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x06, 0x06, 0x07, 0x07, 0x01,
  0xC3, 0x81, 0xC3, 0x80, 0x70, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x1C, 0x70,
  0x07, 0x18, 0x07, 0x1C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x33,
  0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x07, 0x60, 0x03, 0x70, 0x01, 0xF8, 0x00,
  0xDC, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0xF0,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0,
  0x01, 0x7F, 0xF8, 0x03, 0xF1, 0xFE, 0x0F, 0xC0, 0x1F, 0xFE, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x40,
};

const GFXglyph NotoSans_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 38, 12, 1, -37 },
  { 58, 13, 13, 18, 6, -37 },
  { 80, 31, 37, 33, 2, -37 },
  { 224, 25, 42, 29, 2, -39 },
  { 356, 34, 39, 41, 4, -38 },
  { 522, 31, 39, 35, 2, -38 },
  { 674, 5, 13, 10, 6, -37 },
  { 683, 16, 45, 14, 2, -37 },
  { 773, 16, 45, 14, -4, -37 },
  { 863, 23, 23, 28, 6, -40 },
  { 930, 24, 25, 30, 4, -31 },
  { 1005, 8, 13, 11, -2, -6 },
  { 1018, 12, 2, 16, 2, -15 },
  { 1021, 5, 6, 12, 1, -5 },
  { 1025, 24, 37, 17, -2, -37 },
  { 1136, 25, 39, 29, 3, -38 },
  { 1258, 14, 37, 29, 8, -37 },
  { 1323, 27, 38, 29, 0, -38 },
  { 1452, 26, 39, 29, 1, -38 },
  { 1579, 27, 37, 29, 1, -37 },
  { 1704, 26, 38, 29, 2, -37 },
  { 1828, 25, 39, 29, 3, -38 },
  { 1950, 24, 37, 29, 5, -37 },
  { 2061, 26, 39, 29, 2, -38 },
  { 2188, 25, 39, 29, 2, -38 },
  { 2310, 10, 29, 12, 1, -28 },
  { 2347, 13, 35, 12, -2, -28 },
  { 2404, 24, 24, 30, 4, -31 },
  { 2476, 24, 13, 30, 4, -25 },
  { 2515, 24, 24, 30, 4, -31 },
  { 2587, 19, 39, 22, 4, -38 },
  { 2680, 39, 42, 44, 3, -37 },
  { 2885, 29, 37, 29, -3, -37 },
  { 3020, 28, 37, 31, 2, -37 },
  { 3150, 29, 39, 31, 4, -38 },
  { 3292, 31, 37, 35, 2, -37 },
  { 3436, 27, 37, 27, 2, -37 },
  { 3561, 27, 37, 25, 2, -37 },
  { 3686, 31, 39, 36, 4, -38 },
  { 3838, 33, 37, 35, 2, -37 },
  { 3991, 18, 37, 16, 0, -37 },
  { 4075, 21, 46, 13, -8, -37 },
  { 4196, 31, 37, 29, 2, -37 },
  { 4340, 20, 37, 25, 2, -37 },
  { 4433, 41, 37, 43, 2, -37 },
  { 4623, 34, 37, 36, 2, -37 },
  { 4781, 32, 39, 37, 4, -38 },
  { 4937, 27, 37, 29, 2, -37 },
  { 5062, 32, 47, 37, 4, -38 },
  { 5250, 27, 37, 30, 2, -37 },
  { 5375, 26, 39, 26, 1, -38 },
  { 5502, 25, 37, 26, 5, -37 },
  { 5618, 32, 38, 36, 4, -37 },
  { 5770, 28, 37, 28, 5, -37 },
  { 5900, 42, 37, 44, 6, -37 },
  { 6095, 34, 37, 26, -3, -37 },
  { 6253, 26, 37, 26, 5, -37 },
  { 6374, 30, 37, 28, 0, -37 },
  { 6513, 19, 45, 15, 0, -37 },
  { 6620, 9, 37, 17, 5, -37 },
  { 6662, 20, 45, 15, -4, -37 },
  { 6775, 25, 23, 29, 2, -37 },
  { 6847, 21, 3, 20, -5, 5 },
  { 6855, 7, 8, 13, 8, -40 },
  { 6862, 25, 29, 29, 3, -28 },
  { 6953, 25, 41, 30, 2, -40 },
  { 7082, 21, 29, 24, 3, -28 },
  { 7159, 28, 41, 30, 3, -40 },
  { 7303, 21, 29, 26, 3, -28 },
  { 7380, 28, 52, 15, -6, -40 },
  { 7562, 27, 40, 30, 1, -28 },
  { 7697, 24, 40, 29, 2, -40 },
  { 7817, 11, 38, 12, 2, -38 },
  { 7870, 20, 50, 12, -7, -38 },
  { 7995, 24, 40, 24, 2, -40 },
  { 8115, 11, 40, 12, 2, -40 },
  { 8170, 40, 28, 45, 2, -28 },
  { 8310, 26, 28, 29, 1, -28 },
  { 8401, 24, 28, 29, 3, -28 },
  { 8485, 28, 40, 30, -1, -28 },
  { 8625, 25, 40, 30, 3, -28 },
  { 8750, 19, 28, 20, 2, -28 },
  { 8817, 21, 29, 22, 0, -28 },
  { 8894, 15, 35, 17, 3, -34 },
  { 8960, 25, 29, 29, 3, -28 },
  { 9051, 22, 28, 23, 3, -28 },
  { 9128, 34, 28, 36, 3, -28 },
  { 9247, 27, 28, 24, -2, -28 },
  { 9342, 30, 41, 23, -5, -28 },
  { 9496, 24, 28, 23, -1, -28 },
  { 9580, 19, 45, 18, 1, -37 },
  { 9687, 3, 53, 28, 14, -40 },
  { 9707, 19, 45, 18, -2, -37 },
  { 9814, 24, 6, 30, 4, -21 },
};

const GFXfont NotoSans_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_LIGHTITALIC52PT7B_H_
