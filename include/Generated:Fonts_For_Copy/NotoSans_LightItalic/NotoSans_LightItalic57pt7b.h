#ifndef _NOTOSANS_LIGHTITALIC57PT7B_H_
#define _NOTOSANS_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x01, 0x00, 0x00, 0x1C, 0x0E,
  0x38, 0x3C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x18,
  0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0E,
  0x38, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFE, 0xFE, 0x01, 0xF0, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x81, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x06,
  0xFC, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x1E,
  0x08, 0x01, 0x83, 0xC0, 0xF0, 0x38, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x0E,
  0x03, 0xE7, 0xC0, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1C, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x06,
  0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x0E, 0x0E, 0x0F, 0x87, 0x00, 0x70,
  0xE1, 0xFF, 0x38, 0x07, 0x0E, 0x1F, 0xF9, 0xC0, 0x38, 0x71, 0xE0, 0xEE,
  0x03, 0x87, 0x1E, 0x07, 0x78, 0x3C, 0x70, 0xE0, 0x1D, 0xF7, 0xC7, 0x0E,
  0x00, 0xE7, 0xFC, 0x38, 0x70, 0x07, 0x1F, 0x83, 0x87, 0x00, 0x38, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x1C, 0x0C, 0x00,
  0x60, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x38, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x38,
  0x00, 0x1E, 0x3C, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x38, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xB8,
  0x00, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x78,
  0x07, 0x00, 0x0E, 0x1E, 0x00, 0xF0, 0x03, 0x87, 0x80, 0x0F, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0x1E, 0x07, 0x87, 0x00, 0x01, 0xE0,
  0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x3C, 0x00, 0x01, 0xCF, 0x07, 0x80, 0x00,
  0x3F, 0xC0, 0xF0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x01, 0xF7, 0x80,
  0x78, 0x00, 0xF8, 0x70, 0x07, 0xE0, 0xFE, 0x0F, 0x00, 0x7F, 0xFF, 0x00,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x05, 0x00, 0x00, 0x00, 0x1C, 0x73,
  0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x80,
  0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xF8, 0x1C, 0x00, 0xFC, 0x18, 0x00, 0x3F,
  0x18, 0x00, 0x07, 0xD8, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x8E, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x78, 0x07, 0x80, 0x30,
  0x03, 0x80, 0x10, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x39, 0xE7, 0xFE, 0x78, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x81, 0xC0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFB, 0x87,
  0xC7, 0x3F, 0x1E, 0xF8, 0x3C, 0xC0, 0x71, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x40, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x08, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x1C, 0x01,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x08, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x7C, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x3F, 0xE0, 0x07,
  0x1F, 0xFF, 0x01, 0xE7, 0xEF, 0xF0, 0x39, 0xC0, 0x1F, 0x07, 0x60, 0x01,
  0xE0, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x07, 0xE3,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07,
  0xC0, 0x07, 0xC0, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x70, 0x00, 0x1F, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0xDC, 0x1E, 0x00, 0x77, 0x81, 0xF0, 0x3C, 0xE0, 0x1F,
  0xFF, 0x1C, 0x01, 0xFF, 0x87, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x1E, 0x01, 0x00, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x38,
  0x03, 0xE1, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00, 0x03, 0xFE, 0x00, 0x70, 0xE0,
  0x03, 0xFF, 0xF0, 0x0E, 0x38, 0x00, 0xFC, 0x3E, 0x01, 0xC7, 0x00, 0x3C,
  0x01, 0xC0, 0x39, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0x6E, 0x00, 0xE0, 0x01, 0xC0, 0x0D, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0xB8, 0x07, 0x00, 0x06, 0x00, 0x77, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0xC0,
  0x38, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xDC, 0x03, 0x80, 0x07,
  0x00, 0x3B, 0x80, 0x70, 0x01, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0x7C, 0x01,
  0xCE, 0x01, 0xC0, 0x0F, 0x80, 0x71, 0xC0, 0x38, 0x03, 0x70, 0x1E, 0x38,
  0x03, 0x81, 0xE7, 0x07, 0x83, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x70, 0x07,
  0xFC, 0x0F, 0xF0, 0x0E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0xF8, 0x07,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x38,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x02, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x07, 0xFC,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xF0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x03, 0xF0, 0x07, 0x80,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x1C, 0x00, 0x0F, 0xFF, 0x87,
  0x00, 0x03, 0xFF, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x70, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xE7, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0x00, 0x70, 0x0F, 0x80, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x00, 0xEE, 0x70, 0x00,
  0x00, 0x7E, 0x38, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xD8,
  0x00, 0x00, 0x0F, 0xE0, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x01, 0xDC, 0x00,
  0x00, 0x1D, 0xE0, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x03, 0xDC, 0x00, 0x00,
  0x39, 0xC0, 0x39, 0xC0, 0x00, 0x07, 0x9C, 0x03, 0x9C, 0x00, 0x00, 0x71,
  0xC0, 0x38, 0xE0, 0x00, 0x0F, 0x3C, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x78, 0xE0, 0x00, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x00, 0x38, 0x78, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x70, 0x60,
  0x00, 0x70, 0x70, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x81, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x87,
  0x80, 0x3C, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x80, 0x78, 0x01, 0xCF, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xDC, 0x00, 0x78,
  0x07, 0x00, 0x1D, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xF8, 0x00, 0x70, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x1F, 0x80, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00,
  0x0E, 0x01, 0xDC, 0x00, 0x00, 0xE0, 0x1D, 0xC0, 0x00, 0x0E, 0x03, 0x9E,
  0x00, 0x01, 0xE0, 0x38, 0xE0, 0x00, 0x1C, 0x03, 0x8F, 0x00, 0x01, 0xC0,
  0x38, 0x70, 0x00, 0x1C, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x78, 0x78, 0x00,
  0x3C, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70, 0x3C, 0x00, 0x38, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x1E, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x1C, 0x00,
  0x38, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x00, 0x1C, 0x0E, 0x03,
  0xC0, 0x01, 0xC1, 0xE0, 0x38, 0x00, 0x1E, 0x1C, 0x03, 0x80, 0x00, 0xE1,
  0xC0, 0x38, 0x00, 0x0F, 0x1C, 0x03, 0x80, 0x00, 0x71, 0xC0, 0x78, 0x00,
  0x07, 0x3C, 0x07, 0x00, 0x00, 0x7B, 0x80, 0x70, 0x00, 0x03, 0xB8, 0x07,
  0x00, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x00, 0x1F,
  0x80, 0xE0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x3F, 0xC0, 0x1E, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x3F, 0xC0, 0x1E,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0x00, 0xE0, 0x1F, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x7C, 0x0E, 0x00,
  0x0F, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xEE,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0x80, 0x00, 0xF3, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x73, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0xF0, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x07, 0x03, 0x80, 0x1C,
  0x07, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38,
  0x0E, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x30, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x1C, 0x03, 0xFF, 0xE3, 0x81, 0xF8, 0x1C,
  0x70, 0x3C, 0x01, 0xCC, 0x0F, 0x00, 0x1B, 0x83, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E,
  0x00, 0x1B, 0x81, 0xC0, 0x06, 0x70, 0x3C, 0x03, 0x8E, 0x03, 0xE1, 0xE1,
  0x80, 0x3F, 0xF8, 0x70, 0x03, 0xFE, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x38, 0x3F, 0xF0,
  0x03, 0x8F, 0xFF, 0x80, 0x39, 0xE0, 0x7C, 0x07, 0x38, 0x03, 0xC0, 0x77,
  0x00, 0x1E, 0x07, 0x60, 0x00, 0xE0, 0x7C, 0x00, 0x0E, 0x0F, 0x80, 0x00,
  0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x7C, 0x00,
  0x03, 0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0,
  0x76, 0x00, 0x3E, 0x0E, 0x70, 0x07, 0xC0, 0xE3, 0xC1, 0xF8, 0x0E, 0x1F,
  0xFE, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x70, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x03, 0x01, 0xF8, 0x3E, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x07, 0x00, 0x0F, 0xFE, 0x1E, 0x00,
  0x3F, 0xFE, 0x38, 0x01, 0xF8, 0x1E, 0x70, 0x07, 0xC0, 0x0E, 0xE0, 0x0F,
  0x00, 0x0D, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x06, 0xE0, 0x1E, 0x00, 0x1D, 0xC0, 0x1C, 0x00, 0x77, 0x00,
  0x3C, 0x03, 0xCE, 0x00, 0x3E, 0x1F, 0x1C, 0x00, 0x3F, 0xF8, 0x38, 0x00,
  0x3F, 0xE0, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x3C, 0x01, 0xE0, 0xF0,
  0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x78, 0x00,
  0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x0F, 0x8E, 0x00, 0x7E,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x03, 0x81, 0xF8, 0x3F, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x21, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x03, 0xFF, 0xE1,
  0x80, 0x3F, 0x03, 0xCE, 0x01, 0xF0, 0x03, 0xB8, 0x07, 0x80, 0x06, 0xE0,
  0x3C, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1B, 0x80, 0xF0,
  0x00, 0xFE, 0x01, 0xC0, 0x07, 0x70, 0x07, 0x80, 0x79, 0xC0, 0x0F, 0x87,
  0xC7, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x07, 0x07,
  0xFE, 0x00, 0xE3, 0xFF, 0xE0, 0x1C, 0xF8, 0x3E, 0x07, 0x3C, 0x01, 0xC0,
  0xEE, 0x00, 0x3C, 0x1D, 0x80, 0x03, 0x83, 0xE0, 0x00, 0x70, 0xF8, 0x00,
  0x0E, 0x1F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x87, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x02, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x73, 0xE0, 0x00,
  0x0E, 0xFE, 0x00, 0x01, 0xFD, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x0F, 0xC3,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x01,
  0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x38, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0x8F, 0xFF, 0x03, 0xFF, 0xC0, 0x31, 0xE0, 0xF0, 0x78, 0x3E, 0x07, 0x38,
  0x07, 0x8E, 0x01, 0xE0, 0x77, 0x00, 0x39, 0xC0, 0x0E, 0x07, 0x60, 0x03,
  0xB8, 0x00, 0xF0, 0x7C, 0x00, 0x3B, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE1,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x7F, 0xF0, 0x0E, 0x3F,
  0xFF, 0x03, 0x8F, 0x83, 0xE0, 0x73, 0xC0, 0x1E, 0x0E, 0xE0, 0x03, 0xC1,
  0xF8, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x0F, 0x80, 0x00, 0xE1, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x78, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x78, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x78,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xE0, 0xFF, 0xC0, 0x01, 0xC7, 0xFF, 0xC0, 0x03, 0x1E, 0x07, 0xC0,
  0x0E, 0x70, 0x07, 0x80, 0x1D, 0xC0, 0x07, 0x80, 0x3B, 0x00, 0x07, 0x00,
  0x7C, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x07,
  0x80, 0x3B, 0x00, 0x1F, 0x00, 0xF7, 0x00, 0x7C, 0x01, 0xC7, 0x83, 0xF0,
  0x03, 0x87, 0xFF, 0x80, 0x07, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0x00, 0xFF, 0xF8, 0x60, 0x3F, 0x03,
  0xCE, 0x07, 0xC0, 0x0E, 0xE0, 0x78, 0x00, 0x6E, 0x0F, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x6E, 0x0F, 0x00, 0x0F, 0xE0, 0x70, 0x01, 0xDC, 0x07, 0x80, 0x79,
  0xC0, 0x3E, 0x1F, 0x1C, 0x01, 0xFF, 0xC3, 0xC0, 0x0F, 0xF8, 0x3C, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x1C, 0x1F, 0xC0, 0xE3, 0xFE, 0x06, 0x3E, 0x10, 0x73, 0x80, 0x03, 0xB8,
  0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xF0, 0x0F, 0x0F, 0x00, 0x08, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x88, 0x00, 0x1C, 0x30, 0x01, 0xF0,
  0xF8, 0x1F, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x0C, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C,
  0x38, 0x00, 0x1F, 0x87, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xDC, 0x1E, 0x00,
  0x33, 0x81, 0xE0, 0x1E, 0x70, 0x3F, 0x1F, 0x8C, 0x03, 0xFF, 0xC3, 0x80,
  0x3F, 0xF0, 0x70, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0xEF, 0x00, 0x0F, 0x80, 0x07, 0xBC, 0x00, 0x7E, 0x00, 0x1C,
  0xF0, 0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x0E, 0xE0, 0x03, 0x87, 0x00, 0x3B,
  0x80, 0x1E, 0x1C, 0x01, 0xCE, 0x00, 0x70, 0x70, 0x07, 0x38, 0x01, 0xC1,
  0xC0, 0x3C, 0x60, 0x0F, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x1C, 0x07, 0x87,
  0x01, 0xE0, 0x70, 0x1C, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x70, 0x3C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x1E, 0x07, 0x07, 0x80, 0x70, 0x70, 0x1C,
  0x1C, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x31,
  0xC0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x38, 0x00, 0x77,
  0x00, 0x0D, 0xC0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x19, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x83,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x27, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xEC, 0x00, 0x3F, 0xF9, 0x00, 0x01, 0xFC,
  0x00,
};

const GFXglyph NotoSans_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 42, 13, 1, -41 },
  { 70, 15, 15, 20, 6, -41 },
  { 99, 34, 41, 36, 2, -41 },
  { 274, 28, 46, 31, 2, -43 },
  { 435, 37, 42, 45, 5, -41 },
  { 630, 35, 42, 39, 2, -41 },
  { 814, 6, 15, 11, 6, -41 },
  { 826, 17, 50, 15, 2, -41 },
  { 933, 17, 50, 15, -4, -41 },
  { 1040, 24, 25, 31, 7, -43 },
  { 1115, 27, 27, 33, 4, -34 },
  { 1207, 10, 14, 13, -3, -7 },
  { 1225, 14, 3, 18, 2, -17 },
  { 1231, 6, 6, 13, 1, -5 },
  { 1236, 27, 41, 19, -3, -41 },
  { 1375, 26, 42, 31, 4, -41 },
  { 1512, 15, 41, 31, 9, -41 },
  { 1589, 30, 41, 31, 0, -41 },
  { 1743, 29, 42, 31, 1, -41 },
  { 1896, 29, 41, 31, 1, -41 },
  { 2045, 29, 42, 31, 2, -41 },
  { 2198, 27, 42, 31, 4, -41 },
  { 2340, 26, 41, 31, 6, -41 },
  { 2474, 28, 42, 31, 3, -41 },
  { 2621, 27, 42, 31, 3, -41 },
  { 2763, 11, 32, 13, 1, -31 },
  { 2807, 15, 38, 13, -3, -31 },
  { 2879, 27, 27, 33, 4, -34 },
  { 2971, 27, 14, 33, 4, -27 },
  { 3019, 27, 27, 33, 4, -34 },
  { 3111, 21, 42, 24, 4, -41 },
  { 3222, 43, 45, 48, 3, -40 },
  { 3464, 32, 41, 32, -3, -41 },
  { 3628, 30, 41, 34, 3, -41 },
  { 3782, 32, 42, 34, 4, -41 },
  { 3950, 33, 41, 38, 3, -41 },
  { 4120, 29, 41, 30, 3, -41 },
  { 4269, 29, 41, 27, 3, -41 },
  { 4418, 34, 42, 39, 4, -41 },
  { 4597, 36, 41, 39, 3, -41 },
  { 4782, 20, 41, 17, 0, -41 },
  { 4885, 24, 51, 14, -9, -41 },
  { 5038, 33, 41, 32, 3, -41 },
  { 5208, 21, 41, 28, 3, -41 },
  { 5316, 44, 41, 47, 3, -41 },
  { 5542, 36, 41, 39, 3, -41 },
  { 5727, 35, 42, 41, 4, -41 },
  { 5911, 29, 41, 32, 3, -41 },
  { 6060, 35, 51, 41, 4, -41 },
  { 6284, 29, 41, 32, 3, -41 },
  { 6433, 28, 42, 29, 1, -41 },
  { 6580, 28, 41, 28, 5, -41 },
  { 6724, 34, 42, 39, 5, -41 },
  { 6903, 30, 41, 31, 6, -41 },
  { 7057, 45, 41, 48, 7, -41 },
  { 7288, 36, 41, 29, -3, -41 },
  { 7473, 29, 41, 28, 5, -41 },
  { 7622, 34, 41, 31, -1, -41 },
  { 7797, 22, 50, 17, -1, -41 },
  { 7935, 10, 41, 19, 6, -41 },
  { 7987, 21, 50, 17, -4, -41 },
  { 8119, 27, 25, 32, 3, -41 },
  { 8204, 22, 2, 22, -5, 6 },
  { 8210, 8, 9, 14, 8, -44 },
  { 8219, 27, 32, 32, 3, -31 },
  { 8327, 28, 44, 33, 2, -43 },
  { 8481, 23, 32, 26, 3, -31 },
  { 8573, 31, 44, 33, 3, -43 },
  { 8744, 23, 32, 28, 3, -31 },
  { 8836, 31, 58, 17, -7, -44 },
  { 9061, 30, 45, 33, 1, -31 },
  { 9230, 27, 43, 32, 2, -43 },
  { 9376, 12, 42, 13, 2, -42 },
  { 9439, 22, 56, 13, -8, -42 },
  { 9593, 27, 43, 27, 2, -43 },
  { 9739, 12, 43, 13, 2, -43 },
  { 9804, 44, 31, 49, 2, -31 },
  { 9975, 27, 31, 32, 2, -31 },
  { 10080, 26, 32, 32, 3, -31 },
  { 10184, 31, 44, 33, -1, -31 },
  { 10355, 28, 44, 33, 3, -31 },
  { 10509, 21, 31, 22, 2, -31 },
  { 10591, 22, 32, 24, 1, -31 },
  { 10679, 17, 39, 18, 3, -38 },
  { 10762, 27, 31, 32, 3, -30 },
  { 10867, 25, 30, 25, 3, -30 },
  { 10961, 38, 30, 39, 3, -30 },
  { 11104, 30, 30, 27, -2, -30 },
  { 11217, 34, 44, 25, -6, -30 },
  { 11404, 26, 30, 25, -1, -30 },
  { 11502, 21, 50, 19, 1, -41 },
  { 11634, 3, 57, 31, 15, -43 },
  { 11656, 21, 50, 19, -2, -41 },
  { 11788, 27, 6, 33, 4, -23 },
};

const GFXfont NotoSans_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_LIGHTITALIC57PT7B_H_
