#ifndef _NOTOSANS_LIGHTITALIC39PT7B_H_
#define _NOTOSANS_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x38, 0x1C, 0x00, 0x30, 0xCC, 0x33,
  0x0D, 0xC7, 0x61, 0x98, 0x66, 0x19, 0x06, 0x41, 0x30, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x60, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80, 0x03, 0x01,
  0x00, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x06, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0xF3, 0x0C, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x82, 0x00, 0x61,
  0x80, 0x1C, 0x60, 0x03, 0x98, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x37, 0x80, 0x0C, 0xE0, 0x02, 0x1C, 0x00, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x06, 0x18, 0x01, 0x0E, 0x30, 0xCF, 0x0F, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x03, 0x03, 0xF8, 0x01, 0x81, 0x86, 0x00, 0xE0, 0xC0, 0xC0, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x07, 0x01, 0x80, 0xC1, 0x80,
  0x60, 0x60, 0xC0, 0x30, 0x18, 0x60, 0x0C, 0x06, 0x38, 0x03, 0x01, 0x8C,
  0x7C, 0xC0, 0xC6, 0x7F, 0xB0, 0x33, 0x18, 0x66, 0x18, 0xCC, 0x19, 0xFC,
  0x63, 0x03, 0x3E, 0x31, 0x80, 0xC0, 0x18, 0x60, 0x20, 0x06, 0x18, 0x18,
  0x03, 0x0C, 0x06, 0x01, 0x83, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x07, 0x00, 0xC1, 0x81, 0x80,
  0x1D, 0xC0, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x06,
  0x07, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0E, 0x38,
  0x00, 0x0D, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xD8, 0x00,
  0x0E, 0x18, 0x03, 0x30, 0x38, 0x0C, 0xC0, 0x38, 0x1B, 0x80, 0x30, 0x66,
  0x00, 0x31, 0xCC, 0x00, 0x77, 0x18, 0x00, 0x7C, 0x30, 0x00, 0x70, 0x60,
  0x01, 0xE0, 0xE0, 0x07, 0xE1, 0xE0, 0x3C, 0xC1, 0xFF, 0xE0, 0xC0, 0xFF,
  0x01, 0xC0, 0x33, 0x37, 0x66, 0x64, 0x4C, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x0E,
  0x00, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x04, 0x06, 0x03,
  0x82, 0x03, 0xE3, 0x00, 0x3D, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xD0,
  0x00, 0xCC, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x20, 0x70, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x1C, 0x30,
  0xE1, 0x87, 0x0C, 0x38, 0x61, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0E, 0x0E, 0x03, 0x80,
  0xE0, 0xE0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00,
  0xE6, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x06,
  0x70, 0x01, 0xCE, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x70,
  0x70, 0x0C, 0x07, 0x07, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xE0,
  0x38, 0x1F, 0x0F, 0x63, 0xDD, 0xE3, 0x10, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x03, 0xC0, 0xE0, 0x30, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x3E, 0x07, 0x83, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x18, 0x01,
  0xC3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x1C, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x30, 0x01,
  0x81, 0x80, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x1C, 0x03, 0x81, 0xC0, 0x18, 0x1C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xDF, 0x80, 0x0F, 0xFE, 0x00, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x0C, 0x01,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1C,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x8F, 0xE0, 0x6F, 0xFE, 0x3F,
  0x03, 0x8F, 0x00, 0x73, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x38,
  0xE0, 0x0C, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x00, 0x70, 0xE0, 0x0E,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x00, 0xC0, 0xC0, 0x38,
  0x1C, 0x0E, 0x01, 0xC7, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xEE, 0x00,
  0xF0, 0x70, 0x38, 0x07, 0x0E, 0x00, 0x63, 0x80, 0x0E, 0x60, 0x01, 0xCC,
  0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x07, 0x0E,
  0x01, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x70, 0x38, 0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01,
  0xCE, 0x00, 0xF1, 0x80, 0x7C, 0x7C, 0xF6, 0x07, 0xF1, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x1C,
  0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x87, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0xC3, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x38, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x03, 0xF8, 0x18, 0xC0, 0x3F,
  0xF0, 0x33, 0x01, 0xC0, 0xC0, 0xD8, 0x0C, 0x03, 0x03, 0x60, 0x60, 0x18,
  0x0D, 0x81, 0x80, 0x60, 0x36, 0x0C, 0x01, 0x80, 0xF0, 0x30, 0x0C, 0x06,
  0xC0, 0xC0, 0x30, 0x1B, 0x07, 0x00, 0xC0, 0x6C, 0x18, 0x07, 0x03, 0x30,
  0x70, 0x1C, 0x0C, 0xC0, 0xC0, 0xF0, 0x63, 0x03, 0x86, 0xC3, 0x86, 0x07,
  0xF1, 0xFC, 0x18, 0x0F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x08,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x70,
  0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00,
  0x61, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x66,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0x80,
  0x7C, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x03,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x60, 0x3E, 0x07, 0x00, 0x38, 0x30,
  0x00, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC7, 0x00, 0x0E,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x03, 0x87, 0x00,
  0x78, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1E, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x02, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x0F, 0x80, 0x30, 0x03, 0x80,
  0x60, 0x03, 0x80, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80,
  0x00, 0xE3, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x60, 0x07, 0x81,
  0xC0, 0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x07,
  0x80, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xFE,
  0x70, 0x07, 0xFC, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC7,
  0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x30, 0x38, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x38, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x60, 0x00,
  0x60, 0x70, 0x00, 0x30, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x18,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x81,
  0xC0, 0x06, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x71, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x7C, 0x00, 0x07, 0x98, 0x00,
  0x1E, 0x38, 0x00, 0x38, 0x30, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0xE0, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xD8, 0x3B, 0x00,
  0x03, 0x60, 0xCC, 0x00, 0x19, 0x83, 0x30, 0x00, 0xEE, 0x0C, 0xC0, 0x03,
  0x30, 0x33, 0x00, 0x18, 0xC1, 0xCC, 0x00, 0x63, 0x06, 0x18, 0x03, 0x1C,
  0x18, 0x60, 0x0C, 0x70, 0x61, 0x80, 0x61, 0x81, 0x86, 0x03, 0x86, 0x0E,
  0x18, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xE0, 0xC1, 0x81, 0x83, 0x03, 0x03,
  0x0C, 0x0C, 0x0C, 0x0C, 0x70, 0x30, 0x70, 0x31, 0x80, 0xC1, 0x80, 0xCE,
  0x07, 0x06, 0x03, 0x30, 0x18, 0x18, 0x0D, 0x80, 0x60, 0xE0, 0x1E, 0x01,
  0x83, 0x00, 0x70, 0x06, 0x0C, 0x01, 0xC0, 0x38, 0x30, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xC0, 0xF0, 0x00,
  0x60, 0x7C, 0x00, 0x30, 0x76, 0x00, 0x18, 0x33, 0x00, 0x1C, 0x18, 0xC0,
  0x0C, 0x0C, 0x60, 0x06, 0x06, 0x38, 0x03, 0x07, 0x0C, 0x01, 0x83, 0x06,
  0x01, 0xC1, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x70,
  0x18, 0x18, 0x30, 0x0C, 0x1C, 0x18, 0x03, 0x0C, 0x0C, 0x01, 0x86, 0x06,
  0x00, 0xE3, 0x07, 0x00, 0x33, 0x83, 0x00, 0x19, 0x81, 0x80, 0x06, 0xC0,
  0xC0, 0x03, 0x60, 0xE0, 0x01, 0xF0, 0x60, 0x00, 0x78, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x06, 0x03, 0xC0,
  0x60, 0x0E, 0x06, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x18, 0x00,
  0xC1, 0x80, 0x3C, 0x18, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x06, 0x03, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07,
  0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x18, 0x01, 0xC1, 0x80, 0x78, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x1C, 0x03, 0x00,
  0xC0, 0x70, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x70, 0x60,
  0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1E, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x10, 0x03, 0x83, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x70,
  0x01, 0x80, 0x38, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xE0, 0x00, 0xCE,
  0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x60,
  0x60, 0x0E, 0x06, 0x00, 0xC0, 0x60, 0x1C, 0x07, 0x01, 0x80, 0x30, 0x38,
  0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C,
  0x00, 0x31, 0x80, 0x03, 0x98, 0x00, 0x3B, 0x00, 0x01, 0xB0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0x80, 0x0E, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x76, 0x00, 0x68, 0x00,
  0xCC, 0x00, 0xD8, 0x03, 0x98, 0x03, 0xB0, 0x06, 0x30, 0x06, 0x60, 0x0C,
  0x60, 0x0C, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x63, 0x01, 0xC3,
  0x01, 0x86, 0x03, 0x06, 0x03, 0x0C, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x70, 0x30, 0x60, 0x60, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0xC3,
  0x01, 0x86, 0x01, 0x86, 0x03, 0x0C, 0x03, 0x9C, 0x06, 0x30, 0x07, 0x30,
  0x0C, 0x60, 0x0E, 0xE0, 0x19, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x1B, 0x00,
  0x36, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x58, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x03, 0x80, 0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x73, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x06, 0x30, 0x01, 0xC6,
  0x00, 0x70, 0xC0, 0x0C, 0x1C, 0x03, 0x81, 0x80, 0xE0, 0x30, 0x18, 0x07,
  0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x3B, 0x80, 0x03,
  0x60, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x30, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x1C,
  0x10, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03,
  0x0C, 0x00, 0x67, 0x00, 0x19, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC7, 0x18, 0x63, 0x0C, 0x01, 0xF8, 0x60, 0xFF, 0x88, 0x3C,
  0x1B, 0x0E, 0x01, 0x61, 0x80, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0x63, 0x80,
  0x0C, 0x60, 0x01, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x06,
  0xC1, 0xC1, 0x98, 0x3F, 0xE3, 0x01, 0xF8, 0x40, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC7, 0xE0, 0x39, 0xFE, 0x06, 0x60,
  0xE0, 0xD8, 0x0E, 0x1E, 0x00, 0xC7, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01,
  0xCC, 0x00, 0x31, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xE0, 0x1C,
  0x36, 0x07, 0x0C, 0xFF, 0xC1, 0x87, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFF,
  0x0F, 0x01, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x08, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x0F, 0xC3, 0x01, 0xFF, 0x98, 0x1E, 0x0D, 0xC1, 0xC0, 0x3C,
  0x0C, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x58, 0x38, 0x07,
  0x80, 0xE0, 0xEC, 0x07, 0xFE, 0x60, 0x1F, 0xC3, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x0F, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x07, 0x70,
  0x06, 0x60, 0x1C, 0x63, 0xF8, 0xFF, 0xE0, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x78, 0x08, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x80,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x3F, 0xF3, 0x07, 0x83, 0x30, 0xE0,
  0x1E, 0x0C, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x30,
  0x00, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x78, 0x70, 0x05, 0x87, 0x00, 0xF0,
  0x38, 0x3B, 0x03, 0xFF, 0x30, 0x0F, 0xC3, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x08, 0x03,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC3, 0xE0, 0x31, 0xFF, 0x06, 0x60, 0xE0, 0xD8,
  0x0E, 0x1E, 0x00, 0xC7, 0x80, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00,
  0x18, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00,
  0x61, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x31, 0xC0, 0x0E, 0x00, 0x03, 0x83, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1C,
  0x38, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x38, 0x07, 0x0E, 0x00,
  0xC3, 0x80, 0x18, 0xE0, 0x03, 0x38, 0x00, 0x6E, 0x00, 0x1B, 0xE0, 0x03,
  0xEC, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x80, 0x70, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x30, 0x0E, 0x0E, 0x00, 0xC1, 0xC0, 0x1C, 0x00,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x00, 0x04, 0x3F,
  0x03, 0xF0, 0x31, 0xFE, 0x1F, 0xE0, 0xCC, 0x18, 0xC1, 0xC3, 0x40, 0x76,
  0x03, 0x0F, 0x00, 0xF0, 0x0C, 0x78, 0x03, 0x80, 0x31, 0xC0, 0x0C, 0x00,
  0xC7, 0x00, 0x70, 0x03, 0x18, 0x01, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x73,
  0x80, 0x18, 0x01, 0x8C, 0x00, 0x60, 0x06, 0x30, 0x03, 0x80, 0x18, 0xC0,
  0x0C, 0x00, 0xE3, 0x00, 0x30, 0x03, 0x1C, 0x00, 0xC0, 0x0C, 0x60, 0x07,
  0x00, 0x31, 0x80, 0x18, 0x00, 0xC6, 0x00, 0x60, 0x07, 0x38, 0x01, 0x80,
  0x18, 0xE0, 0x0E, 0x00, 0x60, 0x0C, 0x3F, 0x81, 0x8F, 0xF8, 0x33, 0x07,
  0x06, 0xC0, 0x70, 0xF0, 0x0E, 0x3C, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C,
  0x60, 0x03, 0x1C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61,
  0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x70, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xF0, 0x70, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x00, 0x77, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x80, 0x0C, 0xE0, 0x07, 0x18, 0x03, 0x87,
  0x01, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0x07, 0xC0, 0x18, 0xFF,
  0x00, 0xCC, 0x1C, 0x06, 0xC0, 0x70, 0x3C, 0x01, 0x83, 0xC0, 0x0C, 0x1C,
  0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80,
  0x0C, 0x1C, 0x00, 0xE0, 0xF0, 0x0E, 0x06, 0xC0, 0xE0, 0x77, 0xFE, 0x03,
  0x8F, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xF8, 0x60, 0xFF, 0xCC, 0x3C, 0x19, 0x8E, 0x01, 0xE1,
  0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0x9C,
  0x00, 0x33, 0x80, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30,
  0x01, 0xC6, 0x00, 0x78, 0xE0, 0x0B, 0x1C, 0x03, 0xC1, 0xC1, 0xD8, 0x3F,
  0xF3, 0x01, 0xF8, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x3E, 0x18, 0xFC, 0x33, 0x00, 0x6C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x0E, 0x02,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0xC0, 0x38, 0xFF, 0xF0, 0x7F, 0xE0,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xFF, 0xFF, 0xE1, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x7F, 0x07, 0xF0, 0x1C, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x80, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x0E,
  0x38, 0x01, 0xC6, 0x00, 0x78, 0xC0, 0x1E, 0x1C, 0x02, 0xC3, 0x81, 0xD8,
  0x3F, 0xE3, 0x03, 0xF8, 0x60, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xDC,
  0x00, 0xCE, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x30,
  0x30, 0x38, 0x18, 0x18, 0x0E, 0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC6,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x1B,
  0x80, 0xD0, 0x0E, 0xE0, 0x36, 0x03, 0x38, 0x19, 0x81, 0xCE, 0x06, 0x60,
  0x61, 0x83, 0x18, 0x38, 0x60, 0xC6, 0x0C, 0x18, 0x61, 0x87, 0x06, 0x18,
  0x61, 0x81, 0x8C, 0x18, 0x60, 0x63, 0x06, 0x30, 0x19, 0x81, 0x8C, 0x06,
  0x60, 0x66, 0x01, 0xB0, 0x19, 0x80, 0x6C, 0x02, 0xE0, 0x1A, 0x00, 0xB0,
  0x07, 0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x60, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x00,
  0x18, 0x70, 0x01, 0x8E, 0x00, 0x0D, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x3B, 0x80, 0x07, 0x18,
  0x00, 0xE1, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0xE0, 0x30, 0x06, 0x07, 0x00,
  0x60, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x70, 0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x1C,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00,
  0x67, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x0D, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0xF8,
  0x03, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xC0,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3C, 0x1F, 0xFE, 0x01,
  0xFE,
};

const GFXglyph NotoSans_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 28, 9, 1, -28 },
  { 33, 10, 10, 14, 4, -28 },
  { 46, 24, 28, 25, 1, -28 },
  { 130, 18, 32, 21, 2, -30 },
  { 202, 26, 28, 30, 3, -28 },
  { 293, 23, 28, 26, 2, -28 },
  { 374, 4, 10, 8, 4, -28 },
  { 379, 12, 34, 10, 1, -28 },
  { 430, 12, 34, 10, -3, -28 },
  { 481, 17, 18, 21, 4, -30 },
  { 520, 18, 18, 22, 3, -23 },
  { 561, 7, 10, 9, -2, -5 },
  { 570, 10, 3, 12, 1, -12 },
  { 574, 3, 3, 9, 1, -3 },
  { 576, 18, 28, 13, -2, -28 },
  { 639, 19, 28, 21, 2, -28 },
  { 706, 11, 28, 21, 6, -28 },
  { 745, 20, 28, 21, 0, -28 },
  { 815, 19, 28, 21, 1, -28 },
  { 882, 21, 28, 21, 0, -28 },
  { 956, 20, 28, 21, 1, -28 },
  { 1026, 18, 28, 21, 3, -28 },
  { 1089, 18, 28, 21, 4, -28 },
  { 1152, 19, 28, 21, 2, -28 },
  { 1219, 18, 28, 21, 2, -28 },
  { 1282, 7, 21, 9, 1, -21 },
  { 1301, 10, 26, 9, -2, -21 },
  { 1334, 18, 18, 22, 3, -23 },
  { 1375, 18, 10, 22, 3, -19 },
  { 1398, 18, 18, 22, 3, -23 },
  { 1439, 14, 28, 16, 3, -28 },
  { 1488, 30, 32, 33, 2, -28 },
  { 1608, 22, 28, 22, -2, -28 },
  { 1685, 21, 28, 23, 2, -28 },
  { 1759, 22, 28, 23, 3, -28 },
  { 1836, 23, 28, 26, 2, -28 },
  { 1917, 20, 28, 20, 2, -28 },
  { 1987, 20, 28, 19, 2, -28 },
  { 2057, 23, 28, 27, 3, -28 },
  { 2138, 25, 28, 27, 2, -28 },
  { 2226, 14, 28, 12, 0, -28 },
  { 2275, 16, 35, 10, -6, -28 },
  { 2345, 23, 28, 22, 2, -28 },
  { 2426, 14, 28, 19, 2, -28 },
  { 2475, 30, 28, 32, 2, -28 },
  { 2580, 25, 28, 27, 2, -28 },
  { 2668, 24, 28, 28, 3, -28 },
  { 2752, 20, 28, 22, 2, -28 },
  { 2822, 24, 35, 28, 3, -28 },
  { 2927, 20, 28, 22, 2, -28 },
  { 2997, 19, 28, 20, 1, -28 },
  { 3064, 19, 28, 19, 4, -28 },
  { 3131, 24, 28, 27, 3, -28 },
  { 3215, 20, 28, 21, 4, -28 },
  { 3285, 31, 28, 33, 5, -28 },
  { 3394, 25, 28, 20, -2, -28 },
  { 3482, 19, 28, 19, 4, -28 },
  { 3549, 22, 28, 21, 0, -28 },
  { 3626, 14, 34, 12, 0, -28 },
  { 3686, 7, 28, 13, 4, -28 },
  { 3711, 15, 34, 12, -3, -28 },
  { 3775, 18, 17, 22, 2, -28 },
  { 3814, 15, 2, 15, -3, 4 },
  { 3818, 5, 6, 10, 6, -30 },
  { 3822, 19, 21, 22, 2, -21 },
  { 3872, 19, 30, 22, 1, -30 },
  { 3944, 16, 21, 18, 2, -21 },
  { 3986, 21, 30, 22, 2, -30 },
  { 4065, 16, 21, 19, 2, -21 },
  { 4107, 22, 39, 11, -5, -30 },
  { 4215, 20, 30, 22, 1, -21 },
  { 4290, 19, 30, 22, 1, -30 },
  { 4362, 9, 28, 9, 1, -28 },
  { 4394, 15, 37, 9, -5, -28 },
  { 4464, 19, 30, 18, 1, -30 },
  { 4536, 9, 30, 9, 1, -30 },
  { 4570, 30, 21, 34, 1, -21 },
  { 4649, 19, 21, 22, 1, -21 },
  { 4699, 18, 21, 22, 2, -21 },
  { 4747, 21, 30, 22, -1, -21 },
  { 4826, 19, 30, 22, 2, -21 },
  { 4898, 15, 21, 15, 1, -21 },
  { 4938, 16, 21, 17, 0, -21 },
  { 4980, 12, 26, 13, 2, -26 },
  { 5019, 19, 21, 22, 2, -21 },
  { 5069, 17, 21, 17, 2, -21 },
  { 5114, 26, 21, 27, 2, -21 },
  { 5183, 20, 21, 18, -1, -21 },
  { 5236, 23, 30, 17, -4, -21 },
  { 5323, 18, 21, 17, -1, -21 },
  { 5371, 14, 34, 13, 1, -28 },
  { 5431, 1, 39, 21, 11, -30 },
  { 5436, 15, 34, 13, -2, -28 },
  { 5500, 18, 4, 22, 3, -16 },
};

const GFXfont NotoSans_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_LIGHTITALIC39PT7B_H_
