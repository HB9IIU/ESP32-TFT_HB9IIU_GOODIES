#ifndef _NOTOSANS_LIGHTITALIC67PT7B_H_
#define _NOTOSANS_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x1E, 0x03, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xC3, 0xC0,
  0x70, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x1C, 0x7E, 0x00, 0xFC,
  0x3C, 0x0E, 0x01, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0x9F, 0x80, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x03,
  0x83, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x80, 0x0E, 0x0F, 0x80, 0xF8, 0x1C,
  0x3F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xC0, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x80,
  0x07, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x38,
  0x1E, 0x0F, 0xE1, 0xC0, 0x07, 0x07, 0x87, 0xFF, 0x38, 0x01, 0xE1, 0xE1,
  0xFF, 0xF7, 0x00, 0x38, 0x38, 0x7C, 0x1E, 0xE0, 0x0F, 0x0F, 0x1E, 0x01,
  0xFE, 0x03, 0xC3, 0xC3, 0xC0, 0x3F, 0xE0, 0xF0, 0xF0, 0xF0, 0x07, 0xBF,
  0xFC, 0x1C, 0x1C, 0x00, 0x73, 0xFF, 0x07, 0x87, 0x80, 0x0E, 0x3F, 0xC1,
  0xE0, 0xF0, 0x01, 0xC0, 0xC0, 0x38, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x0F,
  0x80, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1F,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x80, 0x78,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x7C, 0x00, 0x0F, 0xC7, 0xC0,
  0x3F, 0x00, 0x3F, 0x83, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x1C, 0x30, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0xE0,
  0x18, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x3F, 0x8E, 0x00, 0x00, 0x7E, 0x60,
  0x00, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80,
  0x02, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x39, 0xEF, 0xFF, 0xFB, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xF7, 0x01,
  0xF9, 0xE0, 0x7E, 0x3C, 0x3F, 0x87, 0x9F, 0xC0, 0xF1, 0xE0, 0x3C, 0x18,
  0x07, 0x82, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x40,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x73, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x20, 0x00,
  0x03, 0xF0, 0x18, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x10, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x00, 0x01, 0xE0, 0xFF, 0xF0, 0x00, 0xE1, 0xFF, 0xFC, 0x00, 0xF1,
  0xFF, 0xFF, 0x00, 0x79, 0xE0, 0x07, 0xC0, 0x3D, 0xC0, 0x01, 0xF0, 0x1D,
  0xC0, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0x80, 0x01, 0xDE,
  0x07, 0xE0, 0x07, 0x9C, 0x03, 0xF8, 0x7F, 0x3C, 0x01, 0xFF, 0xFE, 0x3C,
  0x00, 0x7F, 0xF8, 0x3C, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0x00, 0xFC, 0x1C, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x78, 0x00,
  0x1F, 0xFF, 0xE0, 0x0E, 0x1E, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xC3, 0x80,
  0x03, 0xE0, 0x07, 0x00, 0x38, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x9C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1E,
  0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xDC, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x7B, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0xF0, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xDE, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x07, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x39, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x38, 0x03, 0xC0,
  0x00, 0xF0, 0x01, 0xE7, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0x0F, 0x1C, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xC3, 0x80,
  0x3C, 0x00, 0x7E, 0x00, 0x78, 0x70, 0x03, 0x80, 0x1F, 0xE0, 0x1E, 0x0F,
  0x00, 0x78, 0x07, 0x9C, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE3, 0xC3, 0xE0,
  0x3C, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0x80, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x7F,
  0x00, 0x78, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x18, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x3F, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x78, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF3, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0x80,
  0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF1, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x01, 0xC0,
  0xF8, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x00, 0x07,
  0x9F, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0E, 0xE0,
  0x07, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x07, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x79, 0xC0, 0x0F, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x00, 0xF3, 0x80, 0x00,
  0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x78,
  0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0E,
  0x00, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x38, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x3D, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x1D, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xC0, 0x1E, 0x78, 0x00, 0x00, 0x70, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x00,
  0x78, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x70,
  0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x0E,
  0x00, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x78, 0x00,
  0x00, 0xF1, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x38, 0x01, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x07,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0x80,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x18, 0x01,
  0xF0, 0x00, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00, 0xF8, 0x0E,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x00,
  0xE0, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x83,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x38,
  0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0x80, 0x0F, 0xFF,
  0x83, 0x80, 0x0F, 0xFF, 0xE1, 0xC0, 0x1F, 0xC0, 0xF8, 0xE0, 0x1F, 0x80,
  0x1C, 0xF0, 0x1F, 0x80, 0x07, 0x70, 0x0F, 0x80, 0x01, 0xB8, 0x0F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0xEE, 0x01, 0xF0, 0x00, 0xE7,
  0x00, 0x78, 0x00, 0xE3, 0x80, 0x3F, 0x01, 0xE3, 0xC0, 0x0F, 0xFF, 0xE1,
  0xE0, 0x03, 0xFF, 0xE0, 0xE0, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0xFF, 0xF8,
  0x00, 0xF0, 0xFF, 0xFE, 0x00, 0x78, 0xF8, 0x1F, 0x80, 0x38, 0xF0, 0x07,
  0xC0, 0x3C, 0xE0, 0x01, 0xF0, 0x1E, 0xE0, 0x00, 0x78, 0x0F, 0xE0, 0x00,
  0x3C, 0x07, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x83, 0xF0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F, 0x03, 0xD8, 0x00, 0x1F, 0x01,
  0xCE, 0x00, 0x1F, 0x00, 0xE3, 0xC0, 0x3F, 0x00, 0x71, 0xFF, 0xFF, 0x00,
  0x70, 0x7F, 0xFF, 0x00, 0x38, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x1E, 0x01, 0xF8, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x20, 0x1F, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x78, 0x00,
  0x1F, 0xFF, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0xFE, 0x03, 0xC7,
  0x80, 0x1F, 0x80, 0x0E, 0x70, 0x03, 0xF0, 0x00, 0x6F, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x07, 0x80, 0x00, 0xEE, 0x00, 0x78, 0x00, 0x1C, 0xE0, 0x07, 0xC0, 0x03,
  0xDE, 0x00, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xF0, 0x1F, 0x1C, 0x00, 0x1F,
  0xFF, 0xE1, 0xC0, 0x00, 0xFF, 0xF8, 0x1C, 0x00, 0x07, 0xFE, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0xC3, 0xC0, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x20, 0x1F, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x18, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01,
  0xC0, 0x03, 0xFF, 0xE0, 0x70, 0x01, 0xFF, 0xFC, 0x1C, 0x01, 0xFC, 0x07,
  0x8F, 0x00, 0xFC, 0x00, 0x73, 0x80, 0x7E, 0x00, 0x0C, 0xE0, 0x1F, 0x00,
  0x03, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7E, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0x70, 0x0F,
  0x00, 0x03, 0xBC, 0x03, 0xE0, 0x01, 0xEF, 0x00, 0x78, 0x00, 0xF3, 0xC0,
  0x1F, 0x80, 0xF8, 0xE0, 0x03, 0xFF, 0xFC, 0x78, 0x00, 0x7F, 0xFC, 0x1E,
  0x00, 0x0F, 0xFC, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x08,
  0x00, 0x03, 0xE0, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x3F, 0xE0, 0x01, 0xE0, 0xFF, 0xF8, 0x01, 0xE1, 0xFF,
  0xFC, 0x01, 0xE3, 0xE0, 0x7E, 0x01, 0xC7, 0x80, 0x1E, 0x03, 0xCE, 0x00,
  0x1F, 0x03, 0xDC, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x04, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07,
  0x0F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x0E,
  0x7F, 0x80, 0x00, 0x0E, 0xF7, 0x80, 0x00, 0x1F, 0xE7, 0xC0, 0x00, 0x1F,
  0xC3, 0xC0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1C,
  0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x01, 0xCF, 0x00, 0x78, 0x78, 0x03, 0xE0,
  0x3C, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x00,
  0xF0, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x3F,
  0xF0, 0x01, 0xE0, 0xFF, 0xF8, 0x01, 0xC1, 0xFF, 0xFC, 0x01, 0xC3, 0xF0,
  0x7E, 0x01, 0xC7, 0x80, 0x1E, 0x03, 0xCE, 0x00, 0x1F, 0x03, 0xDC, 0x00,
  0x0F, 0x03, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0xFC, 0x00, 0x03, 0xC1, 0xFF, 0xF0, 0x00, 0x38, 0x3F, 0xFF, 0x80, 0x03,
  0x87, 0xC0, 0xFC, 0x00, 0x38, 0xF0, 0x07, 0xC0, 0x07, 0x9C, 0x00, 0x3E,
  0x00, 0x7B, 0x80, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x0F, 0x60, 0x00, 0x7C, 0x00, 0xF7, 0x00, 0x0F, 0x80, 0x0E, 0x3C, 0x03,
  0xF0, 0x00, 0xE3, 0xFF, 0xFE, 0x00, 0x1E, 0x0F, 0xFF, 0xC0, 0x01, 0xE0,
  0x7F, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x0F, 0xFF, 0x81, 0xC0,
  0x0F, 0xFF, 0xE0, 0xE0, 0x1F, 0xC0, 0x78, 0xF0, 0x1F, 0x80, 0x1E, 0x70,
  0x1F, 0x80, 0x03, 0x38, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF8, 0x3C, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0xFE, 0x07, 0x80,
  0x00, 0xEE, 0x03, 0xC0, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0xF7, 0x80, 0x78,
  0x00, 0xF3, 0xC0, 0x3F, 0x01, 0xF1, 0xC0, 0x0F, 0xFF, 0xF1, 0xE0, 0x03,
  0xFF, 0xE0, 0xF0, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x78, 0x3F, 0xE0, 0x1C, 0x1F, 0xF8,
  0x07, 0x1F, 0x82, 0x01, 0xC7, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x3D, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xC0, 0x00, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC2, 0x00, 0x01, 0xE0, 0xF0, 0x01, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F,
  0xC0, 0xF0, 0x00, 0x3B, 0xC0, 0xF0, 0x00, 0x73, 0x80, 0xF8, 0x00, 0xE3,
  0x80, 0x7C, 0x03, 0xC3, 0x80, 0x7F, 0xFF, 0x87, 0x80, 0x3F, 0xFF, 0x07,
  0x00, 0x0F, 0xFC, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E, 0x03, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x77,
  0x00, 0x07, 0x8F, 0x00, 0x0F, 0x70, 0x00, 0x78, 0xF0, 0x00, 0xE7, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC7, 0x80, 0x0F,
  0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0x80, 0x3C, 0x07, 0x00,
  0xF0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x00, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x07, 0x03, 0xC0, 0x38,
  0x1E, 0x00, 0x70, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x38, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x02, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x00,
  0x3F, 0xFF, 0xD0, 0x00, 0x1F, 0xFF, 0x20, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph NotoSans_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 15, 49, 16, 2, -48 },
  { 93, 18, 17, 24, 7, -48 },
  { 132, 41, 48, 42, 2, -48 },
  { 378, 32, 55, 37, 3, -51 },
  { 598, 43, 50, 52, 6, -49 },
  { 867, 40, 50, 45, 3, -49 },
  { 1117, 7, 17, 13, 7, -48 },
  { 1132, 21, 59, 18, 2, -48 },
  { 1287, 21, 59, 18, -5, -48 },
  { 1442, 29, 30, 36, 8, -51 },
  { 1551, 31, 31, 38, 5, -39 },
  { 1672, 11, 17, 15, -3, -8 },
  { 1696, 17, 4, 21, 2, -20 },
  { 1705, 6, 7, 16, 2, -6 },
  { 1711, 31, 48, 22, -3, -48 },
  { 1897, 32, 50, 37, 4, -49 },
  { 2097, 19, 48, 37, 10, -48 },
  { 2211, 35, 49, 37, 0, -49 },
  { 2426, 34, 50, 37, 1, -49 },
  { 2639, 35, 48, 37, 1, -48 },
  { 2849, 33, 49, 37, 3, -48 },
  { 3052, 33, 50, 37, 4, -49 },
  { 3259, 31, 48, 37, 7, -48 },
  { 3445, 33, 50, 37, 3, -49 },
  { 3652, 32, 50, 37, 3, -49 },
  { 3852, 12, 37, 16, 2, -36 },
  { 3908, 17, 45, 16, -3, -36 },
  { 4004, 31, 31, 38, 5, -40 },
  { 4125, 31, 17, 38, 5, -32 },
  { 4191, 31, 31, 38, 5, -40 },
  { 4312, 24, 50, 28, 5, -49 },
  { 4462, 51, 54, 56, 4, -48 },
  { 4807, 38, 48, 37, -4, -48 },
  { 5035, 36, 48, 40, 3, -48 },
  { 5251, 37, 50, 40, 5, -49 },
  { 5483, 40, 48, 45, 3, -48 },
  { 5723, 34, 48, 35, 3, -48 },
  { 5927, 34, 48, 32, 3, -48 },
  { 6131, 39, 50, 46, 5, -49 },
  { 6375, 43, 48, 46, 3, -48 },
  { 6633, 23, 48, 20, 0, -48 },
  { 6771, 28, 60, 17, -11, -48 },
  { 6981, 40, 48, 37, 3, -48 },
  { 7221, 25, 48, 33, 3, -48 },
  { 7371, 52, 48, 55, 3, -48 },
  { 7683, 43, 48, 46, 3, -48 },
  { 7941, 41, 50, 48, 5, -49 },
  { 8198, 35, 48, 38, 3, -48 },
  { 8408, 41, 60, 48, 5, -49 },
  { 8716, 35, 48, 38, 3, -48 },
  { 8926, 33, 50, 34, 1, -49 },
  { 9133, 33, 48, 33, 6, -48 },
  { 9331, 40, 49, 46, 6, -48 },
  { 9576, 35, 48, 36, 7, -48 },
  { 9786, 53, 48, 56, 8, -48 },
  { 10104, 43, 48, 34, -4, -48 },
  { 10362, 34, 48, 33, 6, -48 },
  { 10566, 39, 48, 36, -1, -48 },
  { 10800, 26, 59, 20, -1, -48 },
  { 10992, 11, 48, 22, 7, -48 },
  { 11058, 26, 59, 20, -5, -48 },
  { 11250, 32, 30, 38, 3, -48 },
  { 11370, 27, 3, 26, -6, 7 },
  { 11381, 9, 10, 17, 10, -51 },
  { 11393, 33, 37, 37, 3, -36 },
  { 11546, 33, 52, 38, 2, -51 },
  { 11761, 28, 37, 30, 3, -36 },
  { 11891, 36, 52, 38, 3, -51 },
  { 12125, 27, 37, 33, 4, -36 },
  { 12250, 37, 67, 20, -8, -51 },
  { 12560, 34, 52, 38, 2, -36 },
  { 12781, 32, 51, 38, 2, -51 },
  { 12985, 14, 49, 16, 2, -49 },
  { 13071, 25, 65, 16, -9, -49 },
  { 13275, 32, 51, 31, 2, -51 },
  { 13479, 15, 51, 16, 2, -51 },
  { 13575, 52, 36, 58, 2, -36 },
  { 13809, 32, 36, 38, 2, -36 },
  { 13953, 31, 37, 38, 3, -36 },
  { 14097, 36, 52, 38, -1, -36 },
  { 14331, 33, 52, 38, 3, -36 },
  { 14546, 26, 36, 26, 2, -36 },
  { 14663, 26, 37, 29, 1, -36 },
  { 14784, 20, 45, 22, 3, -44 },
  { 14897, 32, 37, 38, 4, -36 },
  { 15045, 30, 36, 29, 3, -36 },
  { 15180, 44, 36, 46, 4, -36 },
  { 15378, 35, 36, 31, -2, -36 },
  { 15536, 40, 52, 29, -7, -36 },
  { 15796, 30, 36, 30, -1, -36 },
  { 15931, 25, 59, 23, 1, -48 },
  { 16116, 3, 67, 36, 18, -51 },
  { 16142, 25, 59, 23, -3, -48 },
  { 16327, 31, 7, 38, 5, -27 },
};

const GFXfont NotoSans_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_LIGHTITALIC67PT7B_H_
