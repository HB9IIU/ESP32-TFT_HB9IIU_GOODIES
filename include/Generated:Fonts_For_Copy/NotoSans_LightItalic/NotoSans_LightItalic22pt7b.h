#ifndef _NOTOSANS_LIGHTITALIC22PT7B_H_
#define _NOTOSANS_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x13, 0x22, 0x22, 0x64, 0x44, 0x00, 0xC8, 0x65, 0x14, 0xD2,
  0x4A, 0x20, 0x02, 0x30, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x3F, 0xFC,
  0x21, 0x01, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xFC, 0x22, 0x02, 0x10, 0x10,
  0x80, 0x88, 0x08, 0x40, 0x01, 0x00, 0x80, 0x78, 0x69, 0x22, 0x08, 0x82,
  0x40, 0xD0, 0x1C, 0x01, 0xC0, 0x58, 0x22, 0x08, 0x82, 0x68, 0xB1, 0xF0,
  0x10, 0x04, 0x00, 0x38, 0x09, 0x90, 0x44, 0x41, 0x21, 0x08, 0x84, 0x42,
  0x13, 0x08, 0x49, 0xA2, 0x5B, 0x9A, 0x45, 0xDA, 0x10, 0x48, 0x42, 0x21,
  0x10, 0x84, 0xC2, 0x22, 0x09, 0x90, 0x3C, 0x07, 0x80, 0x66, 0x06, 0x10,
  0x20, 0x81, 0x04, 0x0C, 0x40, 0x2C, 0x01, 0x80, 0x36, 0x03, 0x10, 0xF0,
  0x45, 0x03, 0x68, 0x0E, 0x40, 0x63, 0x06, 0x8F, 0xC6, 0x69, 0x25, 0x00,
  0x04, 0x21, 0x84, 0x20, 0x84, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x04, 0x00, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x18, 0x20, 0x41, 0x82, 0x0C, 0x10, 0x43, 0x80, 0x0C, 0x06, 0x22, 0x19,
  0x03, 0x88, 0xFC, 0xA0, 0x88, 0xC4, 0x03, 0x00, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x32, 0x24, 0x48,
  0xFF, 0xC0, 0xE0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x07,
  0x83, 0x18, 0x41, 0x10, 0x32, 0x06, 0xC0, 0xD0, 0x1A, 0x03, 0x40, 0x58,
  0x0B, 0x01, 0x60, 0x6C, 0x08, 0x83, 0x18, 0xC1, 0xF0, 0x04, 0x73, 0x73,
  0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x07, 0xC1, 0x8C,
  0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x07, 0xFE, 0x07, 0xC1, 0xC6, 0x10, 0x20,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0xF8, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x81, 0x87, 0xF0, 0x00, 0x20, 0x06, 0x00, 0xA0,
  0x12, 0x03, 0x40, 0x64, 0x0C, 0x40, 0x84, 0x10, 0xC2, 0x08, 0x40, 0x8F,
  0xFF, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x0F, 0xE3, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x09, 0x01, 0xF8, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x20, 0xC7, 0xF0, 0x03, 0xE0, 0xC0, 0x60, 0x08, 0x02, 0x00,
  0x40, 0x19, 0xC2, 0xCC, 0x60, 0xC8, 0x0B, 0x01, 0x60, 0x24, 0x08, 0x81,
  0x18, 0x41, 0xF0, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x07,
  0x83, 0x18, 0x41, 0x98, 0x13, 0x06, 0x20, 0x86, 0x60, 0x70, 0x1B, 0x0C,
  0x33, 0x02, 0x40, 0x68, 0x0D, 0x81, 0x10, 0x61, 0xF0, 0x0F, 0x03, 0x18,
  0xC1, 0x10, 0x26, 0x06, 0x80, 0x90, 0x13, 0x06, 0x21, 0x43, 0xD8, 0x02,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x87, 0xE0, 0x32, 0x00, 0x00, 0x00, 0x00,
  0xC8, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x18, 0x41, 0x08,
  0x00, 0x00, 0x40, 0xE0, 0xE0, 0xE0, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x70, 0x70, 0x60, 0x20, 0x00, 0x3C,
  0xC6, 0x03, 0x03, 0x03, 0x02, 0x04, 0x08, 0x30, 0x20, 0x40, 0x40, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x01, 0xC6, 0x03, 0x00, 0xC2, 0x00, 0x22,
  0x00, 0x1B, 0x0F, 0xC5, 0x08, 0x42, 0x88, 0x21, 0xC4, 0x10, 0xC6, 0x18,
  0xE2, 0x08, 0x51, 0x8C, 0x6C, 0x4F, 0x62, 0x18, 0xC1, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x40, 0x0C, 0x01, 0xC0, 0x14,
  0x03, 0x60, 0x26, 0x06, 0x20, 0x42, 0x08, 0x21, 0xFE, 0x1F, 0xE3, 0x03,
  0x20, 0x36, 0x01, 0x40, 0x1C, 0x01, 0x1F, 0x81, 0x0E, 0x10, 0x31, 0x01,
  0x30, 0x33, 0x02, 0x20, 0x63, 0xF8, 0x20, 0xC6, 0x04, 0x40, 0x64, 0x06,
  0x40, 0x64, 0x04, 0xC1, 0x8F, 0xF0, 0x03, 0xE0, 0xC3, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x83, 0xF8, 0x1F, 0x80, 0x87, 0x04, 0x0C, 0x20,
  0x23, 0x01, 0x98, 0x04, 0x80, 0x24, 0x01, 0x20, 0x1B, 0x00, 0xD0, 0x04,
  0x80, 0x64, 0x02, 0x20, 0x63, 0x0E, 0x1F, 0xC0, 0x1F, 0xE2, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0xFC, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x07, 0xF8, 0x1F, 0xE2, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x3F, 0x8C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x03, 0xE0, 0x61, 0xC4, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x81, 0xF4, 0x11, 0x20, 0x09, 0x00, 0x48,
  0x06, 0x60, 0x31, 0x81, 0x07, 0xF8, 0x18, 0x04, 0x40, 0x31, 0x00, 0x84,
  0x02, 0x30, 0x08, 0xC0, 0x22, 0x01, 0x8F, 0xFC, 0x20, 0x11, 0x80, 0x44,
  0x01, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x8C, 0x02, 0x20, 0x18, 0x1F, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0xF8, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x83, 0xC0, 0x18, 0x18, 0x81, 0x84, 0x18, 0x21, 0x83, 0x18, 0x11,
  0x80, 0x90, 0x05, 0x80, 0x36, 0x03, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10,
  0x20, 0xC3, 0x02, 0x10, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xFF, 0x18, 0x01, 0x8C,
  0x01, 0xC6, 0x00, 0xE3, 0x80, 0xE3, 0x40, 0x51, 0x20, 0x48, 0x90, 0x24,
  0x48, 0x26, 0x24, 0x32, 0x33, 0x11, 0x10, 0x98, 0x88, 0x48, 0xC4, 0x28,
  0x62, 0x14, 0x23, 0x0C, 0x11, 0x06, 0x08, 0x18, 0x04, 0x60, 0x11, 0x80,
  0xC5, 0x03, 0x34, 0x08, 0x98, 0x22, 0x20, 0x88, 0x86, 0x21, 0x11, 0x84,
  0x44, 0x19, 0x10, 0x24, 0x40, 0xB1, 0x01, 0x8C, 0x06, 0x20, 0x18, 0x07,
  0xC0, 0xE3, 0x0C, 0x04, 0xC0, 0x34, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x02, 0x60, 0x31, 0x83, 0x07,
  0xF0, 0x1F, 0x82, 0x18, 0x40, 0x88, 0x13, 0x02, 0x60, 0x48, 0x09, 0x02,
  0x3F, 0x8F, 0x81, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x07,
  0xC0, 0xE3, 0x0C, 0x04, 0xC0, 0x34, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x02, 0x60, 0x31, 0x83, 0x07,
  0xE0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x1F, 0x82, 0x18, 0x40,
  0x88, 0x13, 0x02, 0x40, 0x48, 0x19, 0x06, 0x3F, 0x8C, 0x41, 0x04, 0x20,
  0x84, 0x18, 0x81, 0x30, 0x24, 0x06, 0x07, 0xC1, 0x8C, 0x40, 0x08, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x20, 0x67, 0xF0, 0xFF, 0xE0, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x09, 0x00, 0x48, 0x06, 0xC0, 0x36, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x06, 0xC0, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x04, 0x40,
  0x61, 0x06, 0x07, 0xE0, 0x80, 0x3C, 0x02, 0xC0, 0x64, 0x04, 0x40, 0xC4,
  0x08, 0x41, 0x04, 0x10, 0x42, 0x04, 0x20, 0x64, 0x06, 0xC0, 0x28, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x50, 0x50,
  0x68, 0x28, 0x24, 0x24, 0x12, 0x12, 0x11, 0x19, 0x08, 0x88, 0x88, 0x4C,
  0x64, 0x24, 0x36, 0x16, 0x0A, 0x0A, 0x07, 0x05, 0x03, 0x03, 0x01, 0x81,
  0x80, 0x80, 0x08, 0x0C, 0x20, 0x20, 0xC1, 0x01, 0x08, 0x04, 0x40, 0x0B,
  0x00, 0x28, 0x00, 0xC0, 0x03, 0x00, 0x14, 0x00, 0xC8, 0x06, 0x20, 0x10,
  0xC0, 0x81, 0x04, 0x04, 0x30, 0x18, 0x80, 0x78, 0x09, 0x02, 0x20, 0xC4,
  0x10, 0x44, 0x09, 0x81, 0x20, 0x38, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x1F, 0xF8, 0x0F, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80,
  0xF0, 0x8C, 0x44, 0x44, 0x46, 0x22, 0x22, 0x23, 0x11, 0x0F, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x3E, 0x00, 0x02, 0x01, 0x80, 0xE0, 0x24,
  0x11, 0x04, 0x22, 0x09, 0x82, 0x40, 0x60, 0x10, 0xFF, 0x80, 0xC8, 0x90,
  0x0F, 0x23, 0x38, 0x83, 0x30, 0x64, 0x0D, 0x81, 0xB0, 0x24, 0x04, 0x81,
  0x98, 0x51, 0x1E, 0x3E, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x09,
  0xE2, 0x8C, 0xC1, 0x60, 0x58, 0x14, 0x05, 0x01, 0x40, 0x70, 0x3C, 0x0A,
  0x84, 0xBE, 0x00, 0x0F, 0x8C, 0x48, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x60, 0x18, 0x47, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0xF2, 0x19, 0xE2, 0x0C, 0x60, 0x44, 0x04, 0xC0, 0x4C, 0x0C, 0x80,
  0x88, 0x18, 0xC1, 0x84, 0x28, 0x7D, 0x80, 0x0F, 0x0C, 0xC8, 0x2C, 0x14,
  0x1E, 0x7B, 0xC1, 0x00, 0xC0, 0x60, 0x18, 0x47, 0xE0, 0x00, 0x70, 0x09,
  0x01, 0x00, 0x10, 0x01, 0x00, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x0F, 0x00, 0x0F, 0x23, 0x14, 0x83, 0x30, 0x24,
  0x05, 0x80, 0xB0, 0x34, 0x04, 0x81, 0x98, 0x31, 0x0A, 0x3E, 0xC0, 0x10,
  0x02, 0x00, 0xC4, 0x30, 0xFC, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x09, 0xE2, 0x8C, 0xC1, 0x60, 0x58, 0x14, 0x05, 0x03, 0x40, 0xB0, 0x28,
  0x0A, 0x06, 0x81, 0x80, 0x11, 0x00, 0x22, 0x26, 0x64, 0x44, 0xC8, 0x88,
  0x01, 0x01, 0x00, 0x00, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0xE0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x32, 0x18, 0x8C, 0x66, 0x13, 0x05, 0x81, 0xA0,
  0x44, 0x31, 0x08, 0x62, 0x08, 0x83, 0x00, 0x11, 0x11, 0x32, 0x22, 0x64,
  0x44, 0x4C, 0x88, 0x80, 0x27, 0x8E, 0x14, 0x48, 0x8C, 0x28, 0x6C, 0x18,
  0x36, 0x0C, 0x12, 0x04, 0x09, 0x02, 0x04, 0x81, 0x02, 0xC1, 0x83, 0x40,
  0x81, 0x20, 0x40, 0x90, 0x20, 0x40, 0x27, 0x8B, 0x33, 0x05, 0x81, 0x60,
  0x50, 0x34, 0x0D, 0x02, 0xC0, 0xA0, 0x28, 0x1A, 0x06, 0x0F, 0x06, 0x22,
  0x05, 0x01, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0xF0, 0x24, 0x10, 0xF8,
  0x13, 0xC2, 0x8C, 0x60, 0x98, 0x13, 0x02, 0x40, 0x48, 0x09, 0x01, 0x60,
  0x6C, 0x09, 0x42, 0x2F, 0x84, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x00,
  0x0F, 0x23, 0x34, 0x83, 0x30, 0x24, 0x05, 0x80, 0xB0, 0x34, 0x04, 0x81,
  0x98, 0x31, 0x0A, 0x3E, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x27, 0x28, 0x30, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x1F, 0x18, 0x48, 0x04, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x01, 0xA0,
  0x9F, 0x80, 0x10, 0x20, 0xC7, 0xF2, 0x04, 0x18, 0x20, 0x40, 0x81, 0x06,
  0x08, 0x18, 0x1C, 0x00, 0x20, 0x64, 0x08, 0x81, 0x30, 0x24, 0x04, 0x81,
  0x90, 0x26, 0x04, 0xC1, 0x90, 0x33, 0x1E, 0x3E, 0x80, 0x80, 0xE0, 0x2C,
  0x11, 0x04, 0x42, 0x11, 0x84, 0x41, 0x30, 0x48, 0x16, 0x07, 0x00, 0x80,
  0x81, 0x07, 0x86, 0x0B, 0x0C, 0x16, 0x28, 0x4C, 0x50, 0x99, 0x32, 0x12,
  0x24, 0x28, 0x50, 0x50, 0xA0, 0xC1, 0xC1, 0x83, 0x02, 0x06, 0x00, 0x10,
  0x31, 0x86, 0x08, 0xC0, 0xC8, 0x05, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x19,
  0x03, 0x10, 0x20, 0x8C, 0x0C, 0x10, 0x18, 0xC0, 0x86, 0x08, 0x10, 0x40,
  0x84, 0x04, 0x20, 0x22, 0x01, 0x30, 0x0D, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x20,
  0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x03, 0xFC,
  0x01, 0x83, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x30, 0x28,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0E, 0x00, 0xFF, 0xFF,
  0xFC, 0x0C, 0x06, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x03, 0x07,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0xE0, 0xF0, 0x63, 0xF0,
};

const GFXglyph NotoSans_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 6, 6, 8, 2, -16 },
  { 14, 13, 16, 14, 1, -16 },
  { 40, 10, 18, 12, 1, -17 },
  { 63, 14, 16, 17, 2, -16 },
  { 91, 13, 16, 15, 1, -16 },
  { 117, 3, 6, 4, 2, -16 },
  { 120, 6, 19, 6, 1, -16 },
  { 135, 7, 19, 6, -2, -16 },
  { 152, 9, 10, 12, 3, -17 },
  { 164, 10, 10, 13, 2, -13 },
  { 177, 4, 6, 5, -1, -3 },
  { 180, 5, 2, 7, 1, -7 },
  { 182, 2, 2, 5, 1, -2 },
  { 183, 10, 16, 7, -1, -16 },
  { 203, 11, 16, 12, 1, -16 },
  { 225, 6, 16, 12, 3, -16 },
  { 237, 11, 16, 12, 0, -16 },
  { 259, 12, 16, 12, 0, -16 },
  { 283, 12, 16, 12, 0, -16 },
  { 307, 11, 16, 12, 1, -16 },
  { 329, 11, 16, 12, 1, -16 },
  { 351, 10, 16, 12, 2, -16 },
  { 371, 11, 16, 12, 1, -16 },
  { 393, 11, 16, 12, 1, -16 },
  { 415, 4, 12, 5, 1, -12 },
  { 421, 6, 15, 5, -1, -12 },
  { 433, 10, 10, 13, 2, -13 },
  { 446, 10, 6, 13, 2, -11 },
  { 454, 10, 10, 13, 2, -13 },
  { 467, 8, 16, 9, 2, -16 },
  { 483, 17, 18, 19, 1, -16 },
  { 522, 12, 16, 12, -1, -16 },
  { 546, 12, 16, 13, 1, -16 },
  { 570, 12, 16, 13, 2, -16 },
  { 594, 13, 16, 15, 1, -16 },
  { 620, 11, 16, 12, 1, -16 },
  { 642, 11, 16, 11, 1, -16 },
  { 664, 13, 16, 15, 2, -16 },
  { 690, 14, 16, 15, 1, -16 },
  { 718, 8, 16, 7, 0, -16 },
  { 734, 10, 20, 6, -4, -16 },
  { 759, 13, 16, 12, 1, -16 },
  { 785, 8, 16, 11, 1, -16 },
  { 801, 17, 16, 18, 1, -16 },
  { 835, 14, 16, 15, 1, -16 },
  { 863, 13, 16, 16, 2, -16 },
  { 889, 11, 16, 12, 1, -16 },
  { 911, 13, 20, 16, 2, -16 },
  { 944, 11, 16, 13, 1, -16 },
  { 966, 11, 16, 11, 0, -16 },
  { 988, 11, 16, 11, 2, -16 },
  { 1010, 13, 16, 15, 2, -16 },
  { 1036, 12, 16, 12, 2, -16 },
  { 1060, 17, 16, 19, 3, -16 },
  { 1094, 14, 16, 11, -1, -16 },
  { 1122, 11, 16, 11, 2, -16 },
  { 1144, 13, 16, 12, 0, -16 },
  { 1170, 8, 19, 7, 0, -16 },
  { 1189, 4, 16, 7, 2, -16 },
  { 1197, 9, 19, 7, -2, -16 },
  { 1219, 10, 10, 12, 1, -16 },
  { 1232, 9, 1, 8, -2, 2 },
  { 1234, 3, 4, 6, 3, -17 },
  { 1236, 11, 12, 12, 1, -12 },
  { 1253, 10, 17, 13, 1, -17 },
  { 1275, 9, 12, 10, 1, -12 },
  { 1289, 12, 17, 13, 1, -17 },
  { 1315, 9, 12, 11, 1, -12 },
  { 1329, 12, 22, 6, -3, -17 },
  { 1362, 11, 17, 13, 1, -12 },
  { 1386, 10, 17, 12, 1, -17 },
  { 1408, 4, 16, 5, 1, -16 },
  { 1416, 8, 21, 5, -3, -16 },
  { 1437, 10, 17, 10, 1, -17 },
  { 1459, 4, 17, 5, 1, -17 },
  { 1468, 17, 12, 19, 1, -12 },
  { 1494, 10, 12, 12, 1, -12 },
  { 1509, 10, 12, 12, 1, -12 },
  { 1524, 11, 17, 13, 0, -12 },
  { 1548, 11, 17, 13, 1, -12 },
  { 1572, 8, 12, 8, 1, -12 },
  { 1584, 9, 12, 9, 0, -12 },
  { 1598, 7, 15, 7, 1, -15 },
  { 1612, 11, 12, 12, 1, -12 },
  { 1629, 10, 12, 10, 1, -12 },
  { 1644, 15, 12, 15, 1, -12 },
  { 1667, 12, 12, 10, -1, -12 },
  { 1685, 13, 17, 10, -2, -12 },
  { 1713, 10, 12, 10, 0, -12 },
  { 1728, 9, 19, 7, 0, -16 },
  { 1750, 1, 22, 12, 6, -17 },
  { 1753, 8, 19, 7, -1, -16 },
  { 1772, 10, 2, 13, 2, -9 },
};

const GFXfont NotoSans_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_LIGHTITALIC22PT7B_H_
