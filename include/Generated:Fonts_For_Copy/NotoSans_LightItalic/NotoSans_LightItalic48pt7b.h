#ifndef _NOTOSANS_LIGHTITALIC48PT7B_H_
#define _NOTOSANS_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0x80, 0x00, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x60, 0xE3, 0x07, 0x38, 0x31,
  0xC1, 0x8C, 0x1C, 0x60, 0xC3, 0x06, 0x18, 0x31, 0x81, 0x80, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x07, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF2, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xF9, 0xC7, 0x01, 0xC3,
  0x02, 0x07, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0xC6, 0x00,
  0x03, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x06, 0x3C, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x06,
  0x0E, 0x10, 0x0C, 0x3C, 0x38, 0x39, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x0F,
  0xE0, 0x00, 0x70, 0x3D, 0xE0, 0x00, 0xC0, 0xE0, 0xE0, 0x03, 0x81, 0x81,
  0xC0, 0x0E, 0x07, 0x01, 0x80, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x06,
  0x01, 0xC0, 0x60, 0x0C, 0x07, 0x00, 0xC0, 0x18, 0x1C, 0x03, 0x80, 0x70,
  0x30, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0x83, 0x80, 0x18, 0x03, 0x06,
  0x00, 0x30, 0x0E, 0x18, 0x7C, 0x60, 0x18, 0x71, 0xFE, 0xC0, 0x71, 0xC7,
  0x1D, 0xC0, 0xC3, 0x1C, 0x1F, 0x83, 0x8C, 0x70, 0x1B, 0xDE, 0x38, 0xC0,
  0x33, 0xF8, 0xE3, 0x80, 0x61, 0xC1, 0x87, 0x00, 0xC0, 0x06, 0x0C, 0x01,
  0x80, 0x1C, 0x18, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x00, 0xC0, 0xE0, 0x1C,
  0x03, 0x81, 0x80, 0x30, 0x0E, 0x03, 0x00, 0x60, 0x38, 0x06, 0x01, 0xC0,
  0x60, 0x0C, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x1C,
  0x00, 0x70, 0x70, 0x30, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x07,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF3, 0x80, 0x00,
  0x1E, 0x1C, 0x00, 0x71, 0xC0, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x39, 0xC0,
  0x0F, 0x03, 0x8C, 0x00, 0x38, 0x1C, 0xE0, 0x00, 0xE1, 0xC7, 0x00, 0x03,
  0x9C, 0x38, 0x00, 0x1D, 0xC1, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF8, 0x0E, 0x00, 0x3C, 0xE0, 0x7C,
  0x07, 0xC3, 0x81, 0xFF, 0xF8, 0x1C, 0x03, 0xFF, 0x00, 0x78, 0x39, 0xCE,
  0x63, 0x39, 0xCC, 0x63, 0x19, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x80, 0x30, 0x0E, 0x03,
  0x00, 0xF8, 0x60, 0x07, 0xC6, 0x00, 0x0F, 0x60, 0x10, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1E, 0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x1E, 0x38, 0x03,
  0xC1, 0x80, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x20, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xC0, 0xFF, 0xFF, 0xFC, 0x77, 0xFD,
  0xE2, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x78, 0x1E, 0x03,
  0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00,
  0x0C, 0x70, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0D,
  0xC0, 0x00, 0x37, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00,
  0x38, 0x1E, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x0F, 0x70, 0xF3, 0x1F, 0x3B, 0xE1,
  0xCC, 0x0E, 0x40, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x01, 0xE0, 0x0C, 0x00,
  0x70, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xE0, 0x1E, 0x03,
  0x80, 0x0F, 0x02, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xF8,
  0x07, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x60, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x06, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x7C,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x08, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x80, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x1F, 0xE0, 0x18, 0xFF, 0xE0, 0x77,
  0x81, 0xE0, 0xFC, 0x01, 0xE1, 0xF0, 0x01, 0xC3, 0xC0, 0x01, 0xC7, 0x00,
  0x03, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x86, 0x00, 0x06,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x3C, 0x0F, 0x80,
  0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0xF0, 0x00, 0x73, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE7,
  0x80, 0x0F, 0x81, 0xC0, 0x1E, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x78, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x78, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03,
  0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x71,
  0x80, 0x00, 0xE3, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0F, 0x1C,
  0x00, 0x3E, 0x38, 0x00, 0xD8, 0x38, 0x03, 0xF0, 0x7E, 0x3E, 0xE0, 0x3F,
  0xF1, 0xC0, 0x3F, 0x87, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xC0, 0x7C, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0xF0, 0x78, 0x08,
  0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x86, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x80, 0x07, 0x18, 0x00, 0xFF, 0xC0, 0x73, 0x80, 0x3F, 0xFE, 0x07, 0x30,
  0x07, 0x00, 0xC0, 0x37, 0x00, 0xE0, 0x0C, 0x03, 0x60, 0x1C, 0x01, 0xC0,
  0x36, 0x03, 0x80, 0x1C, 0x03, 0xE0, 0x30, 0x01, 0x80, 0x3E, 0x07, 0x00,
  0x38, 0x07, 0xC0, 0x70, 0x03, 0x80, 0x7C, 0x06, 0x00, 0x30, 0x06, 0xC0,
  0x60, 0x03, 0x00, 0x6C, 0x06, 0x00, 0x70, 0x0E, 0xC0, 0x60, 0x07, 0x00,
  0xCC, 0x06, 0x00, 0xF0, 0x1C, 0xC0, 0x60, 0x1B, 0x03, 0x8C, 0x07, 0x03,
  0xB0, 0x78, 0xE0, 0x38, 0xF3, 0x8F, 0x0E, 0x03, 0xFE, 0x1F, 0xC0, 0x60,
  0x0F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1C, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1C, 0x01,
  0xF8, 0x06, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0x80, 0x03,
  0x80, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0x00,
  0x3E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x81, 0x80, 0x7F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x80, 0x70, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x70, 0x0F, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x3E,
  0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xCE, 0x00, 0x3F, 0xFC,
  0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x60, 0x3C,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x01, 0xDF, 0x00, 0x00, 0x0F, 0xDC, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xB0,
  0x00, 0x03, 0xB8, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x3B, 0x00, 0x00, 0x77,
  0x00, 0xCE, 0x00, 0x01, 0x9C, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x1C, 0xE0,
  0x00, 0x31, 0x80, 0x71, 0x80, 0x01, 0xCE, 0x01, 0xC6, 0x00, 0x0E, 0x38,
  0x06, 0x18, 0x00, 0x38, 0xE0, 0x38, 0x60, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0x06, 0x0C, 0x03, 0x87, 0x00, 0x38, 0x70, 0x0E, 0x1C, 0x00, 0xC1, 0xC0,
  0x30, 0x30, 0x07, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x1C, 0x07, 0x03, 0x00,
  0xE0, 0x60, 0x1C, 0x0C, 0x07, 0x03, 0x80, 0x60, 0x38, 0x18, 0x0E, 0x01,
  0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x83, 0x00, 0xE0, 0x38, 0x06, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0xE0, 0x1C, 0x03, 0x00, 0x63, 0x80, 0x70, 0x0C,
  0x01, 0xDC, 0x01, 0xC0, 0x70, 0x07, 0x60, 0x06, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x18, 0x00, 0xF0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x80, 0x00,
  0x60, 0x3F, 0x00, 0x01, 0xC0, 0x76, 0x00, 0x03, 0x80, 0xEE, 0x00, 0x07,
  0x01, 0x8C, 0x00, 0x0E, 0x03, 0x1C, 0x00, 0x18, 0x0E, 0x38, 0x00, 0x70,
  0x1C, 0x30, 0x00, 0xE0, 0x38, 0x70, 0x01, 0xC0, 0x60, 0x60, 0x03, 0x01,
  0xC0, 0xE0, 0x06, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x01, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x18, 0x03, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x80, 0xE0,
  0x0E, 0x07, 0x01, 0xC0, 0x0C, 0x0E, 0x03, 0x00, 0x1C, 0x1C, 0x06, 0x00,
  0x18, 0x30, 0x1C, 0x00, 0x38, 0xE0, 0x38, 0x00, 0x71, 0xC0, 0x70, 0x00,
  0x63, 0x80, 0xC0, 0x00, 0xE7, 0x01, 0x80, 0x00, 0xCC, 0x07, 0x00, 0x01,
  0xD8, 0x0E, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x70,
  0x1F, 0x80, 0x30, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x7C, 0x06, 0x07, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x70, 0x0F,
  0x80, 0x30, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x78, 0x0E, 0x01, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01,
  0xF0, 0x0E, 0x03, 0xC0, 0x02, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x80,
  0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x7E,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x18, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0xEC, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00,
  0x3C, 0x00, 0x1C, 0xC0, 0x01, 0xF0, 0x00, 0x73, 0x00, 0x06, 0xE0, 0x01,
  0x8E, 0x00, 0x3B, 0x80, 0x0E, 0x38, 0x00, 0xCE, 0x00, 0x38, 0xE0, 0x07,
  0x38, 0x01, 0xC3, 0x80, 0x18, 0xE0, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x38,
  0x38, 0x03, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x60, 0x1C, 0x0E, 0x03, 0x81, 0x80, 0xE0, 0x38, 0x0E, 0x06, 0x03, 0x80,
  0xE0, 0x70, 0x18, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x70, 0x0E, 0x06, 0x01,
  0x81, 0x80, 0x38, 0x38, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x18, 0x38, 0x01,
  0x87, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x07,
  0x38, 0x00, 0x63, 0x00, 0x1C, 0xE0, 0x01, 0x9C, 0x00, 0x73, 0x00, 0x06,
  0x60, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x07, 0x60, 0x00, 0x6C, 0x00, 0x1F,
  0x80, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x00,
  0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x18, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xE0, 0xE0,
  0xE0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38,
  0x38, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x03, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x60,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x30, 0xE0,
  0x00, 0x71, 0x80, 0x00, 0x67, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x83, 0x03, 0x00,
  0x3F, 0x06, 0x01, 0xFF, 0x0C, 0x0F, 0xCF, 0x18, 0x3C, 0x03, 0x70, 0xF0,
  0x06, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC3, 0x00, 0x0F, 0x07, 0x00, 0x3E, 0x0E,
  0x00, 0xEC, 0x1E, 0x03, 0xB8, 0x1E, 0x0E, 0x70, 0x1F, 0xF8, 0xC0, 0x1F,
  0xC1, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x83, 0xF0, 0x03,
  0x0F, 0xF8, 0x07, 0x3E, 0x7C, 0x07, 0x70, 0x1E, 0x07, 0x60, 0x0E, 0x06,
  0xC0, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x7C,
  0x00, 0x70, 0x76, 0x00, 0xF0, 0x67, 0x03, 0xE0, 0x63, 0xFF, 0x80, 0xE1,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xF9, 0xF0, 0x7C, 0x01,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x30, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x70, 0x03, 0xFF, 0x1C, 0x03, 0xF3,
  0xE7, 0x01, 0xE0, 0x19, 0x80, 0xF0, 0x03, 0x60, 0x38, 0x00, 0x78, 0x1C,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x18, 0x00, 0x3C, 0x07, 0x00, 0x1F, 0x01,
  0xC0, 0x0D, 0xC0, 0x78, 0x06, 0x60, 0x0F, 0x07, 0x18, 0x03, 0xFF, 0x86,
  0x00, 0x3F, 0x83, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x9F, 0x03,
  0x80, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x39, 0x80, 0x1E, 0x70, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x41, 0xE0,
  0x38, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x3F, 0xF0, 0xC0, 0x7E,
  0x7C, 0xE0, 0x78, 0x06, 0x60, 0x78, 0x01, 0xB0, 0x38, 0x00, 0x78, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1E, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x81, 0xC0, 0x0D,
  0x80, 0xF0, 0x0C, 0xC0, 0x3C, 0x1C, 0xE0, 0x0F, 0xFC, 0x70, 0x03, 0xF8,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x40,
  0x03, 0xC0, 0x38, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x18,
  0x7F, 0xE0, 0x71, 0xE7, 0xC0, 0xEE, 0x01, 0xC1, 0xD8, 0x03, 0x83, 0x60,
  0x03, 0x07, 0x80, 0x06, 0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x80,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xC7, 0x80, 0x03, 0x9E,
  0x00, 0x07, 0x7C, 0x00, 0x0F, 0xDC, 0x00, 0x1F, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81,
  0x80, 0x07, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x07, 0xE0, 0x0F,
  0xC0, 0x18, 0xFF, 0x80, 0xFF, 0x81, 0xCF, 0x3E, 0x1E, 0x3E, 0x0E, 0xE0,
  0x79, 0xC0, 0x70, 0x6E, 0x01, 0xDC, 0x03, 0x83, 0x60, 0x0E, 0xC0, 0x0C,
  0x1E, 0x00, 0x7C, 0x00, 0x61, 0xE0, 0x03, 0xC0, 0x03, 0x0F, 0x00, 0x1E,
  0x00, 0x18, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x00, 0x0E, 0x38, 0x00,
  0x30, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x30,
  0x00, 0x71, 0xC0, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE0, 0x01, 0xC7, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x03, 0xF0,
  0x06, 0x1F, 0xF8, 0x1C, 0xFD, 0xF8, 0x3B, 0xC0, 0xF0, 0x7E, 0x00, 0xE0,
  0xD8, 0x01, 0xC3, 0xE0, 0x01, 0x87, 0x80, 0x03, 0x0F, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3C, 0x03, 0xC0,
  0xF0, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xC0, 0xFC, 0x00, 0x30, 0xFF, 0x80, 0x1C, 0x79,
  0xF0, 0x07, 0x70, 0x1E, 0x01, 0x98, 0x03, 0x80, 0x6C, 0x00, 0x70, 0x1E,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07,
  0xC0, 0x07, 0x01, 0xD8, 0x03, 0xC0, 0x77, 0x03, 0xE0, 0x18, 0xFF, 0xE0,
  0x06, 0x1F, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0x00, 0xFF, 0xC3, 0x03, 0xF3,
  0xE7, 0x07, 0x80, 0x66, 0x0F, 0x00, 0x36, 0x0E, 0x00, 0x3E, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0x60, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x70, 0x03, 0x70, 0x78, 0x06,
  0x60, 0x3C, 0x1C, 0xE0, 0x1F, 0xF8, 0xE0, 0x0F, 0xF0, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03, 0x07, 0xE0, 0x61, 0xFC,
  0x1C, 0xFF, 0x03, 0xB8, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xFC, 0x1F, 0x9F, 0x87, 0x80, 0x10, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x20, 0x01, 0xC7, 0x80, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x08, 0x1F, 0xF0, 0x1F, 0xE0, 0x0C,
  0x00, 0x0E, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x86, 0x00, 0x1F, 0x0C, 0x00, 0x3C, 0x1C,
  0x00, 0xD8, 0x38, 0x07, 0x70, 0x78, 0x1C, 0xE0, 0x7F, 0xF1, 0x80, 0x7F,
  0x83, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x00,
  0xE7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x81, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xC3,
  0x80, 0x06, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x0E, 0xC0, 0x07, 0x80, 0x0E, 0xE0,
  0x07, 0x80, 0x1C, 0xE0, 0x0F, 0x80, 0x1C, 0xE0, 0x0D, 0x80, 0x38, 0xE0,
  0x1D, 0x80, 0x38, 0xE0, 0x19, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0x70, 0xE0,
  0x31, 0xC0, 0x60, 0xE0, 0x71, 0xC0, 0xE0, 0xE0, 0x61, 0xC0, 0xC0, 0xE0,
  0xE1, 0xC1, 0xC0, 0xE0, 0xC0, 0xC1, 0xC0, 0xE1, 0xC0, 0xC3, 0x80, 0xE1,
  0x80, 0xC3, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0x63, 0x00, 0xC7, 0x00, 0x67,
  0x00, 0xCE, 0x00, 0x66, 0x00, 0xCE, 0x00, 0x6E, 0x00, 0xCC, 0x00, 0x6C,
  0x00, 0xDC, 0x00, 0x7C, 0x00, 0xD8, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x3D, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x05, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1C,
  0x00,
};

const GFXglyph NotoSans_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 35, 11, 1, -34 },
  { 50, 13, 12, 17, 5, -34 },
  { 70, 29, 34, 30, 2, -34 },
  { 194, 23, 39, 26, 2, -36 },
  { 307, 31, 36, 37, 4, -35 },
  { 447, 29, 35, 33, 2, -35 },
  { 574, 5, 12, 9, 5, -34 },
  { 582, 14, 42, 13, 2, -34 },
  { 656, 14, 42, 13, -3, -34 },
  { 730, 20, 21, 26, 6, -36 },
  { 783, 23, 22, 27, 3, -28 },
  { 847, 8, 12, 11, -2, -6 },
  { 859, 11, 2, 15, 2, -14 },
  { 862, 5, 5, 11, 1, -4 },
  { 866, 22, 34, 16, -2, -34 },
  { 960, 22, 35, 26, 3, -35 },
  { 1057, 13, 34, 26, 7, -34 },
  { 1113, 25, 35, 26, 0, -35 },
  { 1223, 24, 35, 26, 1, -35 },
  { 1328, 25, 34, 26, 1, -34 },
  { 1435, 24, 34, 26, 2, -34 },
  { 1537, 23, 35, 26, 3, -35 },
  { 1638, 22, 34, 26, 5, -34 },
  { 1732, 24, 35, 26, 2, -35 },
  { 1837, 23, 35, 26, 2, -35 },
  { 1938, 9, 27, 11, 1, -26 },
  { 1969, 12, 32, 11, -2, -26 },
  { 2017, 23, 23, 27, 3, -29 },
  { 2084, 22, 12, 27, 4, -23 },
  { 2117, 23, 23, 27, 3, -29 },
  { 2184, 17, 36, 20, 4, -35 },
  { 2261, 36, 38, 40, 3, -34 },
  { 2432, 27, 34, 27, -3, -34 },
  { 2547, 26, 34, 29, 2, -34 },
  { 2658, 26, 35, 28, 4, -35 },
  { 2772, 29, 34, 32, 2, -34 },
  { 2896, 25, 34, 25, 2, -34 },
  { 3003, 25, 34, 23, 2, -34 },
  { 3110, 28, 35, 33, 4, -35 },
  { 3233, 31, 34, 33, 2, -34 },
  { 3365, 17, 34, 15, 0, -34 },
  { 3438, 20, 43, 12, -8, -34 },
  { 3546, 29, 34, 27, 2, -34 },
  { 3670, 18, 34, 23, 2, -34 },
  { 3747, 38, 34, 40, 2, -34 },
  { 3909, 31, 34, 33, 2, -34 },
  { 4041, 29, 35, 35, 4, -35 },
  { 4168, 25, 34, 27, 2, -34 },
  { 4275, 29, 43, 35, 4, -35 },
  { 4431, 25, 34, 27, 2, -34 },
  { 4538, 24, 35, 24, 1, -35 },
  { 4643, 24, 34, 24, 4, -34 },
  { 4745, 29, 34, 33, 4, -34 },
  { 4869, 25, 34, 26, 5, -34 },
  { 4976, 38, 34, 40, 6, -34 },
  { 5138, 31, 34, 24, -3, -34 },
  { 5270, 23, 34, 24, 5, -34 },
  { 5368, 27, 34, 26, 0, -34 },
  { 5483, 18, 42, 14, 0, -34 },
  { 5578, 8, 34, 16, 5, -34 },
  { 5612, 18, 42, 14, -3, -34 },
  { 5707, 23, 22, 27, 2, -35 },
  { 5771, 19, 2, 18, -4, 5 },
  { 5776, 7, 8, 12, 7, -37 },
  { 5783, 23, 26, 27, 2, -26 },
  { 5858, 24, 36, 28, 1, -36 },
  { 5966, 20, 26, 22, 2, -26 },
  { 6031, 26, 36, 28, 2, -36 },
  { 6148, 19, 26, 24, 3, -26 },
  { 6210, 27, 49, 14, -6, -37 },
  { 6376, 25, 38, 28, 1, -26 },
  { 6495, 23, 36, 27, 1, -36 },
  { 6599, 11, 35, 11, 1, -35 },
  { 6648, 18, 47, 11, -6, -35 },
  { 6754, 23, 36, 22, 1, -36 },
  { 6858, 11, 36, 11, 1, -36 },
  { 6908, 37, 26, 41, 1, -26 },
  { 7029, 23, 26, 27, 1, -26 },
  { 7104, 23, 26, 27, 2, -26 },
  { 7179, 26, 37, 28, -1, -26 },
  { 7300, 24, 37, 28, 2, -26 },
  { 7411, 19, 26, 18, 1, -26 },
  { 7473, 19, 26, 21, 0, -26 },
  { 7535, 15, 32, 15, 2, -32 },
  { 7595, 23, 26, 27, 3, -26 },
  { 7670, 21, 26, 21, 2, -26 },
  { 7739, 32, 26, 33, 3, -26 },
  { 7843, 26, 26, 23, -2, -26 },
  { 7928, 28, 38, 21, -5, -26 },
  { 8061, 22, 26, 21, -1, -26 },
  { 8133, 18, 42, 16, 1, -34 },
  { 8228, 2, 48, 26, 13, -36 },
  { 8240, 18, 42, 16, -2, -34 },
  { 8335, 23, 6, 27, 3, -20 },
};

const GFXfont NotoSans_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_LIGHTITALIC48PT7B_H_
