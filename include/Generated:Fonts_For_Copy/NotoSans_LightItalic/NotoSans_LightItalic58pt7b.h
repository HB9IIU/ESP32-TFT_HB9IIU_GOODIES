#ifndef _NOTOSANS_LIGHTITALIC58PT7B_H_
#define _NOTOSANS_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x04, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x79, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0xE3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0xF8, 0x60, 0xE0, 0x1E, 0x0E, 0x02, 0x03, 0xC0, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x18, 0x00,
  0x03, 0xC1, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x77, 0xE0, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x60, 0xF0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xC0,
  0x78, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xC1, 0xE0, 0x80, 0x18, 0x3E, 0x0F, 0x81, 0x8F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x10, 0x1F,
  0xF0, 0x00, 0x07, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x1E, 0x0E, 0x00, 0x07,
  0x01, 0xE0, 0x78, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x07, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x07, 0x07, 0x00,
  0x07, 0x00, 0x70, 0x70, 0xFF, 0x38, 0x03, 0x87, 0x0F, 0xFD, 0xC0, 0x38,
  0x78, 0xF1, 0xEE, 0x01, 0xC3, 0x8F, 0x03, 0xF0, 0x1C, 0x38, 0x70, 0x1D,
  0xC1, 0xE3, 0x87, 0x00, 0xEF, 0xFE, 0x3C, 0x38, 0x03, 0x3F, 0xE1, 0xC3,
  0x80, 0x18, 0xFC, 0x1C, 0x1C, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x3C, 0x00, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0xF0, 0x1C,
  0x00, 0x03, 0xFF, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0x1C, 0x3E, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x00, 0xF8, 0x70, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x0F, 0x00,
  0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x00, 0x38, 0xF0, 0x00, 0xE0, 0x0E, 0x3C,
  0x00, 0x1E, 0x03, 0xC7, 0x00, 0x01, 0xE0, 0x70, 0xE0, 0x00, 0x1C, 0x1C,
  0x3C, 0x00, 0x03, 0xC7, 0x87, 0x80, 0x00, 0x3D, 0xE0, 0xF0, 0x00, 0x03,
  0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x3E, 0xF0, 0x0F,
  0x80, 0x1F, 0x8F, 0x00, 0xFC, 0x1F, 0xC0, 0xF0, 0x0F, 0xFF, 0xE0, 0x0E,
  0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x73,
  0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0x00, 0x38, 0x01, 0xE0, 0x18, 0x00, 0xFC, 0x0C, 0x00,
  0x1F, 0x8E, 0x00, 0x03, 0xF6, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0xC0,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x77, 0xFF, 0xEF, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x7C, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0xF8,
  0x00, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xDE, 0x0F, 0x9C, 0x3F, 0x1C, 0xFC, 0x1C, 0xF0, 0x3C, 0x60, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xC0, 0x01, 0xE0,
  0x02, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x3C, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x40, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF8,
  0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x08, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x7E, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xF8, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x03, 0x83, 0xFF, 0x00, 0x38, 0xFF, 0xFC, 0x07, 0xBE, 0x07, 0xE0,
  0x77, 0x80, 0x1E, 0x07, 0x60, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0x70, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x3B, 0x83, 0xE0, 0x0F, 0x70, 0x3F, 0xBF, 0x9E, 0x03, 0xFF, 0xE3, 0x80,
  0x1F, 0xF0, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x20, 0x03, 0xE0, 0x07, 0xC7,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0,
  0xF8, 0x3C, 0x0F, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xE0, 0x3E, 0x30, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x71, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0x1C,
  0x00, 0x7C, 0x07, 0x80, 0x73, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x73, 0x80, 0x38, 0x00, 0x70, 0x07, 0x70, 0x07, 0x80,
  0x0E, 0x00, 0x77, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0x77, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0x7E, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xEE,
  0x01, 0xC0, 0x03, 0xC0, 0x0E, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xCE, 0x01,
  0xC0, 0x07, 0x80, 0x1C, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x8E, 0x01, 0xC0,
  0x0D, 0x80, 0x78, 0xE0, 0x0E, 0x01, 0xDC, 0x07, 0x07, 0x00, 0xF0, 0x39,
  0xC1, 0xE0, 0x70, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x1F,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x7E,
  0x00, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x1C, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x00,
  0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x3C,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0x8E, 0x00, 0x03, 0xFF, 0xE3, 0x80, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x3E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x38,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xF3,
  0xF0, 0x00, 0x00, 0x3D, 0xFC, 0x00, 0x00, 0x0E, 0xE7, 0x80, 0x00, 0x03,
  0xF1, 0xE0, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0xE0,
  0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x78, 0x07,
  0x70, 0x00, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x00, 0x03, 0x9C, 0x03, 0xDC,
  0x00, 0x00, 0x3C, 0xE0, 0x1C, 0x70, 0x00, 0x01, 0xCF, 0x00, 0xE3, 0x80,
  0x00, 0x1E, 0x70, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x00,
  0x0E, 0x1C, 0x03, 0xC7, 0x00, 0x00, 0x71, 0xE0, 0x1C, 0x38, 0x00, 0x07,
  0x0F, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0,
  0x1C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0,
  0x70, 0x07, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x1C, 0x01, 0xE0, 0x1C, 0x00, 0xE1, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0xE0, 0x03,
  0x80, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x70, 0x01, 0xE0,
  0x1C, 0x00, 0x73, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x07,
  0x00, 0x0F, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x1F,
  0xC0, 0x00, 0x07, 0x00, 0xEE, 0x00, 0x00, 0x38, 0x07, 0x70, 0x00, 0x03,
  0xC0, 0x39, 0xC0, 0x00, 0x1C, 0x03, 0xCE, 0x00, 0x00, 0xE0, 0x1C, 0x78,
  0x00, 0x07, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x07, 0x0E, 0x00, 0x03, 0xC0,
  0x38, 0x38, 0x00, 0x1C, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x1C, 0x0F, 0x00,
  0x07, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0x1C, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x78, 0x07, 0x00, 0x07, 0x03, 0x80, 0x78, 0x00, 0x1C,
  0x1C, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x07, 0x87, 0x00, 0xE0,
  0x00, 0x1C, 0x78, 0x07, 0x00, 0x00, 0xE3, 0x80, 0x78, 0x00, 0x03, 0x9C,
  0x03, 0x80, 0x00, 0x1C, 0xE0, 0x1C, 0x00, 0x00, 0xF7, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x03,
  0x80, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x38,
  0x00, 0xFC, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xF0, 0x0E, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x40, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0xF0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF3, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x0E,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE0, 0xF0,
  0x01, 0xC3, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x0F, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x07,
  0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x1C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x70, 0x1E, 0x01,
  0xC0, 0x78, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x1C,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x01, 0xC0,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xCE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x1F, 0xE0, 0x70, 0x07,
  0xFF, 0x87, 0x01, 0xFE, 0xF8, 0xE0, 0x3E, 0x01, 0xCE, 0x07, 0xC0, 0x0E,
  0xE0, 0xF8, 0x00, 0x6E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x38, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x6E, 0x07, 0x00,
  0x0F, 0xC0, 0x78, 0x01, 0xDC, 0x07, 0xC0, 0x79, 0xC0, 0x3F, 0x1F, 0x1C,
  0x01, 0xFF, 0xC1, 0xC0, 0x0F, 0xF8, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x1F, 0xF0,
  0x03, 0x87, 0xFF, 0x80, 0x38, 0xFD, 0xFC, 0x03, 0x9E, 0x03, 0xE0, 0x7B,
  0x80, 0x1E, 0x07, 0x70, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x70, 0xF8, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x70,
  0x7E, 0x00, 0x0F, 0x07, 0x60, 0x01, 0xE0, 0xE7, 0x00, 0x7C, 0x0E, 0x3E,
  0x1F, 0x80, 0xE1, 0xFF, 0xF0, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0x7E, 0x03, 0xE0,
  0x02, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x20, 0x1F, 0xC3, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x0E, 0x00, 0x1F, 0xFE, 0x1C, 0x00,
  0xFF, 0x3E, 0x38, 0x03, 0xE0, 0x0E, 0xF0, 0x0F, 0x80, 0x0D, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0x80,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x3B, 0x80, 0x3C, 0x00, 0xE7, 0x00,
  0x7C, 0x03, 0x8E, 0x00, 0x7E, 0x3E, 0x38, 0x00, 0x7F, 0xF8, 0x70, 0x00,
  0x7F, 0xC0, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0xFE, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0x07,
  0x80, 0x0F, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0x70,
  0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x1F, 0xC3, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x18, 0x01, 0xFF, 0xE1, 0xC0, 0x3F, 0xCF, 0x8E, 0x03,
  0xE0, 0x0E, 0x70, 0x3E, 0x00, 0x33, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3E, 0x0E,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x3F, 0x01, 0xC0, 0x03, 0xB8, 0x0F, 0x00,
  0x39, 0xC0, 0x7C, 0x03, 0x9E, 0x01, 0xF8, 0xF8, 0xE0, 0x07, 0xFF, 0x87,
  0x00, 0x1F, 0xF0, 0x38, 0x00, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x03, 0xFE, 0x00, 0xE1, 0xFF, 0xE0, 0x1C,
  0x7E, 0xFE, 0x03, 0x9E, 0x01, 0xE0, 0xE7, 0x00, 0x3C, 0x1D, 0xC0, 0x03,
  0x83, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x0E, 0x1F, 0x00, 0x01, 0xC3, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x83, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x0E,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x0E,
  0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x7E, 0x00,
  0x01, 0xDF, 0xC0, 0x00, 0x3F, 0xBC, 0x00, 0x07, 0xE3, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x38, 0x7F, 0xF0, 0x1F, 0xFE,
  0x03, 0x8F, 0xBF, 0x83, 0xE7, 0xE0, 0x31, 0xC0, 0x78, 0x70, 0x0F, 0x07,
  0x38, 0x03, 0x8E, 0x00, 0xF0, 0x77, 0x00, 0x3D, 0xC0, 0x07, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x70, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x70, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x38, 0x1F, 0xF0, 0x03,
  0x87, 0xFF, 0xC0, 0x38, 0xFF, 0xFC, 0x07, 0x9E, 0x03, 0xE0, 0x73, 0x80,
  0x1E, 0x07, 0x70, 0x00, 0xE0, 0x7E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x3F, 0xE0,
  0x00, 0xE1, 0xFF, 0xE0, 0x01, 0xC7, 0xEF, 0xE0, 0x03, 0x1E, 0x03, 0xE0,
  0x0E, 0x70, 0x03, 0xC0, 0x1D, 0xC0, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x80, 0x03,
  0xC0, 0x3B, 0x00, 0x0F, 0x00, 0x77, 0x00, 0x7C, 0x01, 0xE7, 0xC3, 0xF0,
  0x03, 0x87, 0xFF, 0xC0, 0x07, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x30, 0x07, 0xFF, 0x87, 0x01, 0xFE,
  0x7C, 0x70, 0x3E, 0x00, 0xE7, 0x07, 0xC0, 0x06, 0x60, 0xF8, 0x00, 0x7E,
  0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x1F, 0x0E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7E, 0x07, 0x00, 0x0E, 0xE0, 0x78, 0x01,
  0xCE, 0x07, 0xC0, 0x39, 0xE0, 0x3F, 0x1F, 0x1C, 0x01, 0xFF, 0xE1, 0xC0,
  0x0F, 0xF8, 0x1C, 0x00, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x81, 0xFC, 0x0E, 0x1F, 0xF0, 0x38,
  0xFF, 0x80, 0xC7, 0x80, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x1F, 0xE7, 0xF0, 0x3C, 0x00, 0x60, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC2, 0x00, 0x07,
  0x86, 0x00, 0x1E, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x0C, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x08, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x6E, 0x0F, 0x00, 0x0E, 0xE0, 0xF0, 0x01, 0xDC,
  0x07, 0x80, 0x79, 0xC0, 0x7E, 0x3F, 0x1C, 0x03, 0xFF, 0xE1, 0xC0, 0x1F,
  0xF8, 0x18, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00,
  0x78, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xC0, 0x01, 0xCF, 0x00, 0x0D, 0x80, 0x07, 0x8E, 0x00, 0x3B, 0x80, 0x0E,
  0x1C, 0x00, 0x77, 0x00, 0x3C, 0x38, 0x01, 0xCE, 0x00, 0x70, 0x70, 0x03,
  0x9C, 0x01, 0xE0, 0xE0, 0x0E, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x70, 0x07,
  0x03, 0x80, 0x70, 0xE0, 0x1E, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x0E, 0x03,
  0x83, 0x80, 0xF0, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x07,
  0x80, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x01, 0xC1,
  0xC0, 0x38, 0x70, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x07, 0x0E, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x1D,
  0xC0, 0x00, 0xDC, 0x00, 0x3F, 0x00, 0x01, 0xB0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80,
  0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x05, 0xFF, 0xF8,
  0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xFD, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 42, 14, 2, -41 },
  { 64, 15, 15, 20, 6, -41 },
  { 93, 35, 41, 37, 2, -41 },
  { 273, 28, 47, 32, 2, -44 },
  { 438, 37, 43, 45, 5, -42 },
  { 637, 35, 43, 39, 2, -42 },
  { 826, 6, 15, 11, 6, -41 },
  { 838, 18, 50, 15, 2, -41 },
  { 951, 18, 50, 15, -4, -41 },
  { 1064, 25, 26, 31, 7, -44 },
  { 1146, 27, 27, 33, 4, -34 },
  { 1238, 10, 14, 13, -3, -7 },
  { 1256, 14, 3, 18, 2, -17 },
  { 1262, 5, 6, 14, 2, -5 },
  { 1266, 27, 41, 19, -3, -41 },
  { 1405, 27, 43, 32, 4, -42 },
  { 1551, 16, 41, 32, 9, -41 },
  { 1633, 30, 42, 32, 0, -42 },
  { 1791, 29, 43, 32, 1, -42 },
  { 1947, 30, 42, 32, 1, -42 },
  { 2105, 29, 42, 32, 2, -41 },
  { 2258, 28, 43, 32, 4, -42 },
  { 2409, 27, 41, 32, 6, -41 },
  { 2548, 28, 43, 32, 3, -42 },
  { 2699, 27, 43, 32, 3, -42 },
  { 2845, 10, 32, 14, 2, -31 },
  { 2885, 15, 38, 14, -3, -31 },
  { 2957, 27, 28, 33, 4, -35 },
  { 3052, 27, 15, 33, 4, -28 },
  { 3103, 27, 28, 33, 4, -35 },
  { 3198, 20, 43, 24, 5, -42 },
  { 3306, 44, 46, 49, 3, -41 },
  { 3559, 32, 41, 32, -3, -41 },
  { 3723, 31, 41, 35, 3, -41 },
  { 3882, 32, 43, 34, 5, -42 },
  { 4054, 34, 41, 39, 3, -41 },
  { 4229, 29, 41, 30, 3, -41 },
  { 4378, 29, 41, 28, 3, -41 },
  { 4527, 34, 43, 40, 5, -42 },
  { 4710, 36, 41, 40, 3, -41 },
  { 4895, 20, 41, 18, 0, -41 },
  { 4998, 24, 52, 15, -9, -41 },
  { 5154, 34, 41, 32, 3, -41 },
  { 5329, 21, 41, 28, 3, -41 },
  { 5437, 45, 41, 48, 3, -41 },
  { 5668, 37, 41, 40, 3, -41 },
  { 5858, 35, 43, 42, 5, -42 },
  { 6047, 30, 41, 33, 3, -41 },
  { 6201, 35, 52, 42, 5, -42 },
  { 6429, 30, 41, 33, 3, -41 },
  { 6583, 29, 43, 29, 1, -42 },
  { 6739, 29, 41, 29, 5, -41 },
  { 6888, 35, 42, 40, 5, -41 },
  { 7072, 30, 41, 32, 6, -41 },
  { 7226, 46, 41, 49, 7, -41 },
  { 7462, 37, 41, 29, -3, -41 },
  { 7652, 29, 41, 29, 5, -41 },
  { 7801, 34, 41, 31, -1, -41 },
  { 7976, 22, 50, 17, -1, -41 },
  { 8114, 10, 41, 19, 6, -41 },
  { 8166, 22, 50, 17, -4, -41 },
  { 8304, 27, 26, 33, 3, -42 },
  { 8392, 23, 2, 22, -5, 6 },
  { 8398, 8, 9, 15, 9, -44 },
  { 8407, 28, 32, 32, 3, -31 },
  { 8519, 28, 45, 33, 2, -44 },
  { 8677, 24, 32, 26, 3, -31 },
  { 8773, 31, 45, 33, 3, -44 },
  { 8948, 24, 32, 29, 3, -31 },
  { 9044, 32, 58, 17, -7, -44 },
  { 9276, 29, 45, 33, 2, -31 },
  { 9440, 27, 44, 33, 2, -44 },
  { 9589, 12, 42, 14, 2, -42 },
  { 9652, 22, 56, 14, -8, -42 },
  { 9806, 27, 44, 27, 2, -44 },
  { 9955, 12, 44, 14, 2, -44 },
  { 10021, 44, 31, 50, 2, -31 },
  { 10192, 28, 32, 33, 2, -32 },
  { 10304, 27, 32, 33, 3, -31 },
  { 10412, 31, 45, 33, -1, -31 },
  { 10587, 28, 45, 33, 3, -31 },
  { 10745, 22, 31, 22, 2, -31 },
  { 10831, 23, 32, 25, 1, -31 },
  { 10923, 17, 39, 19, 3, -38 },
  { 11006, 28, 32, 33, 3, -31 },
  { 11118, 25, 31, 25, 3, -31 },
  { 11215, 39, 31, 40, 3, -31 },
  { 11367, 30, 31, 27, -2, -31 },
  { 11484, 34, 45, 25, -6, -31 },
  { 11676, 26, 31, 26, -1, -31 },
  { 11777, 22, 50, 20, 1, -41 },
  { 11915, 3, 58, 32, 16, -44 },
  { 11937, 22, 50, 20, -3, -41 },
  { 12075, 27, 7, 33, 4, -24 },
};

const GFXfont NotoSans_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_LIGHTITALIC58PT7B_H_
