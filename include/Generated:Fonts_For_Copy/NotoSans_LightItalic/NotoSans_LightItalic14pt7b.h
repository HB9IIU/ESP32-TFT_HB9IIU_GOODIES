#ifndef _NOTOSANS_LIGHTITALIC14PT7B_H_
#define _NOTOSANS_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x90, 0x18, 0xB6, 0xE0, 0x09, 0x04, 0x84, 0x8F, 0xF1,
  0x20, 0x93, 0xFC, 0x48, 0x24, 0x24, 0x00, 0x08, 0x27, 0x54, 0x51, 0x83,
  0x89, 0x2B, 0xE2, 0x10, 0x70, 0xA8, 0xA4, 0x92, 0x89, 0x7F, 0x54, 0x52,
  0x49, 0x24, 0xA3, 0x80, 0x3C, 0x24, 0x24, 0x28, 0x30, 0x51, 0x8A, 0x86,
  0x84, 0xFA, 0xF0, 0x18, 0x88, 0x84, 0x21, 0x10, 0x84, 0x10, 0x80, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x4C, 0x10, 0x8E, 0x0F, 0x62, 0x41, 0x00, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x00, 0x29, 0x40, 0xF0, 0xC0, 0x02, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x61,
  0x89, 0xC0, 0x35, 0x92, 0x22, 0x24, 0x44, 0x1E, 0x44, 0x08, 0x10, 0x41,
  0x04, 0x10, 0x41, 0xF8, 0x3E, 0x04, 0x08, 0x11, 0xC4, 0x80, 0x81, 0x05,
  0xF0, 0x02, 0x0C, 0x28, 0x92, 0x48, 0xA1, 0x7F, 0x04, 0x10, 0x3E, 0x81,
  0x02, 0x07, 0x80, 0x81, 0x02, 0x09, 0xE0, 0x1E, 0x41, 0x02, 0x0F, 0x90,
  0xA1, 0x42, 0x88, 0xE0, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41,
  0x80, 0x3C, 0x85, 0x0A, 0x23, 0x89, 0x21, 0x42, 0x85, 0xF0, 0x39, 0x18,
  0x61, 0x85, 0xF0, 0x42, 0x0B, 0xC0, 0x24, 0x00, 0x06, 0x11, 0x00, 0x00,
  0x24, 0x48, 0x0E, 0x61, 0x06, 0x03, 0x80, 0xC0, 0xFC, 0x00, 0x3F, 0xC0,
  0x60, 0x30, 0x73, 0x18, 0x00, 0x78, 0x42, 0x11, 0x11, 0x00, 0x04, 0x00,
  0x1F, 0x88, 0x14, 0x06, 0x3D, 0x92, 0x68, 0x9A, 0x26, 0x9A, 0x99, 0x10,
  0x03, 0xE0, 0x02, 0x06, 0x0A, 0x0A, 0x12, 0x11, 0x3F, 0x21, 0x41, 0x81,
  0x3C, 0x85, 0x0A, 0x17, 0xD0, 0xA0, 0xC1, 0x85, 0xF0, 0x1F, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x7C, 0x3C, 0x42, 0x41, 0x41, 0x41,
  0x81, 0x81, 0x82, 0x84, 0xF8, 0x3E, 0x81, 0x02, 0x07, 0xD0, 0x20, 0x40,
  0x81, 0xF0, 0x3E, 0x81, 0x02, 0x04, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x1F,
  0x20, 0x40, 0x40, 0x80, 0x8F, 0x82, 0x82, 0x42, 0x7E, 0x20, 0xA0, 0x90,
  0x48, 0x27, 0xF4, 0x12, 0x09, 0x04, 0x82, 0x41, 0x00, 0x38, 0x88, 0x42,
  0x10, 0x88, 0x47, 0x00, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x08, 0xC0, 0x23, 0x44, 0x48, 0x50, 0x60, 0x50, 0x90, 0x88, 0x88, 0x84,
  0x22, 0x10, 0x84, 0x42, 0x10, 0x87, 0xC0, 0x20, 0x6C, 0x19, 0x83, 0x28,
  0xA5, 0x15, 0x25, 0x25, 0x24, 0xA4, 0x98, 0x91, 0x10, 0x20, 0xB0, 0x94,
  0x4A, 0x25, 0x14, 0x4A, 0x29, 0x0C, 0x86, 0x41, 0x00, 0x1E, 0x10, 0x90,
  0x50, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x42, 0x3E, 0x00, 0x3C, 0x85, 0x0A,
  0x14, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x1E, 0x10, 0x90, 0x50, 0x18, 0x0C,
  0x0A, 0x05, 0x02, 0x42, 0x3E, 0x02, 0x00, 0x80, 0x3C, 0x85, 0x0A, 0x14,
  0x4F, 0x22, 0x44, 0x89, 0x08, 0x1E, 0x41, 0x01, 0x03, 0x01, 0x01, 0x02,
  0x05, 0xF0, 0xFE, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x80, 0x40,
  0xA0, 0x90, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x3E, 0x00, 0x81,
  0x82, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x20, 0x84, 0x31, 0x8A,
  0x31, 0x4A, 0x49, 0x49, 0x4A, 0x29, 0x46, 0x28, 0xC6, 0x10, 0xC0, 0x10,
  0x88, 0x84, 0x81, 0x80, 0xC0, 0x60, 0x50, 0x48, 0x42, 0x61, 0x00, 0x82,
  0x89, 0x12, 0x45, 0x04, 0x08, 0x10, 0x40, 0x80, 0x3F, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0xFC, 0x39, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x21, 0xC0, 0x89, 0x24, 0x91, 0x24, 0x38, 0x42, 0x11, 0x08, 0x42, 0x11,
  0x09, 0xC0, 0x10, 0xA2, 0x92, 0x86, 0x10, 0xF8, 0x94, 0x31, 0x38, 0x61,
  0x86, 0x28, 0xBE, 0x10, 0x40, 0x81, 0x63, 0x24, 0x50, 0xA1, 0x42, 0x8A,
  0xE0, 0x3A, 0x21, 0x08, 0x42, 0x0E, 0x02, 0x04, 0x09, 0x94, 0xD0, 0xA1,
  0x42, 0x85, 0x13, 0xE0, 0x31, 0x28, 0x66, 0xE2, 0x08, 0x1E, 0x03, 0x04,
  0x08, 0x1E, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xE0,
  0x18, 0x25, 0x42, 0x42, 0x42, 0x42, 0x44, 0x7C, 0x04, 0x04, 0xF8, 0x10,
  0x40, 0x81, 0x63, 0x24, 0x50, 0xA1, 0x42, 0x8A, 0x10, 0x20, 0x14, 0x92,
  0x50, 0x08, 0x00, 0x11, 0x08, 0x42, 0x11, 0x08, 0x4E, 0x00, 0x10, 0x40,
  0x81, 0x12, 0x49, 0x14, 0x38, 0x48, 0x92, 0x10, 0x24, 0x92, 0x92, 0x4A,
  0x00, 0x0C, 0xC6, 0x64, 0x88, 0xA1, 0x14, 0x42, 0x88, 0x51, 0x14, 0x22,
  0x0C, 0x64, 0x8A, 0x14, 0x28, 0x51, 0x42, 0x39, 0x18, 0x61, 0x86, 0x18,
  0x9C, 0x0C, 0x64, 0x8A, 0x14, 0x28, 0x51, 0x5C, 0x81, 0x02, 0x00, 0x30,
  0x96, 0x14, 0x28, 0x50, 0xA2, 0x7C, 0x08, 0x10, 0x60, 0x0C, 0xC2, 0x10,
  0x41, 0x04, 0x20, 0x39, 0x14, 0x18, 0x10, 0x20, 0xBC, 0x4F, 0x48, 0x88,
  0x88, 0xC0, 0x46, 0x18, 0x61, 0x8A, 0x2F, 0x80, 0x8E, 0x29, 0x24, 0xA2,
  0x84, 0x00, 0x88, 0xCC, 0xAA, 0x55, 0x4C, 0xA6, 0x62, 0x10, 0x46, 0x50,
  0x40, 0x83, 0x09, 0x22, 0x00, 0x23, 0x22, 0x24, 0x24, 0x28, 0x28, 0x10,
  0x20, 0x20, 0xC0, 0x7C, 0x21, 0x08, 0x41, 0x0F, 0x80, 0x08, 0x84, 0x42,
  0x13, 0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x18, 0x20, 0x82, 0x10, 0x30,
  0x84, 0x10, 0x82, 0x30, 0x63, 0x38,
};

const GFXglyph NotoSans_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 5, 2, -10 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 6, 12, 8, 1, -11 },
  { 28, 9, 10, 11, 1, -10 },
  { 40, 8, 10, 9, 1, -10 },
  { 50, 1, 4, 3, 2, -10 },
  { 51, 5, 12, 4, 0, -10 },
  { 59, 4, 12, 4, -1, -10 },
  { 65, 6, 7, 8, 2, -11 },
  { 71, 7, 6, 8, 1, -8 },
  { 77, 3, 4, 3, -1, -2 },
  { 79, 4, 1, 4, 0, -4 },
  { 80, 2, 1, 3, 0, -1 },
  { 81, 7, 10, 5, -1, -10 },
  { 90, 6, 10, 8, 1, -10 },
  { 98, 4, 10, 8, 2, -10 },
  { 103, 7, 10, 8, 0, -10 },
  { 112, 7, 10, 8, 0, -10 },
  { 121, 7, 10, 8, 0, -10 },
  { 130, 7, 10, 8, 1, -10 },
  { 139, 7, 10, 8, 1, -10 },
  { 148, 7, 10, 8, 1, -10 },
  { 157, 7, 10, 8, 1, -10 },
  { 166, 6, 10, 8, 1, -10 },
  { 174, 3, 8, 3, 0, -8 },
  { 177, 4, 10, 3, -1, -8 },
  { 182, 7, 6, 8, 1, -8 },
  { 188, 6, 4, 8, 1, -7 },
  { 191, 7, 6, 8, 1, -8 },
  { 197, 5, 10, 6, 1, -10 },
  { 204, 10, 11, 12, 1, -10 },
  { 218, 8, 10, 8, -1, -10 },
  { 228, 7, 10, 8, 1, -10 },
  { 237, 8, 10, 8, 1, -10 },
  { 247, 8, 10, 9, 1, -10 },
  { 257, 7, 10, 7, 1, -10 },
  { 266, 7, 10, 7, 1, -10 },
  { 275, 8, 10, 10, 1, -10 },
  { 285, 9, 10, 10, 1, -10 },
  { 297, 5, 10, 4, 0, -10 },
  { 304, 6, 13, 4, -2, -10 },
  { 314, 8, 10, 8, 1, -10 },
  { 324, 5, 10, 7, 1, -10 },
  { 331, 11, 10, 12, 1, -10 },
  { 345, 9, 10, 10, 1, -10 },
  { 357, 9, 10, 10, 1, -10 },
  { 369, 7, 10, 8, 1, -10 },
  { 378, 9, 12, 10, 1, -10 },
  { 392, 7, 10, 8, 1, -10 },
  { 401, 7, 10, 7, 0, -10 },
  { 410, 7, 10, 7, 1, -10 },
  { 419, 9, 10, 10, 1, -10 },
  { 431, 8, 10, 8, 1, -10 },
  { 441, 11, 10, 12, 2, -10 },
  { 455, 9, 10, 7, -1, -10 },
  { 467, 7, 10, 7, 1, -10 },
  { 476, 8, 10, 7, 0, -10 },
  { 486, 5, 12, 4, 0, -10 },
  { 494, 3, 10, 5, 1, -10 },
  { 498, 5, 12, 4, -1, -10 },
  { 506, 6, 6, 8, 1, -10 },
  { 511, 5, 1, 5, -1, 1 },
  { 512, 2, 3, 4, 2, -11 },
  { 513, 6, 8, 8, 1, -8 },
  { 519, 7, 11, 8, 0, -11 },
  { 529, 5, 8, 6, 1, -8 },
  { 534, 7, 11, 8, 1, -11 },
  { 544, 6, 8, 7, 1, -8 },
  { 550, 8, 14, 4, -2, -11 },
  { 564, 8, 11, 8, 0, -8 },
  { 575, 7, 11, 8, 0, -11 },
  { 585, 3, 10, 3, 0, -10 },
  { 589, 5, 13, 3, -2, -10 },
  { 598, 7, 11, 7, 0, -11 },
  { 608, 3, 11, 3, 0, -11 },
  { 613, 11, 8, 12, 0, -8 },
  { 624, 7, 8, 8, 0, -8 },
  { 631, 6, 8, 8, 1, -8 },
  { 637, 7, 11, 8, 0, -8 },
  { 647, 7, 11, 8, 1, -8 },
  { 657, 6, 8, 5, 0, -8 },
  { 663, 6, 8, 6, 0, -8 },
  { 669, 4, 9, 5, 1, -9 },
  { 674, 6, 7, 8, 1, -7 },
  { 680, 6, 7, 6, 1, -7 },
  { 686, 9, 7, 10, 1, -7 },
  { 694, 7, 7, 7, 0, -7 },
  { 701, 8, 10, 6, -1, -7 },
  { 711, 6, 7, 6, 0, -7 },
  { 717, 5, 12, 5, 0, -10 },
  { 725, 1, 14, 8, 4, -11 },
  { 727, 6, 12, 5, -1, -10 },
  { 736, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_LIGHTITALIC14PT7B_H_
