#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_LightItalic6pt7b, 6, "NotoSans_LightItalic6pt7b" },
  { &NotoSans_LightItalic7pt7b, 7, "NotoSans_LightItalic7pt7b" },
  { &NotoSans_LightItalic8pt7b, 8, "NotoSans_LightItalic8pt7b" },
  { &NotoSans_LightItalic9pt7b, 9, "NotoSans_LightItalic9pt7b" },
  { &NotoSans_LightItalic10pt7b, 10, "NotoSans_LightItalic10pt7b" },
  { &NotoSans_LightItalic11pt7b, 11, "NotoSans_LightItalic11pt7b" },
  { &NotoSans_LightItalic12pt7b, 12, "NotoSans_LightItalic12pt7b" },
  { &NotoSans_LightItalic13pt7b, 13, "NotoSans_LightItalic13pt7b" },
  { &NotoSans_LightItalic14pt7b, 14, "NotoSans_LightItalic14pt7b" },
  { &NotoSans_LightItalic15pt7b, 15, "NotoSans_LightItalic15pt7b" },
  { &NotoSans_LightItalic16pt7b, 16, "NotoSans_LightItalic16pt7b" },
  { &NotoSans_LightItalic17pt7b, 17, "NotoSans_LightItalic17pt7b" },
  { &NotoSans_LightItalic18pt7b, 18, "NotoSans_LightItalic18pt7b" },
  { &NotoSans_LightItalic19pt7b, 19, "NotoSans_LightItalic19pt7b" },
  { &NotoSans_LightItalic20pt7b, 20, "NotoSans_LightItalic20pt7b" },
  { &NotoSans_LightItalic21pt7b, 21, "NotoSans_LightItalic21pt7b" },
  { &NotoSans_LightItalic22pt7b, 22, "NotoSans_LightItalic22pt7b" },
  { &NotoSans_LightItalic23pt7b, 23, "NotoSans_LightItalic23pt7b" },
  { &NotoSans_LightItalic24pt7b, 24, "NotoSans_LightItalic24pt7b" },
  { &NotoSans_LightItalic25pt7b, 25, "NotoSans_LightItalic25pt7b" },
  { &NotoSans_LightItalic26pt7b, 26, "NotoSans_LightItalic26pt7b" },
  { &NotoSans_LightItalic27pt7b, 27, "NotoSans_LightItalic27pt7b" },
  { &NotoSans_LightItalic28pt7b, 28, "NotoSans_LightItalic28pt7b" },
  { &NotoSans_LightItalic29pt7b, 29, "NotoSans_LightItalic29pt7b" },
  { &NotoSans_LightItalic30pt7b, 30, "NotoSans_LightItalic30pt7b" },
  { &NotoSans_LightItalic31pt7b, 31, "NotoSans_LightItalic31pt7b" },
  { &NotoSans_LightItalic32pt7b, 32, "NotoSans_LightItalic32pt7b" },
  { &NotoSans_LightItalic33pt7b, 33, "NotoSans_LightItalic33pt7b" },
  { &NotoSans_LightItalic34pt7b, 34, "NotoSans_LightItalic34pt7b" },
  { &NotoSans_LightItalic35pt7b, 35, "NotoSans_LightItalic35pt7b" },
  { &NotoSans_LightItalic36pt7b, 36, "NotoSans_LightItalic36pt7b" },
  { &NotoSans_LightItalic37pt7b, 37, "NotoSans_LightItalic37pt7b" },
  { &NotoSans_LightItalic38pt7b, 38, "NotoSans_LightItalic38pt7b" },
  { &NotoSans_LightItalic39pt7b, 39, "NotoSans_LightItalic39pt7b" },
  { &NotoSans_LightItalic40pt7b, 40, "NotoSans_LightItalic40pt7b" },
  { &NotoSans_LightItalic41pt7b, 41, "NotoSans_LightItalic41pt7b" },
  { &NotoSans_LightItalic42pt7b, 42, "NotoSans_LightItalic42pt7b" },
  { &NotoSans_LightItalic43pt7b, 43, "NotoSans_LightItalic43pt7b" },
  { &NotoSans_LightItalic44pt7b, 44, "NotoSans_LightItalic44pt7b" },
  { &NotoSans_LightItalic45pt7b, 45, "NotoSans_LightItalic45pt7b" },
  { &NotoSans_LightItalic46pt7b, 46, "NotoSans_LightItalic46pt7b" },
  { &NotoSans_LightItalic47pt7b, 47, "NotoSans_LightItalic47pt7b" },
  { &NotoSans_LightItalic48pt7b, 48, "NotoSans_LightItalic48pt7b" },
  { &NotoSans_LightItalic49pt7b, 49, "NotoSans_LightItalic49pt7b" },
  { &NotoSans_LightItalic50pt7b, 50, "NotoSans_LightItalic50pt7b" },
  { &NotoSans_LightItalic51pt7b, 51, "NotoSans_LightItalic51pt7b" },
  { &NotoSans_LightItalic52pt7b, 52, "NotoSans_LightItalic52pt7b" },
  { &NotoSans_LightItalic53pt7b, 53, "NotoSans_LightItalic53pt7b" },
  { &NotoSans_LightItalic54pt7b, 54, "NotoSans_LightItalic54pt7b" },
  { &NotoSans_LightItalic55pt7b, 55, "NotoSans_LightItalic55pt7b" },
  { &NotoSans_LightItalic56pt7b, 56, "NotoSans_LightItalic56pt7b" },
  { &NotoSans_LightItalic57pt7b, 57, "NotoSans_LightItalic57pt7b" },
  { &NotoSans_LightItalic58pt7b, 58, "NotoSans_LightItalic58pt7b" },
  { &NotoSans_LightItalic59pt7b, 59, "NotoSans_LightItalic59pt7b" },
  { &NotoSans_LightItalic60pt7b, 60, "NotoSans_LightItalic60pt7b" },
  { &NotoSans_LightItalic61pt7b, 61, "NotoSans_LightItalic61pt7b" },
  { &NotoSans_LightItalic62pt7b, 62, "NotoSans_LightItalic62pt7b" },
  { &NotoSans_LightItalic63pt7b, 63, "NotoSans_LightItalic63pt7b" },
  { &NotoSans_LightItalic64pt7b, 64, "NotoSans_LightItalic64pt7b" },
  { &NotoSans_LightItalic65pt7b, 65, "NotoSans_LightItalic65pt7b" },
  { &NotoSans_LightItalic66pt7b, 66, "NotoSans_LightItalic66pt7b" },
  { &NotoSans_LightItalic67pt7b, 67, "NotoSans_LightItalic67pt7b" },
  { &NotoSans_LightItalic68pt7b, 68, "NotoSans_LightItalic68pt7b" },
  { &NotoSans_LightItalic69pt7b, 69, "NotoSans_LightItalic69pt7b" },
  { &NotoSans_LightItalic70pt7b, 70, "NotoSans_LightItalic70pt7b" },
  { &NotoSans_LightItalic71pt7b, 71, "NotoSans_LightItalic71pt7b" },
  { &NotoSans_LightItalic72pt7b, 72, "NotoSans_LightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
