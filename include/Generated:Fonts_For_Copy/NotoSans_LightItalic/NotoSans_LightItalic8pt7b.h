#ifndef _NOTOSANS_LIGHTITALIC8PT7B_H_
#define _NOTOSANS_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xA0, 0xF0, 0x29, 0x5C, 0xAF, 0xB0, 0x36, 0x62, 0x3C, 0xCE,
  0xBD, 0xD6, 0xDC, 0x32, 0x88, 0xD9, 0x7C, 0xC0, 0x2A, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x80, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00,
  0x35, 0x99, 0x96, 0x75, 0x50, 0x71, 0x12, 0x4F, 0x71, 0x17, 0x1E, 0x13,
  0x55, 0xF2, 0x34, 0x61, 0x1E, 0x73, 0x5B, 0xC0, 0xF2, 0x24, 0x88, 0x35,
  0x57, 0x9F, 0x35, 0x97, 0x1E, 0x42, 0x42, 0x80, 0x2B, 0x10, 0xFC, 0x89,
  0xC0, 0xC5, 0x49, 0x00, 0x3C, 0x86, 0xED, 0x5B, 0xC8, 0x0E, 0x00, 0x22,
  0x57, 0x99, 0x32, 0x52, 0xE8, 0xF8, 0x78, 0x88, 0x8E, 0x32, 0x52, 0x98,
  0xF8, 0x34, 0x47, 0x8E, 0x34, 0x47, 0x88, 0x78, 0x8B, 0x9F, 0x4A, 0x52,
  0xF8, 0xC4, 0x69, 0x25, 0x80, 0x24, 0x94, 0xB0, 0x4A, 0x98, 0xC9, 0x48,
  0x49, 0x29, 0xC0, 0x42, 0x89, 0xB3, 0x6B, 0x54, 0x80, 0x45, 0x96, 0x96,
  0x9A, 0x20, 0x79, 0x99, 0x9E, 0x32, 0x52, 0xE8, 0x40, 0x79, 0x99, 0x9E,
  0x20, 0x32, 0x52, 0xE9, 0x48, 0x34, 0x42, 0x1E, 0xF4, 0x44, 0x88, 0x8C,
  0x65, 0x29, 0x70, 0x99, 0xAA, 0xC8, 0x96, 0x9B, 0x76, 0x92, 0x40, 0x4A,
  0x88, 0x46, 0x48, 0x9A, 0xC4, 0x88, 0x78, 0x88, 0x84, 0x78, 0x69, 0x49,
  0x30, 0xFC, 0x24, 0x92, 0x70, 0x25, 0x59, 0xE0, 0x80, 0x79, 0x9E, 0x46,
  0x55, 0x9F, 0x78, 0x86, 0x09, 0x55, 0x29, 0x78, 0x7E, 0x87, 0x37, 0x22,
  0x44, 0x48, 0x79, 0x9F, 0x1E, 0x46, 0x55, 0x99, 0x46, 0xA0, 0x20, 0xA4,
  0x94, 0x44, 0x7C, 0xAA, 0x56, 0xA0, 0x7D, 0x59, 0x65, 0x75, 0x99, 0x79,
  0x96, 0x75, 0x9F, 0x88, 0x79, 0x9F, 0x12, 0x6A, 0x40, 0xE8, 0xF0, 0xEA,
  0x4C, 0x59, 0x9E, 0x9A, 0xA4, 0xA6, 0xA5, 0x24, 0x56, 0x4A, 0x4A, 0x88,
  0x42, 0x60, 0x74, 0x4E, 0x29, 0x65, 0x30, 0xFF, 0x49, 0x34, 0xA0, 0xE0,
};

const GFXglyph NotoSans_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 6, 1, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 2, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 4, 1, -6 },
  { 28, 3, 4, 5, 1, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 2, 6, 4, 1, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 1, -6 },
  { 56, 4, 6, 4, 1, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 5, 2, 0, -4 },
  { 68, 3, 4, 5, 1, -5 },
  { 70, 3, 2, 5, 1, -4 },
  { 71, 3, 4, 5, 1, -5 },
  { 73, 3, 6, 3, 1, -6 },
  { 76, 7, 7, 7, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 3, 6, 2, 0, -6 },
  { 113, 3, 7, 2, -1, -6 },
  { 116, 5, 6, 4, 0, -6 },
  { 120, 3, 6, 4, 0, -6 },
  { 123, 7, 6, 7, 0, -6 },
  { 129, 6, 6, 6, 0, -6 },
  { 134, 4, 6, 6, 1, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 4, 7, 6, 1, -6 },
  { 145, 5, 6, 5, 0, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 6, 4, 1, -6 },
  { 155, 5, 6, 5, 1, -6 },
  { 159, 4, 6, 4, 1, -6 },
  { 162, 6, 6, 7, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 1, -6 },
  { 174, 5, 6, 4, 0, -6 },
  { 178, 3, 7, 2, 0, -6 },
  { 181, 1, 6, 3, 1, -6 },
  { 182, 3, 7, 2, -1, -6 },
  { 185, 4, 4, 4, 0, -6 },
  { 187, 3, 1, 3, -1, 0 },
  { 188, 1, 1, 2, 1, -6 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 4, 6, 5, 0, -6 },
  { 194, 4, 4, 4, 0, -4 },
  { 196, 5, 6, 5, 0, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 8, 2, -1, -6 },
  { 206, 4, 6, 5, 0, -4 },
  { 209, 4, 6, 5, 0, -6 },
  { 212, 2, 6, 2, 0, -6 },
  { 214, 3, 8, 2, -1, -6 },
  { 217, 4, 6, 4, 0, -6 },
  { 220, 2, 6, 2, 0, -6 },
  { 222, 6, 4, 7, 0, -4 },
  { 225, 4, 4, 5, 0, -4 },
  { 227, 4, 4, 5, 0, -4 },
  { 229, 4, 6, 5, 0, -4 },
  { 232, 4, 6, 5, 0, -4 },
  { 235, 3, 4, 3, 0, -4 },
  { 237, 3, 4, 3, 0, -4 },
  { 239, 3, 5, 3, 0, -5 },
  { 241, 4, 4, 5, 0, -4 },
  { 243, 4, 4, 4, 0, -4 },
  { 245, 6, 4, 6, 0, -4 },
  { 248, 4, 4, 4, 0, -4 },
  { 250, 5, 6, 4, -1, -4 },
  { 254, 4, 4, 4, 0, -4 },
  { 256, 3, 7, 3, 0, -6 },
  { 259, 1, 8, 4, 2, -6 },
  { 260, 3, 7, 3, 0, -6 },
  { 263, 3, 1, 5, 1, -3 },
};

const GFXfont NotoSans_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_LIGHTITALIC8PT7B_H_
