#ifndef _NOTOSANS_LIGHTITALIC19PT7B_H_
#define _NOTOSANS_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x18, 0x84, 0x21, 0x10, 0x04, 0x60, 0x4A, 0x55,
  0x29, 0x00, 0x04, 0x41, 0x08, 0x22, 0x04, 0x40, 0x88, 0xEE, 0xC4, 0x40,
  0x88, 0x21, 0x1F, 0xF8, 0x88, 0x11, 0x04, 0x40, 0x88, 0x00, 0x06, 0x07,
  0x8D, 0x24, 0x84, 0x41, 0x40, 0xE0, 0x1C, 0x0B, 0x04, 0x84, 0x52, 0x4F,
  0xC0, 0x80, 0x80, 0x30, 0x24, 0x84, 0x88, 0x48, 0x88, 0x89, 0x08, 0x90,
  0x92, 0xE9, 0x51, 0x69, 0x10, 0xA1, 0x12, 0x12, 0x22, 0x42, 0x2C, 0x1C,
  0x06, 0x03, 0x30, 0x42, 0x08, 0x41, 0x10, 0x24, 0x03, 0x01, 0xE0, 0x44,
  0x30, 0x4A, 0x07, 0x40, 0xC8, 0x38, 0xF8, 0x80, 0x56, 0x80, 0x08, 0x84,
  0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x40, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x0C, 0x88, 0xE8, 0x1F,
  0x18, 0x28, 0x44, 0x04, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x2D, 0x60, 0xF0, 0x70, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00, 0x0E,
  0x08, 0x88, 0x2C, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x81, 0xC0, 0xA0, 0x50,
  0x44, 0x63, 0xE0, 0x09, 0xDB, 0x21, 0x08, 0x46, 0x21, 0x08, 0x46, 0x20,
  0x07, 0x06, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x3F, 0xC0, 0x07, 0x06, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x20, 0xF0, 0x4C, 0x01, 0x80, 0x20, 0x08, 0x06, 0x81, 0x1F, 0x80,
  0x00, 0xC0, 0x30, 0x18, 0x0A, 0x04, 0x82, 0x21, 0x18, 0x84, 0x61, 0x10,
  0x4F, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x1F, 0x88, 0x08, 0x04, 0x02, 0x01,
  0x01, 0xF8, 0x06, 0x01, 0x00, 0x80, 0x40, 0x68, 0x27, 0xE0, 0x03, 0x86,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x7C, 0xC2, 0xC1, 0x40, 0xA0, 0x58, 0x24,
  0x21, 0xE0, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x0C, 0x04, 0x04, 0x00, 0x0E, 0x08, 0xC8, 0x24, 0x12, 0x09,
  0x88, 0x78, 0x6C, 0x43, 0x40, 0xA0, 0x50, 0x2C, 0x23, 0xE0, 0x0E, 0x18,
  0x88, 0x28, 0x14, 0x0A, 0x05, 0x06, 0xC7, 0x3D, 0x00, 0x80, 0x80, 0x40,
  0x47, 0xC0, 0x32, 0x00, 0x00, 0x00, 0x4C, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x23, 0x11, 0x80, 0x01, 0x83, 0x06, 0x0C, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x00, 0x3C, 0x8C, 0x08, 0x10, 0x20,
  0xC3, 0x08, 0x20, 0x41, 0x00, 0x04, 0x18, 0x00, 0x07, 0xF0, 0x60, 0x22,
  0x00, 0x50, 0x71, 0x46, 0x26, 0x21, 0x18, 0x84, 0x62, 0x11, 0x88, 0xC6,
  0x23, 0x28, 0xF7, 0x10, 0x00, 0x60, 0x00, 0xC1, 0x00, 0xF8, 0x00, 0x00,
  0x80, 0x30, 0x0E, 0x01, 0x40, 0x48, 0x09, 0x02, 0x10, 0x42, 0x1F, 0xC2,
  0x08, 0x81, 0x30, 0x24, 0x05, 0x00, 0xC0, 0x1E, 0x04, 0x62, 0x04, 0x81,
  0x20, 0x48, 0x27, 0xF1, 0x0C, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x83, 0x3F,
  0x80, 0x03, 0xC1, 0x84, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x00, 0x1E, 0x02, 0x30,
  0x81, 0x10, 0x12, 0x02, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01,
  0x40, 0x48, 0x31, 0xF8, 0x00, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x07, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x3F, 0x80, 0x1F,
  0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0xFC, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x03, 0xC0, 0xC3, 0x10, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x3E, 0xC0, 0x6C, 0x04, 0x40, 0x44, 0x04, 0x20,
  0x41, 0xF8, 0x10, 0x11, 0x01, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x7F,
  0xE4, 0x04, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x0C, 0x80, 0x88, 0x08, 0x1E,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x1E, 0x00,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0xF0, 0x10, 0x22, 0x08, 0x82, 0x10, 0x82, 0x60,
  0x58, 0x1E, 0x03, 0x40, 0x44, 0x08, 0x81, 0x08, 0x41, 0x08, 0x11, 0x02,
  0x00, 0x10, 0x20, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x1F, 0xC0, 0x10, 0x06, 0x60, 0x18, 0xA0, 0x31, 0x40, 0xA2, 0x81, 0x45,
  0x05, 0x92, 0x1A, 0x24, 0x24, 0x48, 0x88, 0x89, 0x11, 0x14, 0x64, 0x28,
  0x88, 0x61, 0x10, 0x82, 0x00, 0x10, 0x13, 0x01, 0x28, 0x12, 0x82, 0x28,
  0x22, 0x42, 0x64, 0x24, 0x22, 0x42, 0x44, 0x24, 0x41, 0x48, 0x14, 0x80,
  0xC8, 0x08, 0x07, 0x81, 0x86, 0x30, 0x22, 0x01, 0x60, 0x14, 0x01, 0x40,
  0x14, 0x01, 0xC0, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0xC1, 0xF0, 0x1E,
  0x04, 0x62, 0x08, 0x81, 0x20, 0x48, 0x26, 0x09, 0xFC, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0x81, 0x86, 0x30, 0x22, 0x01, 0x60,
  0x14, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20,
  0xC1, 0xF0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x1E, 0x04, 0x62, 0x0C, 0x81,
  0x20, 0x48, 0x26, 0x19, 0xF8, 0x44, 0x10, 0x84, 0x23, 0x08, 0x81, 0x20,
  0x40, 0x07, 0x86, 0x33, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x83, 0x3F, 0x80, 0xFF, 0x84, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x00, 0x20,
  0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x8C, 0x30, 0xFC, 0x00, 0x80, 0x60, 0x28, 0x0A, 0x04,
  0x81, 0x30, 0x84, 0x61, 0x10, 0x4C, 0x12, 0x05, 0x01, 0x40, 0x60, 0x18,
  0x00, 0x81, 0x03, 0x02, 0x06, 0x0A, 0x14, 0x14, 0x28, 0x48, 0xD0, 0x91,
  0x32, 0x22, 0x24, 0x48, 0x50, 0x90, 0xA1, 0x41, 0x42, 0x83, 0x06, 0x06,
  0x0C, 0x08, 0x10, 0x00, 0x10, 0x10, 0x82, 0x08, 0x40, 0x8C, 0x04, 0x80,
  0x50, 0x02, 0x00, 0x60, 0x0E, 0x00, 0x90, 0x11, 0x02, 0x08, 0x40, 0x8C,
  0x0C, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x42, 0x60, 0xA0, 0x60, 0x30, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x00, 0x1F, 0xE0, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0xFE,
  0x00, 0x1E, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0xF0, 0x92, 0x44, 0x92, 0x48, 0x92, 0x40, 0x1E, 0x04,
  0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0xE0, 0x04, 0x06, 0x03, 0x02, 0x42, 0x21, 0x09, 0x04, 0x82, 0x80, 0x80,
  0xFF, 0xA4, 0x1E, 0x90, 0xD0, 0x78, 0x28, 0x14, 0x0A, 0x0D, 0x04, 0x86,
  0x3D, 0x00, 0x30, 0x10, 0x08, 0x04, 0x02, 0xF2, 0x8D, 0x82, 0x81, 0x40,
  0xA0, 0x60, 0x58, 0x2C, 0x25, 0xE0, 0x1F, 0x20, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x7C, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x1E, 0x88, 0x64,
  0x1B, 0x06, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x86, 0x1E, 0x80, 0x1E, 0x21,
  0x41, 0x42, 0xFC, 0x80, 0x80, 0x80, 0x40, 0x7E, 0x00, 0x80, 0xD0, 0x20,
  0x10, 0x04, 0x07, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x0E, 0x02, 0x00, 0x0F, 0x44, 0x32,
  0x0D, 0x83, 0x40, 0x90, 0x24, 0x09, 0x06, 0x43, 0x0F, 0x40, 0x10, 0x04,
  0x02, 0x33, 0x83, 0x00, 0x30, 0x10, 0x08, 0x04, 0x02, 0xF2, 0x8D, 0x82,
  0x83, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x24, 0x10, 0x32, 0x00, 0x24, 0x44,
  0x44, 0x88, 0x88, 0x03, 0x02, 0x00, 0x00, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0xB0, 0x40, 0x30, 0x10,
  0x08, 0x04, 0x12, 0x12, 0x11, 0x10, 0x90, 0x70, 0x3C, 0x22, 0x11, 0x88,
  0x44, 0x30, 0x32, 0x22, 0x24, 0x44, 0x44, 0x88, 0x88, 0x2F, 0x3D, 0x45,
  0x16, 0x18, 0x50, 0x41, 0x41, 0x05, 0x04, 0x18, 0x20, 0xA0, 0x82, 0x82,
  0x0A, 0x08, 0x20, 0x2F, 0x28, 0xD8, 0x28, 0x34, 0x16, 0x0A, 0x05, 0x02,
  0x82, 0x41, 0x00, 0x1F, 0x10, 0x90, 0x38, 0x18, 0x0C, 0x0E, 0x05, 0x02,
  0xC2, 0x3E, 0x00, 0x17, 0x8A, 0x33, 0x04, 0x81, 0x20, 0x48, 0x14, 0x09,
  0x82, 0x61, 0x17, 0x8C, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x90, 0xD0,
  0x78, 0x38, 0x14, 0x0A, 0x05, 0x06, 0x86, 0x3D, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x2E, 0xA1, 0x82, 0x04, 0x08, 0x20, 0x40, 0x81, 0x00, 0x3F, 0x20,
  0x60, 0x20, 0x18, 0x0C, 0x06, 0x02, 0x84, 0xFC, 0x20, 0x82, 0x3F, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x20, 0xF0, 0x60, 0xA0, 0x50, 0x28, 0x24, 0x14,
  0x0A, 0x0D, 0x06, 0x86, 0x3D, 0x00, 0x81, 0x82, 0x82, 0x84, 0x44, 0x48,
  0x58, 0x50, 0x60, 0x60, 0x86, 0x1C, 0x30, 0xA2, 0x89, 0x14, 0x49, 0xA6,
  0x49, 0x22, 0x49, 0x14, 0x30, 0xA1, 0x82, 0x08, 0x00, 0x10, 0x44, 0x20,
  0x90, 0x28, 0x04, 0x03, 0x01, 0xA0, 0xC8, 0x21, 0x30, 0x40, 0x10, 0x22,
  0x08, 0x41, 0x04, 0x40, 0x88, 0x12, 0x02, 0xC0, 0x50, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x01, 0x60, 0x30, 0x00, 0x3F, 0x02, 0x06, 0x04, 0x08,
  0x10, 0x20, 0x60, 0xC0, 0xFE, 0x02, 0x18, 0x20, 0x41, 0x82, 0x04, 0x08,
  0xE0, 0x40, 0x81, 0x02, 0x04, 0x10, 0x30, 0x30, 0xFF, 0xFF, 0xE0, 0x10,
  0x18, 0x10, 0x20, 0x40, 0x82, 0x04, 0x06, 0x18, 0x20, 0x81, 0x02, 0x04,
  0x10, 0xE0, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 4, 0, -14 },
  { 10, 5, 5, 7, 2, -14 },
  { 14, 11, 14, 12, 1, -14 },
  { 34, 9, 15, 10, 1, -14 },
  { 51, 12, 14, 15, 2, -14 },
  { 72, 11, 14, 13, 1, -14 },
  { 92, 2, 5, 4, 2, -14 },
  { 94, 5, 17, 5, 1, -14 },
  { 105, 5, 17, 5, -1, -14 },
  { 116, 8, 8, 10, 2, -14 },
  { 124, 9, 9, 11, 1, -11 },
  { 135, 3, 4, 4, -1, -2 },
  { 137, 4, 1, 6, 1, -6 },
  { 138, 2, 2, 4, 0, -2 },
  { 139, 9, 14, 6, -1, -14 },
  { 155, 9, 14, 10, 1, -14 },
  { 171, 5, 14, 10, 3, -14 },
  { 180, 10, 14, 10, 0, -14 },
  { 198, 10, 14, 10, 0, -14 },
  { 216, 10, 14, 10, 0, -14 },
  { 234, 9, 14, 10, 1, -14 },
  { 250, 9, 14, 10, 1, -14 },
  { 266, 9, 14, 10, 2, -14 },
  { 282, 9, 14, 10, 1, -14 },
  { 298, 9, 14, 10, 1, -14 },
  { 314, 4, 10, 4, 0, -10 },
  { 319, 5, 12, 4, -1, -10 },
  { 327, 9, 9, 11, 1, -11 },
  { 338, 9, 5, 11, 1, -9 },
  { 344, 9, 9, 11, 1, -11 },
  { 355, 7, 14, 8, 1, -14 },
  { 368, 14, 15, 16, 1, -13 },
  { 395, 11, 14, 11, -1, -14 },
  { 415, 10, 14, 11, 1, -14 },
  { 433, 11, 14, 11, 1, -14 },
  { 453, 11, 14, 13, 1, -14 },
  { 473, 10, 14, 10, 1, -14 },
  { 491, 10, 14, 9, 1, -14 },
  { 509, 12, 14, 13, 1, -14 },
  { 530, 12, 14, 13, 1, -14 },
  { 551, 7, 14, 6, 0, -14 },
  { 564, 8, 17, 5, -3, -14 },
  { 581, 11, 14, 11, 1, -14 },
  { 601, 7, 14, 9, 1, -14 },
  { 614, 15, 14, 16, 1, -14 },
  { 641, 12, 14, 13, 1, -14 },
  { 662, 12, 14, 14, 1, -14 },
  { 683, 10, 14, 11, 1, -14 },
  { 701, 12, 17, 14, 1, -14 },
  { 727, 10, 14, 11, 1, -14 },
  { 745, 10, 14, 10, 0, -14 },
  { 763, 9, 14, 9, 2, -14 },
  { 779, 11, 14, 13, 2, -14 },
  { 799, 10, 14, 10, 2, -14 },
  { 817, 15, 14, 16, 2, -14 },
  { 844, 12, 14, 10, -1, -14 },
  { 865, 9, 14, 9, 2, -14 },
  { 881, 11, 14, 10, 0, -14 },
  { 901, 7, 17, 6, 0, -14 },
  { 916, 3, 14, 6, 2, -14 },
  { 922, 7, 17, 6, -1, -14 },
  { 937, 9, 9, 11, 1, -14 },
  { 948, 8, 1, 7, -2, 2 },
  { 949, 2, 3, 5, 3, -15 },
  { 950, 9, 10, 11, 1, -10 },
  { 962, 9, 14, 11, 1, -14 },
  { 978, 8, 10, 9, 1, -10 },
  { 988, 10, 14, 11, 1, -14 },
  { 1006, 8, 10, 9, 1, -10 },
  { 1016, 10, 20, 6, -2, -15 },
  { 1041, 10, 15, 11, 0, -10 },
  { 1060, 9, 14, 11, 1, -14 },
  { 1076, 4, 14, 4, 1, -14 },
  { 1083, 8, 19, 4, -3, -14 },
  { 1102, 9, 14, 9, 1, -14 },
  { 1118, 4, 14, 4, 1, -14 },
  { 1125, 14, 10, 16, 1, -10 },
  { 1143, 9, 10, 11, 1, -10 },
  { 1155, 9, 10, 11, 1, -10 },
  { 1167, 10, 14, 11, 0, -10 },
  { 1185, 9, 14, 11, 1, -10 },
  { 1201, 7, 10, 7, 1, -10 },
  { 1210, 8, 10, 8, 0, -10 },
  { 1220, 6, 13, 6, 1, -13 },
  { 1230, 9, 10, 11, 1, -10 },
  { 1242, 8, 10, 8, 1, -10 },
  { 1252, 13, 10, 13, 1, -10 },
  { 1269, 10, 10, 9, -1, -10 },
  { 1282, 11, 15, 8, -2, -10 },
  { 1303, 8, 10, 8, 0, -10 },
  { 1313, 7, 17, 6, 0, -14 },
  { 1328, 1, 19, 10, 5, -14 },
  { 1331, 7, 17, 6, -1, -14 },
  { 1346, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_LIGHTITALIC19PT7B_H_
