#ifndef _NOTOSANS_LIGHTITALIC20PT7B_H_
#define _NOTOSANS_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x44, 0x00, 0x88, 0x4A, 0x53, 0x29, 0x00,
  0x04, 0x40, 0x44, 0x08, 0x40, 0x88, 0x7F, 0xF1, 0x08, 0x11, 0x01, 0x10,
  0x11, 0x0F, 0xFE, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x02, 0x01, 0x07,
  0xE4, 0x82, 0x41, 0x20, 0x90, 0x38, 0x0E, 0x04, 0x82, 0x41, 0x29, 0x27,
  0xE0, 0x40, 0x20, 0x78, 0x32, 0x21, 0x21, 0x11, 0x11, 0x08, 0x90, 0x44,
  0xBA, 0x2A, 0x5E, 0x91, 0x09, 0x08, 0x48, 0x84, 0x44, 0x42, 0x26, 0x12,
  0x60, 0xF0, 0x02, 0x00, 0xD8, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x0E,
  0x01, 0xC0, 0x64, 0x14, 0x22, 0x83, 0x68, 0x14, 0x80, 0x8C, 0x34, 0x7C,
  0x60, 0x56, 0x80, 0x0C, 0x43, 0x08, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x40, 0x18, 0x20, 0x83, 0x04, 0x10, 0x43, 0x08, 0x20,
  0x86, 0x10, 0xC2, 0x10, 0x80, 0x04, 0x02, 0x32, 0x07, 0x00, 0xF8, 0xA1,
  0x90, 0x8C, 0x04, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC1, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x2D, 0x28, 0xF8, 0xC0, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06,
  0x00, 0x02, 0x07, 0xE3, 0x08, 0x83, 0x60, 0xD0, 0x34, 0x0D, 0x02, 0xC0,
  0xA0, 0x28, 0x0A, 0x04, 0xC1, 0x10, 0x83, 0xC0, 0x1C, 0xEC, 0x82, 0x18,
  0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x80, 0x0F, 0xC4, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x3F,
  0xE0, 0x1F, 0xC2, 0x08, 0x01, 0x80, 0x20, 0x04, 0x01, 0x03, 0xC0, 0x8C,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x48, 0x10, 0xFC, 0x00, 0x00, 0xC0, 0x38,
  0x05, 0x01, 0x60, 0x48, 0x11, 0x04, 0x21, 0x04, 0x41, 0x1F, 0xFC, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x1F, 0xC4, 0x03, 0x00, 0x80, 0x20, 0x0F,
  0x06, 0x30, 0x04, 0x01, 0x80, 0x60, 0x10, 0x04, 0x82, 0x3F, 0x00, 0x00,
  0x83, 0xF1, 0x80, 0xC0, 0x20, 0x18, 0x04, 0xE1, 0xC4, 0x40, 0xB0, 0x28,
  0x0A, 0x06, 0x41, 0x10, 0xC3, 0xC0, 0xFF, 0x80, 0xC0, 0x40, 0x40, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x02, 0x07,
  0xE3, 0x0C, 0x81, 0x20, 0xCC, 0x21, 0x30, 0x30, 0x32, 0x10, 0x48, 0x1A,
  0x06, 0x81, 0x30, 0xC7, 0xE0, 0x1F, 0x10, 0x58, 0x28, 0x14, 0x0A, 0x05,
  0x06, 0x6D, 0x19, 0x80, 0x80, 0x40, 0x40, 0x47, 0xC0, 0x2C, 0x00, 0x00,
  0x12, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x18, 0x84, 0x40, 0x00,
  0x40, 0x60, 0x60, 0x60, 0xE0, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x60, 0x60, 0x60, 0xE0, 0x00, 0xFC, 0x0C, 0x08, 0x10, 0x41, 0x84, 0x10,
  0x40, 0x82, 0x00, 0x08, 0x10, 0x00, 0x03, 0xF8, 0x18, 0x18, 0x40, 0x19,
  0x00, 0x14, 0x3E, 0x28, 0x84, 0x63, 0x08, 0xC4, 0x11, 0x88, 0x43, 0x10,
  0x8A, 0x23, 0x36, 0x39, 0xC4, 0x00, 0x0C, 0x00, 0x0C, 0x18, 0x07, 0xC0,
  0x00, 0x80, 0x30, 0x0F, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x1F,
  0xC6, 0x0C, 0x81, 0xB0, 0x14, 0x03, 0x00, 0x40, 0x1F, 0xC2, 0x08, 0xC1,
  0x90, 0x32, 0x04, 0x41, 0x8F, 0xC2, 0x0C, 0x40, 0xC8, 0x19, 0x03, 0x60,
  0x48, 0x19, 0xFC, 0x00, 0x0F, 0xE6, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x7E, 0x00,
  0x1F, 0x81, 0x06, 0x30, 0x22, 0x03, 0x20, 0x32, 0x01, 0x20, 0x34, 0x03,
  0x40, 0x24, 0x02, 0x40, 0x4C, 0x0C, 0x83, 0x0F, 0xC0, 0x1F, 0xC4, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x3F, 0x80, 0x1F, 0xC4, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0xFC, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE6, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x1E, 0x80, 0x50, 0x0A, 0x01,
  0x40, 0x44, 0x08, 0x7F, 0x00, 0x10, 0x18, 0x80, 0x8C, 0x04, 0x40, 0x22,
  0x03, 0x10, 0x10, 0xFF, 0x88, 0x04, 0x40, 0x22, 0x03, 0x10, 0x11, 0x80,
  0x88, 0x04, 0x40, 0x60, 0x1E, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x1E, 0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x18, 0xB0, 0xC0, 0x10,
  0x31, 0x0C, 0x21, 0x82, 0x30, 0x26, 0x02, 0xC0, 0x3C, 0x06, 0x40, 0x44,
  0x04, 0x20, 0x42, 0x0C, 0x10, 0x81, 0x08, 0x18, 0x10, 0x20, 0xC1, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x06, 0x08, 0x1F, 0xC0, 0x18, 0x06, 0x30,
  0x0C, 0xA0, 0x29, 0x40, 0xD2, 0x81, 0x45, 0x04, 0x99, 0x09, 0x22, 0x22,
  0x44, 0x4C, 0x89, 0x11, 0x16, 0x26, 0x28, 0x48, 0x60, 0x90, 0x43, 0x00,
  0x10, 0x08, 0xC0, 0x8A, 0x04, 0x58, 0x22, 0x41, 0x12, 0x19, 0x88, 0x88,
  0x44, 0x43, 0x22, 0x09, 0x10, 0x59, 0x81, 0x88, 0x0C, 0x40, 0x60, 0x02,
  0x01, 0xFC, 0x30, 0x66, 0x02, 0x40, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0xC4, 0x18, 0x3F, 0x00, 0x1F, 0x84,
  0x33, 0x04, 0x81, 0x20, 0x48, 0x12, 0x19, 0xFC, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x00, 0x02, 0x01, 0xFC, 0x30, 0x66, 0x02, 0x40, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0xC4,
  0x18, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x38, 0x1F, 0x84, 0x33, 0x04, 0x81,
  0x20, 0x48, 0x32, 0x19, 0xF8, 0x42, 0x10, 0x84, 0x33, 0x04, 0x81, 0x20,
  0x60, 0x0F, 0xC4, 0x03, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x00, 0x20, 0x08, 0x06, 0x83, 0x3F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x00, 0x20, 0x36, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0xC1, 0x07, 0xE0, 0x80, 0x70,
  0x1A, 0x02, 0x60, 0xC4, 0x10, 0x84, 0x10, 0x82, 0x20, 0x44, 0x09, 0x01,
  0x20, 0x28, 0x05, 0x00, 0x40, 0x00, 0x81, 0x81, 0xC1, 0x83, 0xC3, 0x82,
  0xC2, 0x86, 0x46, 0x84, 0x44, 0x84, 0x44, 0x88, 0x48, 0x88, 0x48, 0x90,
  0x50, 0x90, 0x50, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x18, 0x18,
  0x41, 0x02, 0x10, 0x09, 0x80, 0x48, 0x01, 0x80, 0x08, 0x00, 0xE0, 0x0D,
  0x00, 0x48, 0x04, 0x20, 0x41, 0x04, 0x08, 0x60, 0x20, 0x80, 0xF0, 0x64,
  0x11, 0x08, 0x44, 0x0B, 0x02, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x00, 0x1F, 0xE0, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0xFF, 0x00, 0x1E,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x20,
  0x40, 0xF0, 0x91, 0x24, 0x92, 0x24, 0x92, 0x40, 0x1E, 0x04, 0x18, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xF0, 0x04,
  0x05, 0x06, 0x82, 0x42, 0x11, 0x09, 0x03, 0x81, 0x80, 0x80, 0xFF, 0xC8,
  0x80, 0x0E, 0x4C, 0x66, 0x19, 0x02, 0xC0, 0xA0, 0x68, 0x12, 0x04, 0x83,
  0x31, 0x47, 0xA0, 0x10, 0x18, 0x08, 0x04, 0x02, 0x71, 0xCD, 0x42, 0xC1,
  0x40, 0xA0, 0x50, 0x38, 0x1C, 0x16, 0x1A, 0xF0, 0x0F, 0x31, 0x60, 0x40,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0xE4, 0x63, 0x98, 0x22, 0x04, 0xC0, 0x90, 0x12, 0x06, 0x40, 0x88,
  0x31, 0x8A, 0x1E, 0x40, 0x0E, 0x31, 0x61, 0x41, 0xC3, 0xFC, 0x80, 0x80,
  0x80, 0x42, 0x3E, 0x01, 0xE0, 0x40, 0x08, 0x02, 0x01, 0xF8, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x60, 0x00, 0x0E, 0x4C, 0x56, 0x09, 0x02,
  0xC0, 0xA0, 0x28, 0x1A, 0x04, 0x83, 0x31, 0x47, 0x90, 0x08, 0x02, 0x01,
  0x88, 0xC3, 0xC0, 0x10, 0x18, 0x08, 0x04, 0x02, 0x71, 0xCD, 0x42, 0xC1,
  0x40, 0xA0, 0x50, 0x70, 0x28, 0x14, 0x0A, 0x0C, 0x13, 0x00, 0x22, 0x64,
  0x44, 0x48, 0x88, 0x80, 0x01, 0x03, 0x00, 0x00, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0xE0,
  0x10, 0x18, 0x08, 0x04, 0x02, 0x09, 0x19, 0x98, 0x98, 0x58, 0x3C, 0x12,
  0x11, 0x88, 0x44, 0x22, 0x08, 0x13, 0x22, 0x22, 0x64, 0x44, 0x48, 0x88,
  0x80, 0x27, 0x1C, 0x72, 0x4D, 0x47, 0x0B, 0x0C, 0x14, 0x18, 0x28, 0x20,
  0xD0, 0x41, 0x40, 0x82, 0x83, 0x05, 0x04, 0x0A, 0x08, 0x30, 0x27, 0x1C,
  0xD4, 0x2C, 0x14, 0x0A, 0x05, 0x07, 0x82, 0x81, 0x40, 0xA0, 0xC0, 0x0E,
  0x18, 0x98, 0x28, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x21, 0x8F, 0x00,
  0x13, 0x87, 0x32, 0x84, 0xC1, 0x20, 0x48, 0x12, 0x05, 0x81, 0x60, 0x98,
  0x65, 0xE1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0E, 0x4C, 0x56, 0x09,
  0x02, 0xC0, 0xA0, 0x28, 0x1A, 0x04, 0x83, 0x31, 0x47, 0x90, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x26, 0x71, 0x43, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x00, 0x1E, 0x21, 0x20, 0x60, 0x30, 0x18, 0x06, 0x02, 0x02, 0x86,
  0xFC, 0x30, 0x8F, 0xC8, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20, 0xF0, 0x20,
  0x58, 0x24, 0x09, 0x02, 0x40, 0x90, 0x6C, 0x12, 0x04, 0x83, 0x31, 0x47,
  0xB0, 0x81, 0xC0, 0xA0, 0xD8, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x28,
  0x18, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0A, 0x28, 0x92, 0x44, 0x93,
  0x45, 0x9A, 0x28, 0x61, 0xC3, 0x0C, 0x10, 0x60, 0x10, 0x62, 0x18, 0x22,
  0x04, 0x80, 0x60, 0x08, 0x02, 0x80, 0xD0, 0x33, 0x04, 0x23, 0x06, 0x00,
  0x10, 0x31, 0x02, 0x10, 0x61, 0x84, 0x08, 0x80, 0x88, 0x09, 0x00, 0x90,
  0x0A, 0x00, 0xA0, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x0E, 0x00,
  0x3F, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x3F,
  0x80, 0x07, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0xC0, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x30, 0xFF, 0xFF, 0xF0, 0x1C, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x30, 0xE0, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 5, 1, -14 },
  { 8, 5, 5, 7, 2, -14 },
  { 12, 12, 14, 13, 1, -14 },
  { 33, 9, 16, 11, 1, -15 },
  { 51, 13, 14, 16, 2, -14 },
  { 74, 12, 15, 14, 1, -15 },
  { 97, 2, 5, 4, 2, -14 },
  { 99, 6, 17, 5, 1, -14 },
  { 112, 6, 17, 5, -1, -14 },
  { 125, 9, 9, 11, 2, -15 },
  { 136, 10, 10, 11, 1, -12 },
  { 149, 3, 5, 4, -1, -2 },
  { 151, 5, 1, 6, 1, -6 },
  { 152, 1, 2, 5, 1, -2 },
  { 153, 9, 14, 7, -1, -14 },
  { 169, 10, 15, 11, 1, -15 },
  { 188, 6, 14, 11, 3, -14 },
  { 199, 10, 14, 11, 0, -14 },
  { 217, 11, 14, 11, 0, -14 },
  { 237, 11, 14, 11, 0, -14 },
  { 257, 10, 14, 11, 1, -14 },
  { 275, 10, 15, 11, 1, -15 },
  { 294, 9, 14, 11, 2, -14 },
  { 310, 10, 15, 11, 1, -15 },
  { 329, 9, 14, 11, 1, -14 },
  { 345, 3, 11, 5, 1, -11 },
  { 350, 5, 14, 5, -1, -11 },
  { 359, 10, 9, 11, 1, -12 },
  { 371, 9, 5, 11, 2, -10 },
  { 377, 10, 9, 11, 1, -12 },
  { 389, 7, 14, 8, 2, -14 },
  { 402, 15, 16, 17, 1, -14 },
  { 432, 11, 14, 11, -1, -14 },
  { 452, 11, 14, 12, 1, -14 },
  { 472, 11, 14, 12, 2, -14 },
  { 492, 12, 14, 13, 1, -14 },
  { 513, 10, 14, 11, 1, -14 },
  { 531, 10, 14, 10, 1, -14 },
  { 549, 11, 14, 14, 2, -14 },
  { 569, 13, 14, 14, 1, -14 },
  { 592, 7, 14, 6, 0, -14 },
  { 605, 8, 18, 5, -3, -14 },
  { 623, 12, 14, 11, 1, -14 },
  { 644, 7, 14, 10, 1, -14 },
  { 657, 15, 14, 16, 1, -14 },
  { 684, 13, 14, 14, 1, -14 },
  { 707, 12, 15, 14, 2, -15 },
  { 730, 10, 14, 11, 1, -14 },
  { 748, 12, 18, 14, 2, -15 },
  { 775, 10, 14, 11, 1, -14 },
  { 793, 10, 14, 10, 0, -14 },
  { 811, 10, 14, 10, 2, -14 },
  { 829, 12, 14, 14, 2, -14 },
  { 850, 11, 14, 11, 2, -14 },
  { 870, 16, 14, 17, 2, -14 },
  { 898, 13, 14, 10, -1, -14 },
  { 921, 10, 14, 10, 2, -14 },
  { 939, 11, 14, 11, 0, -14 },
  { 959, 7, 17, 6, 0, -14 },
  { 974, 3, 14, 7, 2, -14 },
  { 980, 7, 17, 6, -1, -14 },
  { 995, 9, 9, 11, 1, -14 },
  { 1006, 8, 1, 8, -2, 2 },
  { 1007, 3, 3, 5, 3, -15 },
  { 1009, 10, 11, 11, 1, -11 },
  { 1023, 9, 15, 11, 1, -15 },
  { 1040, 8, 11, 9, 1, -11 },
  { 1051, 11, 15, 11, 1, -15 },
  { 1072, 8, 11, 10, 1, -11 },
  { 1083, 11, 20, 6, -2, -15 },
  { 1111, 10, 16, 11, 1, -11 },
  { 1131, 9, 15, 11, 1, -15 },
  { 1148, 4, 15, 5, 1, -15 },
  { 1156, 8, 20, 5, -3, -15 },
  { 1176, 9, 15, 9, 1, -15 },
  { 1193, 4, 15, 5, 1, -15 },
  { 1201, 15, 11, 17, 1, -11 },
  { 1222, 9, 11, 11, 1, -11 },
  { 1235, 9, 11, 11, 1, -11 },
  { 1248, 10, 16, 11, 0, -11 },
  { 1268, 10, 16, 11, 1, -11 },
  { 1288, 7, 11, 8, 1, -11 },
  { 1298, 8, 11, 9, 0, -11 },
  { 1309, 6, 13, 6, 1, -13 },
  { 1319, 10, 11, 11, 1, -11 },
  { 1333, 9, 11, 9, 1, -11 },
  { 1346, 13, 11, 14, 1, -11 },
  { 1364, 11, 11, 9, -1, -11 },
  { 1380, 12, 16, 9, -2, -11 },
  { 1404, 9, 11, 9, 0, -11 },
  { 1417, 8, 17, 7, 0, -14 },
  { 1434, 1, 20, 11, 5, -15 },
  { 1437, 8, 17, 7, -1, -14 },
  { 1454, 10, 2, 11, 1, -8 },
};

const GFXfont NotoSans_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_LIGHTITALIC20PT7B_H_
