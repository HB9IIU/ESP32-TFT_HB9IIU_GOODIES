#ifndef _NOTOSANS_LIGHTITALIC23PT7B_H_
#define _NOTOSANS_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x10, 0x84, 0x62, 0x10, 0x80, 0x03, 0x18, 0xCE,
  0x28, 0xA4, 0x92, 0x40, 0x02, 0x10, 0x08, 0xC0, 0x42, 0x01, 0x08, 0x04,
  0x21, 0xFF, 0xF0, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x42, 0x0F, 0xFF, 0x04,
  0x20, 0x21, 0x00, 0x84, 0x02, 0x10, 0x18, 0x80, 0x01, 0x00, 0x20, 0x7F,
  0x99, 0x02, 0x20, 0x44, 0x08, 0x80, 0xE0, 0x0E, 0x00, 0xF0, 0x12, 0x02,
  0x60, 0x88, 0x11, 0x32, 0xC3, 0xE0, 0x08, 0x02, 0x00, 0x18, 0x04, 0x48,
  0x11, 0x18, 0x62, 0x10, 0x88, 0x62, 0x10, 0x88, 0x21, 0x30, 0x42, 0x4E,
  0x89, 0x27, 0xB4, 0x85, 0x99, 0x08, 0x24, 0x10, 0x88, 0x63, 0x10, 0x84,
  0x21, 0x10, 0x44, 0x40, 0x78, 0x03, 0x80, 0x3B, 0x00, 0x86, 0x06, 0x08,
  0x18, 0x20, 0x61, 0x00, 0x88, 0x03, 0xC0, 0x1E, 0x00, 0xC8, 0x34, 0x10,
  0xB0, 0x66, 0x80, 0x92, 0x01, 0x88, 0x0E, 0x30, 0x6C, 0x7E, 0x18, 0xEA,
  0xA0, 0x06, 0x10, 0x41, 0x82, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x81, 0x03, 0x00, 0x04, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x82, 0x04, 0x10, 0x61, 0x86,
  0x00, 0x04, 0x01, 0x08, 0x81, 0xA0, 0x1F, 0xC6, 0x02, 0x43, 0x10, 0x46,
  0x00, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x32, 0x24, 0x48, 0xF8, 0xF0, 0x00, 0x60, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x03, 0x81, 0xD8, 0x61, 0x98,
  0x12, 0x02, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x28, 0x0F, 0x01, 0xE0, 0x2C,
  0x04, 0x81, 0x10, 0x63, 0x18, 0x3E, 0x00, 0x1C, 0xEC, 0xA2, 0x18, 0x61,
  0x04, 0x10, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x01, 0x80, 0xFE, 0x18, 0x30,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0xEE,
  0x10, 0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x4C, 0x0C, 0x7F, 0x00, 0x00,
  0x30, 0x06, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x66, 0x0C, 0x41, 0x84, 0x30,
  0x42, 0x0C, 0x40, 0xCF, 0xFF, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x0F,
  0xE3, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x0F, 0xC1, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x20, 0xC7, 0xF0, 0x01, 0xE1, 0xE8,
  0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x06, 0xF8, 0xA1, 0x98, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x46, 0x18, 0x7C, 0x00, 0x7F, 0xE0, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x03, 0x81, 0xD8, 0x60, 0x88,
  0x11, 0x02, 0x20, 0x46, 0x10, 0x6C, 0x0E, 0x06, 0x31, 0x83, 0x60, 0x28,
  0x05, 0x00, 0xB0, 0x33, 0x0C, 0x3F, 0x00, 0x07, 0x03, 0xB8, 0xC1, 0x10,
  0x36, 0x02, 0xC0, 0x50, 0x0B, 0x03, 0x60, 0xE6, 0x28, 0x79, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x30, 0xFC, 0x00, 0x32, 0x00, 0x00, 0x00, 0x00,
  0xCC, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x18, 0x41, 0x08,
  0x00, 0x00, 0x40, 0x30, 0x30, 0x30, 0x30, 0x30, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x1C, 0x1C, 0x18, 0x18, 0x08,
  0x00, 0x1C, 0xFE, 0x03, 0x01, 0x01, 0x03, 0x02, 0x04, 0x18, 0x30, 0x20,
  0x40, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xFE, 0x01, 0x80, 0xC0, 0x80,
  0x18, 0x40, 0x02, 0x20, 0x70, 0xD8, 0x62, 0x14, 0x20, 0x85, 0x10, 0x61,
  0xC4, 0x10, 0xE1, 0x04, 0x28, 0x43, 0x0B, 0x10, 0xC4, 0xC6, 0xDF, 0x10,
  0x42, 0x06, 0x00, 0x00, 0x80, 0x00, 0x18, 0x18, 0x01, 0xFC, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x68, 0x02, 0x40, 0x32, 0x01, 0x10, 0x18, 0x80, 0x84,
  0x08, 0x30, 0xFF, 0x84, 0x04, 0x60, 0x22, 0x01, 0x30, 0x09, 0x00, 0x58,
  0x03, 0x1F, 0xE1, 0x03, 0x10, 0x11, 0x01, 0x30, 0x13, 0x03, 0x20, 0x63,
  0xF8, 0x20, 0x46, 0x02, 0x60, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC1, 0xCF,
  0xF0, 0x01, 0xC0, 0x7F, 0xC6, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x08, 0x1F, 0xC0, 0x1F, 0xE0, 0x40, 0xC1, 0x01, 0x84, 0x02,
  0x30, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x09, 0x80, 0x26, 0x01,
  0x90, 0x04, 0x40, 0x31, 0x01, 0x8C, 0x38, 0x3F, 0x80, 0x1F, 0xF1, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xF8, 0x1F, 0xF1, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x3F, 0xC6, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x01, 0xE0, 0x7F,
  0xC6, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x0F, 0xA0, 0x05, 0x00, 0x68, 0x03, 0x60, 0x11, 0x00, 0x8E, 0x0C, 0x1F,
  0xC0, 0x18, 0x06, 0x20, 0x08, 0x40, 0x10, 0x80, 0x63, 0x00, 0xC6, 0x01,
  0x08, 0x02, 0x1F, 0xFC, 0x20, 0x18, 0xC0, 0x31, 0x80, 0x42, 0x00, 0x84,
  0x01, 0x08, 0x06, 0x30, 0x08, 0x40, 0x10, 0x1F, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0xF8, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x83, 0xE0,
  0x18, 0x1C, 0x40, 0xC1, 0x06, 0x04, 0x30, 0x31, 0x00, 0xC8, 0x02, 0x40,
  0x0B, 0x80, 0x32, 0x01, 0x88, 0x06, 0x10, 0x10, 0x40, 0x41, 0x81, 0x02,
  0x0C, 0x0C, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x03, 0xFE, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0x40, 0x28, 0x50, 0x0A, 0x34, 0x04, 0x8D, 0x03, 0x62,
  0x40, 0x90, 0x98, 0x64, 0x22, 0x11, 0x18, 0x88, 0x44, 0x22, 0x31, 0x09,
  0x08, 0x42, 0xC2, 0x10, 0xA0, 0x8C, 0x38, 0x62, 0x04, 0x18, 0x18, 0x06,
  0x38, 0x08, 0x50, 0x10, 0xA0, 0x23, 0x60, 0x46, 0x41, 0x88, 0xC2, 0x10,
  0x84, 0x21, 0x08, 0xC3, 0x11, 0x02, 0x62, 0x06, 0x84, 0x05, 0x08, 0x0A,
  0x30, 0x1C, 0x40, 0x18, 0x03, 0xC0, 0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x60,
  0x09, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0,
  0x06, 0x80, 0x1B, 0x00, 0xC4, 0x02, 0x18, 0x30, 0x1F, 0x80, 0x1F, 0xE1,
  0x02, 0x10, 0x31, 0x01, 0x30, 0x13, 0x03, 0x20, 0x22, 0x06, 0x3F, 0x86,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x03, 0xC0,
  0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x60, 0x09, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x1B, 0x00, 0xC4, 0x02,
  0x18, 0x30, 0x1F, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x1F,
  0xE1, 0x03, 0x10, 0x31, 0x01, 0x30, 0x13, 0x03, 0x20, 0x22, 0x0C, 0x3F,
  0x06, 0x10, 0x61, 0x04, 0x18, 0x40, 0x84, 0x08, 0xC0, 0xC8, 0x04, 0x03,
  0xC0, 0xFF, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC8, 0x18, 0x7F,
  0x00, 0xFF, 0xE0, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30,
  0x0C, 0x80, 0x22, 0x00, 0x88, 0x02, 0x60, 0x09, 0x00, 0x64, 0x01, 0x10,
  0x04, 0xC0, 0x13, 0x00, 0xC8, 0x03, 0x20, 0x08, 0x80, 0x63, 0x01, 0x06,
  0x1C, 0x0F, 0xC0, 0xC0, 0x34, 0x02, 0x40, 0x64, 0x04, 0x40, 0xC4, 0x08,
  0x41, 0x84, 0x10, 0x63, 0x06, 0x20, 0x26, 0x02, 0x40, 0x28, 0x02, 0x80,
  0x30, 0x03, 0x00, 0x80, 0xC0, 0xE0, 0x50, 0x28, 0x14, 0x1A, 0x0D, 0x04,
  0x82, 0x43, 0x21, 0x90, 0x88, 0x44, 0x22, 0x31, 0x10, 0x88, 0x44, 0x22,
  0x13, 0x09, 0x04, 0x82, 0x41, 0x60, 0xA0, 0x50, 0x28, 0x14, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x08, 0x0E, 0x18, 0x30, 0x10, 0x40, 0x21, 0x00, 0x26,
  0x00, 0x58, 0x00, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x09, 0x00, 0x32, 0x00,
  0xC6, 0x01, 0x04, 0x04, 0x08, 0x10, 0x18, 0x60, 0x10, 0xC0, 0x74, 0x04,
  0x40, 0xC6, 0x18, 0x21, 0x02, 0x20, 0x26, 0x03, 0x40, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x1F, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x1F, 0xF8, 0x0F,
  0x84, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x3E, 0x1E, 0x00, 0xC4, 0x44,
  0x46, 0x22, 0x22, 0x23, 0x11, 0x11, 0x0F, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x1E, 0x1F, 0x00, 0x02, 0x00, 0xC0, 0x14, 0x04, 0x80, 0x90,
  0x21, 0x0C, 0x21, 0x02, 0x60, 0x48, 0x0A, 0x00, 0x80, 0xFF, 0x80, 0xC4,
  0x23, 0x1F, 0xA6, 0x14, 0x81, 0xB0, 0x24, 0x05, 0x80, 0xB0, 0x34, 0x06,
  0xC0, 0x98, 0x31, 0x0A, 0x3E, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x4F, 0x8A, 0x19, 0x81, 0x60, 0x2C, 0x05, 0x00, 0xA0, 0x34, 0x05,
  0x80, 0xB0, 0x25, 0x0C, 0x9E, 0x00, 0x1F, 0xCC, 0x02, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x10, 0xFC, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x0F, 0xD0, 0xC2, 0x84, 0x0C, 0x40, 0x62,
  0x02, 0x30, 0x11, 0x80, 0x88, 0x0C, 0x60, 0x63, 0x06, 0x08, 0x50, 0x7C,
  0x80, 0x1F, 0x8C, 0x32, 0x0D, 0x02, 0x41, 0xBF, 0x8C, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x10, 0xFC, 0x00, 0x30, 0x07, 0xC0, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x3F, 0x80, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x03, 0xC0, 0x08, 0x00, 0x1F, 0xA6, 0x14, 0x81, 0xA0,
  0x34, 0x05, 0x80, 0xB0, 0x14, 0x06, 0xC0, 0xD8, 0x31, 0x0A, 0x3E, 0x40,
  0x18, 0x02, 0x00, 0x44, 0x18, 0xFE, 0x02, 0x00, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x4F, 0x8A, 0x19, 0x83, 0x60, 0x6C, 0x09, 0x01, 0x20,
  0x24, 0x0D, 0x81, 0xB0, 0x24, 0x04, 0x80, 0x80, 0x10, 0xC0, 0x01, 0x10,
  0x84, 0x63, 0x10, 0x84, 0x63, 0x10, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x07, 0x81, 0x00, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x02, 0x41, 0x88, 0x61, 0x18, 0x66, 0x0D, 0x81, 0x60,
  0x36, 0x04, 0x41, 0x8C, 0x30, 0x84, 0x18, 0x81, 0x00, 0x18, 0x84, 0x23,
  0x10, 0x84, 0x63, 0x10, 0x84, 0x63, 0x10, 0x80, 0x27, 0x8F, 0x94, 0x28,
  0x4C, 0x18, 0x2C, 0x08, 0x16, 0x04, 0x0A, 0x06, 0x05, 0x02, 0x06, 0x81,
  0x03, 0xC0, 0x81, 0x60, 0xC0, 0xA0, 0x60, 0x50, 0x20, 0x60, 0x01, 0x04,
  0xF8, 0xA1, 0x98, 0x36, 0x06, 0xC0, 0x90, 0x12, 0x02, 0x40, 0xD8, 0x1B,
  0x02, 0x40, 0x48, 0x18, 0x1F, 0x86, 0x09, 0x81, 0xA0, 0x34, 0x07, 0x80,
  0xF0, 0x1E, 0x02, 0xC0, 0xC8, 0x11, 0x86, 0x1F, 0x00, 0x13, 0xE1, 0x43,
  0x18, 0x13, 0x01, 0x30, 0x12, 0x01, 0x20, 0x32, 0x02, 0x60, 0x26, 0x04,
  0x50, 0xC4, 0xF0, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x1F,
  0xA6, 0x14, 0x81, 0xA0, 0x34, 0x05, 0x80, 0xB0, 0x14, 0x06, 0xC0, 0xD8,
  0x31, 0x0A, 0x3E, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x27,
  0x28, 0x30, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x1F,
  0x90, 0x08, 0x04, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x00, 0xA0, 0xDF,
  0xC0, 0x10, 0x20, 0xC7, 0xF2, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C,
  0x18, 0x1E, 0x00, 0x20, 0x24, 0x04, 0x81, 0xB0, 0x24, 0x04, 0x80, 0x90,
  0x36, 0x06, 0xC0, 0x98, 0x33, 0x0A, 0x3E, 0x40, 0xC0, 0xF0, 0x2C, 0x19,
  0x04, 0x43, 0x10, 0x84, 0x41, 0x30, 0x68, 0x1E, 0x03, 0x00, 0xC0, 0xC1,
  0x83, 0xC2, 0x86, 0xC2, 0x84, 0xC6, 0x8C, 0x44, 0x88, 0x4C, 0x88, 0x48,
  0x90, 0x58, 0x90, 0x50, 0xA0, 0x70, 0xA0, 0x60, 0xE0, 0x60, 0xC0, 0x18,
  0x30, 0x86, 0x08, 0xC0, 0x48, 0x05, 0x00, 0x20, 0x06, 0x00, 0x90, 0x19,
  0x03, 0x18, 0x60, 0x8C, 0x0C, 0x18, 0x18, 0xC0, 0x82, 0x0C, 0x10, 0x40,
  0x86, 0x04, 0x20, 0x22, 0x01, 0x90, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x3F,
  0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x03, 0xFC, 0x03, 0x82, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x70, 0x0C, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0E, 0x03,
  0x00, 0xFF, 0xFF, 0xFE, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x06, 0x03, 0x06, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0xE0, 0xC0,
  0xFC, 0x61, 0xF0,
};

const GFXglyph NotoSans_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 16, 5, 1, -16 },
  { 11, 6, 6, 8, 3, -16 },
  { 16, 14, 16, 14, 1, -16 },
  { 44, 11, 18, 13, 1, -17 },
  { 69, 15, 17, 18, 2, -17 },
  { 101, 14, 17, 16, 1, -17 },
  { 131, 2, 6, 5, 3, -16 },
  { 133, 7, 20, 6, 1, -16 },
  { 151, 7, 20, 6, -2, -16 },
  { 169, 10, 10, 12, 3, -17 },
  { 182, 10, 11, 13, 2, -14 },
  { 196, 4, 6, 5, -1, -3 },
  { 199, 5, 1, 7, 1, -7 },
  { 200, 2, 2, 5, 1, -2 },
  { 201, 11, 16, 8, -1, -16 },
  { 223, 11, 17, 13, 1, -17 },
  { 247, 6, 16, 13, 4, -16 },
  { 259, 12, 17, 13, 0, -17 },
  { 285, 12, 17, 13, 0, -17 },
  { 311, 12, 16, 13, 0, -16 },
  { 335, 11, 16, 13, 1, -16 },
  { 357, 11, 17, 13, 2, -17 },
  { 381, 11, 16, 13, 2, -16 },
  { 403, 11, 17, 13, 1, -17 },
  { 427, 11, 17, 13, 1, -17 },
  { 451, 4, 12, 5, 1, -12 },
  { 457, 6, 15, 5, -1, -12 },
  { 469, 10, 11, 13, 2, -14 },
  { 483, 10, 6, 13, 2, -11 },
  { 491, 10, 11, 13, 2, -14 },
  { 505, 8, 17, 10, 2, -17 },
  { 522, 18, 18, 19, 1, -16 },
  { 563, 13, 16, 13, -1, -16 },
  { 589, 12, 16, 14, 1, -16 },
  { 613, 13, 17, 14, 2, -17 },
  { 641, 14, 16, 15, 1, -16 },
  { 669, 12, 16, 12, 1, -16 },
  { 693, 12, 16, 11, 1, -16 },
  { 717, 13, 17, 16, 2, -17 },
  { 745, 15, 16, 16, 1, -16 },
  { 775, 8, 16, 7, 0, -16 },
  { 791, 10, 20, 6, -4, -16 },
  { 816, 14, 16, 13, 1, -16 },
  { 844, 9, 16, 11, 1, -16 },
  { 862, 18, 16, 19, 1, -16 },
  { 898, 15, 16, 16, 1, -16 },
  { 928, 14, 17, 17, 2, -17 },
  { 958, 12, 16, 13, 1, -16 },
  { 982, 14, 21, 17, 2, -17 },
  { 1019, 12, 16, 13, 1, -16 },
  { 1043, 12, 17, 12, 0, -17 },
  { 1069, 11, 16, 11, 2, -16 },
  { 1091, 14, 16, 16, 2, -16 },
  { 1119, 12, 16, 13, 2, -16 },
  { 1143, 18, 16, 19, 3, -16 },
  { 1179, 15, 16, 12, -1, -16 },
  { 1209, 12, 16, 11, 2, -16 },
  { 1233, 13, 16, 12, 0, -16 },
  { 1259, 9, 20, 7, 0, -16 },
  { 1282, 4, 16, 8, 2, -16 },
  { 1290, 9, 20, 7, -2, -16 },
  { 1313, 11, 11, 13, 1, -17 },
  { 1329, 9, 1, 9, -2, 2 },
  { 1331, 4, 4, 6, 3, -18 },
  { 1333, 11, 12, 13, 1, -12 },
  { 1350, 11, 17, 13, 1, -17 },
  { 1374, 10, 12, 10, 1, -12 },
  { 1389, 13, 17, 13, 1, -17 },
  { 1417, 10, 12, 11, 1, -12 },
  { 1432, 13, 24, 7, -3, -18 },
  { 1471, 11, 18, 13, 1, -12 },
  { 1496, 11, 17, 13, 1, -17 },
  { 1520, 5, 17, 5, 1, -17 },
  { 1531, 9, 23, 5, -3, -17 },
  { 1557, 11, 17, 11, 1, -17 },
  { 1581, 5, 17, 5, 1, -17 },
  { 1592, 17, 12, 20, 1, -12 },
  { 1618, 11, 13, 13, 1, -13 },
  { 1636, 11, 12, 13, 1, -12 },
  { 1653, 12, 17, 13, 0, -12 },
  { 1679, 11, 17, 13, 1, -12 },
  { 1703, 8, 12, 9, 1, -12 },
  { 1715, 9, 12, 10, 0, -12 },
  { 1729, 7, 15, 7, 1, -15 },
  { 1743, 11, 12, 13, 1, -12 },
  { 1760, 10, 12, 10, 1, -12 },
  { 1775, 16, 12, 16, 1, -12 },
  { 1799, 12, 12, 11, -1, -12 },
  { 1817, 13, 18, 10, -2, -12 },
  { 1847, 10, 12, 10, 0, -12 },
  { 1862, 9, 20, 8, 0, -16 },
  { 1885, 1, 23, 12, 6, -17 },
  { 1888, 8, 20, 8, -1, -16 },
  { 1908, 10, 2, 13, 2, -9 },
};

const GFXfont NotoSans_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_LIGHTITALIC23PT7B_H_
