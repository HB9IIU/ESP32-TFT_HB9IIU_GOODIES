#ifndef _NOTOSANS_LIGHTITALIC53PT7B_H_
#define _NOTOSANS_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x78, 0x07, 0x80, 0xF8, 0x07, 0x00, 0x20, 0x00,
  0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x31, 0xC1, 0xC7, 0x07,
  0x18, 0x1C, 0x60, 0x61, 0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xC6, 0x1E, 0x03,
  0xC1, 0x80, 0x80, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1F, 0x60, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x33, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x30, 0x78, 0x30, 0x0C, 0x3C, 0x0F,
  0xC7, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x80, 0xFF, 0xC0,
  0x00, 0xE0, 0x3C, 0x38, 0x00, 0x38, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x1C, 0x06, 0x00, 0x30, 0x03, 0x81, 0xC0, 0x06, 0x00, 0x60,
  0x70, 0x00, 0xC0, 0x1C, 0x1C, 0x00, 0x38, 0x03, 0x83, 0x00, 0x07, 0x00,
  0x70, 0xE1, 0xF8, 0xE0, 0x1C, 0x38, 0xFF, 0x9C, 0x03, 0x8E, 0x3C, 0x79,
  0x80, 0xE1, 0xC7, 0x07, 0x38, 0x3C, 0x71, 0xC0, 0x77, 0x8F, 0x1C, 0x70,
  0x0E, 0x7F, 0xC7, 0x0E, 0x01, 0xC7, 0xF0, 0xE1, 0x80, 0x38, 0x00, 0x38,
  0x70, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0xE0, 0x03, 0x81, 0x80, 0x18, 0x00,
  0x70, 0x30, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x1C, 0x00,
  0x30, 0x38, 0x07, 0x00, 0x07, 0x0F, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0x3B, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE7, 0x00, 0x00, 0x07, 0x83, 0x80, 0x07, 0x0F, 0x03, 0xC0, 0x0F,
  0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0xE0, 0x1E, 0x78, 0x00, 0xF0, 0x1C,
  0x70, 0x00, 0x70, 0x38, 0xF0, 0x00, 0x38, 0x78, 0xE0, 0x00, 0x1C, 0x70,
  0xE0, 0x00, 0x1E, 0xE0, 0xE0, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x3D, 0xC0,
  0x78, 0x00, 0xF8, 0xE0, 0x3E, 0x03, 0xF0, 0xF0, 0x1F, 0xFF, 0xC0, 0x70,
  0x07, 0xFF, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x39, 0xCE, 0x77, 0x39,
  0xCC, 0x63, 0x39, 0x8C, 0x60, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x08,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x7E, 0x0C, 0x00, 0x3F, 0x18, 0x00, 0x1F,
  0x30, 0x00, 0x07, 0xDF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x20, 0x1B,
  0x00, 0x00, 0xE7, 0x00, 0x03, 0xC6, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C,
  0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x0F, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x33, 0xDF, 0xF7, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x0F,
  0x80, 0x3E, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1E, 0x00,
  0x1E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x80, 0x01,
  0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x1C, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xE0, 0x7D, 0xC1, 0xF7, 0x0F, 0x8E, 0x7C, 0x1C, 0x70, 0x38, 0x80, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x01, 0xFE, 0x7F, 0x00, 0x7C, 0x01, 0xE0, 0x06, 0x00, 0x1E, 0x00, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x7E,
  0x01, 0xF8, 0x01, 0xE0, 0x18, 0x00, 0x1C, 0x02, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x07, 0x83, 0x80, 0x03, 0xE0,
  0x7E, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1D, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x40, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x20, 0x00,
  0x1E, 0x0C, 0x00, 0x1F, 0x03, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFC, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0xFF, 0x80, 0x38, 0xFF,
  0xF0, 0x0E, 0xF8, 0x1E, 0x03, 0xF0, 0x03, 0xC1, 0xD8, 0x00, 0x78, 0x7C,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x01,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0x01,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE0, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0xEE,
  0x07, 0x80, 0xF7, 0x00, 0xFF, 0xF9, 0xC0, 0x1F, 0xF8, 0x70, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x03, 0x80, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x07, 0x83,
  0xE0, 0x70, 0x08, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0xE0, 0xFC, 0x7E, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x1F, 0xF0, 0x07, 0x1C, 0x00, 0x7F, 0xFC, 0x07, 0x18, 0x01,
  0xF0, 0x7C, 0x07, 0x38, 0x03, 0xC0, 0x18, 0x07, 0x30, 0x07, 0x80, 0x38,
  0x03, 0x70, 0x0F, 0x00, 0x38, 0x03, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x60,
  0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x18, 0x00,
  0x70, 0x07, 0xE0, 0x38, 0x00, 0x60, 0x07, 0xE0, 0x38, 0x00, 0xE0, 0x06,
  0xE0, 0x38, 0x00, 0xE0, 0x0E, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0xE0, 0x38,
  0x01, 0xE0, 0x1C, 0xE0, 0x38, 0x03, 0xC0, 0x1C, 0xE0, 0x38, 0x03, 0xE0,
  0x38, 0xE0, 0x38, 0x06, 0xE0, 0x70, 0xE0, 0x1E, 0x1C, 0x71, 0xF0, 0xE0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x70, 0x07, 0xF0, 0x3F, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1C, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0x80, 0x06,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0x3F, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xF0,
  0x00, 0xE0, 0x0F, 0x80, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xCF, 0x00, 0x07, 0xFF, 0x9C, 0x00, 0x10, 0x0F, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x3E, 0x00,
  0x0F, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x0C, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x3E, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0x0F, 0xC7, 0x00,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x03, 0x60, 0x00, 0x00, 0x7E, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x77,
  0x00, 0x00, 0x0E, 0xE0, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x00, 0x79,
  0xC0, 0x38, 0xC0, 0x00, 0x1C, 0xE0, 0x0E, 0x30, 0x00, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x1C,
  0x1C, 0x01, 0xC1, 0x80, 0x07, 0x07, 0x00, 0x60, 0x60, 0x03, 0x81, 0xC0,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81,
  0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x01, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x87, 0x00, 0x70, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x19,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x70, 0x03, 0x80, 0x38, 0x01, 0xF8, 0x00,
  0xE0, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x07, 0x00, 0x1F, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x1F, 0x80,
  0x00, 0x1C, 0x03, 0xB8, 0x00, 0x03, 0x80, 0x77, 0x00, 0x00, 0xE0, 0x0E,
  0xE0, 0x00, 0x1C, 0x01, 0x8E, 0x00, 0x03, 0x80, 0x71, 0xC0, 0x00, 0x70,
  0x0E, 0x1C, 0x00, 0x1C, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x38, 0x70, 0x00,
  0x70, 0x07, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x1C, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0xE0, 0x1C, 0x00, 0x38, 0x38, 0x03, 0x80, 0x03, 0x87, 0x00, 0x70, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x00, 0xE3, 0x80, 0x70,
  0x00, 0x1C, 0x60, 0x0E, 0x00, 0x01, 0xDC, 0x01, 0xC0, 0x00, 0x3B, 0x80,
  0x38, 0x00, 0x07, 0x70, 0x0E, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x07,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0xF8, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xF1, 0xFC, 0x07,
  0xC0, 0x06, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x0C, 0x00, 0x1F, 0x03, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x70, 0x00,
  0x1F, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x60, 0x00, 0x79, 0xC0, 0x00, 0xEC,
  0x00, 0x0E, 0x38, 0x00, 0x1D, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x30, 0x00,
  0x70, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0xC0, 0x03, 0x81,
  0xC0, 0x07, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x07, 0x00,
  0x38, 0x70, 0x03, 0x80, 0xE0, 0x06, 0x0E, 0x00, 0xF0, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x18, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x61,
  0xC0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x0C,
  0xC0, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0x80, 0x00, 0x37, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xE0,
  0x30, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x07, 0x06, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xE0, 0xC0, 0x7F, 0xF8, 0xE0, 0x7C, 0x0E, 0x70,
  0x78, 0x03, 0x30, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x38, 0x00, 0x3E,
  0x3C, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xE1, 0xC0,
  0x03, 0x60, 0xF0, 0x03, 0x70, 0x38, 0x07, 0x38, 0x1F, 0x0F, 0x1C, 0x07,
  0xFF, 0x0C, 0x01, 0xFE, 0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x07, 0xFC, 0x01, 0xC7, 0xFF, 0x80, 0x73, 0xC1, 0xF0, 0x1D, 0xC0,
  0x1E, 0x06, 0xE0, 0x03, 0x83, 0xB0, 0x00, 0xE0, 0xF8, 0x00, 0x38, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x71, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87,
  0xC0, 0x03, 0xC1, 0xB0, 0x01, 0xE0, 0xEE, 0x00, 0xF0, 0x39, 0xE0, 0xF8,
  0x0C, 0x3F, 0xFC, 0x03, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC0, 0x30, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x0F, 0xC0, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x1C,
  0x00, 0x7F, 0xC3, 0xC0, 0x1F, 0xFE, 0x38, 0x03, 0xE0, 0x73, 0x80, 0x78,
  0x03, 0xB8, 0x0F, 0x00, 0x1B, 0x81, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xB8, 0x0F, 0x00, 0x3B, 0x80,
  0x70, 0x07, 0x30, 0x07, 0xC1, 0xE3, 0x00, 0x3F, 0xF8, 0x70, 0x01, 0xFF,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xF8, 0x1E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xF1, 0xE0,
  0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x07,
  0x9C, 0x00, 0x3C, 0x70, 0x07, 0xE3, 0xCF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x01, 0x03, 0xF0, 0x3C, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x20, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0x07, 0x00, 0x7F, 0xFC, 0x60, 0x0F, 0x81, 0xC6, 0x01,
  0xE0, 0x0E, 0xE0, 0x3C, 0x00, 0x6E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x3E, 0x03, 0x80, 0x06, 0xE0, 0x3C, 0x00, 0xEE,
  0x01, 0xC0, 0x1D, 0xC0, 0x1F, 0x07, 0x9C, 0x00, 0xFF, 0xE1, 0xC0, 0x07,
  0xFC, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x3C, 0x00, 0xF0, 0x0F,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x70, 0x7F, 0xC0, 0x38, 0xFF, 0xF0, 0x1C, 0xF0, 0x3C, 0x0E,
  0xE0, 0x0F, 0x06, 0xE0, 0x03, 0x87, 0x60, 0x01, 0xC3, 0xE0, 0x00, 0xE1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0x00, 0x40, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x10, 0x70,
  0x00, 0xF0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x0C, 0xFC, 0x00, 0x0E, 0xEE, 0x00, 0x07, 0xE7, 0x80,
  0x03, 0xE1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x78, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0x38, 0x1E, 0x3C, 0x0F, 0x06, 0x70, 0x0E, 0x30, 0x07, 0x06, 0xE0,
  0x0E, 0x60, 0x07, 0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0xF8, 0x00, 0xE0, 0xFF, 0xC0, 0x38, 0xFF, 0xF8, 0x0E, 0x78, 0x1E, 0x03,
  0xB8, 0x03, 0xC1, 0xDC, 0x00, 0x70, 0x76, 0x00, 0x1C, 0x1F, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0x07, 0xFC, 0x00, 0x38, 0xFF, 0xF0, 0x01,
  0xCF, 0x07, 0xC0, 0x0C, 0xE0, 0x0F, 0x00, 0x6E, 0x00, 0x38, 0x07, 0x60,
  0x01, 0xC0, 0x3E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0xF0, 0x0D, 0x80, 0x0F, 0x00, 0xEE, 0x00, 0xF0, 0x07, 0x3C,
  0x1F, 0x00, 0x38, 0xFF, 0xF0, 0x01, 0xC3, 0xFE, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xF0, 0x70, 0x1F, 0xFE, 0x18, 0x0F, 0x81, 0xC6, 0x07, 0x80,
  0x3B, 0x83, 0xC0, 0x06, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x83,
  0x80, 0x06, 0xE0, 0xF0, 0x03, 0xB8, 0x1C, 0x01, 0xDC, 0x07, 0xC1, 0xE7,
  0x00, 0xFF, 0xE1, 0xC0, 0x1F, 0xF0, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x7F, 0x07, 0x1F, 0xE0, 0x73, 0xC0,
  0x06, 0x70, 0x00, 0x6E, 0x00, 0x0E, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1,
  0xF0, 0x0E, 0x07, 0x00, 0x08, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC3,
  0x00, 0x0F, 0x0F, 0x80, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x40, 0xFF, 0x80, 0xFF, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x87, 0x00, 0x07, 0xC3, 0x80, 0x06, 0xC1, 0xC0, 0x06,
  0x60, 0xF0, 0x0E, 0x70, 0x3C, 0x1E, 0x38, 0x0F, 0xFE, 0x1C, 0x03, 0xFE,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x0E, 0x07, 0x80,
  0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3B, 0x80,
  0x07, 0x80, 0x07, 0x70, 0x01, 0xF0, 0x01, 0xEE, 0x00, 0x36, 0x00, 0x39,
  0xC0, 0x0E, 0xC0, 0x0F, 0x38, 0x01, 0x9C, 0x01, 0xC7, 0x00, 0x73, 0x80,
  0x78, 0xE0, 0x0C, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xC1, 0x80, 0x61,
  0xC0, 0x70, 0x30, 0x1C, 0x38, 0x0E, 0x07, 0x03, 0x07, 0x03, 0x80, 0xE0,
  0xE0, 0xE0, 0x70, 0x1C, 0x1C, 0x1C, 0x1C, 0x03, 0x87, 0x01, 0x83, 0x80,
  0x70, 0xE0, 0x30, 0xE0, 0x0E, 0x38, 0x06, 0x1C, 0x01, 0xC7, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1E,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x30, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x0F, 0xF1, 0xEC, 0x00, 0xFF, 0xE4,
  0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 39, 13, 1, -38 },
  { 60, 14, 14, 19, 6, -38 },
  { 85, 32, 38, 33, 2, -38 },
  { 237, 26, 43, 29, 2, -40 },
  { 377, 35, 39, 41, 4, -38 },
  { 548, 32, 39, 36, 2, -38 },
  { 704, 5, 14, 10, 6, -38 },
  { 713, 16, 46, 14, 2, -38 },
  { 805, 16, 46, 14, -4, -38 },
  { 897, 23, 23, 29, 6, -40 },
  { 964, 25, 25, 30, 4, -31 },
  { 1043, 8, 13, 12, -2, -6 },
  { 1056, 13, 3, 17, 2, -16 },
  { 1061, 5, 6, 12, 1, -5 },
  { 1065, 24, 38, 18, -2, -38 },
  { 1179, 25, 39, 29, 3, -38 },
  { 1301, 15, 38, 29, 8, -38 },
  { 1373, 27, 38, 29, 0, -38 },
  { 1502, 27, 39, 29, 1, -38 },
  { 1634, 27, 38, 29, 1, -38 },
  { 1763, 26, 39, 29, 2, -38 },
  { 1890, 26, 39, 29, 3, -38 },
  { 2017, 25, 38, 29, 5, -38 },
  { 2136, 26, 39, 29, 2, -38 },
  { 2263, 26, 39, 29, 2, -38 },
  { 2390, 10, 30, 12, 1, -29 },
  { 2428, 13, 36, 12, -2, -29 },
  { 2487, 25, 25, 30, 4, -32 },
  { 2566, 24, 13, 30, 4, -25 },
  { 2605, 25, 25, 30, 4, -32 },
  { 2684, 19, 39, 22, 4, -38 },
  { 2777, 40, 43, 45, 3, -38 },
  { 2992, 30, 38, 29, -3, -38 },
  { 3135, 29, 38, 32, 2, -38 },
  { 3273, 30, 39, 31, 4, -38 },
  { 3420, 32, 38, 36, 2, -38 },
  { 3572, 28, 38, 28, 2, -38 },
  { 3705, 28, 38, 26, 2, -38 },
  { 3838, 31, 39, 36, 4, -38 },
  { 3990, 34, 38, 36, 2, -38 },
  { 4152, 19, 38, 16, 0, -38 },
  { 4243, 23, 48, 13, -9, -38 },
  { 4381, 32, 38, 29, 2, -38 },
  { 4533, 20, 38, 26, 2, -38 },
  { 4628, 42, 38, 44, 2, -38 },
  { 4828, 35, 38, 37, 2, -38 },
  { 4995, 32, 39, 38, 4, -38 },
  { 5151, 28, 38, 30, 2, -38 },
  { 5284, 32, 47, 38, 4, -38 },
  { 5472, 28, 38, 30, 2, -38 },
  { 5605, 26, 39, 27, 1, -38 },
  { 5732, 26, 38, 26, 5, -38 },
  { 5856, 33, 39, 36, 4, -38 },
  { 6017, 28, 38, 29, 5, -38 },
  { 6150, 43, 38, 45, 6, -38 },
  { 6355, 34, 38, 27, -3, -38 },
  { 6517, 26, 38, 26, 5, -38 },
  { 6641, 30, 38, 28, 0, -38 },
  { 6784, 20, 46, 16, 0, -38 },
  { 6899, 9, 38, 18, 5, -38 },
  { 6942, 20, 46, 16, -4, -38 },
  { 7057, 26, 24, 30, 2, -38 },
  { 7135, 21, 3, 20, -5, 5 },
  { 7143, 7, 9, 13, 8, -41 },
  { 7151, 25, 30, 30, 3, -29 },
  { 7245, 26, 41, 30, 2, -40 },
  { 7379, 21, 30, 24, 3, -29 },
  { 7458, 28, 41, 30, 3, -40 },
  { 7602, 22, 30, 26, 3, -29 },
  { 7685, 29, 54, 15, -6, -41 },
  { 7881, 28, 42, 30, 1, -29 },
  { 8028, 25, 40, 30, 2, -40 },
  { 8153, 11, 39, 12, 2, -39 },
  { 8207, 20, 52, 12, -7, -39 },
  { 8337, 25, 40, 25, 2, -40 },
  { 8462, 11, 40, 12, 2, -40 },
  { 8517, 40, 29, 46, 2, -29 },
  { 8662, 26, 29, 30, 1, -29 },
  { 8757, 24, 29, 30, 3, -29 },
  { 8844, 29, 42, 30, -1, -29 },
  { 8997, 26, 42, 30, 3, -29 },
  { 9134, 20, 29, 20, 2, -29 },
  { 9207, 22, 30, 23, 0, -29 },
  { 9290, 15, 36, 17, 3, -35 },
  { 9358, 25, 29, 30, 3, -28 },
  { 9449, 23, 28, 23, 3, -28 },
  { 9530, 35, 28, 36, 3, -28 },
  { 9653, 28, 28, 25, -2, -28 },
  { 9751, 32, 41, 23, -6, -28 },
  { 9915, 24, 28, 23, -1, -28 },
  { 9999, 20, 46, 18, 1, -38 },
  { 10114, 3, 53, 29, 14, -40 },
  { 10134, 19, 46, 18, -2, -38 },
  { 10244, 25, 6, 30, 4, -22 },
};

const GFXfont NotoSans_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_LIGHTITALIC53PT7B_H_
