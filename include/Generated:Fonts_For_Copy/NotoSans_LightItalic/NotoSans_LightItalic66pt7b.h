#ifndef _NOTOSANS_LIGHTITALIC66PT7B_H_
#define _NOTOSANS_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x18,
  0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x71,
  0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1C, 0x03,
  0x8E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0x80, 0x71, 0xC0, 0x30, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFC, 0x70, 0x7C,
  0x03, 0xE0, 0xE0, 0x10, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x7E,
  0x70, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3B,
  0xF8, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x01, 0xC1,
  0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0xC1,
  0x00, 0x38, 0x1F, 0x03, 0xC0, 0x70, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x03,
  0x80, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x00, 0xE0,
  0x70, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x1F, 0xF9, 0xE0, 0x07, 0x07, 0x87,
  0xFF, 0x9C, 0x00, 0xE0, 0xE1, 0xF0, 0xF3, 0x80, 0x3C, 0x38, 0x78, 0x0F,
  0x70, 0x0F, 0x0F, 0x0E, 0x01, 0xEF, 0x03, 0xC3, 0xC3, 0xC0, 0x1C, 0xF9,
  0xF0, 0x70, 0x70, 0x03, 0x9F, 0xFC, 0x1C, 0x1E, 0x00, 0x71, 0xFF, 0x07,
  0x83, 0x80, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x00, 0x07, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF9, 0xF8, 0x03, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0x00, 0x79, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFD, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0x1F, 0x81,
  0xE0, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0x00, 0xF1, 0xF0, 0x03, 0xC0, 0x03,
  0xC7, 0xC0, 0x03, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0xC0, 0x1E, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0xF0, 0x00, 0x07, 0x80, 0xF1, 0xE0, 0x00, 0x07, 0x83,
  0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x87, 0x80, 0x00, 0x0F, 0x1E, 0x0E, 0x00,
  0x00, 0x0F, 0x78, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xE0,
  0x00, 0x03, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0xBC, 0x03, 0xE0, 0x00, 0x7E,
  0x3C, 0x03, 0xF0, 0x03, 0xF0, 0x7C, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x03,
  0xFF, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7A, 0x00,
  0x00, 0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC3,
  0x87, 0x0E, 0x18, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x40, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0xE0,
  0x70, 0x00, 0x7F, 0x07, 0x00, 0x00, 0xFC, 0x60, 0x00, 0x03, 0xF6, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x07,
  0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xEF, 0xFF, 0xFB, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0xFD, 0xE0, 0xFE, 0x78, 0x7E, 0x1C, 0x7F, 0x0F, 0x3F, 0x03, 0xC7,
  0x80, 0xF0, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0x80, 0x00, 0x78, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x78, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x00, 0x0F, 0x80,
  0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF4, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xBE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x1C, 0x1F, 0xFF, 0x00,
  0x3C, 0x7F, 0xFF, 0x80, 0x3C, 0xF8, 0x0F, 0xC0, 0x3D, 0xE0, 0x03, 0xE0,
  0x3B, 0x80, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xFE, 0x0F,
  0x80, 0x01, 0xDC, 0x07, 0xC0, 0x07, 0xBC, 0x03, 0xF0, 0x1F, 0x3C, 0x01,
  0xFF, 0xFE, 0x38, 0x00, 0xFF, 0xF8, 0x78, 0x00, 0x3F, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1E, 0x00, 0x7C, 0x18, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x38, 0x78, 0x00, 0x3F, 0xFF, 0xE0, 0x0E, 0x1C, 0x00, 0x1F, 0x80,
  0xF8, 0x03, 0xCF, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0xF3, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x3C, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x78, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0xDC, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF7, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x07,
  0x80, 0x01, 0xC0, 0x03, 0xB8, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xEE, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0xE0,
  0x0F, 0x00, 0x03, 0x80, 0x07, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xCE,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0xF3, 0x80, 0x38, 0x00, 0x3E, 0x00, 0x38,
  0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x1E, 0x38, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0x0E, 0x00, 0xF0, 0x03, 0xB8, 0x03, 0xC3, 0x80, 0x1E, 0x01, 0xCE, 0x03,
  0xE0, 0xF0, 0x07, 0xC1, 0xF3, 0xC1, 0xF0, 0x3C, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x07, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x00, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x7F, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xF1, 0xE0, 0x00, 0x0F, 0xFF, 0xE3, 0xC0, 0x00,
  0x1F, 0xFF, 0xC7, 0x80, 0x00, 0x40, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0x40, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xBF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x38, 0xFC, 0x00, 0x00, 0x00, 0xF3,
  0xF8, 0x00, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x3F,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xF0,
  0x07, 0xB8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x1C, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x00, 0x00,
  0x3C, 0x78, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x80, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x71, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x78, 0x00, 0x78, 0x01,
  0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x1D, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0x80, 0x1C, 0x78, 0x00, 0x00, 0xF0, 0x03, 0x8F, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x1E,
  0x00, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x0E, 0x00, 0x00, 0x1E, 0x70, 0x01, 0xC0, 0x00, 0x01,
  0xEE, 0x00, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x07, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x1E,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x7C, 0x03, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x18, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x73, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x1C, 0x00,
  0x78, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xF0,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78,
  0x3E, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0x00, 0x3F, 0xFF, 0x07, 0x00,
  0x7F, 0xFF, 0x8F, 0x00, 0xFC, 0x03, 0xCE, 0x01, 0xF0, 0x01, 0xCE, 0x03,
  0xE0, 0x00, 0xDE, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0xF0,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0D, 0xC0, 0x78, 0x00, 0x1D, 0xC0, 0x78,
  0x00, 0x3B, 0xC0, 0x3C, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE3, 0x80, 0x1F,
  0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0x03, 0x80, 0x07, 0xFE, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x7F, 0xE0, 0x01, 0xE1, 0xFF, 0xF8, 0x01,
  0xE3, 0xFB, 0xFC, 0x01, 0xC7, 0x80, 0x7C, 0x03, 0xCF, 0x00, 0x3E, 0x03,
  0xDC, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x0F, 0x03, 0xB0, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x07,
  0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x01, 0xF0, 0x7B,
  0x00, 0x03, 0xE0, 0x73, 0x80, 0x07, 0xC0, 0x71, 0xE0, 0x1F, 0x80, 0x71,
  0xFF, 0xFF, 0x00, 0xE0, 0xFF, 0xFC, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0x04, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x20, 0x1F, 0x80, 0x1C, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x78, 0x00, 0x3F, 0xFF, 0x07,
  0x00, 0x07, 0xFF, 0xF8, 0xF0, 0x00, 0xFC, 0x03, 0xCF, 0x00, 0x1F, 0x00,
  0x0E, 0xF0, 0x03, 0xE0, 0x00, 0x6F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x01,
  0xDE, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x03, 0xC0, 0x07, 0x1C, 0x00, 0x3E,
  0x01, 0xE1, 0xC0, 0x01, 0xFF, 0xFC, 0x1C, 0x00, 0x0F, 0xFF, 0x83, 0xC0,
  0x00, 0x7F, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x70, 0x7C, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xC3, 0xC0, 0x07, 0xF0, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x3F, 0x00,
  0x3C, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0xFC,
  0x38, 0x00, 0xFF, 0xBF, 0x0E, 0x00, 0x7E, 0x01, 0xE3, 0x80, 0x3E, 0x00,
  0x1D, 0xE0, 0x1F, 0x00, 0x03, 0x78, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x07, 0xF0, 0x0F, 0x00, 0x03, 0xBC, 0x03, 0xC0, 0x01, 0xCE, 0x00,
  0x78, 0x00, 0xE3, 0x80, 0x1F, 0x00, 0xF1, 0xE0, 0x03, 0xFF, 0xF8, 0x78,
  0x00, 0x7F, 0xFC, 0x1E, 0x00, 0x0F, 0xFC, 0x07, 0x00, 0x00, 0x30, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x08, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x7F, 0xF0, 0x01, 0xE1, 0xFF,
  0xF8, 0x01, 0xC3, 0xFF, 0xFC, 0x01, 0xC7, 0x80, 0x3E, 0x03, 0xCF, 0x00,
  0x1E, 0x03, 0xDC, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x0E, 0x03, 0xB0, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x00,
  0x0E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x7E, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x07, 0x3F, 0x80,
  0x00, 0x0E, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F, 0x0F, 0x00,
  0x00, 0xFC, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xE1,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0x1C, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x07,
  0x9C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0xF7, 0x00, 0x0E, 0x78, 0x00, 0x78,
  0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x03, 0xB0, 0x00, 0x3F, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x7F,
  0xF0, 0x01, 0xC1, 0xFF, 0xF8, 0x01, 0xC3, 0xFF, 0xFC, 0x01, 0xC7, 0xC0,
  0x7E, 0x03, 0xCF, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x1E, 0x03, 0xF8, 0x00,
  0x0F, 0x03, 0xB0, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x81,
  0xFF, 0x80, 0x00, 0xE0, 0xFF, 0xFC, 0x00, 0x1C, 0x3F, 0xBF, 0xC0, 0x03,
  0x8F, 0x00, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0x80, 0x1E, 0xE0, 0x00, 0xF0,
  0x03, 0xB8, 0x00, 0x0F, 0x00, 0x76, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00,
  0x3C, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x0F, 0x80,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xD8, 0x00, 0x1F, 0x00, 0x7B, 0x80, 0x07,
  0xC0, 0x0E, 0x3C, 0x03, 0xF0, 0x01, 0xC7, 0xFF, 0xFC, 0x00, 0x78, 0x7F,
  0xFF, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x01, 0xC0, 0x0F, 0xFF, 0xC1, 0xC0, 0x0F, 0xFB, 0xF0, 0xE0, 0x0F, 0xC0,
  0x3C, 0x70, 0x0F, 0x80, 0x07, 0x78, 0x0F, 0x80, 0x01, 0xBC, 0x0F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0xEF, 0x01, 0xE0, 0x00, 0xE7,
  0x00, 0x78, 0x00, 0xE3, 0x80, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0xFF, 0xE1,
  0xE0, 0x03, 0xFF, 0xE0, 0xF0, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x06, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x3F, 0xC0, 0x70,
  0x7F, 0xE0, 0x38, 0x7F, 0xF0, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xE0,
  0x03, 0x81, 0xE0, 0x00, 0x20, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC2, 0x00, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x3F, 0x07,
  0x00, 0x00, 0xDC, 0x0F, 0x00, 0x03, 0xB8, 0x1E, 0x00, 0x0E, 0x70, 0x3E,
  0x00, 0x79, 0xE0, 0x3E, 0x01, 0xE3, 0x80, 0x7F, 0xFF, 0x87, 0x00, 0x7F,
  0xFE, 0x0E, 0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0xF7, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x70,
  0x00, 0xF0, 0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x70, 0x01,
  0xE0, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x70, 0x03, 0xC0,
  0xF0, 0x07, 0x87, 0x00, 0x3C, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0x70, 0x1E,
  0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x00, 0x70, 0x3C, 0x03,
  0x81, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0x78, 0x03, 0x83,
  0xC0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80,
  0x07, 0x0E, 0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x07,
  0x1C, 0x00, 0x38, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x3F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F,
  0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x63, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x02, 0x7F, 0xF8, 0x00, 0x0D, 0xFF, 0xFE, 0x00, 0x3F,
  0xC3, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xD8, 0x00, 0x3F, 0xFF, 0x20,
  0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph NotoSans_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 14, 48, 16, 2, -47 },
  { 85, 17, 17, 23, 7, -47 },
  { 122, 40, 47, 42, 2, -47 },
  { 357, 31, 54, 36, 3, -50 },
  { 567, 43, 49, 52, 5, -48 },
  { 831, 39, 49, 45, 3, -48 },
  { 1070, 7, 17, 13, 7, -47 },
  { 1085, 20, 57, 18, 2, -47 },
  { 1228, 20, 57, 18, -5, -47 },
  { 1371, 28, 29, 36, 8, -50 },
  { 1473, 31, 31, 38, 5, -39 },
  { 1594, 11, 17, 15, -3, -8 },
  { 1618, 16, 4, 21, 2, -20 },
  { 1626, 6, 7, 15, 2, -6 },
  { 1632, 31, 47, 22, -3, -47 },
  { 1815, 31, 49, 36, 4, -48 },
  { 2005, 18, 47, 36, 10, -47 },
  { 2111, 34, 48, 36, 0, -48 },
  { 2315, 34, 49, 36, 1, -48 },
  { 2524, 34, 47, 36, 1, -47 },
  { 2724, 32, 48, 36, 3, -47 },
  { 2916, 32, 49, 36, 4, -48 },
  { 3112, 31, 47, 36, 6, -47 },
  { 3295, 32, 49, 36, 3, -48 },
  { 3491, 32, 49, 36, 3, -48 },
  { 3687, 12, 37, 15, 2, -36 },
  { 3743, 17, 45, 15, -3, -36 },
  { 3839, 31, 31, 38, 5, -39 },
  { 3960, 30, 16, 38, 5, -31 },
  { 4020, 31, 31, 38, 5, -39 },
  { 4141, 24, 49, 28, 5, -48 },
  { 4288, 50, 53, 56, 4, -47 },
  { 4620, 37, 47, 37, -4, -47 },
  { 4838, 36, 47, 40, 3, -47 },
  { 5050, 37, 49, 39, 5, -48 },
  { 5277, 39, 47, 44, 3, -47 },
  { 5507, 34, 47, 35, 3, -47 },
  { 5707, 34, 47, 32, 3, -47 },
  { 5907, 39, 49, 45, 5, -48 },
  { 6146, 42, 47, 45, 3, -47 },
  { 6393, 23, 47, 20, 0, -47 },
  { 6529, 28, 59, 17, -11, -47 },
  { 6736, 39, 47, 37, 3, -47 },
  { 6966, 24, 47, 32, 3, -47 },
  { 7107, 51, 47, 54, 3, -47 },
  { 7407, 43, 47, 46, 3, -47 },
  { 7660, 40, 49, 47, 5, -48 },
  { 7905, 34, 47, 37, 3, -47 },
  { 8105, 40, 59, 47, 5, -48 },
  { 8400, 34, 47, 37, 3, -47 },
  { 8600, 33, 49, 33, 1, -48 },
  { 8803, 32, 47, 33, 6, -47 },
  { 8991, 40, 48, 45, 6, -47 },
  { 9231, 34, 47, 36, 7, -47 },
  { 9431, 53, 47, 56, 8, -47 },
  { 9743, 43, 47, 34, -4, -47 },
  { 9996, 33, 47, 33, 6, -47 },
  { 10190, 39, 47, 35, -1, -47 },
  { 10420, 25, 57, 20, -1, -47 },
  { 10599, 11, 47, 22, 7, -47 },
  { 10664, 25, 57, 20, -5, -47 },
  { 10843, 31, 29, 37, 3, -47 },
  { 10956, 26, 3, 25, -6, 7 },
  { 10966, 9, 11, 17, 10, -51 },
  { 10979, 32, 37, 37, 3, -36 },
  { 11127, 32, 51, 38, 2, -50 },
  { 11331, 27, 37, 30, 3, -36 },
  { 11456, 36, 51, 38, 3, -50 },
  { 11686, 27, 37, 33, 4, -36 },
  { 11811, 36, 66, 19, -8, -50 },
  { 12108, 34, 52, 38, 2, -36 },
  { 12329, 32, 50, 37, 2, -50 },
  { 12529, 14, 48, 15, 2, -48 },
  { 12613, 25, 64, 15, -9, -48 },
  { 12813, 31, 50, 31, 2, -50 },
  { 13007, 14, 50, 15, 2, -50 },
  { 13095, 51, 36, 57, 2, -36 },
  { 13325, 32, 36, 37, 2, -36 },
  { 13469, 31, 37, 37, 3, -36 },
  { 13613, 35, 52, 38, -1, -36 },
  { 13841, 33, 52, 38, 3, -36 },
  { 14056, 25, 36, 25, 2, -36 },
  { 14169, 26, 37, 28, 1, -36 },
  { 14290, 20, 45, 21, 3, -44 },
  { 14403, 31, 36, 37, 4, -35 },
  { 14543, 29, 35, 29, 3, -35 },
  { 14670, 44, 35, 45, 4, -35 },
  { 14863, 34, 35, 31, -2, -35 },
  { 15012, 39, 51, 29, -7, -35 },
  { 15261, 30, 35, 29, -1, -35 },
  { 15393, 25, 57, 22, 1, -47 },
  { 15572, 3, 66, 36, 18, -50 },
  { 15597, 24, 57, 22, -3, -47 },
  { 15768, 31, 7, 38, 5, -27 },
};

const GFXfont NotoSans_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_LightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_LIGHTITALIC66PT7B_H_
