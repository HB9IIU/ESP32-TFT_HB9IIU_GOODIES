#ifndef _ROBOTOMONO_LIGHTITALIC32PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x86, 0x00, 0x63, 0x62, 0x62, 0x46, 0x46,
  0x46, 0xC4, 0x00, 0x30, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0,
  0x04, 0x10, 0x01, 0x86, 0x00, 0x20, 0xC0, 0xFF, 0xFF, 0x01, 0x86, 0x00,
  0x20, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01,
  0x86, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0x06, 0x00, 0x20, 0x80, 0x0C,
  0x30, 0x01, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x0F, 0x80, 0x7F, 0xC1, 0xC1, 0xC7, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x20, 0x0C, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x30, 0x00, 0x36, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0x98, 0x06, 0x30, 0x1C, 0x3C, 0xF0, 0x3F, 0x80, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xEC, 0x01, 0x8C, 0x06, 0x18, 0x2C,
  0x30, 0xD8, 0x63, 0x30, 0xCC, 0x61, 0x10, 0x46, 0x60, 0xF9, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x47, 0x81, 0x9B, 0x86, 0x61, 0x18, 0x82,
  0x23, 0x04, 0xC6, 0x0B, 0x0C, 0x30, 0x18, 0x60, 0x11, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xF8, 0x06, 0x08, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x08,
  0x0C, 0x18, 0x04, 0x30, 0x06, 0x60, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0x00,
  0x1D, 0x80, 0x38, 0xC1, 0x30, 0xC3, 0x60, 0x63, 0x60, 0x66, 0xC0, 0x36,
  0xC0, 0x1C, 0x40, 0x18, 0x60, 0x3C, 0x38, 0xEE, 0x1F, 0x86, 0x6D, 0x2D,
  0xB0, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x80,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x83, 0x07, 0x8C, 0xF7,
  0xFF, 0x83, 0xF0, 0x07, 0x00, 0x36, 0x01, 0x98, 0x0C, 0x30, 0x60, 0x61,
  0x81, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x33, 0x36,
  0x6C, 0xC8, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x30, 0x30, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x07,
  0x60, 0x1E, 0xC0, 0xED, 0x83, 0x1B, 0x0C, 0x34, 0x30, 0x79, 0xC0, 0xB6,
  0x03, 0x78, 0x06, 0xE0, 0x0D, 0x80, 0x33, 0x00, 0x63, 0x01, 0x86, 0x07,
  0x07, 0x3C, 0x07, 0xE0, 0x00, 0x00, 0x83, 0x87, 0xDE, 0x6C, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x03, 0xF0, 0x0F, 0xF0, 0x30,
  0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xC8, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFF,
  0xBF, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x30, 0x38, 0xC0, 0x31, 0x80,
  0x66, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x03, 0xC0,
  0x3F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0D, 0x80,
  0x1B, 0x00, 0x66, 0x00, 0xC6, 0x03, 0x0F, 0x1C, 0x07, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0xCC, 0x00,
  0xCC, 0x01, 0x8C, 0x03, 0x08, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18,
  0x18, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x31, 0xFF, 0xFE, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xFE, 0x1F,
  0xFC, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x31, 0x80, 0x5F, 0xC0, 0xE1, 0xC3, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x19, 0x00, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x06,
  0x0E, 0x38, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x23, 0xC1, 0xBF, 0xC7, 0x83,
  0x9C, 0x06, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00,
  0x6C, 0x01, 0x98, 0x0C, 0x60, 0x70, 0xE7, 0x81, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E,
  0x1C, 0x06, 0x18, 0x02, 0x18, 0x03, 0x10, 0x02, 0x10, 0x06, 0x18, 0x06,
  0x18, 0x1C, 0x0F, 0xF8, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x18, 0x60, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x38,
  0x38, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xC1, 0x83, 0x8C, 0x06, 0x60,
  0x0D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x06, 0x60, 0x39, 0xC3, 0x63, 0xF9, 0x81, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x81, 0xF8, 0x07, 0xC0, 0x00, 0x19, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1C, 0xC0, 0x06, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x61,
  0x83, 0x0C, 0x10, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x30, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x20, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xFE, 0x70, 0x6E, 0x03, 0xC0,
  0x3C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x70, 0x30, 0x30,
  0x06, 0x18, 0x00, 0x84, 0x3E, 0x23, 0x18, 0x88, 0x8C, 0x22, 0x62, 0x08,
  0x91, 0x86, 0x24, 0x41, 0x0B, 0x10, 0x42, 0xCC, 0x30, 0xA3, 0x0C, 0x68,
  0xC2, 0x12, 0x31, 0x8C, 0x8C, 0xA2, 0x21, 0xCF, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x68, 0x00, 0xC8, 0x00, 0xCC, 0x01, 0x8C,
  0x01, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x04, 0x06, 0x04, 0x04, 0x06,
  0x0C, 0x06, 0x0F, 0xFE, 0x1F, 0xFE, 0x10, 0x06, 0x30, 0x06, 0x30, 0x02,
  0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x0F, 0xF0, 0x0F, 0xFC, 0x0C, 0x06,
  0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06,
  0x10, 0x0E, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x1C, 0x30, 0x06, 0x30, 0x06,
  0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x18,
  0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x0E, 0x18, 0x06,
  0x30, 0x02, 0x30, 0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x40, 0x18, 0x60, 0x30, 0x38, 0xE0,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x02, 0x03, 0x03, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x04, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x04,
  0x60, 0x06, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0x86, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x0E, 0x18,
  0x06, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFE, 0xC0, 0xFE, 0xC0, 0x04, 0xC0,
  0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x3C,
  0xF0, 0x1F, 0xC0, 0x08, 0x00, 0xC2, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x20, 0x02, 0x18, 0x00, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x01, 0x84, 0x00, 0x43, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x06, 0x30, 0x06,
  0x0C, 0x03, 0x06, 0x03, 0x01, 0xC7, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xE1,
  0x80, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x4E, 0x00, 0x1B,
  0xC0, 0x03, 0xCC, 0x00, 0x71, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0xC3, 0x00, 0x71, 0xE0,
  0x38, 0x78, 0x0A, 0x1E, 0x07, 0x87, 0x83, 0x61, 0x20, 0xD8, 0x48, 0x66,
  0x33, 0x19, 0x0C, 0xCC, 0xC3, 0x33, 0x30, 0xCD, 0x8C, 0x31, 0x63, 0x08,
  0x70, 0x86, 0x18, 0x61, 0x86, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00,
  0x61, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC3, 0x00, 0x61, 0xC0, 0x18, 0x78, 0x06, 0x1E, 0x01, 0x86, 0x80, 0x61,
  0xB0, 0x10, 0xCC, 0x0C, 0x31, 0x03, 0x0C, 0x60, 0xC3, 0x18, 0x30, 0xC3,
  0x0C, 0x20, 0xC2, 0x18, 0x31, 0x86, 0x06, 0x61, 0x81, 0x98, 0x60, 0x26,
  0x18, 0x0D, 0x84, 0x03, 0x43, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x07, 0x0C,
  0x00, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x66,
  0x00, 0xD8, 0x00, 0xB0, 0x01, 0x60, 0x02, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x62, 0x01, 0x86, 0x07, 0x07, 0x3C, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x0F, 0xFE, 0x06, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x08, 0x40,
  0x04, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01, 0x84, 0x03, 0x87,
  0xFF, 0x83, 0xFC, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0C, 0x0C, 0x18, 0x06, 0x30, 0x06, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x18, 0x60, 0x70, 0x39, 0xE0, 0x1F, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x10, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0x01, 0x81,
  0x80, 0x60, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x18, 0x03,
  0x0C, 0x01, 0x84, 0x01, 0x86, 0x03, 0x83, 0xFF, 0x01, 0x83, 0x00, 0xC0,
  0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x63, 0x00, 0x38, 0x03, 0xF0, 0x07, 0xFC, 0x1C, 0x0E,
  0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x38,
  0x7C, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x04, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x46, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x30, 0x06, 0x18, 0x06, 0x06,
  0x07, 0x01, 0xCF, 0x00, 0x7E, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x20, 0x18, 0x30, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x10, 0xC0,
  0x19, 0x80, 0x19, 0x80, 0x1B, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x81, 0xE0, 0xE0, 0xF0, 0x70, 0x58, 0x38,
  0x6C, 0x3C, 0x36, 0x1E, 0x13, 0x0B, 0x19, 0x8D, 0x8C, 0xC6, 0xC6, 0x62,
  0x62, 0x33, 0x33, 0x19, 0x99, 0x8C, 0x8C, 0x86, 0xC6, 0xC3, 0x63, 0x61,
  0xA1, 0xB0, 0xF0, 0xD0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E,
  0x06, 0x07, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x07,
  0x03, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x00, 0x98, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x60, 0x00, 0xEC, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01, 0x81, 0x80,
  0x70, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x00, 0xC0,
  0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x18,
  0x10, 0x30, 0x18, 0x30, 0x18, 0x60, 0x08, 0xC0, 0x0C, 0xC0, 0x0D, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F,
  0xC3, 0xE0, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3E,
  0x0F, 0x80, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1,
  0x81, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x06,
  0x07, 0xC1, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0x0F, 0xC0, 0x01, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0xC8, 0x19, 0x06,
  0x30, 0xC6, 0x30, 0xC4, 0x09, 0x81, 0xE0, 0x3C, 0x06, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE6, 0x31, 0x07, 0xF0, 0x79, 0xE3, 0x81, 0xCC, 0x03, 0x60, 0x0C,
  0x00, 0x30, 0x00, 0xC1, 0xFF, 0x3F, 0xF9, 0xC0, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0xEC, 0x07, 0x9C, 0xF6, 0x3F, 0x18, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0xFC,
  0x1B, 0xBC, 0x38, 0x18, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01,
  0x8E, 0x07, 0x17, 0x3C, 0x67, 0xF0, 0x07, 0xF0, 0x3D, 0xE1, 0x80, 0xCC,
  0x03, 0x30, 0x05, 0x80, 0x16, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x19, 0x80, 0x66, 0x03, 0x0E, 0x38, 0x1F, 0xC0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x07, 0xE6, 0x0E, 0x76, 0x18, 0x1E, 0x30, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x18, 0x40, 0x38, 0x60, 0x70, 0x39, 0xD0, 0x1F, 0xB0,
  0x03, 0xF0, 0x1E, 0x70, 0x60, 0x71, 0x80, 0x66, 0x00, 0x4C, 0x00, 0x90,
  0x01, 0x7F, 0xFE, 0xFF, 0xFD, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x02, 0x18, 0x0E, 0x1C, 0x78, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0xFF,
  0x01, 0xC1, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0xF3,
  0x07, 0x3B, 0x0C, 0x0F, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x20, 0x1C, 0x30, 0x38, 0x1C, 0xF8, 0x0F, 0xD8, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0xC0, 0x70, 0x60, 0xE0, 0x3F, 0xC0, 0x0F, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x7C, 0x1B, 0xFC, 0x3C, 0x0C, 0x70, 0x19, 0xC0, 0x33, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x98, 0x03, 0x20, 0x06, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x90, 0x03, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x07, 0x30, 0x1C, 0x60,
  0x70, 0xC1, 0x81, 0x86, 0x03, 0x38, 0x0C, 0xE0, 0x1B, 0x80, 0x3F, 0x80,
  0x73, 0x00, 0xC3, 0x01, 0x07, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x0E, 0x30,
  0x0C, 0x60, 0x0C, 0x0F, 0xF0, 0x7F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x17, 0xCF, 0x8F, 0xFF, 0x73, 0x87,
  0x0C, 0xC1, 0x83, 0x30, 0x60, 0xC8, 0x18, 0x32, 0x04, 0x09, 0x83, 0x02,
  0x60, 0xC1, 0x98, 0x30, 0x66, 0x0C, 0x19, 0x03, 0x06, 0x40, 0x81, 0x30,
  0x60, 0x4C, 0x18, 0x33, 0x06, 0x0C, 0xC1, 0x83, 0x00, 0x18, 0xF8, 0x37,
  0xF8, 0x78, 0x18, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x40, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x20, 0x06, 0xC0, 0x18, 0x07, 0xE0, 0x1C, 0xF0, 0x60, 0x61, 0x80,
  0x66, 0x00, 0xCC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x07, 0x18, 0x1C, 0x1C, 0xF0, 0x1F,
  0x80, 0x0C, 0xFC, 0x0F, 0xDE, 0x0E, 0x06, 0x0C, 0x03, 0x08, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x0C, 0x38, 0x1C, 0x3E, 0x78, 0x67, 0xE0, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x07, 0xE6, 0x1C, 0xEC, 0x60, 0x79, 0x80, 0x67, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x88, 0x07, 0x18, 0x1C, 0x1C, 0xF8, 0x1F, 0xB0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x19, 0xFC,
  0x4F, 0xE3, 0x60, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x1E, 0xF0, 0x60, 0x31, 0x80, 0x63,
  0x00, 0x66, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xCC, 0x00, 0x98, 0x03, 0x18, 0x0E, 0x3C, 0x78, 0x1F, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0xC4, 0x0F, 0xC0, 0x30, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x22, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x11, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x88, 0x07, 0x18, 0x1E,
  0x3C, 0xE8, 0x3F, 0x30, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x32, 0x00, 0xC6,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x10, 0x30, 0x30, 0x40, 0x61, 0x80, 0xC6,
  0x00, 0x8C, 0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x81, 0xE0, 0xC0, 0xF0, 0x70, 0x58, 0x38, 0x6C, 0x3C, 0x36, 0x16,
  0x31, 0x1B, 0x18, 0x89, 0x88, 0x44, 0x4C, 0x26, 0x26, 0x12, 0x12, 0x0B,
  0x0B, 0x05, 0x05, 0x02, 0x82, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x00, 0x1C, 0x01, 0xC3, 0x00, 0xE0, 0x60, 0x70, 0x1C, 0x18, 0x03, 0x0C,
  0x00, 0x66, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x3B, 0x00, 0x1C, 0xC0, 0x06, 0x18, 0x03, 0x06, 0x01, 0x80, 0xC0, 0xC0,
  0x18, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x06, 0x0C,
  0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x20, 0x60, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xF0,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x04, 0x30,
  0xC3, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x30, 0xC2,
  0x08, 0x61, 0x86, 0x18, 0x41, 0x04, 0x30, 0x04, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x07, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xBB, 0x80, 0xF0, 0x70,
  0x50, 0x1C, 0xE8, 0x07, 0xE0,
};

const GFXglyph RobotoMono_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 23, 19, 6, -23 },
  { 19, 8, 7, 19, 7, -24 },
  { 26, 19, 23, 19, 0, -23 },
  { 81, 15, 29, 19, 2, -26 },
  { 136, 15, 23, 19, 2, -23 },
  { 180, 16, 23, 19, 1, -23 },
  { 226, 3, 7, 19, 9, -24 },
  { 229, 10, 33, 19, 5, -26 },
  { 271, 10, 33, 19, 3, -26 },
  { 313, 14, 14, 19, 4, -23 },
  { 338, 15, 17, 19, 2, -19 },
  { 370, 4, 8, 19, 4, -3 },
  { 374, 12, 2, 19, 3, -11 },
  { 377, 3, 3, 19, 7, -3 },
  { 379, 16, 25, 19, 2, -23 },
  { 429, 15, 23, 19, 2, -23 },
  { 473, 9, 23, 19, 5, -23 },
  { 499, 15, 23, 19, 1, -23 },
  { 543, 15, 23, 19, 1, -23 },
  { 587, 16, 23, 19, 1, -23 },
  { 633, 15, 23, 19, 3, -23 },
  { 677, 14, 23, 19, 2, -23 },
  { 718, 15, 23, 19, 4, -23 },
  { 762, 16, 23, 19, 2, -23 },
  { 808, 14, 23, 19, 3, -23 },
  { 849, 5, 17, 19, 8, -17 },
  { 860, 7, 22, 19, 6, -17 },
  { 880, 14, 13, 19, 3, -17 },
  { 903, 15, 8, 19, 2, -14 },
  { 918, 14, 13, 19, 2, -17 },
  { 941, 12, 23, 19, 5, -23 },
  { 976, 18, 23, 19, 1, -23 },
  { 1028, 16, 23, 19, 0, -23 },
  { 1074, 16, 23, 19, 1, -23 },
  { 1120, 16, 23, 19, 2, -23 },
  { 1166, 17, 23, 19, 1, -23 },
  { 1215, 17, 23, 19, 1, -23 },
  { 1264, 17, 23, 19, 2, -23 },
  { 1313, 16, 23, 19, 2, -23 },
  { 1359, 18, 23, 19, 1, -23 },
  { 1411, 17, 23, 19, 1, -23 },
  { 1460, 17, 23, 19, 1, -23 },
  { 1509, 19, 23, 19, 1, -23 },
  { 1564, 13, 23, 19, 2, -23 },
  { 1602, 18, 23, 19, 1, -23 },
  { 1654, 18, 23, 19, 1, -23 },
  { 1706, 15, 23, 19, 2, -23 },
  { 1750, 17, 23, 19, 2, -23 },
  { 1799, 16, 27, 19, 2, -23 },
  { 1853, 17, 23, 19, 1, -23 },
  { 1902, 16, 23, 19, 2, -23 },
  { 1948, 17, 23, 19, 3, -23 },
  { 1997, 17, 23, 19, 2, -23 },
  { 2046, 16, 23, 19, 3, -23 },
  { 2092, 17, 23, 19, 3, -23 },
  { 2141, 19, 23, 19, 0, -23 },
  { 2196, 16, 23, 19, 3, -23 },
  { 2242, 17, 23, 19, 1, -23 },
  { 2291, 10, 31, 19, 5, -26 },
  { 2330, 7, 25, 19, 6, -23 },
  { 2352, 10, 31, 19, 4, -26 },
  { 2391, 11, 13, 19, 4, -23 },
  { 2409, 13, 2, 19, 1, 0 },
  { 2413, 4, 4, 19, 9, -23 },
  { 2415, 14, 17, 19, 2, -17 },
  { 2445, 15, 24, 19, 1, -24 },
  { 2490, 14, 17, 19, 2, -17 },
  { 2520, 16, 24, 19, 2, -24 },
  { 2568, 15, 17, 19, 2, -17 },
  { 2600, 16, 25, 19, 4, -25 },
  { 2650, 16, 24, 19, 1, -17 },
  { 2698, 15, 24, 19, 1, -24 },
  { 2743, 13, 23, 19, 2, -23 },
  { 2781, 15, 30, 19, 0, -23 },
  { 2838, 15, 24, 19, 2, -24 },
  { 2883, 13, 24, 19, 2, -24 },
  { 2922, 18, 17, 19, 0, -17 },
  { 2961, 15, 17, 19, 1, -17 },
  { 2993, 15, 17, 19, 2, -17 },
  { 3025, 16, 24, 19, 0, -17 },
  { 3073, 15, 24, 19, 2, -17 },
  { 3118, 14, 17, 19, 4, -17 },
  { 3148, 15, 17, 19, 2, -17 },
  { 3180, 12, 21, 19, 4, -21 },
  { 3212, 15, 17, 19, 2, -17 },
  { 3244, 15, 17, 19, 3, -17 },
  { 3276, 17, 17, 19, 2, -17 },
  { 3313, 18, 17, 19, 0, -17 },
  { 3352, 19, 24, 19, 0, -17 },
  { 3409, 16, 17, 19, 1, -17 },
  { 3443, 12, 31, 19, 5, -25 },
  { 3490, 6, 28, 19, 6, -23 },
  { 3511, 12, 31, 19, 3, -25 },
  { 3558, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_LIGHTITALIC32PT7B_H_
