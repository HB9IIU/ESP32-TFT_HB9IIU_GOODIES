#ifndef _ROBOTOMONO_LIGHTITALIC61PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xC0,
  0x00, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x31, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0x80, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0x00,
  0x3E, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x80,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x41, 0xC0, 0x38, 0x03, 0x1C,
  0x01, 0xC0, 0x3C, 0xE0, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x1C, 0x38, 0x03,
  0x81, 0xC1, 0xC0, 0x1C, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x0E,
  0x03, 0x80, 0x70, 0xF0, 0x1E, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x70, 0x01,
  0xFF, 0x07, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x0E, 0x0F, 0xF8,
  0x00, 0xE0, 0xFF, 0xE0, 0x07, 0x0F, 0x07, 0x00, 0x70, 0xF0, 0x38, 0x07,
  0x07, 0x00, 0xE0, 0x78, 0x38, 0x07, 0x03, 0x83, 0x80, 0x38, 0x38, 0x1C,
  0x01, 0xC3, 0x80, 0xE0, 0x0E, 0x1C, 0x07, 0x00, 0x71, 0xC0, 0x38, 0x03,
  0x1C, 0x01, 0xC0, 0x38, 0x60, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x1C, 0x3C,
  0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x0F, 0x01, 0xC7, 0x80,
  0x0E, 0x07, 0x9E, 0x00, 0x1E, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x70, 0x00,
  0x3C, 0x78, 0xE0, 0x00, 0x3D, 0xE1, 0xC0, 0x00, 0x3B, 0x83, 0x80, 0x00,
  0x7F, 0x07, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xF0, 0x1E, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0xFD, 0xE0, 0x3F, 0xCF, 0xF1,
  0xE0, 0x1F, 0xFF, 0x81, 0xC0, 0x1F, 0xFC, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x01, 0x30, 0x07, 0x00, 0xEF, 0xC0, 0xC0, 0xFF, 0xFE, 0x18,
  0xFF, 0x9F, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x70,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x3C,
  0x01, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78,
  0xF0, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x11, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x7C, 0x70,
  0x00, 0x0F, 0xE7, 0x80, 0x00, 0xFF, 0x3C, 0x00, 0x0F, 0x79, 0xE0, 0x00,
  0xF3, 0xCE, 0x00, 0x1F, 0x1C, 0x70, 0x01, 0xE0, 0xE3, 0x80, 0x1E, 0x07,
  0x3C, 0x01, 0xE0, 0x79, 0xE0, 0x3E, 0x03, 0xCF, 0x03, 0xC0, 0x1E, 0x70,
  0x3C, 0x00, 0xE3, 0x83, 0xC0, 0x07, 0x1C, 0x7C, 0x00, 0x39, 0xE7, 0x80,
  0x03, 0xCF, 0x78, 0x00, 0x1E, 0x7F, 0x80, 0x00, 0xE3, 0xF8, 0x00, 0x07,
  0x1F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x7F,
  0xE0, 0xFF, 0x73, 0xFE, 0x79, 0xF8, 0x3D, 0xF0, 0x1C, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0F, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xE0, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x1F,
  0xF0, 0x0F, 0x1F, 0xFF, 0x03, 0x9F, 0xFF, 0xE0, 0xEF, 0x80, 0x7C, 0x7F,
  0x80, 0x0F, 0x1F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x7E, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03,
  0xC1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7E, 0x3C,
  0x00, 0x3F, 0x8F, 0x80, 0x3D, 0xC1, 0xFC, 0x7E, 0x70, 0x3F, 0xFF, 0x1C,
  0x07, 0xFF, 0x0F, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x10, 0x01, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xE1, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x0C, 0x01, 0xC1,
  0xC0, 0x3F, 0xC0, 0xE0, 0xE0, 0x3F, 0xF0, 0x30, 0xE0, 0x7C, 0x38, 0x18,
  0x70, 0x38, 0x0C, 0x0C, 0x70, 0x38, 0x0E, 0x06, 0x30, 0x38, 0x06, 0x03,
  0x38, 0x1C, 0x03, 0x01, 0x9C, 0x1C, 0x01, 0x80, 0xCC, 0x0E, 0x01, 0xC0,
  0x6E, 0x06, 0x00, 0xC0, 0x77, 0x07, 0x00, 0x60, 0x3B, 0x03, 0x80, 0x30,
  0x1F, 0x81, 0x80, 0x38, 0x0D, 0xC1, 0xC0, 0x18, 0x06, 0xE0, 0xE0, 0x0C,
  0x07, 0x70, 0x70, 0x0E, 0x03, 0xB0, 0x38, 0x07, 0x01, 0x98, 0x18, 0x07,
  0x00, 0xCC, 0x0C, 0x03, 0x80, 0xE6, 0x06, 0x03, 0xC0, 0x63, 0x03, 0x83,
  0xE0, 0x71, 0x81, 0xC3, 0xB8, 0x70, 0xE0, 0xFF, 0x9E, 0xF0, 0x70, 0x3F,
  0x87, 0xF0, 0x38, 0x0F, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x10, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xE0,
  0x01, 0xC0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0xFF, 0xF8, 0xE0, 0x03, 0xFF,
  0xF3, 0xC0, 0x07, 0xFF, 0xE7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x03, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00,
  0x07, 0x1F, 0x00, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x00, 0x3D, 0xFE, 0x00,
  0x00, 0x07, 0xF9, 0xE0, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x1F, 0x83,
  0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0xEE, 0x00, 0x0E, 0xE0, 0x3B, 0x80, 0x07, 0xF8,
  0x0E, 0xE0, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0xEE, 0x00, 0x39,
  0xC0, 0x7B, 0xC0, 0x1E, 0x70, 0x1C, 0x70, 0x07, 0x3C, 0x07, 0x1C, 0x03,
  0xCF, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0x70,
  0x3C, 0x38, 0x0F, 0x1E, 0x0E, 0x0E, 0x03, 0x83, 0x87, 0x87, 0x80, 0xE0,
  0xE1, 0xC1, 0xE0, 0x38, 0x38, 0xF0, 0x70, 0x0E, 0x0E, 0x38, 0x1C, 0x07,
  0x83, 0x9E, 0x07, 0x01, 0xE0, 0x77, 0x03, 0xC0, 0x78, 0x1F, 0xC0, 0xF0,
  0x1C, 0x07, 0xE0, 0x38, 0x07, 0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x7C, 0x03,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xC0,
  0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x7E, 0x00,
  0x00, 0xF0, 0x3F, 0x00, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x38, 0x0F, 0xE0,
  0x00, 0x1C, 0x07, 0x70, 0x00, 0x1E, 0x03, 0xBC, 0x00, 0x0F, 0x03, 0xCE,
  0x00, 0x07, 0x81, 0xE7, 0x00, 0x03, 0x80, 0xF3, 0xC0, 0x01, 0xC0, 0x70,
  0xE0, 0x00, 0xE0, 0x38, 0x70, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0x1E,
  0x0E, 0x00, 0x3C, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0x0E, 0x03,
  0x80, 0xE0, 0x07, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x03, 0xC0,
  0xF0, 0x0E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x38, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0xE0, 0x78, 0x0E, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x1C, 0x1E,
  0x07, 0x80, 0x0E, 0x0F, 0x03, 0xC0, 0x07, 0x87, 0x01, 0xC0, 0x01, 0xC3,
  0x80, 0xE0, 0x00, 0xE3, 0xC0, 0x70, 0x00, 0x79, 0xE0, 0x78, 0x00, 0x1C,
  0xF0, 0x3C, 0x00, 0x0F, 0x70, 0x1E, 0x00, 0x07, 0xB8, 0x0E, 0x00, 0x01,
  0xDC, 0x07, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x7F, 0x03, 0xC0, 0x00,
  0x1F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xFC,
  0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0E, 0xF0, 0x07, 0xC0, 0x0E, 0xF0,
  0x07, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x1C, 0xF0, 0x0F, 0xC0, 0x1C, 0xF0,
  0x0F, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x38, 0xE0,
  0x1D, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x78, 0xE0, 0x39, 0xC0, 0x70, 0xE0,
  0x39, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0xF0, 0xE0, 0x71, 0xC0, 0xE0, 0xE0,
  0x71, 0xC0, 0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0xE0, 0xE1, 0xC1, 0xE0, 0xE0,
  0xE1, 0xC1, 0xC0, 0xE0, 0xE1, 0xC1, 0xC0, 0xE1, 0xC1, 0xC3, 0xC0, 0xE1,
  0xC1, 0xC3, 0x80, 0xE1, 0xC1, 0xC3, 0x80, 0xE3, 0x81, 0xC3, 0x80, 0xE3,
  0x80, 0xC7, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0xE7,
  0x00, 0xEF, 0x00, 0xE7, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xEE,
  0x00, 0xEE, 0x00, 0xEE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70,
  0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x1E,
  0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x1C, 0x0F,
  0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x8F, 0x00, 0x0E, 0x38, 0x00,
  0x39, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xC1, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x1C, 0x1F, 0x80, 0x01, 0xC3, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x8F,
  0x00, 0x03, 0xF8, 0x78, 0x00, 0x7F, 0x87, 0xC0, 0x1F, 0x78, 0x3F, 0xFF,
  0xE7, 0x81, 0xFF, 0xF8, 0x78, 0x07, 0xFE, 0x07, 0x80, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F,
  0x80, 0x07, 0x0F, 0xFE, 0x00, 0x71, 0xFF, 0xF0, 0x07, 0x7F, 0x1F, 0x80,
  0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x38,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x38, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0xE0, 0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x0F, 0x7F, 0xFF, 0x80, 0xE3, 0xFF,
  0xF0, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x3E,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x3E,
  0x01, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x1F,
  0xFC, 0x3C, 0x00, 0x7F, 0xFE, 0x78, 0x01, 0xFC, 0x7E, 0xF0, 0x07, 0xC0,
  0x1D, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x70, 0x00, 0xFF, 0xF8, 0xE0, 0x00, 0x7F,
  0xC3, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x70, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x03,
  0xFF, 0xF1, 0xC0, 0x1F, 0xC3, 0xEF, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xF0,
  0x0F, 0x00, 0x1F, 0xC0, 0x3E, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xB8, 0x00,
  0xFF, 0xF8, 0xE0, 0x00, 0xFF, 0x87, 0x80, 0x00, 0x60, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x02, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x0E,
  0x0F, 0xFE, 0x00, 0x70, 0xFF, 0xF8, 0x03, 0x9F, 0x87, 0xE0, 0x3D, 0xE0,
  0x0F, 0x81, 0xFE, 0x00, 0x3C, 0x0E, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0xF8, 0x01, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0E, 0x0F, 0x80, 0x00,
  0x38, 0x7C, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x07, 0xE3,
  0xC0, 0x00, 0x3F, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x73, 0xFE, 0x1F, 0xF0, 0x0E, 0xFF,
  0xE7, 0xFF, 0x01, 0xFE, 0x7D, 0xF1, 0xE0, 0x7E, 0x07, 0xF0, 0x1E, 0x0F,
  0x80, 0x7C, 0x01, 0xC1, 0xE0, 0x0F, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x07,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0xE0,
  0x07, 0x87, 0x80, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0xF0, 0x03, 0x83, 0x80, 0x1E, 0x00, 0x70, 0x70, 0x03, 0x80, 0x0E, 0x1E,
  0x00, 0x70, 0x03, 0xC3, 0x80, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC0, 0x0E,
  0x0E, 0x00, 0x78, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x38, 0x78, 0x01, 0xC0,
  0x07, 0x0F, 0x00, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0x00, 0x3C, 0x38, 0x01,
  0xE0, 0x07, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x1C, 0x3C,
  0x00, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0xF0, 0x03, 0x83, 0x80, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0xE1, 0xFF,
  0xF0, 0x07, 0x3F, 0x0F, 0xC0, 0x7B, 0xC0, 0x1F, 0x03, 0xB8, 0x00, 0x78,
  0x1D, 0x80, 0x01, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC3,
  0xFF, 0x80, 0x03, 0x9F, 0xFF, 0x80, 0x07, 0x7E, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xFC,
  0x03, 0xF0, 0x07, 0xBF, 0xBF, 0xC0, 0x0E, 0x3F, 0xFF, 0x00, 0x1C, 0x1F,
  0xF8, 0x00, 0x38, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0x00, 0xFF, 0xFC, 0x70,
  0x1F, 0xC7, 0xEF, 0x03, 0xE0, 0x0F, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xF0, 0x3C, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0xEF,
  0xEE, 0x00, 0xFF, 0xF8, 0xE0, 0x03, 0xFE, 0x1E, 0x00, 0x06, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xA0, 0x70, 0x3F, 0xF8, 0x0E, 0x1F,
  0xFF, 0x03, 0xC7, 0xFF, 0xE0, 0x7B, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xE0, 0x07,
  0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0xE0, 0x7C,
  0x03, 0xDE, 0x03, 0xFF, 0xF9, 0xC0, 0x1F, 0xFF, 0x1C, 0x00, 0xFF, 0xC1,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x01, 0xE0,
  0x03, 0xBC, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0x78, 0x01, 0xCF, 0x00, 0x7C,
  0x00, 0xE3, 0x80, 0x36, 0x00, 0xE1, 0xC0, 0x3B, 0x00, 0x70, 0xE0, 0x1D,
  0x80, 0x78, 0x70, 0x0C, 0xC0, 0x38, 0x38, 0x0E, 0x60, 0x1C, 0x1C, 0x07,
  0x30, 0x1C, 0x0E, 0x07, 0x18, 0x0E, 0x07, 0x03, 0x8E, 0x07, 0x03, 0x83,
  0x87, 0x07, 0x01, 0xC1, 0xC3, 0x83, 0x80, 0xE0, 0xE1, 0xC1, 0xC0, 0x70,
  0xE0, 0xE1, 0xC0, 0x38, 0x70, 0x70, 0xE0, 0x1C, 0x70, 0x38, 0xE0, 0x0E,
  0x38, 0x1C, 0x70, 0x07, 0x18, 0x0E, 0x38, 0x03, 0x9C, 0x07, 0x38, 0x01,
  0xCE, 0x01, 0x9C, 0x00, 0xEE, 0x00, 0xCC, 0x00, 0x77, 0x00, 0x6E, 0x00,
  0x3B, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x1B, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xE3, 0xFF, 0xF0, 0x00, 0x73, 0xE0, 0xFC, 0x00, 0x39,
  0xC0, 0x1F, 0x00, 0x39, 0xC0, 0x07, 0xC0, 0x3C, 0xE0, 0x01, 0xF0, 0x3C,
  0xE0, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00,
};

const GFXglyph RobotoMono_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 11, 43, 36, 12, -43 },
  { 61, 14, 14, 36, 14, -46 },
  { 86, 35, 43, 36, 1, -43 },
  { 275, 29, 56, 36, 4, -50 },
  { 478, 29, 45, 36, 4, -44 },
  { 642, 31, 45, 36, 2, -44 },
  { 817, 6, 14, 36, 17, -46 },
  { 828, 19, 63, 36, 10, -49 },
  { 978, 19, 63, 36, 5, -49 },
  { 1128, 27, 26, 36, 7, -43 },
  { 1216, 29, 32, 36, 4, -36 },
  { 1332, 8, 15, 36, 7, -6 },
  { 1347, 22, 3, 36, 7, -21 },
  { 1356, 6, 6, 36, 13, -6 },
  { 1361, 29, 47, 36, 4, -43 },
  { 1532, 29, 45, 36, 4, -44 },
  { 1696, 17, 43, 36, 9, -43 },
  { 1788, 30, 44, 36, 1, -44 },
  { 1953, 30, 45, 36, 1, -44 },
  { 2122, 31, 43, 36, 1, -43 },
  { 2289, 30, 44, 36, 5, -43 },
  { 2454, 26, 45, 36, 4, -44 },
  { 2601, 28, 43, 36, 7, -43 },
  { 2752, 30, 45, 36, 4, -44 },
  { 2921, 26, 44, 36, 6, -44 },
  { 3064, 10, 32, 36, 15, -32 },
  { 3104, 14, 41, 36, 11, -32 },
  { 3176, 27, 25, 36, 5, -32 },
  { 3261, 28, 15, 36, 4, -27 },
  { 3314, 28, 25, 36, 3, -32 },
  { 3402, 24, 44, 36, 9, -44 },
  { 3534, 33, 44, 36, 2, -44 },
  { 3716, 30, 43, 36, 0, -43 },
  { 3878, 31, 43, 36, 2, -43 },
  { 4045, 31, 45, 36, 3, -44 },
  { 4220, 32, 43, 36, 2, -43 },
  { 4392, 32, 43, 36, 3, -43 },
  { 4564, 32, 43, 36, 3, -43 },
  { 4736, 31, 45, 36, 3, -44 },
  { 4911, 33, 43, 36, 2, -43 },
  { 5089, 32, 43, 36, 2, -43 },
  { 5261, 32, 44, 36, 2, -43 },
  { 5437, 35, 43, 36, 3, -43 },
  { 5626, 26, 43, 36, 3, -43 },
  { 5766, 34, 43, 36, 2, -43 },
  { 5949, 33, 43, 36, 2, -43 },
  { 6127, 30, 45, 36, 3, -44 },
  { 6296, 32, 43, 36, 3, -43 },
  { 6468, 31, 52, 36, 3, -44 },
  { 6670, 31, 43, 36, 3, -43 },
  { 6837, 31, 45, 36, 3, -44 },
  { 7012, 30, 43, 36, 7, -43 },
  { 7174, 31, 44, 36, 4, -43 },
  { 7345, 30, 43, 36, 7, -43 },
  { 7507, 32, 43, 36, 6, -43 },
  { 7679, 37, 43, 36, 0, -43 },
  { 7878, 30, 43, 36, 7, -43 },
  { 8040, 33, 43, 36, 1, -43 },
  { 8218, 19, 59, 36, 9, -50 },
  { 8359, 12, 47, 36, 12, -43 },
  { 8430, 19, 59, 36, 8, -50 },
  { 8571, 22, 23, 36, 7, -43 },
  { 8635, 26, 3, 36, 1, 0 },
  { 8645, 8, 8, 36, 17, -45 },
  { 8653, 28, 34, 36, 3, -33 },
  { 8772, 28, 47, 36, 3, -46 },
  { 8937, 27, 34, 36, 4, -33 },
  { 9052, 31, 47, 36, 4, -46 },
  { 9235, 28, 34, 36, 4, -33 },
  { 9354, 30, 47, 36, 7, -47 },
  { 9531, 30, 46, 36, 2, -33 },
  { 9704, 29, 46, 36, 2, -46 },
  { 9871, 26, 44, 36, 3, -44 },
  { 10014, 28, 57, 36, 0, -44 },
  { 10214, 30, 46, 36, 3, -46 },
  { 10387, 26, 46, 36, 3, -46 },
  { 10537, 35, 33, 36, -1, -33 },
  { 10682, 29, 33, 36, 2, -33 },
  { 10802, 29, 34, 36, 3, -33 },
  { 10926, 31, 45, 36, 0, -33 },
  { 11101, 28, 45, 36, 4, -33 },
  { 11259, 27, 33, 36, 7, -33 },
  { 11371, 28, 34, 36, 4, -33 },
  { 11490, 24, 41, 36, 7, -40 },
  { 11613, 28, 33, 36, 5, -32 },
  { 11729, 30, 32, 36, 5, -32 },
  { 11849, 33, 32, 36, 4, -32 },
  { 11981, 33, 32, 36, 1, -32 },
  { 12113, 37, 45, 36, -1, -32 },
  { 12322, 31, 32, 36, 2, -32 },
  { 12446, 24, 60, 36, 9, -48 },
  { 12626, 11, 53, 36, 12, -43 },
  { 12699, 24, 60, 36, 5, -48 },
  { 12879, 33, 11, 36, 1, -24 },
};

const GFXfont RobotoMono_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic61pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_LIGHTITALIC61PT7B_H_
