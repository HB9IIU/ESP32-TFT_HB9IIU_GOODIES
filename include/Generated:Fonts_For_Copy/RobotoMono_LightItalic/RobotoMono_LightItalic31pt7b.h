#ifndef _ROBOTOMONO_LIGHTITALIC31PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC2,
  0x10, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x62, 0x8D, 0x1A, 0x2C, 0x58, 0xA1,
  0x00, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x10, 0x03, 0x04, 0x00, 0xC3,
  0x00, 0x20, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0x04, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x08, 0x20, 0x06, 0x18, 0x01, 0x06, 0x07, 0xFF, 0xF3, 0xFF,
  0xFC, 0x08, 0x20, 0x02, 0x08, 0x01, 0x86, 0x00, 0x41, 0x00, 0x30, 0x40,
  0x0C, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x1F, 0xC0, 0x73,
  0xC1, 0x81, 0x86, 0x01, 0x8C, 0x03, 0x10, 0x06, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x26, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x18, 0x0C, 0x1C, 0x70,
  0x1F, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x3E, 0x00, 0xC4, 0x01,
  0x0C, 0x26, 0x18, 0x6C, 0x31, 0x90, 0x46, 0x20, 0x88, 0x63, 0x30, 0x7C,
  0xC0, 0x21, 0x00, 0x06, 0x00, 0x18, 0x00, 0x23, 0x00, 0x8F, 0x83, 0x31,
  0x0C, 0xC3, 0x11, 0x86, 0x63, 0x0D, 0x84, 0x11, 0x0C, 0x20, 0x18, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x07, 0x18, 0x06, 0x18, 0x0C, 0x08, 0x0C, 0x18,
  0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0D, 0x00, 0x39, 0x83, 0x30, 0xC3, 0x60, 0xC6, 0x60, 0x66, 0xC0, 0x3C,
  0xC0, 0x3C, 0xC0, 0x18, 0x60, 0x38, 0x38, 0xEC, 0x1F, 0x86, 0x5F, 0xE8,
  0x00, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x01, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x0C, 0x31,
  0xF9, 0x3C, 0xFF, 0x80, 0xC0, 0x0F, 0x00, 0xCC, 0x0C, 0x60, 0xC1, 0x86,
  0x0E, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x18, 0xCC, 0x63, 0x33,
  0x00, 0x7F, 0xFF, 0xFE, 0xDF, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x03, 0xF0, 0x1C, 0x70, 0x70, 0x30, 0xC0, 0x23, 0x00,
  0x46, 0x00, 0xC8, 0x03, 0xB0, 0x0F, 0x60, 0x76, 0xC1, 0x89, 0x86, 0x32,
  0x18, 0x6C, 0xE0, 0xDB, 0x01, 0xBC, 0x03, 0x70, 0x0C, 0xC0, 0x19, 0x80,
  0x21, 0x00, 0xC3, 0x03, 0x03, 0x9C, 0x03, 0xF0, 0x00, 0x03, 0x0F, 0x7F,
  0xE2, 0x82, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x03, 0xF8, 0x07, 0x1C, 0x0C,
  0x06, 0x18, 0x06, 0x18, 0x02, 0x10, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0x03, 0xF0, 0x1C, 0x38, 0x70, 0x30, 0xC0, 0x33, 0x00,
  0x66, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x1F, 0x80,
  0x3F, 0x80, 0x03, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0xC0, 0x19, 0x80,
  0x33, 0x00, 0xE3, 0x01, 0x87, 0x8E, 0x03, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x00, 0x66, 0x01, 0x8C,
  0x06, 0x18, 0x08, 0x30, 0x30, 0x40, 0xC0, 0x83, 0x03, 0x0C, 0x06, 0x30,
  0x0C, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x17, 0xE0, 0x1F, 0xF0, 0x38,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0,
  0x18, 0x40, 0x18, 0x60, 0x38, 0x60, 0x30, 0x38, 0xE0, 0x1F, 0x80, 0x00,
  0xF8, 0x1F, 0x81, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x6F, 0xE3, 0xE3, 0x9C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xB0, 0x0C, 0xC0, 0xC3, 0x9C, 0x0F, 0xC0, 0x7F,
  0xFE, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x0E, 0x38, 0x30, 0x30, 0xC0,
  0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x88, 0x06, 0x18, 0x0C, 0x18, 0x70,
  0x1F, 0x80, 0xF7, 0x83, 0x01, 0x8C, 0x03, 0x10, 0x03, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x33, 0x00, 0x63, 0x01, 0x87, 0x8E, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0xE3, 0x8C, 0x0C, 0xC0, 0x36, 0x01, 0xA0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x77, 0x0D, 0x1F, 0xC8, 0x38, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x07, 0xE0, 0x3C, 0x00, 0x18,
  0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x18, 0x0C,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C,
  0x10, 0x60, 0xC3, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0C, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x30, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0x30, 0x00, 0x80, 0x00, 0x1F, 0x83, 0x9C, 0x60, 0x6C, 0x06, 0xC0, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xFC, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x86, 0x19,
  0x8F, 0xC4, 0x8C, 0x22, 0xC4, 0x21, 0x46, 0x10, 0xA2, 0x08, 0xF1, 0x0C,
  0x71, 0x84, 0x28, 0x82, 0x14, 0x43, 0x0A, 0x21, 0x89, 0x19, 0x4C, 0x8F,
  0x3C, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x86, 0x00, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x62, 0x00, 0xC4, 0x03, 0x08, 0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0x40,
  0xC1, 0x81, 0x83, 0xFF, 0x0F, 0xFE, 0x10, 0x06, 0x60, 0x0C, 0x80, 0x1B,
  0x00, 0x34, 0x00, 0x78, 0x00, 0x40, 0x0F, 0xF8, 0x0F, 0xFC, 0x08, 0x06,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x10, 0x0E,
  0x30, 0x38, 0x3F, 0xE0, 0x30, 0x38, 0x30, 0x0C, 0x30, 0x06, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x38, 0x7F, 0xF0,
  0xFF, 0xC0, 0x03, 0xF0, 0x1C, 0x78, 0x70, 0x30, 0xC0, 0x33, 0x00, 0x64,
  0x00, 0xD8, 0x01, 0xB0, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x33,
  0x00, 0xC3, 0x03, 0x83, 0x9E, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x18, 0x0C, 0x18, 0x06, 0x18, 0x02, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x02,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x40, 0x38, 0xC0, 0x70,
  0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0F, 0xFF, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x1E, 0x78, 0x70, 0x30, 0xC0, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x1F, 0xD0,
  0x01, 0xA0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x63, 0x01,
  0xC3, 0x8F, 0x03, 0xF8, 0x00, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x21, 0x00, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02,
  0x18, 0x01, 0x0F, 0xFF, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x10, 0xC0, 0x08, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0x86, 0x00, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x30, 0x60, 0x70, 0x39, 0xE0, 0x1F, 0x80, 0x0C, 0x01, 0xC3, 0x00,
  0xE0, 0xC0, 0x70, 0x20, 0x38, 0x18, 0x1C, 0x06, 0x0E, 0x01, 0x87, 0x00,
  0x63, 0x80, 0x11, 0xC0, 0x04, 0xE0, 0x03, 0x78, 0x00, 0xF6, 0x00, 0x38,
  0xC0, 0x0C, 0x30, 0x02, 0x06, 0x01, 0x81, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x40, 0x0C, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x0C, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xD0, 0xB0, 0x68, 0x58,
  0x6C, 0x64, 0x26, 0x32, 0x33, 0x19, 0x91, 0x8C, 0xD8, 0x84, 0x68, 0xC2,
  0x1C, 0x63, 0x0C, 0x31, 0x86, 0x18, 0xC0, 0x08, 0x60, 0x04, 0x20, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x40, 0x0C, 0x01, 0x8E,
  0x00, 0xC7, 0x00, 0x63, 0xC0, 0x21, 0xE0, 0x30, 0x90, 0x18, 0xCC, 0x0C,
  0x66, 0x06, 0x31, 0x02, 0x18, 0xC1, 0x0C, 0x61, 0x84, 0x10, 0xC6, 0x0C,
  0x63, 0x06, 0x31, 0x81, 0x90, 0xC0, 0xD8, 0x60, 0x6C, 0x20, 0x1E, 0x30,
  0x0F, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC0, 0x03, 0xF0, 0x1E, 0x70,
  0x70, 0x30, 0xC0, 0x63, 0x00, 0x64, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x40,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x2C, 0x00, 0x58, 0x01, 0xA0, 0x03,
  0x60, 0x04, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC3, 0x03, 0x03, 0x9C, 0x03,
  0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x18, 0x06, 0x18, 0x02, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x0E, 0x20, 0x1C,
  0x7F, 0xF8, 0x7F, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03, 0xF0,
  0x1E, 0x70, 0x70, 0x31, 0xC0, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xA0, 0x03, 0x40, 0x06, 0x80, 0x09, 0x80, 0x33, 0x00, 0xC3, 0x03, 0x03,
  0x9C, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0C, 0x06, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x06, 0x10, 0x06, 0x30, 0x1C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x30, 0x60, 0x20, 0x30, 0x20, 0x30, 0x60, 0x30, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x40, 0x0C, 0xC0, 0x0C, 0x01, 0xF8, 0x07, 0x9E, 0x0C,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x40, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x1C, 0x3C,
  0x78, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x30, 0x60, 0x60, 0x71, 0xC0, 0x1F, 0x80, 0xC0, 0x07, 0x40, 0x06, 0x60,
  0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x30, 0x20,
  0x30, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x80, 0x11,
  0x80, 0x11, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0xC1, 0x81, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x82, 0xC3,
  0x86, 0xC2, 0x86, 0xC6, 0x84, 0xC6, 0x8C, 0xC4, 0x8C, 0xCC, 0x8C, 0xCC,
  0x88, 0xC8, 0x98, 0xD8, 0x98, 0xD8, 0x90, 0xD0, 0xB0, 0xF0, 0xF0, 0xE0,
  0xA0, 0xE0, 0xA0, 0xE0, 0xE0, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0C,
  0x00, 0xE0, 0x80, 0x38, 0x18, 0x06, 0x03, 0x01, 0x80, 0x30, 0x60, 0x06,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x00, 0xB0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x30,
  0xC0, 0x0C, 0x18, 0x03, 0x81, 0x80, 0x60, 0x30, 0x18, 0x06, 0x06, 0x00,
  0x61, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x0C, 0x20, 0x18,
  0x30, 0x18, 0x30, 0x30, 0x10, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x18, 0x80,
  0x0D, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x07,
  0xC1, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7C, 0x3F,
  0x00, 0xC3, 0x04, 0x10, 0x61, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x10, 0x41,
  0x86, 0x18, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x07, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xF8, 0x3E, 0x00, 0x03, 0x00, 0x60,
  0x1C, 0x02, 0xC0, 0xD8, 0x31, 0x06, 0x21, 0x86, 0x20, 0xCC, 0x19, 0x01,
  0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xC4, 0x63, 0x01, 0x80, 0x3F, 0xC1,
  0x83, 0x8C, 0x06, 0x60, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x7E, 0x1F, 0xF9,
  0xC0, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x12, 0x00, 0xCC, 0x0F, 0x38, 0xEC,
  0x7F, 0x30, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x38, 0x0D, 0xFC, 0x1E, 0x1C, 0x30, 0x18, 0x60, 0x11, 0x80,
  0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x90, 0x02, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0xC7, 0x03, 0x0B, 0x1E, 0x33, 0xF0, 0x00, 0x01, 0x80,
  0x3F, 0xC1, 0xC1, 0x8C, 0x02, 0x30, 0x0D, 0x80, 0x36, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x19, 0x00, 0xC6, 0x07,
  0x0C, 0x38, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x03, 0x84, 0x0F, 0xEC, 0x1C, 0x3C, 0x30, 0x1C,
  0x30, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x60, 0x70, 0x79, 0xF0,
  0x3F, 0x30, 0x01, 0xC0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x0D, 0x80,
  0x34, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x03, 0x0E, 0x38, 0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xFC,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF,
  0xF0, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0F, 0xE4, 0x38, 0x78, 0xC0,
  0x71, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x0C, 0x0E, 0x1E, 0x7C, 0x1F,
  0x98, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x8C, 0x06, 0x0C, 0x38, 0x0F, 0xE0,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x1C, 0x0D, 0xFC, 0x16, 0x0C, 0x38, 0x08, 0xE0, 0x19, 0x80,
  0x33, 0x00, 0x66, 0x00, 0x8C, 0x01, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0x46, 0x00, 0x88, 0x03, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x3F, 0x80, 0x78,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x98, 0x0E, 0x30, 0x38, 0x60, 0xC0, 0xC3, 0x01, 0x1C, 0x06,
  0x70, 0x0D, 0xC0, 0x1F, 0x80, 0x39, 0x80, 0x63, 0x00, 0x83, 0x03, 0x03,
  0x06, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x20, 0x0E, 0x00, 0x0F, 0xE0, 0x83,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0x86, 0x1B, 0xEF, 0xCE, 0x3C, 0x66, 0x0C, 0x13, 0x04, 0x09, 0x02, 0x0C,
  0x83, 0x06, 0xC1, 0x83, 0x60, 0xC1, 0xB0, 0x60, 0x98, 0x20, 0x48, 0x10,
  0x64, 0x18, 0x36, 0x0C, 0x1B, 0x06, 0x0D, 0x83, 0x04, 0xC1, 0x02, 0x00,
  0x00, 0x70, 0x37, 0xF0, 0x58, 0x30, 0xE0, 0x23, 0x80, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x02, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x18, 0x03, 0x80, 0x3F, 0xC1,
  0xC3, 0x8C, 0x06, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xC6, 0x07, 0x1C, 0x78,
  0x1F, 0x80, 0x00, 0x70, 0x0D, 0xFC, 0x0B, 0x0E, 0x0C, 0x06, 0x1C, 0x06,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x38, 0x18, 0x2C, 0x70, 0x67, 0xE0,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x3F, 0x91, 0xC3, 0xCC, 0x07, 0x30, 0x0D, 0x80, 0x36, 0x00,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x13, 0x00,
  0xC6, 0x07, 0x1C, 0x7C, 0x3F, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x00, 0x71, 0x9F, 0xCD, 0xC0, 0x78, 0x03,
  0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x3F,
  0xC1, 0x81, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x00, 0x06, 0xC0, 0x1B, 0x00, 0x6E, 0x03, 0x1C,
  0x3C, 0x1F, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x3F,
  0xFE, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x40,
  0x7E, 0x00, 0x30, 0x06, 0x60, 0x18, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x02, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00,
  0x8C, 0x03, 0x0C, 0x0E, 0x1C, 0x7C, 0x1F, 0x98, 0xC0, 0x0F, 0x80, 0x1B,
  0x00, 0x62, 0x00, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x60, 0x30,
  0xC0, 0x63, 0x00, 0xC4, 0x00, 0x98, 0x01, 0xA0, 0x03, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0xC1, 0x81, 0xE0, 0xC1, 0xB0, 0x60, 0xD8, 0x70, 0xCC, 0x28,
  0x66, 0x34, 0x23, 0x12, 0x30, 0x99, 0x98, 0x4C, 0xC8, 0x24, 0x6C, 0x16,
  0x34, 0x0A, 0x1A, 0x07, 0x07, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x80,
  0x1C, 0x03, 0x86, 0x03, 0x81, 0x81, 0x80, 0x61, 0x80, 0x31, 0x80, 0x0D,
  0x80, 0x07, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xCC, 0x00,
  0xC6, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x31, 0xC0, 0x0C, 0x38, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x10, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x09,
  0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x30, 0x82, 0x08, 0x61,
  0x86, 0x10, 0x41, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x61, 0x04,
  0x10, 0xC3, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0xF0, 0x0F, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x3C, 0x00, 0x7F, 0x01, 0xC3, 0x83, 0xC0, 0xC6, 0x80, 0x7E, 0x00,
  0x10,
};

const GFXglyph RobotoMono_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 7, 7, 18, 7, -23 },
  { 25, 18, 22, 18, 0, -22 },
  { 75, 15, 28, 18, 2, -25 },
  { 128, 15, 22, 18, 2, -22 },
  { 170, 16, 22, 18, 1, -22 },
  { 214, 2, 7, 18, 9, -23 },
  { 216, 10, 32, 18, 5, -25 },
  { 256, 9, 32, 18, 3, -25 },
  { 292, 13, 13, 18, 4, -22 },
  { 314, 15, 16, 18, 2, -18 },
  { 344, 5, 7, 18, 3, -3 },
  { 349, 12, 2, 18, 3, -11 },
  { 352, 3, 3, 18, 7, -3 },
  { 354, 15, 24, 18, 2, -22 },
  { 399, 15, 22, 18, 2, -22 },
  { 441, 8, 22, 18, 5, -22 },
  { 463, 16, 22, 18, 0, -22 },
  { 507, 15, 22, 18, 1, -22 },
  { 549, 15, 22, 18, 1, -22 },
  { 591, 16, 22, 18, 2, -22 },
  { 635, 13, 22, 18, 2, -22 },
  { 671, 15, 22, 18, 3, -22 },
  { 713, 15, 22, 18, 2, -22 },
  { 755, 13, 22, 18, 3, -22 },
  { 791, 6, 16, 18, 7, -16 },
  { 803, 7, 20, 18, 6, -16 },
  { 821, 14, 12, 18, 2, -16 },
  { 842, 15, 8, 18, 2, -14 },
  { 857, 14, 13, 18, 2, -16 },
  { 880, 12, 22, 18, 5, -22 },
  { 913, 17, 22, 18, 1, -22 },
  { 960, 15, 22, 18, 0, -22 },
  { 1002, 16, 22, 18, 1, -22 },
  { 1046, 15, 22, 18, 2, -22 },
  { 1088, 16, 22, 18, 1, -22 },
  { 1132, 17, 22, 18, 1, -22 },
  { 1179, 16, 22, 18, 2, -22 },
  { 1223, 15, 22, 18, 2, -22 },
  { 1265, 17, 22, 18, 1, -22 },
  { 1312, 16, 22, 18, 1, -22 },
  { 1356, 16, 22, 18, 1, -22 },
  { 1400, 18, 22, 18, 1, -22 },
  { 1450, 13, 22, 18, 2, -22 },
  { 1486, 17, 22, 18, 1, -22 },
  { 1533, 17, 22, 18, 1, -22 },
  { 1580, 15, 22, 18, 2, -22 },
  { 1622, 16, 22, 18, 2, -22 },
  { 1666, 15, 26, 18, 2, -22 },
  { 1715, 16, 22, 18, 1, -22 },
  { 1759, 16, 22, 18, 1, -22 },
  { 1803, 16, 22, 18, 3, -22 },
  { 1847, 16, 22, 18, 2, -22 },
  { 1891, 16, 22, 18, 3, -22 },
  { 1935, 16, 22, 18, 3, -22 },
  { 1979, 19, 22, 18, 0, -22 },
  { 2032, 16, 22, 18, 3, -22 },
  { 2076, 17, 22, 18, 0, -22 },
  { 2123, 10, 30, 18, 4, -25 },
  { 2161, 6, 24, 18, 6, -22 },
  { 2179, 10, 30, 18, 4, -25 },
  { 2217, 11, 12, 18, 4, -22 },
  { 2234, 13, 2, 18, 1, 0 },
  { 2238, 4, 4, 18, 9, -23 },
  { 2240, 14, 17, 18, 2, -17 },
  { 2270, 15, 23, 18, 1, -23 },
  { 2314, 14, 17, 18, 2, -17 },
  { 2344, 16, 23, 18, 2, -23 },
  { 2390, 14, 17, 18, 2, -17 },
  { 2420, 15, 24, 18, 4, -24 },
  { 2465, 15, 24, 18, 1, -17 },
  { 2510, 15, 23, 18, 1, -23 },
  { 2554, 13, 22, 18, 2, -22 },
  { 2590, 14, 29, 18, 0, -22 },
  { 2641, 15, 23, 18, 2, -23 },
  { 2685, 13, 23, 18, 2, -23 },
  { 2723, 17, 17, 18, 0, -17 },
  { 2760, 15, 17, 18, 1, -17 },
  { 2792, 14, 17, 18, 2, -17 },
  { 2822, 16, 23, 18, 0, -17 },
  { 2868, 14, 23, 18, 2, -17 },
  { 2909, 13, 17, 18, 4, -17 },
  { 2937, 14, 17, 18, 2, -17 },
  { 2967, 13, 21, 18, 3, -21 },
  { 3002, 15, 16, 18, 2, -16 },
  { 3032, 15, 16, 18, 3, -16 },
  { 3062, 17, 16, 18, 2, -16 },
  { 3096, 17, 16, 18, 0, -16 },
  { 3130, 18, 23, 18, 0, -16 },
  { 3182, 16, 16, 18, 1, -16 },
  { 3214, 12, 30, 18, 5, -24 },
  { 3259, 6, 27, 18, 6, -22 },
  { 3280, 12, 30, 18, 3, -24 },
  { 3325, 16, 6, 18, 1, -12 },
};

const GFXfont RobotoMono_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_LIGHTITALIC31PT7B_H_
