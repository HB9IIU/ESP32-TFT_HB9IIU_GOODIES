#ifndef _ROBOTOMONO_LIGHTITALIC7PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0x80, 0x37, 0x6F, 0xA0, 0x25, 0x42, 0x1A, 0x40, 0xDE,
  0x25, 0x30, 0x66, 0x4B, 0xF0, 0x80, 0x5A, 0xA9, 0x95, 0x5A, 0x5F, 0x00,
  0x2F, 0x44, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0xC0, 0x79, 0xBD, 0xE0, 0xD5,
  0x80, 0x71, 0x24, 0xE0, 0x71, 0x61, 0xE0, 0x22, 0x6F, 0x20, 0xF3, 0x9C,
  0x2A, 0xDE, 0xE5, 0x48, 0x75, 0x69, 0xE0, 0xF6, 0xBC, 0x90, 0x42, 0x80,
  0x71, 0x00, 0x7E, 0x43, 0xC0, 0xE5, 0x48, 0x7F, 0xFB, 0xE0, 0x2D, 0xBA,
  0x75, 0x69, 0xE0, 0x79, 0x89, 0xE0, 0x75, 0x99, 0xE0, 0x74, 0x68, 0xE0,
  0x74, 0x68, 0x80, 0x78, 0xA9, 0xF0, 0x59, 0x79, 0x90, 0x72, 0x24, 0xE0,
  0x11, 0x11, 0xE0, 0x56, 0x4A, 0x90, 0x49, 0x4E, 0x55, 0xBD, 0x90, 0x5D,
  0xBA, 0xA0, 0x79, 0x99, 0xE0, 0x75, 0xF8, 0x80, 0x79, 0x99, 0xE2, 0x75,
  0xEA, 0x90, 0x74, 0x21, 0xE0, 0xE9, 0x48, 0x59, 0x99, 0xE0, 0xB7, 0x68,
  0xFF, 0xEC, 0x56, 0x26, 0x90, 0xB5, 0x48, 0x72, 0x44, 0xE0, 0x5A, 0xA8,
  0xA5, 0x40, 0x55, 0x58, 0x7C, 0xE0, 0x80, 0x61, 0xFE, 0x46, 0x99, 0xE0,
  0x69, 0x8E, 0x17, 0x99, 0xE0, 0x69, 0xEE, 0x7E, 0x48, 0x79, 0x9A, 0xE0,
  0x46, 0x99, 0x90, 0x2C, 0x9E, 0x2C, 0x92, 0xA0, 0x45, 0xEA, 0xA0, 0x64,
  0x9E, 0x5B, 0xDD, 0x69, 0x9A, 0x69, 0x9E, 0x69, 0x9E, 0x80, 0x79, 0x9E,
  0x20, 0xF2, 0x40, 0x65, 0x2E, 0x5E, 0x4C, 0xB6, 0xE0, 0xB7, 0x40, 0xBB,
  0x6A, 0x56, 0x4A, 0x95, 0x64, 0x48, 0x72, 0x4E, 0x69, 0x49, 0x80, 0x56,
  0xA0, 0x55, 0xA0, 0xD2,
};

const GFXglyph RobotoMono_LightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 1, 1, 4, 2, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 1, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 3, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 3, 5, 4, 1, -5 },
  { 57, 1, 4, 4, 2, -4 },
  { 58, 2, 5, 4, 1, -4 },
  { 60, 3, 3, 4, 1, -4 },
  { 62, 4, 2, 4, 0, -3 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 3, 5, 4, 1, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 3, 5, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 3, 5, 4, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 6, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 3, 5, 4, 1, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 3, 5, 4, 1, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 2, 7, 4, 1, -6 },
  { 144, 2, 5, 4, 1, -5 },
  { 146, 2, 7, 4, 1, -6 },
  { 148, 2, 3, 4, 1, -5 },
  { 149, 3, 1, 4, 0, 0 },
  { 150, 1, 1, 4, 2, -5 },
  { 151, 4, 4, 4, 0, -4 },
  { 153, 4, 5, 4, 0, -5 },
  { 156, 4, 4, 4, 0, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 4, 4, 4, 0, -4 },
  { 163, 3, 5, 4, 1, -5 },
  { 165, 4, 5, 4, 0, -4 },
  { 168, 4, 5, 4, 0, -5 },
  { 171, 3, 5, 4, 0, -5 },
  { 173, 3, 7, 4, 0, -5 },
  { 176, 4, 5, 4, 0, -5 },
  { 179, 3, 5, 4, 0, -5 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 4, 4, 4, 0, -4 },
  { 187, 4, 5, 4, 0, -4 },
  { 190, 4, 5, 4, 0, -4 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 3, 5, 4, 1, -5 },
  { 199, 3, 4, 4, 1, -4 },
  { 201, 3, 4, 4, 1, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 3, 6, 4, 1, -5 },
  { 215, 2, 6, 4, 1, -5 },
  { 217, 2, 6, 4, 1, -5 },
  { 219, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_LightItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_LIGHTITALIC7PT7B_H_
