#ifndef _ROBOTOMONO_LIGHTITALIC56PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E,
  0x0F, 0x81, 0xC0, 0x38, 0x39, 0x81, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0x81, 0x8C, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x80, 0xF0, 0x03, 0xE0, 0x0F, 0xC3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x03, 0x1C, 0x03, 0x00, 0xE3, 0x80,
  0x60, 0x38, 0x60, 0x0C, 0x07, 0x0C, 0x01, 0x81, 0xC1, 0x80, 0x70, 0x70,
  0x30, 0x0E, 0x0C, 0x06, 0x01, 0x83, 0x80, 0xE0, 0x70, 0xE0, 0x1C, 0x1C,
  0x38, 0x01, 0xFF, 0x07, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xFC, 0x00, 0x70, 0x7F, 0xC0,
  0x0E, 0x1C, 0x38, 0x03, 0x87, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x1C, 0x38,
  0x06, 0x07, 0x06, 0x00, 0xC1, 0xC0, 0xC0, 0x18, 0x70, 0x38, 0x07, 0x0E,
  0x07, 0x00, 0xE3, 0x80, 0xE0, 0x1C, 0x60, 0x1C, 0x03, 0x04, 0x03, 0x80,
  0xE0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07,
  0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x70, 0xF0, 0x78, 0x07, 0x1E, 0x03, 0x80, 0x73, 0xC0, 0x3C,
  0x07, 0x38, 0x01, 0xC0, 0xE7, 0x80, 0x1E, 0x0E, 0x70, 0x00, 0xF1, 0xE7,
  0x00, 0x07, 0x1C, 0x70, 0x00, 0x7B, 0xCF, 0x00, 0x03, 0xF8, 0x70, 0x00,
  0x1F, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xF0,
  0x3C, 0x01, 0xF7, 0x81, 0xF8, 0x7E, 0x38, 0x0F, 0xFF, 0x83, 0xC0, 0x3F,
  0xF0, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x39, 0x9C, 0xE7, 0x39, 0xCC, 0xE7,
  0x39, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x40, 0x1C, 0x01, 0x70, 0x1C, 0x07, 0xFC, 0x1C, 0x3F, 0xFF,
  0x99, 0xFF, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x87, 0x00, 0x07,
  0x87, 0x80, 0x0F, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x78,
  0x01, 0xE0, 0x10, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE7, 0xE0, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xF3, 0x80, 0x03, 0xDC, 0xE0,
  0x01, 0xE7, 0x78, 0x00, 0xF1, 0xDC, 0x00, 0xF0, 0xF7, 0x00, 0x78, 0x39,
  0xC0, 0x3C, 0x0E, 0x70, 0x1E, 0x03, 0x9C, 0x1E, 0x00, 0xEF, 0x0F, 0x00,
  0x3B, 0x87, 0x80, 0x1E, 0xE3, 0xC0, 0x07, 0x3B, 0xC0, 0x01, 0xCF, 0xE0,
  0x00, 0x73, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0xC3,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFE, 0x3F, 0x8E,
  0x7E, 0x1E, 0x70, 0x1C, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x81, 0x00, 0x00, 0x77, 0xFE,
  0x00, 0x1D, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x7F,
  0x80, 0x38, 0xFF, 0xE0, 0x1D, 0xFF, 0xFC, 0x1D, 0xF0, 0x1E, 0x0F, 0xE0,
  0x07, 0x87, 0xC0, 0x01, 0xC7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x0E,
  0x0E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x01,
  0xE0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xE7,
  0x80, 0x01, 0xF1, 0xC0, 0x03, 0xF0, 0xF0, 0x03, 0xB8, 0x3E, 0x07, 0x9C,
  0x0F, 0xFF, 0x9E, 0x03, 0xFF, 0x8E, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x0F, 0xC3,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xC0, 0x3C, 0x3E, 0x00,
  0x78, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0x70, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x78,
  0x0E, 0x07, 0x01, 0xFE, 0x06, 0x07, 0x03, 0xFF, 0x06, 0x0E, 0x07, 0x03,
  0x06, 0x0E, 0x0E, 0x03, 0x06, 0x1C, 0x1C, 0x06, 0x06, 0x1C, 0x1C, 0x06,
  0x06, 0x18, 0x38, 0x06, 0x06, 0x38, 0x30, 0x0E, 0x06, 0x30, 0x30, 0x0C,
  0x06, 0x30, 0x70, 0x0C, 0x06, 0x70, 0x60, 0x0C, 0x0E, 0x70, 0x60, 0x1C,
  0x0C, 0x60, 0x60, 0x18, 0x0C, 0x60, 0xE0, 0x18, 0x0C, 0x60, 0xE0, 0x18,
  0x1C, 0x60, 0xC0, 0x38, 0x18, 0x60, 0xC0, 0x70, 0x18, 0x60, 0xC0, 0x70,
  0x38, 0x60, 0xE0, 0xF0, 0x30, 0x60, 0xE1, 0xB8, 0x60, 0x60, 0x7F, 0x1D,
  0xE0, 0x60, 0x7E, 0x1F, 0xC0, 0x70, 0x38, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x70, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00,
  0xF8, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0xFE, 0xF0, 0x03, 0xFF, 0xCE, 0x00, 0x3F, 0xFC, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00,
  0x0E, 0x7E, 0x00, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0x00, 0x00,
  0x0F, 0xC7, 0x80, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xDC, 0x00, 0x77, 0x03, 0xB8,
  0x00, 0xEE, 0x07, 0x70, 0x03, 0xB8, 0x0E, 0xE0, 0x0F, 0x70, 0x1D, 0xC0,
  0x1C, 0xE0, 0x39, 0x80, 0x79, 0xC0, 0xE3, 0x80, 0xE3, 0x81, 0xC7, 0x03,
  0xCF, 0x03, 0x8E, 0x07, 0x1C, 0x07, 0x1C, 0x1C, 0x38, 0x0E, 0x18, 0x38,
  0x70, 0x3C, 0x38, 0xE0, 0xE0, 0x70, 0x71, 0xC1, 0xC0, 0xE0, 0xE7, 0x07,
  0x81, 0xC1, 0xCE, 0x0E, 0x03, 0x83, 0xB8, 0x1C, 0x07, 0x03, 0xF0, 0x38,
  0x1E, 0x07, 0xC0, 0x70, 0x38, 0x0F, 0x81, 0xE0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x70, 0x1F, 0x00,
  0x01, 0xE0, 0x7E, 0x00, 0x03, 0xC0, 0xEE, 0x00, 0x07, 0x01, 0xDC, 0x00,
  0x0E, 0x03, 0xB8, 0x00, 0x1C, 0x07, 0x38, 0x00, 0x38, 0x0E, 0x70, 0x00,
  0xF0, 0x3C, 0xE0, 0x01, 0xC0, 0x70, 0xE0, 0x03, 0x80, 0xE1, 0xC0, 0x07,
  0x01, 0xC3, 0xC0, 0x0E, 0x03, 0x83, 0x80, 0x1C, 0x0F, 0x07, 0x00, 0x78,
  0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x07, 0x80, 0x70, 0x3C, 0x0F,
  0x00, 0x70, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x70,
  0x01, 0xC3, 0x80, 0xE0, 0x03, 0x8F, 0x03, 0xC0, 0x07, 0x9E, 0x07, 0x00,
  0x07, 0x38, 0x0E, 0x00, 0x0E, 0x70, 0x1C, 0x00, 0x1E, 0xE0, 0x38, 0x00,
  0x1D, 0xC0, 0x70, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7F, 0x03, 0x80, 0x00,
  0x7C, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x3C,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x01, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x3C, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x81, 0xC0, 0x01,
  0xF0, 0x1C, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x1D,
  0xC0, 0x0E, 0x00, 0x77, 0x00, 0x78, 0x03, 0x9C, 0x01, 0xE0, 0x0E, 0x70,
  0x07, 0x80, 0x39, 0xC0, 0x3E, 0x01, 0xC7, 0x00, 0xF8, 0x07, 0x1C, 0x07,
  0xE0, 0x1C, 0x70, 0x1F, 0x80, 0x71, 0xC0, 0x7E, 0x03, 0x87, 0x03, 0xB8,
  0x0E, 0x1C, 0x0E, 0xE0, 0x38, 0x70, 0x39, 0x81, 0xC1, 0xC1, 0xC6, 0x07,
  0x07, 0x07, 0x18, 0x1C, 0x1C, 0x1C, 0x60, 0xE0, 0x70, 0xE1, 0x83, 0x81,
  0x83, 0x86, 0x0E, 0x06, 0x0E, 0x18, 0x38, 0x18, 0x70, 0x61, 0xC0, 0x61,
  0xC1, 0x87, 0x01, 0x87, 0x06, 0x1C, 0x0E, 0x38, 0x18, 0xE0, 0x38, 0xE0,
  0x63, 0x80, 0xE3, 0x81, 0x8E, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1D,
  0xC0, 0x39, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0,
  0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x70, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x20, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0,
  0x07, 0x38, 0x01, 0xE7, 0x00, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x70, 0x38, 0x1E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0x0E, 0x1F, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x7E, 0x1E, 0x00, 0xF7, 0x07, 0xE3, 0xF3, 0x83, 0xFF, 0xF1, 0xC0, 0x7F,
  0xE0, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x87, 0xF8, 0x01,
  0xC7, 0xFF, 0x00, 0x73, 0xFF, 0xF0, 0x1D, 0xE0, 0x3C, 0x07, 0xE0, 0x07,
  0x81, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0x7C, 0x00, 0x1E, 0x1F, 0x80, 0x0F, 0x07, 0x70, 0x0F, 0x81,
  0xDF, 0x9F, 0xC0, 0x73, 0xFF, 0xE0, 0x3C, 0x3F, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7C,
  0x07, 0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x83, 0xC0,
  0x0F, 0xFE, 0x38, 0x03, 0xFF, 0xF3, 0x80, 0x7C, 0x07, 0xB8, 0x0F, 0x80,
  0x1F, 0x80, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x80, 0x3C, 0x03, 0xF8, 0x03, 0xF1, 0xFB, 0x80, 0x1F, 0xFF,
  0x38, 0x00, 0x7F, 0xC3, 0x80, 0x00, 0x80, 0x40, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x07,
  0xC0, 0x3F, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xE0, 0x10, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x70, 0x03, 0xFF, 0x8E, 0x00,
  0xFF, 0xFC, 0xE0, 0x1F, 0x01, 0xEE, 0x03, 0xE0, 0x07, 0xE0, 0x3C, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0xFE, 0x00, 0xFC, 0x7E, 0xE0, 0x07, 0xFF, 0xCE, 0x00, 0x1F, 0xF1,
  0xE0, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x04, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x3F, 0xC0, 0x0E, 0x1F, 0xFC, 0x01, 0xC7, 0xFF, 0xC0, 0x39, 0xE0,
  0x7C, 0x07, 0x70, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x01, 0xDF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFB, 0xC0, 0x00, 0x3F, 0x1E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x38, 0x07,
  0x80, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x07, 0x1F, 0x81, 0xF8, 0x1C, 0xFF, 0x8F, 0xF8, 0x3B,
  0xFF, 0x3F, 0xF8, 0x7E, 0x0F, 0xE0, 0xF0, 0xF0, 0x0F, 0x80, 0xE1, 0xE0,
  0x1E, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x8E, 0x00, 0x70, 0x07, 0x1C, 0x00,
  0xE0, 0x0E, 0x38, 0x03, 0xC0, 0x1C, 0x70, 0x07, 0x00, 0x38, 0xE0, 0x0E,
  0x00, 0x71, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0x03, 0x8E, 0x00, 0x70,
  0x07, 0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x03, 0x80, 0x1C, 0x70, 0x07, 0x00,
  0x38, 0xE0, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0x03,
  0x8E, 0x00, 0xE0, 0x07, 0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x03, 0x80, 0x1C,
  0xF0, 0x07, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x01, 0xC7,
  0x00, 0x70, 0x03, 0x8E, 0x00, 0xE0, 0x07, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0x07, 0x03, 0xFC, 0x00, 0xE1, 0xFF, 0xC0, 0x1C, 0x7F, 0xFC, 0x03, 0x9E,
  0x07, 0xC0, 0x77, 0x00, 0x3C, 0x0D, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x70,
  0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x0F, 0x03, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC1, 0xFE, 0x00, 0x1C, 0x7F, 0xF0, 0x01, 0xCF, 0xFF, 0x80, 0x1D, 0xE0,
  0x7C, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1F,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xDF, 0x1F,
  0xC0, 0x1C, 0xFF, 0xF8, 0x03, 0xC3, 0xFE, 0x00, 0x3C, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x81, 0xC0, 0x3F, 0xF8, 0xE0, 0x3F, 0xFF, 0x38, 0x1F, 0x00, 0xEE,
  0x0F, 0x80, 0x1F, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x03,
  0xC0, 0x3F, 0x80, 0xFC, 0x3E, 0xE0, 0x1F, 0xFF, 0x38, 0x01, 0xFF, 0x1E,
  0x00, 0x08, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x01, 0xFF, 0x07, 0x0F, 0xFE, 0x0F, 0x1F, 0xFE, 0x0E, 0x7E,
  0x02, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x70,
  0x00, 0x38, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1C, 0x38, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x07, 0xF0, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE3,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x1E, 0x00, 0x37, 0x07, 0x80,
  0x3F, 0x80, 0xFC, 0x7E, 0xE0, 0x1F, 0xFE, 0x38, 0x03, 0xFF, 0x0E, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0xEE, 0x00, 0x70, 0x03, 0xB8, 0x03, 0xC0, 0x1C,
  0xE0, 0x0F, 0x00, 0x73, 0x80, 0x7C, 0x01, 0xCE, 0x01, 0xF0, 0x0E, 0x38,
  0x06, 0xC0, 0x38, 0xE0, 0x3B, 0x00, 0xC3, 0x80, 0xCE, 0x07, 0x0E, 0x07,
  0x38, 0x1C, 0x38, 0x1C, 0xE0, 0xE0, 0xE0, 0x63, 0x83, 0x81, 0x83, 0x8E,
  0x0E, 0x06, 0x0C, 0x38, 0x70, 0x18, 0x70, 0xE1, 0xC0, 0x61, 0xC1, 0x86,
  0x01, 0x8E, 0x06, 0x38, 0x06, 0x38, 0x18, 0xE0, 0x18, 0xC0, 0x63, 0x00,
  0x67, 0x01, 0x9C, 0x01, 0x98, 0x06, 0x60, 0x06, 0xE0, 0x1B, 0x80, 0x1B,
  0x80, 0x6E, 0x00, 0x6C, 0x01, 0xB0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x31, 0xFB, 0xF0,
  0x00, 0xE3, 0x80, 0xF8, 0x01, 0xCE, 0x00, 0xF8, 0x07, 0x1C, 0x00, 0xF8,
  0x1E, 0x70, 0x00, 0xFF, 0xF8, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x80,
};

const GFXglyph RobotoMono_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 10, 40, 33, 11, -40 },
  { 51, 13, 12, 33, 13, -42 },
  { 71, 32, 40, 33, 1, -40 },
  { 231, 27, 52, 33, 4, -46 },
  { 407, 27, 41, 33, 3, -40 },
  { 546, 28, 41, 33, 2, -40 },
  { 690, 5, 12, 33, 16, -42 },
  { 698, 18, 58, 33, 9, -45 },
  { 829, 17, 58, 33, 5, -45 },
  { 953, 24, 24, 33, 7, -40 },
  { 1025, 27, 29, 33, 3, -33 },
  { 1123, 8, 13, 33, 6, -5 },
  { 1136, 20, 3, 33, 6, -19 },
  { 1144, 5, 5, 33, 12, -5 },
  { 1148, 27, 43, 33, 4, -40 },
  { 1294, 26, 41, 33, 4, -40 },
  { 1428, 16, 40, 33, 8, -40 },
  { 1508, 27, 40, 33, 1, -40 },
  { 1643, 28, 41, 33, 1, -40 },
  { 1787, 28, 40, 33, 1, -40 },
  { 1927, 27, 41, 33, 5, -40 },
  { 2066, 25, 41, 33, 3, -40 },
  { 2195, 26, 40, 33, 6, -40 },
  { 2325, 28, 41, 33, 3, -40 },
  { 2469, 25, 40, 33, 5, -40 },
  { 2594, 10, 29, 33, 13, -29 },
  { 2631, 13, 37, 33, 10, -29 },
  { 2692, 25, 24, 33, 4, -30 },
  { 2767, 26, 14, 33, 4, -25 },
  { 2813, 26, 24, 33, 3, -30 },
  { 2891, 22, 40, 33, 8, -40 },
  { 3001, 32, 40, 33, 1, -40 },
  { 3161, 28, 40, 33, 0, -40 },
  { 3301, 29, 40, 33, 2, -40 },
  { 3446, 28, 41, 33, 3, -40 },
  { 3590, 29, 40, 33, 2, -40 },
  { 3735, 30, 40, 33, 2, -40 },
  { 3885, 29, 40, 33, 3, -40 },
  { 4030, 28, 41, 33, 3, -40 },
  { 4174, 31, 40, 33, 1, -40 },
  { 4329, 30, 40, 33, 2, -40 },
  { 4479, 29, 41, 33, 2, -40 },
  { 4628, 32, 40, 33, 2, -40 },
  { 4788, 23, 40, 33, 3, -40 },
  { 4903, 31, 40, 33, 2, -40 },
  { 5058, 31, 40, 33, 1, -40 },
  { 5213, 28, 41, 33, 3, -40 },
  { 5357, 29, 40, 33, 3, -40 },
  { 5502, 28, 47, 33, 3, -40 },
  { 5667, 28, 40, 33, 3, -40 },
  { 5807, 28, 41, 33, 3, -40 },
  { 5951, 28, 40, 33, 6, -40 },
  { 6091, 29, 41, 33, 3, -40 },
  { 6240, 28, 40, 33, 6, -40 },
  { 6380, 30, 40, 33, 5, -40 },
  { 6530, 34, 40, 33, 0, -40 },
  { 6700, 28, 40, 33, 6, -40 },
  { 6840, 30, 40, 33, 1, -40 },
  { 6990, 18, 55, 33, 8, -46 },
  { 7114, 11, 43, 33, 11, -40 },
  { 7174, 17, 55, 33, 8, -46 },
  { 7291, 19, 22, 33, 7, -40 },
  { 7344, 24, 3, 33, 1, 0 },
  { 7353, 7, 7, 33, 16, -41 },
  { 7360, 25, 31, 33, 3, -30 },
  { 7457, 26, 43, 33, 2, -42 },
  { 7597, 25, 31, 33, 4, -30 },
  { 7694, 28, 43, 33, 4, -42 },
  { 7845, 26, 31, 33, 3, -30 },
  { 7946, 27, 43, 33, 7, -43 },
  { 8092, 28, 42, 33, 2, -30 },
  { 8239, 27, 42, 33, 2, -42 },
  { 8381, 24, 40, 33, 3, -40 },
  { 8501, 26, 52, 33, 0, -40 },
  { 8670, 28, 42, 33, 3, -42 },
  { 8817, 24, 42, 33, 3, -42 },
  { 8943, 31, 30, 33, 0, -30 },
  { 9060, 27, 30, 33, 2, -30 },
  { 9162, 26, 31, 33, 3, -30 },
  { 9263, 28, 41, 33, 0, -30 },
  { 9407, 26, 41, 33, 4, -30 },
  { 9541, 24, 30, 33, 7, -30 },
  { 9631, 25, 31, 33, 4, -30 },
  { 9728, 23, 38, 33, 6, -37 },
  { 9838, 26, 31, 33, 4, -30 },
  { 9939, 27, 30, 33, 5, -30 },
  { 10041, 30, 30, 33, 4, -30 },
  { 10154, 31, 30, 33, 1, -30 },
  { 10271, 34, 42, 33, -1, -30 },
  { 10450, 29, 30, 33, 1, -30 },
  { 10559, 21, 55, 33, 9, -44 },
  { 10704, 10, 49, 33, 11, -40 },
  { 10766, 22, 55, 33, 5, -44 },
  { 10918, 31, 10, 33, 1, -22 },
};

const GFXfont RobotoMono_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_LIGHTITALIC56PT7B_H_
