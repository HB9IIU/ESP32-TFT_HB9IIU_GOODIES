#ifndef _ROBOTOMONO_LIGHTITALIC58PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E,
  0x38, 0x39, 0xC0, 0xE7, 0x03, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xC6, 0x07,
  0x38, 0x18, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x81, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x02, 0x38, 0x07, 0x00, 0x67, 0x00, 0xE0, 0x1C, 0xE0,
  0x1C, 0x07, 0x1C, 0x03, 0x81, 0xC3, 0x00, 0x70, 0x38, 0x60, 0x0E, 0x0E,
  0x0C, 0x03, 0x83, 0x81, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x87,
  0x87, 0x00, 0x7F, 0xE1, 0xE0, 0x07, 0xF8, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x3F, 0x00, 0x0E, 0x0F, 0xF0,
  0x03, 0x83, 0xCF, 0x00, 0x70, 0xE0, 0x70, 0x1C, 0x38, 0x0E, 0x07, 0x07,
  0x01, 0xC0, 0xE0, 0xC0, 0x18, 0x38, 0x38, 0x03, 0x0E, 0x07, 0x00, 0xE1,
  0xC0, 0xE0, 0x1C, 0x70, 0x1C, 0x03, 0x9C, 0x03, 0x80, 0x73, 0x00, 0x70,
  0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x73, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x0F, 0x87, 0x80, 0x38, 0xF8, 0x1E, 0x01, 0xC7, 0x80, 0x70, 0x0E,
  0x78, 0x03, 0xC0, 0xF3, 0x80, 0x0F, 0x07, 0x3C, 0x00, 0x78, 0x79, 0xC0,
  0x01, 0xE3, 0x8E, 0x00, 0x07, 0x3C, 0x70, 0x00, 0x3D, 0xC3, 0x80, 0x00,
  0xFE, 0x1C, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF8,
  0x1E, 0x00, 0x1F, 0xC0, 0xF8, 0x03, 0xEF, 0x03, 0xF0, 0xFE, 0x38, 0x0F,
  0xFF, 0xC1, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x39, 0xCE,
  0x73, 0x9D, 0xCE, 0x73, 0x9C, 0xCE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x80, 0x1C, 0x01, 0x70, 0x0E,
  0x07, 0xBF, 0x06, 0x0F, 0xFF, 0xE3, 0x3F, 0xE1, 0xFF, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x30, 0x01, 0xC0,
  0x08, 0x00, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x06, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF9, 0xC0, 0x00, 0xF7,
  0x38, 0x00, 0x3C, 0xE7, 0x00, 0x0F, 0x1D, 0xE0, 0x07, 0x87, 0xBC, 0x01,
  0xE0, 0xF7, 0x00, 0x78, 0x1C, 0xE0, 0x1E, 0x03, 0x9C, 0x0F, 0x00, 0x73,
  0x83, 0xC0, 0x0E, 0xF0, 0xF0, 0x03, 0xDE, 0x3C, 0x00, 0x7B, 0xDE, 0x00,
  0x0E, 0x77, 0x80, 0x01, 0xCF, 0xE0, 0x00, 0x39, 0xF8, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x70,
  0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0xFE, 0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0x1E, 0xFC, 0x1C, 0xE0, 0x1C,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE7, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x01, 0xE0,
  0x04, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x1C, 0x7F, 0xF8,
  0x07, 0x3F, 0xFF, 0x03, 0xDF, 0x03, 0xE0, 0xEE, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x78,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xF8,
  0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF9, 0xE0, 0x00,
  0xF8, 0xF0, 0x01, 0xFC, 0x3E, 0x01, 0xEE, 0x0F, 0xEF, 0xEF, 0x03, 0xFF,
  0xC7, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0xF0,
  0xF8, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xF0, 0xFC, 0x3E, 0x00, 0xF8, 0xF0, 0x01,
  0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x78, 0x06, 0x07, 0x01, 0xFE, 0x06, 0x0E, 0x07, 0xFF, 0x06,
  0x0C, 0x0F, 0x07, 0x06, 0x1C, 0x0E, 0x07, 0x06, 0x18, 0x1C, 0x06, 0x06,
  0x38, 0x38, 0x06, 0x06, 0x30, 0x38, 0x06, 0x06, 0x70, 0x70, 0x0E, 0x06,
  0x70, 0x70, 0x0C, 0x06, 0x60, 0x60, 0x0C, 0x06, 0x60, 0xE0, 0x1C, 0x06,
  0xE0, 0xE0, 0x1C, 0x0E, 0xE0, 0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x18, 0x0C,
  0xC0, 0xC0, 0x38, 0x0C, 0xC1, 0xC0, 0x38, 0x1C, 0xC1, 0xC0, 0x70, 0x18,
  0xC1, 0xC0, 0x70, 0x18, 0xC1, 0xC0, 0xF0, 0x30, 0xC0, 0xC1, 0xB0, 0x70,
  0xC0, 0xE3, 0xB8, 0xE0, 0xC0, 0xFF, 0x3F, 0xC0, 0xE0, 0x7C, 0x1F, 0x80,
  0xE0, 0x10, 0x04, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0xF0,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x01,
  0xC0, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00,
  0x70, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78,
  0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0E, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x70, 0x00, 0xFC, 0x01, 0xC0, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xFF, 0xCE, 0x00, 0x3F, 0xFC, 0xF0, 0x01, 0xFF, 0xE7, 0x80, 0x10, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0x80,
  0x1F, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x1C,
  0x1F, 0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x00,
  0xFF, 0x78, 0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xEE, 0x07, 0xF0, 0x01, 0xEE, 0x07, 0x30,
  0x01, 0xDE, 0x07, 0x38, 0x03, 0xDC, 0x07, 0x38, 0x03, 0x9C, 0x07, 0x38,
  0x07, 0x9C, 0x07, 0x38, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0x3C, 0x0E, 0x1C,
  0x0E, 0x38, 0x0E, 0x1C, 0x1C, 0x38, 0x0E, 0x1C, 0x3C, 0x38, 0x0E, 0x1C,
  0x38, 0x38, 0x0E, 0x1C, 0x78, 0x38, 0x1E, 0x1C, 0x70, 0x78, 0x1C, 0x0E,
  0xF0, 0x70, 0x1C, 0x0E, 0xE0, 0x70, 0x1C, 0x0F, 0xE0, 0x70, 0x1C, 0x0F,
  0xC0, 0x70, 0x1C, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x01, 0xC0, 0x3E,
  0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x78, 0x0F,
  0xE0, 0x00, 0x38, 0x07, 0xF8, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x0E, 0x01,
  0xCE, 0x00, 0x07, 0x00, 0xE7, 0x80, 0x07, 0x80, 0x71, 0xC0, 0x03, 0xC0,
  0x78, 0xE0, 0x01, 0xC0, 0x3C, 0x78, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x70,
  0x0E, 0x0E, 0x00, 0x38, 0x07, 0x03, 0x80, 0x3C, 0x03, 0x81, 0xC0, 0x1E,
  0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x03, 0xC0, 0x38, 0x03, 0x81, 0xE0, 0x1C, 0x01, 0xC0,
  0xE0, 0x1E, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0x38, 0x38, 0x07, 0x00, 0x1C,
  0x1C, 0x03, 0x80, 0x0F, 0x1E, 0x01, 0xC0, 0x03, 0x8F, 0x01, 0xE0, 0x01,
  0xC7, 0x00, 0xF0, 0x00, 0xF3, 0x80, 0x70, 0x00, 0x39, 0xC0, 0x38, 0x00,
  0x1E, 0xE0, 0x1C, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x03, 0xF8, 0x0F, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xFD, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x06, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x1F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0xE0, 0x07, 0x80, 0x1D, 0xC0, 0x0F, 0x00, 0x73, 0x80, 0x3E,
  0x00, 0xE7, 0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x07, 0x9C, 0x03, 0xF0,
  0x0E, 0x38, 0x07, 0xE0, 0x1C, 0x70, 0x0F, 0xC0, 0x38, 0xE0, 0x3B, 0x80,
  0xE1, 0xC0, 0x77, 0x01, 0xC3, 0x80, 0xEE, 0x03, 0x87, 0x03, 0x9C, 0x0E,
  0x0E, 0x07, 0x38, 0x1C, 0x1C, 0x0E, 0x70, 0x38, 0x38, 0x38, 0xE0, 0x70,
  0x70, 0x71, 0xC1, 0xC0, 0xE0, 0xE3, 0x83, 0x81, 0xC3, 0x87, 0x07, 0x03,
  0x87, 0x0E, 0x1C, 0x07, 0x0E, 0x1C, 0x38, 0x0E, 0x38, 0x38, 0x70, 0x1C,
  0x70, 0x70, 0xE0, 0x38, 0xE0, 0xE3, 0x80, 0x73, 0x81, 0xC7, 0x00, 0xE7,
  0x03, 0x8E, 0x01, 0xCE, 0x03, 0x38, 0x03, 0xB8, 0x06, 0x70, 0x07, 0x70,
  0x0C, 0xE0, 0x0E, 0xE0, 0x1B, 0x80, 0x1B, 0x80, 0x37, 0x00, 0x37, 0x00,
  0x6E, 0x00, 0xEE, 0x00, 0xDC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x80,
  0x03, 0x80, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3B,
  0x00, 0x07, 0xB8, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x1C,
  0x38, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xF7,
  0x80, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x03, 0x87, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F,
  0x87, 0x00, 0x0F, 0xE1, 0xF0, 0x0F, 0xB8, 0x3F, 0x9F, 0xCE, 0x07, 0xFF,
  0xC3, 0x80, 0xFF, 0xC0, 0xE0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x3D, 0xFF, 0xF8,
  0x0E, 0xF8, 0x1F, 0x03, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F,
  0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0xEF, 0x00, 0xF8, 0x39, 0xFB, 0xFC,
  0x0E, 0x3F, 0xFE, 0x03, 0x87, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x4F, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0xF0, 0x03, 0xFF,
  0xC7, 0x00, 0x3F, 0xFF, 0x38, 0x03, 0xE0, 0x3D, 0xC0, 0x3C, 0x00, 0x7E,
  0x03, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3C, 0x01, 0xFC, 0x00,
  0xFC, 0xFE, 0xE0, 0x03, 0xFF, 0xC7, 0x00, 0x0F, 0xF8, 0x70, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80,
  0x1F, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x38, 0x01, 0xFF, 0xE3, 0xC0, 0x1F, 0xFF, 0x9C,
  0x01, 0xF0, 0x1E, 0xE0, 0x1E, 0x00, 0x3F, 0x01, 0xE0, 0x01, 0xF8, 0x1E,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x0F, 0xC0, 0x1E, 0x00, 0xFE, 0x00, 0x7E, 0x7F, 0x70, 0x01, 0xFF,
  0xE7, 0x80, 0x07, 0xFC, 0x3C, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x04,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x1F, 0xE0, 0x07, 0x87, 0xFF, 0x00, 0x71, 0xFF, 0xF8, 0x07, 0x3C, 0x07,
  0xC0, 0x77, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x0E, 0x0F,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF8,
  0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xE0, 0x1F, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x38, 0x1F,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x07, 0x3E, 0x00, 0x00, 0x3B, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xCF, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x0E,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0,
  0x07, 0x1F, 0x81, 0xFC, 0x03, 0xBF, 0xE1, 0xFF, 0x03, 0xBF, 0xF9, 0xFF,
  0xC1, 0xF8, 0x3D, 0xC1, 0xE0, 0xF8, 0x0F, 0x80, 0x70, 0x78, 0x07, 0xC0,
  0x38, 0x38, 0x03, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0x0E, 0x1E, 0x00, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0x03, 0x87, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x70, 0xF0, 0x07,
  0x00, 0x38, 0x70, 0x03, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00,
  0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0x87, 0x00,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0x38, 0x70, 0x07, 0x80, 0x3C, 0x78, 0x03, 0x80, 0x1C, 0x38,
  0x01, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0x81, 0xFE, 0x00,
  0x78, 0x7F, 0xF0, 0x07, 0x1F, 0xFF, 0x80, 0x73, 0xC0, 0x7C, 0x07, 0x70,
  0x03, 0xE0, 0x7E, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0xFE,
  0x00, 0x07, 0x1F, 0xFC, 0x00, 0x73, 0xFF, 0xF0, 0x03, 0xBC, 0x07, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x38,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0x80, 0x3E, 0x01, 0xDF, 0x8F, 0xE0, 0x0E, 0x3F, 0xFE, 0x00, 0x70, 0xFF,
  0xC0, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1,
  0xE0, 0x1F, 0xFE, 0x38, 0x07, 0xFF, 0xE7, 0x01, 0xF0, 0x1E, 0xE0, 0x78,
  0x00, 0xFC, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x3C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0xFE, 0x01, 0xF8, 0xFD, 0xC0, 0x1F,
  0xFE, 0x78, 0x01, 0xFF, 0x0E, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x01, 0xFF, 0x83, 0x83, 0xFF, 0xC1, 0xC7, 0xFF, 0xC0, 0xE7, 0xE0, 0x20,
  0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80,
  0x7C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3F, 0xC7, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xCF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x3E, 0x0E, 0x00, 0x0F, 0xC1, 0xE0, 0x03, 0xF0, 0x1E, 0x01, 0xEE, 0x03,
  0xF9, 0xF9, 0xC0, 0x3F, 0xFE, 0x38, 0x01, 0xFF, 0x0F, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x78, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x3B, 0x80, 0x1E,
  0x00, 0x77, 0x00, 0x3C, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xF0,
  0x07, 0x38, 0x03, 0x60, 0x1C, 0x70, 0x0E, 0xC0, 0x38, 0xE0, 0x19, 0x80,
  0x71, 0xC0, 0x73, 0x01, 0xC1, 0x80, 0xE6, 0x03, 0x83, 0x01, 0x8C, 0x07,
  0x06, 0x07, 0x18, 0x1C, 0x0C, 0x0E, 0x38, 0x38, 0x1C, 0x38, 0x70, 0xE0,
  0x38, 0x70, 0xE1, 0xC0, 0x71, 0xC1, 0xC3, 0x80, 0xE3, 0x83, 0x8E, 0x01,
  0xC6, 0x07, 0x1C, 0x03, 0x9C, 0x0E, 0x30, 0x07, 0x38, 0x1C, 0xE0, 0x0E,
  0xE0, 0x19, 0xC0, 0x1D, 0xC0, 0x33, 0x00, 0x3B, 0x00, 0x6E, 0x00, 0x7E,
  0x00, 0xD8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0E, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0x1F, 0xFF, 0x00, 0x06, 0x3C, 0x0F, 0x80, 0x0E, 0x78, 0x07,
  0xC0, 0x1E, 0x70, 0x03, 0xE0, 0x1C, 0x70, 0x01, 0xF8, 0x78, 0xE0, 0x00,
  0x7F, 0xF8, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 41, 34, 12, -41 },
  { 53, 14, 13, 34, 13, -44 },
  { 76, 34, 41, 34, 1, -41 },
  { 251, 28, 54, 34, 4, -48 },
  { 440, 27, 43, 34, 4, -42 },
  { 586, 29, 43, 34, 2, -42 },
  { 742, 5, 13, 34, 16, -44 },
  { 751, 18, 59, 34, 10, -46 },
  { 884, 18, 59, 34, 5, -46 },
  { 1017, 25, 25, 34, 7, -41 },
  { 1096, 28, 30, 34, 3, -34 },
  { 1201, 9, 13, 34, 6, -5 },
  { 1216, 21, 3, 34, 6, -20 },
  { 1224, 6, 5, 34, 12, -5 },
  { 1228, 28, 45, 34, 4, -41 },
  { 1386, 27, 43, 34, 4, -42 },
  { 1532, 16, 41, 34, 9, -41 },
  { 1614, 28, 42, 34, 1, -42 },
  { 1761, 29, 43, 34, 1, -42 },
  { 1917, 29, 41, 34, 1, -41 },
  { 2066, 28, 42, 34, 5, -41 },
  { 2213, 26, 43, 34, 3, -42 },
  { 2353, 28, 41, 34, 6, -41 },
  { 2497, 29, 43, 34, 3, -42 },
  { 2653, 25, 42, 34, 6, -42 },
  { 2785, 10, 30, 34, 14, -30 },
  { 2823, 14, 38, 34, 10, -30 },
  { 2890, 26, 24, 34, 5, -31 },
  { 2968, 27, 15, 34, 4, -26 },
  { 3019, 27, 25, 34, 3, -31 },
  { 3104, 22, 42, 34, 9, -42 },
  { 3220, 32, 41, 34, 2, -41 },
  { 3384, 29, 41, 34, 0, -41 },
  { 3533, 30, 41, 34, 2, -41 },
  { 3687, 29, 43, 34, 3, -42 },
  { 3843, 30, 41, 34, 2, -41 },
  { 3997, 30, 41, 34, 3, -41 },
  { 4151, 31, 41, 34, 3, -41 },
  { 4310, 29, 43, 34, 3, -42 },
  { 4466, 33, 41, 34, 1, -41 },
  { 4636, 31, 41, 34, 2, -41 },
  { 4795, 30, 42, 34, 2, -41 },
  { 4953, 33, 41, 34, 3, -41 },
  { 5123, 24, 41, 34, 3, -41 },
  { 5246, 32, 41, 34, 2, -41 },
  { 5410, 33, 41, 34, 1, -41 },
  { 5580, 29, 43, 34, 3, -42 },
  { 5736, 31, 41, 34, 3, -41 },
  { 5895, 29, 49, 34, 3, -42 },
  { 6073, 29, 41, 34, 3, -41 },
  { 6222, 30, 43, 34, 3, -42 },
  { 6384, 30, 41, 34, 6, -41 },
  { 6538, 31, 42, 34, 3, -41 },
  { 6701, 29, 41, 34, 6, -41 },
  { 6850, 31, 41, 34, 5, -41 },
  { 7009, 35, 41, 34, 0, -41 },
  { 7189, 29, 41, 34, 6, -41 },
  { 7338, 31, 41, 34, 1, -41 },
  { 7497, 19, 56, 34, 8, -47 },
  { 7630, 12, 45, 34, 11, -41 },
  { 7698, 18, 56, 34, 8, -47 },
  { 7824, 20, 22, 34, 7, -41 },
  { 7879, 25, 3, 34, 1, 0 },
  { 7889, 7, 7, 34, 17, -42 },
  { 7896, 26, 32, 34, 3, -31 },
  { 8000, 26, 45, 34, 3, -44 },
  { 8147, 26, 32, 34, 4, -31 },
  { 8251, 29, 45, 34, 4, -44 },
  { 8415, 27, 32, 34, 3, -31 },
  { 8523, 28, 44, 34, 7, -44 },
  { 8677, 29, 43, 34, 2, -31 },
  { 8833, 28, 44, 34, 2, -44 },
  { 8987, 25, 42, 34, 3, -42 },
  { 9119, 27, 54, 34, 0, -42 },
  { 9302, 29, 44, 34, 3, -44 },
  { 9462, 25, 44, 34, 3, -44 },
  { 9600, 33, 31, 34, 0, -31 },
  { 9728, 28, 31, 34, 2, -31 },
  { 9837, 27, 32, 34, 3, -31 },
  { 9945, 29, 43, 34, 0, -31 },
  { 10101, 27, 43, 34, 4, -31 },
  { 10247, 25, 31, 34, 7, -31 },
  { 10344, 26, 32, 34, 4, -31 },
  { 10448, 23, 39, 34, 7, -38 },
  { 10561, 27, 32, 34, 4, -31 },
  { 10669, 28, 31, 34, 5, -31 },
  { 10778, 31, 31, 34, 4, -31 },
  { 10899, 32, 31, 34, 1, -31 },
  { 11023, 35, 43, 34, -1, -31 },
  { 11212, 30, 31, 34, 1, -31 },
  { 11329, 22, 56, 34, 9, -45 },
  { 11483, 11, 50, 34, 11, -41 },
  { 11552, 22, 56, 34, 5, -45 },
  { 11706, 32, 10, 34, 1, -22 },
};

const GFXfont RobotoMono_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic58pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_LIGHTITALIC58PT7B_H_
