#ifndef _ROBOTOMONO_LIGHTITALIC38PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xC3,
  0x00, 0x63, 0x63, 0x63, 0x43, 0xC3, 0xC2, 0xC2, 0xC6, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x0F, 0xFF, 0xFE,
  0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x06,
  0x0C, 0x21, 0xFF, 0xFF, 0x84, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xE0, 0x70, 0x30, 0x06, 0x0E,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE3, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x38, 0x03, 0x83, 0x80,
  0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x30, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x46, 0x0C, 0x18, 0x81, 0x86, 0x30, 0x31, 0x86, 0x04, 0x30, 0x41,
  0x8C, 0x0C, 0x63, 0x01, 0xFC, 0x60, 0x0E, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x38, 0x03, 0x1F, 0x80, 0x67, 0x18, 0x18,
  0xC1, 0x06, 0x30, 0x20, 0xC6, 0x04, 0x30, 0xC0, 0x8C, 0x18, 0x31, 0x03,
  0x06, 0x00, 0x61, 0x80, 0x06, 0x70, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x70, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x60, 0x03, 0x0E, 0x00, 0x31, 0xC0, 0x03, 0x70,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x01, 0xC6,
  0x07, 0x38, 0x30, 0x63, 0x03, 0x86, 0x70, 0x18, 0xE6, 0x01, 0xCC, 0x60,
  0x0F, 0xC6, 0x00, 0x78, 0x60, 0x07, 0x07, 0x00, 0x70, 0x30, 0x1D, 0x83,
  0xFF, 0x9C, 0x0F, 0xE0, 0xE0, 0x6D, 0xBD, 0xB6, 0xC0, 0x00, 0x10, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0xC1, 0x83, 0xF1, 0x9F, 0x7F, 0xFE, 0x07,
  0xE0, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x38, 0x70, 0x70,
  0x30, 0x60, 0x38, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0x80, 0xC3, 0x80, 0x71, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0xE0,
  0x03, 0x60, 0x03, 0xB0, 0x07, 0xD8, 0x07, 0x6C, 0x07, 0x3E, 0x06, 0x1E,
  0x0E, 0x0F, 0x0E, 0x0F, 0x8E, 0x06, 0xCC, 0x03, 0x7C, 0x01, 0xBC, 0x00,
  0xD8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31, 0xC0, 0x38, 0x70,
  0x38, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xF6, 0xE1,
  0xA0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30,
  0x06, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x70, 0x18,
  0x38, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0xC0, 0x03, 0x30, 0x00, 0xCE, 0x00, 0x71, 0x80, 0x38, 0x70,
  0x1C, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03,
  0x98, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x60,
  0x70, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x6F,
  0xE0, 0x0F, 0xFE, 0x03, 0xC0, 0xE0, 0x20, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x8C, 0x00,
  0x71, 0x80, 0x0C, 0x38, 0x03, 0x83, 0x00, 0x60, 0x70, 0x3C, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x78, 0x0C, 0xFF, 0x07, 0xE3, 0xC7, 0xC0, 0x73, 0x80, 0x19, 0xC0, 0x0C,
  0xC0, 0x07, 0x60, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x6E, 0x00,
  0x33, 0x00, 0x39, 0x80, 0x18, 0xE0, 0x1C, 0x38, 0x1C, 0x0F, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x07, 0x03, 0x00,
  0x60, 0xE0, 0x0E, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00,
  0xC1, 0x80, 0x38, 0x30, 0x06, 0x03, 0x83, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x03, 0x83, 0x80, 0xC0, 0x18, 0x30, 0x03, 0x8E, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38,
  0x30, 0x0E, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xFC,
  0x1C, 0x0E, 0x38, 0x06, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E,
  0x60, 0x1E, 0x70, 0x76, 0x3F, 0xE6, 0x1F, 0x8C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC7, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x10, 0x00,
  0x0E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xE7,
  0x81, 0x98, 0x07, 0xE0, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x70, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x06, 0x0C,
  0x60, 0xF8, 0x63, 0x0C, 0x63, 0x30, 0xC3, 0x19, 0x8C, 0x10, 0xD8, 0x40,
  0x86, 0xC6, 0x0C, 0x34, 0x30, 0x61, 0xA1, 0x02, 0x0B, 0x18, 0x10, 0x58,
  0xC1, 0x86, 0xC6, 0x0C, 0x36, 0x30, 0xE1, 0x31, 0x8F, 0x19, 0x8E, 0xD9,
  0x8C, 0x3C, 0x78, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x08, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xC0,
  0x03, 0x98, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0E, 0x00, 0xE0, 0xC0,
  0x18, 0x18, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1F, 0x00, 0x01, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE1, 0xC0, 0x0C,
  0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x38,
  0xE0, 0x0E, 0x18, 0x07, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x0C, 0x01, 0xC1,
  0x80, 0x1C, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x07, 0x38, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x1E, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C, 0x07,
  0x07, 0x00, 0x60, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0xCE, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3,
  0x80, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x0C, 0x00, 0xE0, 0xC0,
  0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x07, 0x38, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x70, 0x01, 0x86, 0x00, 0x38, 0x60, 0x07, 0x06, 0x00, 0xE0, 0x60, 0x3C,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1C, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x30, 0x00,
  0xCE, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x0F, 0xF6, 0x03, 0xFE,
  0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xCE, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x80, 0x1C, 0x38, 0x0F, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x86,
  0x00, 0x30, 0x60, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x60, 0x03, 0x83, 0x00, 0x38, 0x18,
  0x03, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x38, 0x03, 0x03, 0x80,
  0x18, 0x38, 0x00, 0xC3, 0x80, 0x06, 0x38, 0x00, 0x73, 0x80, 0x03, 0x3C,
  0x00, 0x1B, 0xE0, 0x00, 0xFB, 0x80, 0x07, 0x8C, 0x00, 0x78, 0x70, 0x03,
  0x81, 0x80, 0x18, 0x0E, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x03, 0x80, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x86, 0x80, 0xF8,
  0x36, 0x06, 0xC3, 0xB0, 0x66, 0x19, 0x83, 0x30, 0xCC, 0x31, 0x86, 0x61,
  0x98, 0x31, 0x18, 0xC1, 0x8C, 0xC6, 0x1C, 0x6C, 0x30, 0xC3, 0xE1, 0x86,
  0x1E, 0x1C, 0x30, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x60, 0xF0, 0x03, 0x06, 0xC0, 0x18, 0x36,
  0x00, 0xC3, 0xB0, 0x06, 0x18, 0xC0, 0x70, 0xC6, 0x03, 0x06, 0x38, 0x18,
  0x30, 0xC0, 0xC3, 0x86, 0x06, 0x18, 0x38, 0x70, 0xC0, 0xC3, 0x06, 0x06,
  0x18, 0x30, 0x38, 0xC1, 0x80, 0xC6, 0x1C, 0x06, 0x30, 0xC0, 0x1B, 0x86,
  0x00, 0xD8, 0x30, 0x06, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0xE0, 0x07,
  0x86, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1C,
  0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x39, 0x80,
  0x03, 0x30, 0x00, 0x6E, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00,
  0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0xCE, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01,
  0x83, 0x80, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60,
  0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x00, 0x78, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x1C, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0xCE, 0x00, 0x19,
  0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x06, 0x18,
  0x01, 0xC3, 0x80, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x38,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60,
  0x03, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x3E, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x70, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x1C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x07, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C, 0x07, 0x07,
  0x00, 0x61, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x38, 0x00, 0xE3, 0x00,
  0x38, 0x78, 0x0E, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0,
  0x01, 0x8C, 0x00, 0x38, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x07,
  0x00, 0xE0, 0x38, 0x1C, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xC0, 0x00,
  0xFC, 0x00, 0x1B, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x30, 0x70, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0xC3, 0x80,
  0x18, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x30, 0x3B, 0x03, 0x81, 0x98, 0x1C, 0x0C, 0xC0,
  0xE0, 0x66, 0x0F, 0x06, 0x30, 0x78, 0x31, 0x83, 0xC1, 0x8C, 0x36, 0x1C,
  0x61, 0xB0, 0xC3, 0x0D, 0x86, 0x18, 0xCC, 0x30, 0xC6, 0x63, 0x06, 0x33,
  0x18, 0x33, 0x18, 0xC1, 0x98, 0xCC, 0x0C, 0xC6, 0x60, 0x6C, 0x33, 0x03,
  0x61, 0x98, 0x1B, 0x0D, 0x80, 0xF0, 0x6C, 0x07, 0x83, 0x60, 0x3C, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C,
  0x01, 0x80, 0x18, 0x07, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xCE, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x36, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x70, 0x30, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38,
  0x00, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xEC, 0x00,
  0x39, 0x80, 0x06, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0E, 0x03,
  0x80, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x07, 0x00, 0x30, 0xC0, 0x06, 0x30,
  0x00, 0xCE, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x3F,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0xE0, 0xFE, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30,
  0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0xF0,
  0x3F, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x76, 0x03, 0x30, 0x31, 0x81, 0x8C, 0x18, 0x31, 0xC1, 0x8C, 0x0C,
  0xE0, 0x66, 0x03, 0x60, 0x0F, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0x18, 0x61, 0x80, 0x03, 0xFC, 0x03, 0xCF, 0x83, 0x80, 0xC3, 0x00, 0x73,
  0x80, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x01, 0xFF, 0x87, 0xFF,
  0x8F, 0x80, 0xCE, 0x00, 0x66, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x1D, 0x80,
  0x0C, 0xE0, 0x1E, 0x30, 0x1F, 0x1F, 0xFD, 0x87, 0xF8, 0xC0, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0xFE, 0x06, 0xFF, 0x83, 0xC0, 0xE1,
  0xC0, 0x39, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xDC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x0C, 0xC0,
  0x0E, 0xE0, 0x06, 0x78, 0x07, 0x3E, 0x07, 0x1B, 0xFF, 0x0C, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xDF, 0x07, 0x01, 0x87, 0x00, 0x63, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0D, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x19, 0x80, 0x1C, 0xE0, 0x0C,
  0x38, 0x1C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x3F, 0x8C, 0x07, 0xFE, 0xC0, 0xE0,
  0x7C, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x30, 0x01, 0x87, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0E,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x07, 0x00, 0xE0,
  0x38, 0x1E, 0x03, 0xFF, 0x60, 0x0F, 0xC6, 0x00, 0x01, 0xFC, 0x01, 0xF7,
  0xC0, 0xE0, 0x30, 0x70, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x67, 0x00, 0x1D,
  0x80, 0x07, 0x7F, 0xFF, 0x9F, 0xFF, 0xEE, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x07, 0x0E, 0x03,
  0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xFC, 0x60, 0x7F, 0xEC, 0x1C, 0x0F, 0x87, 0x00, 0xF1,
  0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC6,
  0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xE1, 0x80, 0x18, 0x38, 0x07, 0x03, 0x81, 0xE0, 0x7F, 0xEC, 0x03,
  0xF1, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x60, 0xE0,
  0x1C, 0x0E, 0x0F, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x7F, 0x06, 0x7F, 0xC3, 0xE0, 0x73, 0x40,
  0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xDC,
  0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0xE0, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x3C,
  0x60, 0x0E, 0x0C, 0x03, 0x81, 0x81, 0xC0, 0x30, 0x70, 0x0E, 0x1C, 0x01,
  0xC7, 0x00, 0x33, 0xC0, 0x06, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x07,
  0x8C, 0x00, 0xC1, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x83, 0x80, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x70, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1B, 0xF3, 0xF0, 0xFF, 0xFF,
  0xC7, 0x0F, 0x06, 0x30, 0x30, 0x33, 0x01, 0x81, 0x98, 0x0C, 0x0C, 0xC0,
  0xE0, 0x66, 0x06, 0x03, 0x30, 0x30, 0x1B, 0x81, 0x81, 0x98, 0x0C, 0x0C,
  0xC0, 0x60, 0x66, 0x06, 0x03, 0x30, 0x30, 0x19, 0x81, 0x81, 0xDC, 0x0C,
  0x0C, 0xC0, 0x60, 0x66, 0x03, 0x03, 0x30, 0x30, 0x19, 0x81, 0x80, 0xC0,
  0x18, 0xFE, 0x0D, 0xFF, 0x87, 0xC0, 0xE6, 0x80, 0x33, 0x80, 0x19, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0xEC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x07,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC0, 0x03, 0xFC, 0x01, 0xF7, 0x80,
  0xE0, 0x70, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x1D, 0x80,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0xEE, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x0E, 0x0C, 0x07, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x06, 0x7F, 0x00, 0xDF, 0xF0, 0x1E, 0x07, 0x07,
  0x80, 0x70, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x80, 0xE0, 0xDF,
  0xF8, 0x19, 0xFC, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xF8, 0xC1, 0xF7, 0xB0, 0xE0, 0x7C, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0xE0, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x70,
  0x0E, 0x0E, 0x07, 0x83, 0xFF, 0x60, 0x3F, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x18, 0xFF, 0x19, 0xFE, 0x1B, 0x80, 0x3E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xE0,
  0x38, 0x70, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x1C, 0x03, 0x83, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0xFC,
  0x03, 0xF8, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x77, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x03, 0xB8,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x39, 0x80, 0x1C,
  0xE0, 0x1C, 0x30, 0x3E, 0x1F, 0xFB, 0x07, 0xF1, 0x80, 0xE0, 0x00, 0xEC,
  0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C,
  0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x3C,
  0x0E, 0x06, 0xC0, 0xE0, 0x6C, 0x1E, 0x0C, 0xC1, 0xE0, 0xCC, 0x16, 0x0C,
  0xC3, 0x61, 0x8C, 0x36, 0x18, 0xC6, 0x61, 0x0C, 0x66, 0x30, 0xC4, 0x23,
  0x0C, 0xC2, 0x60, 0xC8, 0x26, 0x0D, 0x82, 0x60, 0xD8, 0x2C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0xC0, 0x0E, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x07, 0x00,
  0x38, 0x60, 0x01, 0x8C, 0x00, 0x0D, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0x98, 0x00, 0x71, 0xC0, 0x06, 0x0C,
  0x00, 0xC0, 0xE0, 0x18, 0x06, 0x03, 0x80, 0x70, 0x70, 0x03, 0x8E, 0x00,
  0x18, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x70,
  0x03, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x02, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xC0, 0x02, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0xF8, 0x01, 0x7B, 0xC0, 0x36, 0x0E, 0x03, 0xC0,
  0x78, 0x6C, 0x03, 0xFC, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 27, 22, 8, -27 },
  { 25, 8, 9, 22, 9, -29 },
  { 34, 23, 27, 22, 0, -27 },
  { 112, 19, 35, 22, 2, -31 },
  { 196, 19, 27, 22, 2, -27 },
  { 261, 20, 27, 22, 1, -27 },
  { 329, 3, 9, 22, 11, -29 },
  { 333, 12, 39, 22, 6, -30 },
  { 392, 12, 39, 22, 3, -30 },
  { 451, 16, 16, 22, 5, -27 },
  { 483, 19, 19, 22, 2, -22 },
  { 529, 6, 9, 22, 4, -4 },
  { 536, 14, 2, 22, 4, -13 },
  { 540, 4, 4, 22, 8, -4 },
  { 542, 18, 29, 22, 3, -27 },
  { 608, 17, 27, 22, 3, -27 },
  { 666, 10, 27, 22, 6, -27 },
  { 700, 18, 27, 22, 1, -27 },
  { 761, 18, 27, 22, 1, -27 },
  { 822, 19, 27, 22, 1, -27 },
  { 887, 19, 27, 22, 3, -27 },
  { 952, 17, 27, 22, 2, -27 },
  { 1010, 18, 27, 22, 4, -27 },
  { 1071, 19, 27, 22, 2, -27 },
  { 1136, 16, 27, 22, 4, -27 },
  { 1190, 7, 20, 22, 9, -20 },
  { 1208, 9, 25, 22, 7, -20 },
  { 1237, 17, 16, 22, 3, -20 },
  { 1271, 18, 10, 22, 2, -17 },
  { 1294, 17, 16, 22, 2, -20 },
  { 1328, 14, 27, 22, 6, -27 },
  { 1376, 21, 27, 22, 1, -27 },
  { 1447, 19, 27, 22, 0, -27 },
  { 1512, 19, 27, 22, 2, -27 },
  { 1577, 19, 27, 22, 2, -27 },
  { 1642, 20, 27, 22, 1, -27 },
  { 1710, 20, 27, 22, 2, -27 },
  { 1778, 20, 27, 22, 2, -27 },
  { 1846, 19, 27, 22, 2, -27 },
  { 1911, 21, 27, 22, 1, -27 },
  { 1982, 19, 27, 22, 2, -27 },
  { 2047, 20, 27, 22, 1, -27 },
  { 2115, 21, 27, 22, 2, -27 },
  { 2186, 16, 27, 22, 2, -27 },
  { 2240, 21, 27, 22, 1, -27 },
  { 2311, 21, 27, 22, 1, -27 },
  { 2382, 19, 27, 22, 2, -27 },
  { 2447, 20, 27, 22, 2, -27 },
  { 2515, 19, 32, 22, 2, -27 },
  { 2591, 19, 27, 22, 2, -27 },
  { 2656, 19, 27, 22, 2, -27 },
  { 2721, 19, 27, 22, 4, -27 },
  { 2786, 20, 27, 22, 2, -27 },
  { 2854, 19, 27, 22, 4, -27 },
  { 2919, 21, 27, 22, 3, -27 },
  { 2990, 23, 27, 22, 0, -27 },
  { 3068, 19, 27, 22, 4, -27 },
  { 3133, 20, 27, 22, 1, -27 },
  { 3201, 12, 37, 22, 5, -31 },
  { 3257, 8, 29, 22, 7, -27 },
  { 3286, 12, 37, 22, 5, -31 },
  { 3342, 13, 15, 22, 5, -27 },
  { 3367, 16, 2, 22, 1, 0 },
  { 3371, 5, 5, 22, 11, -28 },
  { 3375, 17, 20, 22, 2, -20 },
  { 3418, 17, 29, 22, 2, -29 },
  { 3480, 17, 20, 22, 3, -20 },
  { 3523, 20, 29, 22, 2, -29 },
  { 3596, 18, 20, 22, 2, -20 },
  { 3641, 19, 29, 22, 4, -29 },
  { 3710, 19, 28, 22, 1, -20 },
  { 3777, 17, 29, 22, 2, -29 },
  { 3839, 16, 27, 22, 2, -27 },
  { 3893, 18, 35, 22, 0, -27 },
  { 3972, 19, 29, 22, 2, -29 },
  { 4041, 16, 29, 22, 2, -29 },
  { 4099, 21, 20, 22, 0, -20 },
  { 4152, 17, 20, 22, 2, -20 },
  { 4195, 18, 20, 22, 2, -20 },
  { 4240, 19, 28, 22, 0, -20 },
  { 4307, 18, 28, 22, 2, -20 },
  { 4370, 16, 20, 22, 5, -20 },
  { 4410, 18, 20, 22, 2, -20 },
  { 4455, 15, 25, 22, 4, -25 },
  { 4502, 17, 20, 22, 3, -20 },
  { 4545, 19, 20, 22, 3, -20 },
  { 4593, 20, 20, 22, 3, -20 },
  { 4643, 20, 20, 22, 1, -20 },
  { 4693, 23, 28, 22, -1, -20 },
  { 4774, 19, 20, 22, 1, -20 },
  { 4822, 15, 37, 22, 6, -30 },
  { 4892, 7, 33, 22, 7, -27 },
  { 4921, 15, 38, 22, 3, -30 },
  { 4993, 20, 7, 22, 1, -15 },
};

const GFXfont RobotoMono_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_LIGHTITALIC38PT7B_H_
