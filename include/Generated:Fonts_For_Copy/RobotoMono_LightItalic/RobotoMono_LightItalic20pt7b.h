#ifndef _ROBOTOMONO_LIGHTITALIC20PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x44, 0x44, 0x00, 0x8C, 0x99, 0x9B, 0x02, 0x20,
  0x22, 0x04, 0x40, 0x44, 0x3F, 0xF0, 0x88, 0x08, 0x80, 0x90, 0x11, 0x0F,
  0xFC, 0x22, 0x02, 0x20, 0x22, 0x04, 0x40, 0x02, 0x00, 0x80, 0xF8, 0x42,
  0x20, 0x48, 0x12, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x02, 0xC0, 0x90,
  0x64, 0x30, 0xF8, 0x08, 0x06, 0x00, 0x78, 0x12, 0x28, 0x8A, 0x24, 0x8A,
  0x1C, 0x80, 0x40, 0x20, 0x13, 0x85, 0x12, 0x45, 0x11, 0x04, 0x81, 0xE0,
  0x1F, 0x04, 0x43, 0x10, 0x84, 0x12, 0x07, 0x01, 0x80, 0xA0, 0x44, 0x61,
  0xA8, 0x2A, 0x0C, 0xC3, 0x1F, 0x20, 0xF0, 0x02, 0x08, 0x20, 0x83, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x30, 0x20, 0x40, 0x80, 0x81,
  0x01, 0x00, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x08,
  0x20, 0x84, 0x10, 0x84, 0x20, 0x80, 0x04, 0x02, 0x11, 0x3F, 0x70, 0xC0,
  0xA0, 0x98, 0xC4, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x25, 0xA8, 0xFE, 0x70, 0x00, 0xC0, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x0C, 0x00, 0x1F, 0x8C, 0x22, 0x05, 0x81, 0x41, 0xD0, 0xF4,
  0x49, 0x22, 0xF0, 0xB8, 0x28, 0x19, 0x04, 0x42, 0x0F, 0x00, 0x1B, 0xE2,
  0x10, 0x88, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x0F, 0x84, 0x32, 0x04, 0x81,
  0x00, 0xC0, 0x20, 0x10, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F,
  0xE0, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x00, 0x40, 0x20, 0xF0, 0x04, 0x00,
  0x80, 0x24, 0x09, 0x02, 0x61, 0x0F, 0x80, 0x00, 0xC0, 0x70, 0x38, 0x0A,
  0x04, 0x82, 0x21, 0x08, 0xC6, 0x61, 0x1F, 0xF8, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x1F, 0x84, 0x30, 0x04, 0x01,
  0x00, 0x48, 0x12, 0x08, 0x86, 0x1F, 0x00, 0x07, 0x0C, 0x04, 0x04, 0x06,
  0x02, 0xF9, 0x84, 0x81, 0xC0, 0xC0, 0x60, 0x68, 0x24, 0x21, 0xE0, 0xFF,
  0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x30, 0x00, 0x0F, 0x84, 0x32, 0x04, 0x81, 0x20, 0xCC,
  0x21, 0xF0, 0xC4, 0x40, 0xB0, 0x28, 0x0B, 0x06, 0x43, 0x0F, 0x80, 0x3E,
  0x30, 0x90, 0x50, 0x38, 0x1C, 0x0A, 0x05, 0x86, 0x7D, 0x01, 0x00, 0x80,
  0x81, 0x87, 0x80, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x04, 0x44, 0x88, 0x00, 0x81, 0x83, 0x0E, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x38, 0x07,
  0x00, 0x60, 0x08, 0x38, 0x71, 0xC0, 0x80, 0x00, 0x3E, 0x42, 0x83, 0x03,
  0x02, 0x06, 0x0C, 0x10, 0x30, 0x20, 0x00, 0x00, 0x40, 0x60, 0x0F, 0x82,
  0x08, 0x81, 0x27, 0x95, 0x13, 0x22, 0x64, 0x95, 0x12, 0xA2, 0x54, 0xD2,
  0x6E, 0x40, 0x0C, 0x20, 0x78, 0x00, 0x01, 0x00, 0xC0, 0x30, 0x14, 0x04,
  0x82, 0x20, 0x88, 0x42, 0x10, 0x8F, 0xE2, 0x09, 0x03, 0x40, 0x60, 0x10,
  0x3F, 0x88, 0x22, 0x04, 0x81, 0x60, 0xD0, 0x67, 0xE1, 0x04, 0x40, 0x90,
  0x2C, 0x0A, 0x06, 0x83, 0x3F, 0x80, 0x1F, 0x8C, 0x32, 0x05, 0x01, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0B, 0x04, 0x43, 0x0F, 0x00,
  0x3F, 0x08, 0x62, 0x0D, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0xF0,
  0x28, 0x1A, 0x04, 0x86, 0x3E, 0x00, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x3F, 0xC0,
  0x3F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x1F, 0xE2, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x1F, 0x8C, 0x32, 0x05,
  0x01, 0x40, 0x10, 0x0C, 0x02, 0x1F, 0x80, 0xA0, 0x28, 0x09, 0x02, 0x41,
  0x8F, 0x80, 0x10, 0x31, 0x02, 0x30, 0x22, 0x02, 0x20, 0x22, 0x02, 0x3F,
  0xC2, 0x04, 0x60, 0x44, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x8C, 0x08, 0x3F,
  0xC1, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x3F, 0xC0, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x48, 0x12, 0x04, 0xC2, 0x1F, 0x00, 0x30,
  0x64, 0x18, 0x86, 0x11, 0x82, 0x60, 0x98, 0x16, 0x03, 0xE0, 0x44, 0x08,
  0xC3, 0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0xFF, 0x30, 0x66, 0x18,
  0xC3, 0x28, 0xA5, 0x14, 0xA4, 0x92, 0xB2, 0x64, 0x4C, 0x91, 0x12, 0x02,
  0x40, 0x48, 0x19, 0x02, 0x00, 0x20, 0x66, 0x09, 0xC1, 0x28, 0x24, 0x84,
  0x91, 0x92, 0x22, 0x24, 0xC4, 0x90, 0xD2, 0x0A, 0x41, 0xC8, 0x31, 0x02,
  0x00, 0x1F, 0x8C, 0x22, 0x05, 0x01, 0x40, 0x50, 0x1C, 0x06, 0x03, 0x80,
  0xA0, 0x28, 0x0B, 0x04, 0x42, 0x0F, 0x00, 0x3F, 0x84, 0x08, 0x81, 0x10,
  0x32, 0x04, 0x40, 0x90, 0x23, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x00, 0x1F, 0x8C, 0x22, 0x05, 0x01, 0x40, 0x70, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x28, 0x0B, 0x04, 0x43, 0x0F, 0x00, 0x20, 0x04, 0x3F,
  0x88, 0x32, 0x04, 0x81, 0x20, 0x58, 0x24, 0x19, 0xF8, 0x42, 0x10, 0x84,
  0x32, 0x04, 0x81, 0x20, 0x60, 0x1F, 0x8C, 0x32, 0x05, 0x81, 0x20, 0x0C,
  0x01, 0xC0, 0x0C, 0x01, 0x80, 0x28, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0xFF,
  0xC3, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x00, 0x20, 0x64, 0x09, 0x81, 0x20, 0x24, 0x04,
  0x81, 0x90, 0x22, 0x04, 0xC0, 0x90, 0x12, 0x06, 0x60, 0x84, 0x30, 0x78,
  0x00, 0x80, 0xF0, 0x24, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21, 0x10, 0x24,
  0x0B, 0x02, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x84, 0x63, 0x18, 0xC6, 0x32,
  0x94, 0xA5, 0x29, 0x5A, 0x94, 0xA5, 0x39, 0x4C, 0x63, 0x18, 0xC6, 0x21,
  0x00, 0x30, 0x31, 0x06, 0x08, 0x40, 0x88, 0x05, 0x80, 0x50, 0x06, 0x00,
  0x60, 0x0F, 0x01, 0x90, 0x11, 0x02, 0x08, 0x60, 0x8C, 0x04, 0xC0, 0xD0,
  0x24, 0x11, 0x8C, 0x22, 0x09, 0x02, 0xC0, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x00, 0x1F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0xFF, 0x00,
  0x1C, 0x43, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x30,
  0x82, 0x0E, 0x00, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x10, 0x1C,
  0x10, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x20,
  0x8E, 0x00, 0x0C, 0x18, 0x50, 0xB2, 0x24, 0x70, 0x80, 0xFF, 0x80, 0xB4,
  0x0E, 0x18, 0xD8, 0x20, 0x10, 0x09, 0xFD, 0x07, 0x02, 0x81, 0x61, 0x9F,
  0x40, 0x30, 0x10, 0x08, 0x04, 0x02, 0xE1, 0x89, 0x82, 0x81, 0x40, 0xA0,
  0x50, 0x38, 0x3C, 0x16, 0x1A, 0xF0, 0x0E, 0x18, 0xC8, 0x28, 0x14, 0x06,
  0x02, 0x01, 0x81, 0x41, 0x21, 0x8F, 0x80, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x0E, 0xCC, 0x62, 0x09, 0x02, 0x40, 0xB0, 0x28, 0x1A, 0x04, 0x41, 0x10,
  0xC3, 0xD0, 0x0E, 0x08, 0x88, 0x28, 0x14, 0x0F, 0xFE, 0x01, 0x00, 0x40,
  0x20, 0x8F, 0x80, 0x07, 0xC3, 0x00, 0x80, 0x60, 0x7F, 0xA4, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x0E, 0xCC,
  0x62, 0x09, 0x02, 0x40, 0xB0, 0x28, 0x1A, 0x04, 0x41, 0x10, 0xC3, 0xD0,
  0x0C, 0x02, 0x21, 0x87, 0xC0, 0x30, 0x10, 0x08, 0x04, 0x02, 0x73, 0xCD,
  0x82, 0x81, 0x40, 0xA0, 0x50, 0x38, 0x38, 0x14, 0x0A, 0x04, 0x02, 0x00,
  0x00, 0x07, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x87, 0xFC, 0x01, 0x80, 0x00, 0x01, 0xF1, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x7C, 0x00, 0x10,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0xC8, 0x62, 0x21, 0x10, 0x58, 0x1E, 0x06,
  0xC1, 0x10, 0xC6, 0x20, 0x88, 0x10, 0x1E, 0x11, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x2C,
  0xCA, 0xE5, 0x88, 0xA1, 0x14, 0x42, 0x88, 0x51, 0x1E, 0x22, 0x84, 0x50,
  0x8A, 0x21, 0x00, 0x27, 0x3C, 0xD8, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x83,
  0x81, 0x40, 0xA0, 0x40, 0x0E, 0x18, 0x98, 0x28, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0xC1, 0x21, 0x8F, 0x00, 0x17, 0x0E, 0x23, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x05, 0x83, 0x40, 0x98, 0x65, 0xE1, 0x00, 0x40, 0x30, 0x08, 0x00,
  0x0E, 0xCC, 0x62, 0x09, 0x02, 0x40, 0xB0, 0x28, 0x1A, 0x04, 0x41, 0x10,
  0xC3, 0xD0, 0x04, 0x02, 0x00, 0x80, 0x20, 0x23, 0x96, 0x4C, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x00, 0x0E, 0x18, 0xC8, 0x2C,
  0x02, 0x00, 0xE0, 0x0C, 0x03, 0xC1, 0xA0, 0x8F, 0x80, 0x08, 0x18, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x1E, 0x20, 0xC8,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x24, 0x19, 0x04, 0x41, 0x10, 0xC3, 0xD0,
  0x80, 0xC0, 0x60, 0x48, 0x64, 0x22, 0x21, 0x10, 0x50, 0x28, 0x18, 0x0C,
  0x00, 0x84, 0x30, 0x85, 0x31, 0x26, 0x24, 0xC8, 0xA9, 0x14, 0xA3, 0x18,
  0x63, 0x08, 0x61, 0x08, 0x00, 0x20, 0x22, 0x08, 0x62, 0x04, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0xD8, 0x11, 0x04, 0x13, 0x03, 0x00, 0x20, 0x32, 0x02,
  0x20, 0x43, 0x04, 0x10, 0x81, 0x18, 0x11, 0x00, 0xA0, 0x0A, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0x00,
  0x01, 0x06, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x60, 0xC0, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x12, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x48, 0x88, 0x80, 0x20, 0x30, 0x20, 0x60, 0xC1, 0x82, 0x04,
  0x08, 0x0C, 0x18, 0x41, 0x82, 0x04, 0x08, 0x10, 0x41, 0x84, 0x00, 0x38,
  0x0D, 0x85, 0x19, 0xE0, 0xE0,
};

const GFXglyph RobotoMono_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 4, 4, 12, 5, -15 },
  { 10, 12, 14, 12, 0, -14 },
  { 31, 10, 18, 12, 1, -16 },
  { 54, 10, 14, 12, 1, -14 },
  { 72, 10, 14, 12, 1, -14 },
  { 90, 1, 4, 12, 6, -15 },
  { 91, 7, 21, 12, 3, -16 },
  { 110, 6, 21, 12, 2, -16 },
  { 126, 9, 8, 12, 2, -14 },
  { 135, 10, 11, 12, 1, -12 },
  { 149, 3, 5, 12, 2, -2 },
  { 151, 7, 1, 12, 2, -7 },
  { 152, 2, 2, 12, 4, -2 },
  { 153, 10, 15, 12, 1, -14 },
  { 172, 10, 14, 12, 1, -14 },
  { 190, 5, 14, 12, 3, -14 },
  { 199, 10, 14, 12, 0, -14 },
  { 217, 10, 14, 12, 0, -14 },
  { 235, 10, 14, 12, 0, -14 },
  { 253, 10, 14, 12, 2, -14 },
  { 271, 9, 14, 12, 1, -14 },
  { 287, 10, 14, 12, 2, -14 },
  { 305, 10, 14, 12, 1, -14 },
  { 323, 9, 14, 12, 2, -14 },
  { 339, 3, 11, 12, 5, -11 },
  { 344, 4, 14, 12, 4, -11 },
  { 351, 9, 9, 12, 2, -11 },
  { 362, 10, 5, 12, 1, -9 },
  { 369, 9, 9, 12, 1, -11 },
  { 380, 8, 14, 12, 3, -14 },
  { 394, 11, 14, 12, 1, -14 },
  { 414, 10, 14, 12, 0, -14 },
  { 432, 10, 14, 12, 1, -14 },
  { 450, 10, 14, 12, 1, -14 },
  { 468, 10, 14, 12, 1, -14 },
  { 486, 10, 14, 12, 1, -14 },
  { 504, 11, 14, 12, 1, -14 },
  { 524, 10, 14, 12, 1, -14 },
  { 542, 12, 14, 12, 0, -14 },
  { 563, 10, 14, 12, 1, -14 },
  { 581, 10, 14, 12, 1, -14 },
  { 599, 11, 14, 12, 1, -14 },
  { 619, 8, 14, 12, 1, -14 },
  { 633, 11, 14, 12, 1, -14 },
  { 653, 11, 14, 12, 1, -14 },
  { 673, 10, 14, 12, 1, -14 },
  { 691, 11, 14, 12, 1, -14 },
  { 711, 10, 16, 12, 1, -14 },
  { 731, 10, 14, 12, 1, -14 },
  { 749, 10, 14, 12, 1, -14 },
  { 767, 10, 14, 12, 2, -14 },
  { 785, 11, 14, 12, 1, -14 },
  { 805, 10, 14, 12, 2, -14 },
  { 823, 10, 14, 12, 2, -14 },
  { 841, 12, 14, 12, 0, -14 },
  { 862, 10, 14, 12, 2, -14 },
  { 880, 11, 14, 12, 0, -14 },
  { 900, 6, 19, 12, 3, -16 },
  { 915, 4, 15, 12, 4, -14 },
  { 923, 6, 19, 12, 3, -16 },
  { 938, 7, 7, 12, 2, -14 },
  { 945, 9, 1, 12, 0, 0 },
  { 947, 2, 3, 12, 6, -15 },
  { 948, 9, 11, 12, 1, -11 },
  { 961, 9, 15, 12, 1, -15 },
  { 978, 9, 11, 12, 1, -11 },
  { 991, 10, 15, 12, 1, -15 },
  { 1010, 9, 11, 12, 1, -11 },
  { 1023, 10, 15, 12, 2, -15 },
  { 1042, 10, 15, 12, 1, -11 },
  { 1061, 9, 15, 12, 1, -15 },
  { 1078, 9, 14, 12, 1, -14 },
  { 1094, 9, 18, 12, 0, -14 },
  { 1115, 10, 15, 12, 1, -15 },
  { 1134, 9, 15, 12, 1, -15 },
  { 1151, 11, 11, 12, 0, -11 },
  { 1167, 9, 11, 12, 1, -11 },
  { 1180, 9, 11, 12, 1, -11 },
  { 1193, 10, 15, 12, 0, -11 },
  { 1212, 10, 15, 12, 1, -11 },
  { 1231, 9, 11, 12, 2, -11 },
  { 1244, 9, 11, 12, 1, -11 },
  { 1257, 8, 13, 12, 2, -13 },
  { 1270, 10, 11, 12, 1, -11 },
  { 1284, 9, 11, 12, 2, -11 },
  { 1297, 11, 11, 12, 1, -11 },
  { 1313, 11, 11, 12, 0, -11 },
  { 1329, 12, 15, 12, 0, -11 },
  { 1352, 11, 11, 12, 0, -11 },
  { 1368, 8, 20, 12, 3, -16 },
  { 1388, 4, 17, 12, 4, -14 },
  { 1397, 7, 20, 12, 2, -16 },
  { 1415, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_LIGHTITALIC20PT7B_H_
