#ifndef _ROBOTOMONO_LIGHTITALIC51PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x6E,
  0x0D, 0xC3, 0xB0, 0x76, 0x0D, 0xC1, 0xB8, 0x37, 0x06, 0xC1, 0xD8, 0x33,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x01,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0xF0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x20, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xC0,
  0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x21, 0x80,
  0x60, 0x38, 0xC0, 0x70, 0x38, 0xE0, 0x38, 0x38, 0x70, 0x1C, 0x18, 0x38,
  0x0C, 0x1C, 0x1C, 0x06, 0x1C, 0x0E, 0x07, 0x0C, 0x03, 0x87, 0x0E, 0x01,
  0xFF, 0x0E, 0x00, 0x7F, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x83,
  0xC0, 0x01, 0x87, 0xF8, 0x01, 0xC7, 0x9E, 0x01, 0xC7, 0x07, 0x01, 0xC3,
  0x81, 0x80, 0xC1, 0x80, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0xE0, 0x30, 0x60,
  0x60, 0x18, 0x70, 0x30, 0x0C, 0x70, 0x18, 0x0E, 0x10, 0x0C, 0x07, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x03,
  0x87, 0x80, 0x71, 0xC0, 0xE0, 0x18, 0xF0, 0x1C, 0x0E, 0x78, 0x07, 0x83,
  0x9C, 0x00, 0xE1, 0xC7, 0x00, 0x3C, 0x73, 0x80, 0x07, 0x3C, 0xE0, 0x00,
  0xEE, 0x38, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0xFC, 0x1E, 0x00, 0xFF, 0x03, 0xE0, 0xF9, 0xE0, 0x7F, 0xFC, 0x38,
  0x07, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCC, 0x67, 0x39, 0xCC,
  0x63, 0x38, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x04, 0x01, 0x80, 0x5C, 0x06, 0x07, 0xFE, 0x38, 0xFD, 0xFE,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x1C, 0x01,
  0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x40, 0x04, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x3C, 0x70,
  0xE1, 0xC3, 0x8E, 0x1C, 0x78, 0xE3, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x67, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0xF3, 0x00, 0x03, 0xEE, 0x00, 0x0F, 0xDC, 0x00, 0x7B, 0xB8,
  0x01, 0xE7, 0x70, 0x07, 0x0E, 0xE0, 0x1C, 0x1F, 0x80, 0xF0, 0x3F, 0x03,
  0xC0, 0x6E, 0x0E, 0x01, 0xDC, 0x38, 0x03, 0xB9, 0xE0, 0x07, 0x77, 0x80,
  0x0E, 0xFC, 0x00, 0x1D, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01,
  0xCC, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x3F, 0x83,
  0xFE, 0x7F, 0x3B, 0xE0, 0xEE, 0x03, 0x20, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x70,
  0x1E, 0x00, 0x78, 0x07, 0xC1, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x87, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01,
  0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x73, 0xFC, 0x00, 0x37, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x7C, 0x03, 0x8F, 0xFC, 0x0E, 0x7F,
  0xF8, 0x37, 0x80, 0xF1, 0xF8, 0x01, 0xE7, 0xC0, 0x03, 0x9E, 0x00, 0x0F,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0xE0,
  0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x7C, 0x0F, 0x00, 0x70, 0x78,
  0x01, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00,
  0x07, 0x9C, 0x00, 0x3E, 0x78, 0x01, 0xF8, 0xF0, 0x1E, 0xC1, 0xFB, 0xF7,
  0x03, 0xFF, 0x1C, 0x07, 0xF0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0xF8, 0x7C, 0x1C, 0x00, 0x00, 0xC0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x1F, 0x03, 0xE3, 0xC0, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x01,
  0xC0, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0xE0, 0x3E, 0x06, 0x06, 0x07, 0xF8, 0x30, 0x70, 0x78, 0xE1, 0x83, 0x07,
  0x03, 0x0C, 0x38, 0x30, 0x30, 0x61, 0x83, 0x01, 0x83, 0x1C, 0x38, 0x0C,
  0x18, 0xC1, 0x80, 0x60, 0xC6, 0x0C, 0x06, 0x06, 0x70, 0xE0, 0x30, 0x33,
  0x06, 0x01, 0x81, 0x98, 0x30, 0x1C, 0x0C, 0xC1, 0x80, 0xC0, 0xC6, 0x1C,
  0x06, 0x06, 0x30, 0xC0, 0x30, 0x33, 0x86, 0x03, 0x83, 0x1C, 0x30, 0x38,
  0x18, 0xE1, 0xC3, 0xC1, 0x87, 0x0E, 0x3B, 0x0C, 0x18, 0x3F, 0x9F, 0xC0,
  0xC1, 0xF8, 0xFC, 0x06, 0x03, 0x00, 0x80, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0x07, 0xE0,
  0x0E, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x38, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x70, 0x0F, 0xC0, 0x1C, 0x00, 0x78, 0x07,
  0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xF7, 0x00, 0x7F, 0xFB,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78, 0x01, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0x1C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x18, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xB0, 0x01, 0xF8,
  0x0D, 0xC0, 0x1D, 0xC0, 0xEE, 0x00, 0xEE, 0x07, 0x70, 0x0E, 0x60, 0x39,
  0x80, 0x77, 0x01, 0xCC, 0x07, 0x38, 0x0C, 0x60, 0x39, 0xC0, 0x63, 0x83,
  0x8E, 0x07, 0x1C, 0x18, 0x70, 0x38, 0xE1, 0xC3, 0x01, 0xC3, 0x1C, 0x38,
  0x0E, 0x18, 0xE1, 0xC0, 0x60, 0xCE, 0x0E, 0x07, 0x07, 0x70, 0x70, 0x38,
  0x3F, 0x03, 0x01, 0xC1, 0xF8, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C,
  0x07, 0xC0, 0x00, 0xE0, 0x3E, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x38, 0x1D,
  0xC0, 0x03, 0x80, 0xEE, 0x00, 0x1C, 0x07, 0x38, 0x00, 0xE0, 0x39, 0xC0,
  0x07, 0x01, 0xCE, 0x00, 0x38, 0x0C, 0x38, 0x01, 0xC0, 0xE1, 0xC0, 0x1C,
  0x07, 0x0E, 0x00, 0xE0, 0x38, 0x38, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x0E,
  0x0E, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x06,
  0x07, 0x01, 0xC0, 0x38, 0x38, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x07, 0x0E,
  0x07, 0x00, 0x38, 0xE0, 0x38, 0x01, 0xC7, 0x01, 0xC0, 0x07, 0x38, 0x0E,
  0x00, 0x39, 0xC0, 0x70, 0x01, 0xCE, 0x03, 0x80, 0x07, 0x70, 0x38, 0x00,
  0x3F, 0x01, 0xC0, 0x01, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3E,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0xC3,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1C, 0x00, 0xFC, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x07, 0xC0,
  0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xE0, 0x78, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x98, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x38, 0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x03, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0x60, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0F,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x1E, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1B, 0x80, 0x78, 0x07,
  0x70, 0x0F, 0x00, 0xEE, 0x01, 0xE0, 0x19, 0xC0, 0x7C, 0x07, 0x38, 0x0F,
  0x80, 0xE7, 0x01, 0xB0, 0x1C, 0xE0, 0x76, 0x03, 0x1C, 0x0E, 0xC0, 0xE3,
  0x81, 0x98, 0x1C, 0x70, 0x73, 0x03, 0x0E, 0x0E, 0x60, 0xE1, 0xC1, 0x8C,
  0x1C, 0x38, 0x71, 0x83, 0x87, 0x0E, 0x30, 0x60, 0xE1, 0x86, 0x1C, 0x1C,
  0x70, 0xC3, 0x83, 0x8E, 0x18, 0x60, 0x71, 0x83, 0x1C, 0x0E, 0x70, 0x63,
  0x81, 0xCE, 0x0C, 0x60, 0x39, 0x81, 0x8C, 0x07, 0x70, 0x3B, 0x80, 0xEE,
  0x07, 0x70, 0x1D, 0x80, 0xEC, 0x03, 0x70, 0x1F, 0x80, 0x6E, 0x03, 0xF0,
  0x0D, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78,
  0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x87, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6E, 0x00,
  0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x18, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70,
  0x70, 0x1C, 0x0C, 0x0E, 0x03, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E,
  0x38, 0x01, 0x9C, 0x00, 0x7F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xE0, 0x1F, 0x83, 0xE0, 0x78, 0x01, 0xE0, 0xE0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xC0, 0x06, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x7C, 0x78, 0x03, 0xF8, 0x7C, 0x1F, 0x70, 0x7F, 0xF8, 0xE0,
  0x7F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x1F, 0xE0, 0x06, 0x7F, 0xF8, 0x0E, 0xF8, 0xFC,
  0x0F, 0xC0, 0x1C, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x06,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x70,
  0x7E, 0x01, 0xF0, 0x7F, 0x87, 0xE0, 0xE7, 0xFF, 0x80, 0xE1, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0x07, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x8E,
  0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x01, 0xFE, 0x1C, 0x01, 0xFF, 0xE7, 0x00, 0xF8, 0x7B,
  0xC0, 0x78, 0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x3F, 0x00, 0x78, 0x3D, 0xC0,
  0x1F, 0xFE, 0x70, 0x01, 0xFE, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x3C, 0x01, 0xE0, 0xF0, 0x01,
  0xC3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x04, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE1, 0xC0, 0x3F, 0xFC, 0xE0, 0x3E, 0x1F, 0x70, 0x3C, 0x03,
  0xF0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x1E, 0x01, 0xF8, 0x07, 0x83, 0xDC, 0x03, 0xFF, 0xCE, 0x00, 0x7F, 0x86,
  0x00, 0x04, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x40, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x06,
  0x3F, 0xFC, 0x0E, 0x78, 0x3C, 0x0E, 0xE0, 0x1E, 0x0F, 0xC0, 0x0E, 0x0F,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0xE0, 0x01, 0xE0,
  0x70, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x18, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x0E, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x87, 0xC0, 0x01, 0xC7, 0x80,
  0x00, 0xC7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x77, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x01,
  0xE0, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x7F,
  0x0F, 0xE0, 0x77, 0xFC, 0xFF, 0x83, 0x71, 0xEE, 0x3C, 0x1E, 0x07, 0xC0,
  0xE1, 0xE0, 0x3C, 0x03, 0x0E, 0x01, 0xE0, 0x1C, 0x70, 0x0E, 0x00, 0xC3,
  0x80, 0x70, 0x06, 0x1C, 0x03, 0x80, 0x70, 0xC0, 0x1C, 0x03, 0x8E, 0x00,
  0xE0, 0x1C, 0x70, 0x06, 0x00, 0xE3, 0x80, 0x70, 0x06, 0x1C, 0x03, 0x80,
  0x30, 0xE0, 0x1C, 0x03, 0x86, 0x00, 0xE0, 0x1C, 0x70, 0x06, 0x00, 0xE3,
  0x80, 0x70, 0x07, 0x1C, 0x03, 0x80, 0x30, 0xE0, 0x1C, 0x01, 0x86, 0x00,
  0xE0, 0x1C, 0x30, 0x07, 0x00, 0xE3, 0x80, 0x30, 0x07, 0x1C, 0x03, 0x80,
  0x38, 0xE0, 0x1C, 0x01, 0x87, 0x00, 0xE0, 0x1C, 0x30, 0x07, 0x00, 0xE0,
  0x06, 0x0F, 0xF0, 0x0E, 0x3F, 0xFC, 0x0E, 0x78, 0x3C, 0x0E, 0xE0, 0x1E,
  0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x38,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0x1E, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xC7, 0xF8, 0x00, 0x67, 0xFF, 0x80, 0x3B, 0xE1, 0xF0, 0x0F, 0xC0,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x1F, 0xC1, 0xF8, 0x0E, 0x7F, 0xF8,
  0x03, 0x87, 0xFC, 0x00, 0xE0, 0x10, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x87, 0x01, 0xFF, 0xE7, 0x03, 0xE0, 0xF7, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x3C, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x3C, 0x03,
  0xF0, 0x1E, 0x0F, 0x70, 0x1F, 0xFE, 0x70, 0x07, 0xF8, 0x60, 0x00, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x07, 0x07, 0xFC, 0x18, 0x7F, 0xF0, 0xE7, 0xFB,
  0x83, 0xBC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x10,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x38, 0x03, 0xF0, 0x7C, 0x1E, 0xE0, 0x7F, 0xF9, 0xC0, 0x7F,
  0xC3, 0x80, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x31, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xF8, 0x03, 0x80,
  0x3B, 0x00, 0x70, 0x07, 0x60, 0x0E, 0x00, 0xCC, 0x03, 0xC0, 0x39, 0x80,
  0x78, 0x07, 0x30, 0x1F, 0x81, 0xC6, 0x03, 0x70, 0x38, 0xC0, 0xEE, 0x06,
  0x1C, 0x1D, 0xC1, 0xC3, 0x83, 0x18, 0x38, 0x70, 0xE3, 0x06, 0x0E, 0x18,
  0x61, 0xC1, 0xC7, 0x0C, 0x30, 0x38, 0xC1, 0x86, 0x07, 0x18, 0x31, 0xC0,
  0xE7, 0x06, 0x30, 0x1C, 0xC0, 0xCE, 0x03, 0xB8, 0x19, 0x80, 0x76, 0x03,
  0x30, 0x0E, 0xC0, 0x6E, 0x01, 0xF0, 0x0D, 0x80, 0x1E, 0x01, 0xB0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0x1F, 0xF8, 0x00, 0x63, 0xC3, 0xC0, 0x06, 0x70,
  0x1E, 0x00, 0xE6, 0x00, 0xF8, 0x1C, 0xE0, 0x03, 0xC7, 0xCE, 0x00, 0x1F,
  0xF8, 0x40, 0x00, 0xFE, 0x00,
};

const GFXglyph RobotoMono_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 10, 36, 30, 10, -36 },
  { 46, 11, 11, 30, 12, -38 },
  { 62, 29, 36, 30, 1, -36 },
  { 193, 25, 47, 30, 3, -42 },
  { 340, 25, 38, 30, 3, -37 },
  { 459, 26, 38, 30, 2, -37 },
  { 583, 5, 11, 30, 14, -38 },
  { 590, 16, 53, 30, 9, -41 },
  { 696, 16, 53, 30, 4, -41 },
  { 802, 22, 22, 30, 6, -36 },
  { 863, 25, 26, 30, 3, -30 },
  { 945, 7, 12, 30, 6, -5 },
  { 956, 18, 3, 30, 6, -18 },
  { 963, 5, 5, 30, 11, -5 },
  { 967, 24, 39, 30, 4, -36 },
  { 1084, 23, 38, 30, 4, -37 },
  { 1194, 14, 36, 30, 8, -36 },
  { 1257, 25, 37, 30, 1, -37 },
  { 1373, 25, 38, 30, 1, -37 },
  { 1492, 25, 36, 30, 1, -36 },
  { 1605, 25, 37, 30, 4, -36 },
  { 1721, 22, 38, 30, 3, -37 },
  { 1826, 23, 36, 30, 6, -36 },
  { 1930, 25, 38, 30, 3, -37 },
  { 2049, 22, 37, 30, 5, -37 },
  { 2151, 9, 27, 30, 12, -27 },
  { 2182, 12, 34, 30, 9, -27 },
  { 2233, 23, 21, 30, 4, -27 },
  { 2294, 24, 13, 30, 3, -23 },
  { 2333, 23, 21, 30, 3, -27 },
  { 2394, 19, 37, 30, 8, -37 },
  { 2482, 29, 36, 30, 1, -36 },
  { 2613, 25, 36, 30, 0, -36 },
  { 2726, 26, 36, 30, 2, -36 },
  { 2843, 25, 38, 30, 3, -37 },
  { 2962, 26, 36, 30, 2, -36 },
  { 3079, 27, 36, 30, 2, -36 },
  { 3201, 28, 36, 30, 2, -36 },
  { 3327, 25, 38, 30, 3, -37 },
  { 3446, 29, 36, 30, 1, -36 },
  { 3577, 27, 36, 30, 2, -36 },
  { 3699, 26, 37, 30, 2, -36 },
  { 3820, 29, 36, 30, 2, -36 },
  { 3951, 21, 36, 30, 3, -36 },
  { 4046, 29, 36, 30, 1, -36 },
  { 4177, 29, 36, 30, 1, -36 },
  { 4308, 25, 38, 30, 3, -37 },
  { 4427, 27, 36, 30, 3, -36 },
  { 4549, 26, 43, 30, 2, -37 },
  { 4689, 26, 36, 30, 2, -36 },
  { 4806, 27, 38, 30, 2, -37 },
  { 4935, 26, 36, 30, 5, -36 },
  { 5052, 27, 37, 30, 3, -36 },
  { 5177, 26, 36, 30, 5, -36 },
  { 5294, 27, 36, 30, 5, -36 },
  { 5416, 31, 36, 30, 0, -36 },
  { 5556, 25, 36, 30, 6, -36 },
  { 5669, 27, 36, 30, 1, -36 },
  { 5791, 16, 49, 30, 7, -41 },
  { 5889, 10, 39, 30, 10, -36 },
  { 5938, 16, 49, 30, 7, -41 },
  { 6036, 18, 19, 30, 6, -36 },
  { 6079, 22, 3, 30, 1, 0 },
  { 6088, 6, 6, 30, 15, -37 },
  { 6093, 23, 28, 30, 3, -27 },
  { 6174, 24, 39, 30, 2, -38 },
  { 6291, 23, 29, 30, 3, -28 },
  { 6375, 26, 39, 30, 3, -38 },
  { 6502, 23, 28, 30, 3, -27 },
  { 6583, 25, 39, 30, 6, -39 },
  { 6705, 25, 39, 30, 2, -28 },
  { 6827, 24, 38, 30, 2, -38 },
  { 6941, 21, 37, 30, 3, -37 },
  { 7039, 24, 48, 30, 0, -37 },
  { 7183, 25, 38, 30, 3, -38 },
  { 7302, 21, 38, 30, 3, -38 },
  { 7402, 29, 27, 30, 0, -27 },
  { 7500, 24, 27, 30, 2, -27 },
  { 7581, 24, 29, 30, 3, -28 },
  { 7668, 26, 37, 30, 0, -27 },
  { 7789, 24, 37, 30, 3, -27 },
  { 7900, 22, 27, 30, 6, -27 },
  { 7975, 23, 28, 30, 3, -27 },
  { 8056, 20, 35, 30, 6, -34 },
  { 8144, 23, 28, 30, 4, -27 },
  { 8225, 25, 27, 30, 4, -27 },
  { 8310, 27, 27, 30, 4, -27 },
  { 8402, 28, 27, 30, 1, -27 },
  { 8497, 31, 38, 30, -1, -27 },
  { 8645, 26, 27, 30, 1, -27 },
  { 8733, 20, 50, 30, 8, -40 },
  { 8858, 9, 44, 30, 10, -36 },
  { 8908, 20, 50, 30, 4, -40 },
  { 9033, 28, 9, 30, 1, -20 },
};

const GFXfont RobotoMono_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_LIGHTITALIC51PT7B_H_
