#ifndef _ROBOTOMONO_LIGHTITALIC54PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x38, 0x39, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x39, 0xC1, 0xC0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x0F,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x87, 0x01, 0xC0, 0x71, 0x80, 0x70,
  0x18, 0x60, 0x1C, 0x0E, 0x18, 0x07, 0x07, 0x0E, 0x01, 0x83, 0x83, 0x80,
  0xE0, 0xE0, 0x60, 0x38, 0x70, 0x1C, 0x1C, 0x38, 0x07, 0x0F, 0x0E, 0x00,
  0xFF, 0x87, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x83, 0xE0, 0x01, 0xC1, 0xFC, 0x00, 0x61, 0xF7, 0x80, 0x38, 0x70, 0x70,
  0x1C, 0x38, 0x1C, 0x06, 0x0C, 0x03, 0x03, 0x87, 0x00, 0xC1, 0xC1, 0xC0,
  0x30, 0xE0, 0x60, 0x1C, 0x38, 0x18, 0x07, 0x1C, 0x06, 0x01, 0xCE, 0x01,
  0x80, 0x60, 0x80, 0x60, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0xF0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x03,
  0xC3, 0xC0, 0x38, 0xF0, 0x38, 0x07, 0x3C, 0x07, 0x80, 0xE7, 0x00, 0x70,
  0x39, 0xE0, 0x07, 0x07, 0x38, 0x00, 0xF0, 0xE7, 0x00, 0x0E, 0x38, 0xE0,
  0x01, 0xEF, 0x3C, 0x00, 0x1F, 0xC7, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x3E,
  0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF8, 0x1E, 0x00, 0xFF, 0x81, 0xF0,
  0x7C, 0x70, 0x1F, 0xFF, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x03, 0x00, 0x00,
  0x39, 0xCE, 0x63, 0x39, 0xCE, 0x63, 0x19, 0xC0, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x0C,
  0x07, 0xFC, 0x38, 0x7F, 0xFE, 0x73, 0xFC, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x77, 0x00, 0x01, 0xE7, 0x00,
  0x07, 0x8E, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x1C, 0x07,
  0x80, 0x3C, 0x07, 0x00, 0x38, 0x04, 0x00, 0x40, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x39, 0xF7, 0xFF, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xF9,
  0xC0, 0x00, 0xFC, 0xE0, 0x01, 0xEE, 0xE0, 0x01, 0xE7, 0x70, 0x01, 0xE3,
  0xB8, 0x01, 0xC3, 0xDC, 0x03, 0xC1, 0xCE, 0x03, 0xC0, 0xE7, 0x03, 0xC0,
  0x77, 0x03, 0x80, 0x3B, 0x87, 0x80, 0x1D, 0xC7, 0x80, 0x1E, 0xE7, 0x80,
  0x0E, 0x77, 0x00, 0x07, 0x3F, 0x00, 0x03, 0x9F, 0x00, 0x01, 0xCF, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x78, 0x03,
  0xE0, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x78, 0x07, 0xF0, 0x3F, 0xE3, 0xF9, 0xDF, 0xC3, 0xBC,
  0x07, 0x60, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E,
  0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x9F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x38, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x3F, 0xC0, 0x1C, 0xFF, 0xF0, 0x39, 0xFF, 0xF8, 0x3B, 0xC0,
  0x7C, 0x3F, 0x00, 0x3C, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x07, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x3C,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x7C,
  0x38, 0x00, 0xFC, 0x3C, 0x01, 0xDC, 0x1F, 0x8F, 0x9C, 0x0F, 0xFF, 0x38,
  0x03, 0xFC, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x03, 0xC3, 0xC0, 0x0F, 0x1C,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x03,
  0x80, 0x70, 0x1C, 0x1C, 0x07, 0xF0, 0x30, 0x60, 0x7F, 0xE0, 0xC3, 0x83,
  0xC1, 0x83, 0x0C, 0x0E, 0x06, 0x0C, 0x70, 0x70, 0x38, 0x31, 0x83, 0x80,
  0xC0, 0xCE, 0x0C, 0x03, 0x03, 0x38, 0x30, 0x0C, 0x0C, 0xC1, 0xC0, 0x70,
  0x33, 0x06, 0x01, 0x80, 0xDC, 0x18, 0x06, 0x06, 0x60, 0xE0, 0x18, 0x19,
  0x83, 0x00, 0xE0, 0x66, 0x0C, 0x03, 0x01, 0x98, 0x30, 0x0C, 0x0C, 0x60,
  0xC0, 0x70, 0x33, 0x83, 0x03, 0xC0, 0xCE, 0x0C, 0x0F, 0x06, 0x38, 0x30,
  0x6C, 0x38, 0x60, 0xF7, 0x31, 0xC1, 0x81, 0xF8, 0xFE, 0x06, 0x07, 0xC1,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x08, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x78,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0x80, 0x3F, 0x80, 0x38, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xE0, 0x70, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x07,
  0x80, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0x80, 0x7E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0x80, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0x38, 0x01, 0xFF, 0xE7, 0x00,
  0x3F, 0xFC, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x3B,
  0xF8, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x03, 0xF0,
  0xF0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0E,
  0xE0, 0x76, 0x00, 0x3B, 0x01, 0xD8, 0x01, 0xDC, 0x07, 0x70, 0x07, 0x70,
  0x39, 0xC0, 0x39, 0xC0, 0xE7, 0x00, 0xE7, 0x03, 0x9C, 0x07, 0x1C, 0x0E,
  0x30, 0x1C, 0x60, 0x38, 0xC0, 0xE3, 0x80, 0xE3, 0x87, 0x8E, 0x07, 0x0E,
  0x1C, 0x38, 0x1C, 0x38, 0xE0, 0xE0, 0x70, 0xE3, 0x83, 0x81, 0xC1, 0x9C,
  0x1C, 0x07, 0x07, 0x70, 0x70, 0x1C, 0x1F, 0x81, 0xC0, 0xE0, 0x7E, 0x07,
  0x03, 0x81, 0xF0, 0x1C, 0x0E, 0x07, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0xE0,
  0x3F, 0x00, 0x03, 0x80, 0xEE, 0x00, 0x0E, 0x07, 0xB8, 0x00, 0x38, 0x1C,
  0xF0, 0x01, 0xE0, 0x71, 0xC0, 0x07, 0x01, 0xC7, 0x00, 0x1C, 0x07, 0x0E,
  0x00, 0x70, 0x1C, 0x38, 0x01, 0xC0, 0xF0, 0xE0, 0x07, 0x03, 0x81, 0xC0,
  0x3C, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x07, 0x01,
  0xC0, 0x1C, 0x1C, 0x07, 0x00, 0x78, 0x70, 0x1C, 0x00, 0xE1, 0xC0, 0x70,
  0x03, 0x87, 0x03, 0x80, 0x07, 0x3C, 0x0E, 0x00, 0x1C, 0xE0, 0x38, 0x00,
  0x73, 0x80, 0xE0, 0x00, 0xEE, 0x03, 0x80, 0x03, 0xB8, 0x0E, 0x00, 0x0E,
  0xE0, 0x70, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0x01, 0xF0,
  0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0x80,
  0x1F, 0x80, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xC0, 0x1F, 0x80, 0x3C, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x3B, 0x80,
  0x38, 0x03, 0x9C, 0x03, 0xC0, 0x1C, 0xE0, 0x1E, 0x00, 0xE6, 0x00, 0xF0,
  0x0E, 0x30, 0x0F, 0x80, 0x71, 0x80, 0x7C, 0x03, 0x8C, 0x03, 0x60, 0x18,
  0x60, 0x3B, 0x01, 0xC3, 0x01, 0xD8, 0x0E, 0x38, 0x0C, 0xC0, 0x71, 0xC0,
  0xE6, 0x07, 0x0E, 0x07, 0x30, 0x38, 0x70, 0x31, 0x81, 0xC3, 0x83, 0x8C,
  0x1C, 0x1C, 0x1C, 0x60, 0xE0, 0xE0, 0xC3, 0x07, 0x07, 0x0E, 0x1C, 0x30,
  0x38, 0x70, 0xE3, 0x81, 0xC3, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0xE0, 0x71,
  0xC1, 0xCE, 0x03, 0x8C, 0x0E, 0x70, 0x1C, 0xE0, 0x73, 0x80, 0xE7, 0x03,
  0x98, 0x07, 0x30, 0x1D, 0xC0, 0x3B, 0x80, 0xEE, 0x01, 0xDC, 0x07, 0x70,
  0x0E, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1E, 0x60,
  0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x0C, 0x0E,
  0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x1F, 0x80, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0x80, 0x0E, 0x3E, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0xFC,
  0x78, 0x03, 0xF8, 0x7E, 0x1F, 0xB8, 0x3F, 0xFE, 0x3C, 0x0F, 0xF8, 0x3C,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x38, 0xFF, 0xE0, 0x1D,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x03, 0x83,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0x83, 0xF0,
  0x07, 0xC1, 0xDF, 0x1F, 0xC0, 0xE7, 0xFF, 0x80, 0xE0, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3F, 0x0F, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0xF0, 0x78, 0x03, 0xFF, 0x8E, 0x00, 0xFF, 0xF9, 0xC0,
  0x3E, 0x03, 0xB8, 0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x03, 0xE0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x07, 0x00,
  0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x87, 0xDC, 0x00, 0xFF, 0xF3, 0x80,
  0x0F, 0xF8, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0xE0, 0x78,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x10, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xC7, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0xE0, 0x0F, 0xFE, 0x38, 0x03, 0xFF, 0xE7, 0x00, 0xF8,
  0x0E, 0xE0, 0x3C, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0x81, 0xC0, 0x01, 0xF0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x1C, 0x00, 0x7C,
  0x03, 0xC0, 0x1F, 0x80, 0x3E, 0x1F, 0x70, 0x03, 0xFF, 0xCE, 0x00, 0x3F,
  0xE1, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x03, 0xF8, 0x01, 0xC3, 0xFF,
  0x00, 0x73, 0xFF, 0xF0, 0x1D, 0xE0, 0x3C, 0x0E, 0xE0, 0x07, 0x83, 0xF0,
  0x00, 0xE0, 0xF8, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x81, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x38, 0x00, 0xF8, 0x0E, 0x00, 0x7C, 0x03, 0x80, 0x3C,
  0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x0F, 0x80, 0x07, 0x07,
  0xC0, 0x01, 0xC3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x1C, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x10, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x0E, 0x3F, 0x03, 0xE0, 0x39, 0xFE, 0x3F, 0xE0, 0xEF, 0xFD,
  0xFF, 0x83, 0xE0, 0xFE, 0x0F, 0x0F, 0x01, 0xF0, 0x1C, 0x38, 0x07, 0x80,
  0x71, 0xE0, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x1C,
  0x70, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x60, 0x06, 0x38,
  0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x03, 0x8E, 0x00,
  0xE0, 0x0E, 0x38, 0x03, 0x80, 0x38, 0xC0, 0x1C, 0x00, 0xC7, 0x00, 0x70,
  0x07, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x01,
  0xC7, 0x00, 0x70, 0x07, 0x18, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xE3,
  0x80, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x38, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x03, 0xF8, 0x03, 0x87, 0xFE, 0x01, 0xCF, 0xFF,
  0x80, 0xCF, 0x01, 0xE0, 0xEE, 0x00, 0x78, 0x7E, 0x00, 0x1C, 0x3E, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x07, 0xC1, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC1, 0xF8, 0x00,
  0x38, 0xFF, 0xC0, 0x07, 0x7F, 0xFE, 0x00, 0xFE, 0x03, 0xC0, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x03, 0xF0, 0x07, 0xC0,
  0x77, 0x87, 0xF0, 0x0E, 0x7F, 0xF8, 0x03, 0xC7, 0xFE, 0x00, 0x70, 0x04,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x03, 0x80, 0xFF, 0xE3, 0x80, 0xFF, 0xF9, 0xC0, 0xF8, 0x0E, 0xE0,
  0xF0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0,
  0x01, 0xF0, 0x70, 0x01, 0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0x83, 0xDC, 0x03,
  0xFF, 0xCE, 0x00, 0xFF, 0x87, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x07, 0x01, 0xFF, 0x07, 0x07, 0xFE, 0x07, 0x1F,
  0xFE, 0x07, 0x3E, 0x02, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0x3E, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC3, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0x70, 0x01,
  0xF8, 0x3C, 0x01, 0xD8, 0x0F, 0x87, 0xDC, 0x03, 0xFF, 0xCE, 0x00, 0xFF,
  0x87, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0,
  0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x0E, 0xE0, 0x1E, 0x00, 0xEE, 0x01, 0xF0,
  0x0C, 0xE0, 0x3F, 0x01, 0xCE, 0x03, 0x70, 0x1C, 0xE0, 0x37, 0x01, 0x8E,
  0x07, 0x70, 0x38, 0xE0, 0x67, 0x03, 0x8E, 0x0E, 0x70, 0x70, 0xE0, 0xE3,
  0x07, 0x0E, 0x0C, 0x30, 0x60, 0xE1, 0xC3, 0x0E, 0x0E, 0x18, 0x30, 0xE0,
  0xE3, 0x83, 0x0C, 0x06, 0x30, 0x31, 0xC0, 0x67, 0x03, 0x18, 0x06, 0x70,
  0x33, 0x80, 0x66, 0x03, 0xB8, 0x06, 0xE0, 0x3B, 0x00, 0x6C, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xC7, 0xFF, 0x00, 0x06, 0x78, 0x7C, 0x00, 0x77, 0x80, 0xF0,
  0x03, 0xB8, 0x03, 0xC0, 0x3B, 0x80, 0x0F, 0x87, 0x9C, 0x00, 0x3F, 0xFC,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 38, 32, 11, -38 },
  { 49, 13, 12, 32, 12, -41 },
  { 69, 31, 38, 32, 1, -38 },
  { 217, 27, 49, 32, 3, -44 },
  { 383, 26, 40, 32, 3, -39 },
  { 513, 27, 40, 32, 2, -39 },
  { 648, 5, 12, 32, 15, -41 },
  { 656, 17, 55, 32, 9, -43 },
  { 773, 17, 55, 32, 5, -43 },
  { 890, 23, 23, 32, 7, -38 },
  { 957, 26, 28, 32, 3, -32 },
  { 1048, 8, 13, 32, 6, -5 },
  { 1061, 19, 3, 32, 6, -19 },
  { 1069, 6, 5, 32, 11, -5 },
  { 1073, 26, 41, 32, 4, -38 },
  { 1207, 25, 40, 32, 4, -39 },
  { 1332, 15, 38, 32, 8, -38 },
  { 1404, 26, 39, 32, 1, -39 },
  { 1531, 27, 40, 32, 1, -39 },
  { 1666, 27, 38, 32, 1, -38 },
  { 1795, 27, 39, 32, 4, -38 },
  { 1927, 24, 40, 32, 3, -39 },
  { 2047, 25, 38, 32, 6, -38 },
  { 2166, 27, 40, 32, 3, -39 },
  { 2301, 24, 39, 32, 5, -39 },
  { 2418, 9, 28, 32, 13, -28 },
  { 2450, 12, 36, 32, 10, -28 },
  { 2504, 24, 23, 32, 4, -29 },
  { 2573, 25, 13, 32, 4, -24 },
  { 2614, 25, 23, 32, 3, -29 },
  { 2686, 21, 39, 32, 8, -39 },
  { 2789, 30, 39, 32, 1, -39 },
  { 2936, 27, 38, 32, 0, -38 },
  { 3065, 28, 38, 32, 2, -38 },
  { 3198, 27, 40, 32, 3, -39 },
  { 3333, 28, 38, 32, 2, -38 },
  { 3466, 29, 38, 32, 2, -38 },
  { 3604, 28, 38, 32, 3, -38 },
  { 3737, 27, 40, 32, 3, -39 },
  { 3872, 30, 38, 32, 1, -38 },
  { 4015, 28, 38, 32, 2, -38 },
  { 4148, 28, 39, 32, 2, -38 },
  { 4285, 31, 38, 32, 2, -38 },
  { 4433, 22, 38, 32, 3, -38 },
  { 4538, 30, 38, 32, 2, -38 },
  { 4681, 30, 38, 32, 1, -38 },
  { 4824, 27, 40, 32, 3, -39 },
  { 4959, 28, 38, 32, 3, -38 },
  { 5092, 27, 46, 32, 3, -39 },
  { 5248, 28, 38, 32, 2, -38 },
  { 5381, 27, 40, 32, 3, -39 },
  { 5516, 27, 38, 32, 6, -38 },
  { 5645, 28, 39, 32, 3, -38 },
  { 5782, 27, 38, 32, 6, -38 },
  { 5911, 29, 38, 32, 5, -38 },
  { 6049, 33, 38, 32, 0, -38 },
  { 6206, 27, 38, 32, 6, -38 },
  { 6335, 29, 38, 32, 1, -38 },
  { 6473, 17, 52, 32, 8, -44 },
  { 6584, 11, 41, 32, 11, -38 },
  { 6641, 17, 52, 32, 7, -44 },
  { 6752, 18, 20, 32, 7, -38 },
  { 6797, 23, 3, 32, 1, 0 },
  { 6806, 7, 8, 32, 15, -40 },
  { 6813, 24, 30, 32, 3, -29 },
  { 6903, 25, 42, 32, 2, -41 },
  { 7035, 24, 30, 32, 4, -29 },
  { 7125, 27, 42, 32, 4, -41 },
  { 7267, 25, 30, 32, 3, -29 },
  { 7361, 27, 41, 32, 6, -41 },
  { 7500, 27, 40, 32, 2, -29 },
  { 7635, 26, 41, 32, 2, -41 },
  { 7769, 23, 39, 32, 3, -39 },
  { 7882, 25, 51, 32, 0, -39 },
  { 8042, 26, 41, 32, 3, -41 },
  { 8176, 23, 41, 32, 3, -41 },
  { 8294, 30, 29, 32, 0, -29 },
  { 8403, 25, 29, 32, 2, -29 },
  { 8494, 25, 30, 32, 3, -29 },
  { 8588, 27, 40, 32, 0, -29 },
  { 8723, 25, 40, 32, 4, -29 },
  { 8848, 24, 29, 32, 6, -29 },
  { 8935, 24, 30, 32, 4, -29 },
  { 9025, 22, 37, 32, 6, -36 },
  { 9127, 25, 30, 32, 4, -29 },
  { 9221, 26, 29, 32, 5, -29 },
  { 9316, 28, 29, 32, 4, -29 },
  { 9418, 29, 29, 32, 1, -29 },
  { 9524, 33, 41, 32, -1, -29 },
  { 9694, 28, 29, 32, 1, -29 },
  { 9796, 21, 53, 32, 8, -42 },
  { 9936, 10, 47, 32, 11, -38 },
  { 9995, 21, 53, 32, 5, -42 },
  { 10135, 29, 10, 32, 1, -21 },
};

const GFXfont RobotoMono_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic54pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_LIGHTITALIC54PT7B_H_
