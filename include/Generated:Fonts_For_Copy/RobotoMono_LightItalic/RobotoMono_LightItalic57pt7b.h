#ifndef _ROBOTOMONO_LIGHTITALIC57PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x70, 0x00, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x60,
  0x73, 0x03, 0x38, 0x19, 0xC1, 0xCE, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x7C, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x00, 0xE0, 0x08, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0xE0,
  0x38, 0x70, 0x0E, 0x07, 0x06, 0x00, 0xE0, 0x70, 0x60, 0x0C, 0x0E, 0x06,
  0x01, 0xC1, 0xC0, 0x60, 0x1C, 0x1C, 0x07, 0x01, 0x83, 0x80, 0x70, 0x38,
  0x70, 0x03, 0x8F, 0x0E, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0xFC, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x3F,
  0x80, 0x07, 0x07, 0xFC, 0x00, 0x70, 0xE0, 0xE0, 0x0E, 0x1C, 0x06, 0x01,
  0xC1, 0xC0, 0x70, 0x1C, 0x38, 0x07, 0x03, 0x83, 0x80, 0x70, 0x70, 0x38,
  0x07, 0x06, 0x03, 0x00, 0x70, 0xE0, 0x30, 0x06, 0x1C, 0x03, 0x00, 0xE1,
  0x80, 0x30, 0x0E, 0x08, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x77,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x01,
  0xF0, 0xF0, 0x07, 0x0F, 0x03, 0x80, 0x38, 0xF0, 0x1E, 0x03, 0x8F, 0x00,
  0x70, 0x1C, 0x70, 0x03, 0xC0, 0xE7, 0x80, 0x0F, 0x0E, 0x38, 0x00, 0x38,
  0x71, 0xC0, 0x01, 0xE7, 0x8E, 0x00, 0x07, 0x78, 0x70, 0x00, 0x3F, 0x83,
  0x80, 0x00, 0xFC, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0xF8, 0x1E, 0x00, 0x7F, 0xC0, 0x7E, 0x1F, 0x8F, 0x01, 0xFF, 0xF8,
  0x38, 0x03, 0xFF, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x39, 0xCE, 0x77,
  0x39, 0xCE, 0x73, 0x39, 0xCE, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x60, 0x0C,
  0x03, 0x3C, 0x0E, 0x07, 0xFF, 0xC7, 0x1F, 0xE7, 0xFB, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x10, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x38, 0x78,
  0xF0, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0xCE, 0x00, 0x07, 0xF9, 0xC0, 0x01,
  0xEE, 0x38, 0x00, 0x79, 0xCF, 0x00, 0x3E, 0x39, 0xE0, 0x0F, 0x07, 0x38,
  0x03, 0xC0, 0xE7, 0x00, 0xF0, 0x3C, 0xE0, 0x3C, 0x07, 0x9C, 0x1E, 0x00,
  0xE7, 0x87, 0x80, 0x1C, 0xF1, 0xE0, 0x03, 0x9C, 0x78, 0x00, 0x73, 0xBC,
  0x00, 0x1E, 0x7F, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0xFF, 0x07, 0xFE, 0x1F, 0xEE, 0x7F, 0x0E, 0x7C, 0x0E, 0x60, 0x0E, 0x80,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3E,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x0E, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0C, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x38, 0x7F, 0xE0, 0x1C, 0xFF, 0xF8, 0x1E, 0xFC, 0x7E, 0x0E, 0xF0,
  0x07, 0x87, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x39, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x3F, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x78,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0xEE, 0x3C, 0x01, 0xFE,
  0x3F, 0x0F, 0xDC, 0x1F, 0xFF, 0x1C, 0x07, 0xFE, 0x3C, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x3E, 0x1F, 0x0F, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xE0, 0x3E, 0x1E, 0x00,
  0x78, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0xFE, 0x07, 0x07, 0x01, 0xFF, 0x07,
  0x07, 0x07, 0xC7, 0x87, 0x0E, 0x07, 0x03, 0x03, 0x0C, 0x0E, 0x03, 0x03,
  0x1C, 0x1C, 0x03, 0x03, 0x18, 0x1C, 0x06, 0x03, 0x18, 0x38, 0x06, 0x07,
  0x38, 0x38, 0x06, 0x07, 0x30, 0x30, 0x0E, 0x06, 0x30, 0x70, 0x0C, 0x06,
  0x70, 0x70, 0x0C, 0x06, 0x70, 0x60, 0x0C, 0x06, 0x60, 0x60, 0x1C, 0x0E,
  0x60, 0xE0, 0x18, 0x0C, 0x60, 0xE0, 0x18, 0x0C, 0x60, 0xE0, 0x38, 0x0C,
  0x60, 0xE0, 0x78, 0x18, 0x60, 0xE0, 0x78, 0x18, 0x60, 0xE0, 0xD8, 0x30,
  0x60, 0xE1, 0x98, 0x70, 0x60, 0x7F, 0x9F, 0xE0, 0x60, 0x7E, 0x0F, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0x80, 0x3F, 0x80, 0x1C, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70,
  0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0x9E, 0x00, 0x7F, 0xFC, 0xE0,
  0x03, 0xFF, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x1D, 0xFE, 0x00,
  0x00, 0x1F, 0xEE, 0x00, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x1F, 0x87, 0x80,
  0x00, 0x3F, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xB8, 0x00, 0xFE, 0x07, 0x70, 0x01, 0xDC, 0x0E,
  0xE0, 0x07, 0x38, 0x1C, 0xC0, 0x0E, 0x70, 0x39, 0xC0, 0x39, 0xE0, 0x73,
  0x80, 0x73, 0x81, 0xC7, 0x01, 0xC7, 0x03, 0x8E, 0x07, 0x8E, 0x07, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x3C, 0x38, 0x1C, 0x38, 0x70, 0xE0, 0x38, 0x71,
  0xE1, 0xC0, 0xE0, 0xE3, 0x83, 0x81, 0xC1, 0xCE, 0x07, 0x03, 0x81, 0x9C,
  0x0E, 0x07, 0x03, 0xF0, 0x3C, 0x0E, 0x07, 0xE0, 0x70, 0x3C, 0x0F, 0x80,
  0xE0, 0x70, 0x1F, 0x01, 0xC0, 0xE0, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0x07,
  0x03, 0x80, 0x60, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x1E, 0x03,
  0xBC, 0x00, 0x1E, 0x03, 0x9C, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x1C, 0x03,
  0x9E, 0x00, 0x1C, 0x07, 0x8E, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x3C, 0x07,
  0x0F, 0x00, 0x3C, 0x07, 0x07, 0x00, 0x38, 0x07, 0x07, 0x00, 0x38, 0x07,
  0x07, 0x80, 0x38, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1E,
  0x00, 0xE0, 0x70, 0x1E, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0xF0, 0xF0, 0x1C,
  0x00, 0x70, 0xF0, 0x1C, 0x00, 0x70, 0xE0, 0x1C, 0x00, 0x78, 0xE0, 0x3C,
  0x00, 0x38, 0xE0, 0x3C, 0x00, 0x38, 0xE0, 0x38, 0x00, 0x3D, 0xE0, 0x38,
  0x00, 0x1D, 0xC0, 0x38, 0x00, 0x1D, 0xC0, 0x38, 0x00, 0x0F, 0xC0, 0x78,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x1E, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0xE0,
  0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E,
  0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x1E, 0xE0, 0x07, 0x00, 0x39, 0xC0,
  0x0E, 0x00, 0x73, 0x80, 0x3C, 0x00, 0xE7, 0x00, 0x78, 0x03, 0x8E, 0x00,
  0xF0, 0x07, 0x1C, 0x03, 0xE0, 0x0E, 0x38, 0x07, 0xC0, 0x3C, 0x70, 0x0D,
  0x80, 0x70, 0xE0, 0x3B, 0x00, 0xE1, 0xC0, 0x76, 0x01, 0xC3, 0x80, 0xCC,
  0x07, 0x07, 0x03, 0x9C, 0x0E, 0x0E, 0x07, 0x38, 0x1C, 0x1C, 0x0C, 0x70,
  0x70, 0x38, 0x38, 0xE0, 0xE0, 0x70, 0x71, 0xC1, 0xC0, 0xE0, 0xC3, 0x83,
  0x81, 0xC3, 0x87, 0x0E, 0x03, 0x87, 0x0E, 0x1C, 0x07, 0x0C, 0x1C, 0x38,
  0x0E, 0x38, 0x38, 0xE0, 0x1C, 0x70, 0x71, 0xC0, 0x39, 0xC0, 0xE3, 0x80,
  0x73, 0x81, 0xC7, 0x00, 0xC7, 0x03, 0x9C, 0x01, 0x9C, 0x07, 0x38, 0x07,
  0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1D, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x3B,
  0x80, 0x77, 0x00, 0x77, 0x00, 0xEC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x30,
  0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0x1C, 0x1E, 0x00, 0xE1, 0xC0,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x07, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x07,
  0x07, 0xC0, 0x01, 0xC3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0xE1, 0xE0, 0x0F, 0xB8,
  0x3F, 0x9F, 0xDE, 0x07, 0xFF, 0xC7, 0x80, 0xFF, 0xC1, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x1F, 0xF8,
  0x01, 0xE7, 0xFF, 0xC0, 0x39, 0xF0, 0xF8, 0x07, 0x70, 0x07, 0x80, 0xFC,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x0F,
  0x83, 0xB8, 0x03, 0xE0, 0x73, 0xE7, 0xF8, 0x0E, 0x3F, 0xFC, 0x03, 0xC3,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0xFE, 0x1C, 0x01,
  0xFF, 0xF3, 0xC0, 0x3F, 0x0F, 0xBC, 0x07, 0xC0, 0x1F, 0xC0, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0xFC, 0x03, 0xC0, 0x3D, 0xC0, 0x3F, 0x9F, 0xB8, 0x01, 0xFF, 0xF3,
  0x80, 0x07, 0xFC, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x3E, 0x00,
  0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x06, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF,
  0x87, 0x00, 0x7F, 0xFC, 0x70, 0x0F, 0xC3, 0xEF, 0x01, 0xF0, 0x07, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x01,
  0xF0, 0x1E, 0x00, 0x3F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xE7, 0xEE, 0x00,
  0x7F, 0xFC, 0xE0, 0x01, 0xFF, 0x0E, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x40, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x07, 0xFC,
  0x01, 0xC3, 0xFF, 0xC0, 0x39, 0xF8, 0x7C, 0x07, 0x78, 0x03, 0xC0, 0xEC,
  0x00, 0x38, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x0E,
  0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0x00, 0xF0,
  0x03, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0x00, 0x0E, 0x03, 0xE0,
  0x00, 0xE0, 0x7C, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1C,
  0x7C, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x1D, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0x9C, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x70, 0x07, 0x3F, 0xC3, 0xFC, 0x0E,
  0xFF, 0xC7, 0xFE, 0x0E, 0xE3, 0xEF, 0x1E, 0x0F, 0x81, 0xFC, 0x0F, 0x0F,
  0x00, 0xF8, 0x07, 0x0E, 0x00, 0xF0, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0x1E,
  0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x0E, 0x1C,
  0x01, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x38,
  0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x1E, 0x38, 0x01, 0xC0, 0x1C, 0x38,
  0x03, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x70,
  0x03, 0x80, 0x1C, 0x70, 0x03, 0x80, 0x3C, 0x70, 0x03, 0x80, 0x38, 0x70,
  0x07, 0x80, 0x38, 0x70, 0x07, 0x00, 0x38, 0xF0, 0x07, 0x00, 0x38, 0xE0,
  0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x78, 0xE0, 0x07, 0x00, 0x70, 0xE0,
  0x0F, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x80, 0x70, 0x00, 0xE0,
  0xFF, 0xC0, 0x1C, 0x3F, 0xFC, 0x03, 0x9F, 0x87, 0xC0, 0x77, 0x80, 0x3C,
  0x0F, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x78, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x7C, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x1F, 0xF8, 0x00,
  0x71, 0xFF, 0xE0, 0x03, 0xBF, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0xF8,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3C, 0x07, 0xE0, 0x03, 0xC0, 0x3B, 0x80, 0x3E, 0x01, 0xDF, 0x8F,
  0xE0, 0x0E, 0x7F, 0xFC, 0x00, 0x70, 0xFF, 0xC0, 0x07, 0x80, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x70, 0x1F,
  0xFF, 0x1C, 0x0F, 0xC3, 0xEF, 0x07, 0xC0, 0x1F, 0xC3, 0xC0, 0x03, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x3C, 0x1C, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC0, 0xF0, 0x07, 0xF0, 0x3F,
  0x0F, 0xB8, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xC3, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x03, 0xFF, 0x07, 0x0F, 0xFF, 0x07, 0x3F, 0xFF,
  0x0F, 0x7C, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC1, 0xF0, 0x01, 0xF0, 0x3F, 0x87, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC7,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x1E, 0x00, 0x3F, 0x03, 0xC0,
  0x3D, 0xC0, 0xFC, 0x7E, 0x70, 0x1F, 0xFF, 0x38, 0x03, 0xFF, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xB8, 0x03, 0xC0, 0x0E,
  0xE0, 0x0F, 0x80, 0x73, 0x80, 0x3E, 0x01, 0xCE, 0x01, 0xF8, 0x07, 0x38,
  0x06, 0xE0, 0x38, 0xE0, 0x3B, 0x80, 0xE3, 0x80, 0xEE, 0x03, 0x8E, 0x07,
  0x38, 0x1C, 0x18, 0x1C, 0xE0, 0x70, 0x60, 0x61, 0x83, 0x81, 0x83, 0x86,
  0x0E, 0x06, 0x0E, 0x18, 0x38, 0x18, 0x70, 0x61, 0xC0, 0x61, 0xC1, 0x87,
  0x01, 0x86, 0x06, 0x18, 0x07, 0x38, 0x1C, 0xE0, 0x1C, 0xC0, 0x73, 0x80,
  0x77, 0x01, 0xCC, 0x01, 0xDC, 0x07, 0x70, 0x07, 0x60, 0x1D, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x7F, 0xF8,
  0x00, 0x39, 0xF0, 0xF8, 0x00, 0x73, 0x80, 0x78, 0x01, 0xCE, 0x00, 0x78,
  0x07, 0x9C, 0x00, 0x7C, 0x1E, 0x70, 0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph RobotoMono_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 11, 41, 33, 11, -41 },
  { 58, 13, 13, 33, 13, -43 },
  { 80, 33, 41, 33, 1, -41 },
  { 250, 27, 53, 33, 4, -47 },
  { 429, 28, 42, 33, 3, -41 },
  { 576, 29, 42, 33, 2, -41 },
  { 729, 5, 13, 33, 16, -43 },
  { 738, 17, 58, 33, 10, -45 },
  { 862, 18, 58, 33, 5, -45 },
  { 993, 25, 25, 33, 7, -41 },
  { 1072, 28, 30, 33, 3, -34 },
  { 1177, 8, 13, 33, 6, -5 },
  { 1190, 21, 3, 33, 6, -20 },
  { 1198, 6, 5, 33, 12, -5 },
  { 1202, 27, 44, 33, 4, -41 },
  { 1351, 27, 42, 33, 4, -41 },
  { 1493, 16, 41, 33, 8, -41 },
  { 1575, 28, 41, 33, 1, -41 },
  { 1719, 28, 42, 33, 1, -41 },
  { 1866, 29, 41, 33, 1, -41 },
  { 2015, 28, 42, 33, 5, -41 },
  { 2162, 25, 42, 33, 3, -41 },
  { 2294, 27, 41, 33, 6, -41 },
  { 2433, 28, 42, 33, 3, -41 },
  { 2580, 24, 41, 33, 6, -41 },
  { 2703, 9, 29, 33, 14, -29 },
  { 2736, 13, 37, 33, 10, -29 },
  { 2797, 25, 24, 33, 5, -30 },
  { 2872, 26, 15, 33, 4, -26 },
  { 2921, 26, 24, 33, 3, -30 },
  { 2999, 22, 41, 33, 8, -41 },
  { 3112, 32, 41, 33, 1, -41 },
  { 3276, 28, 41, 33, 0, -41 },
  { 3420, 29, 41, 33, 2, -41 },
  { 3569, 29, 42, 33, 3, -41 },
  { 3722, 30, 41, 33, 2, -41 },
  { 3876, 30, 41, 33, 3, -41 },
  { 4030, 30, 41, 33, 3, -41 },
  { 4184, 29, 42, 33, 3, -41 },
  { 4337, 32, 41, 33, 1, -41 },
  { 4501, 30, 41, 33, 2, -41 },
  { 4655, 30, 42, 33, 2, -41 },
  { 4813, 32, 41, 33, 3, -41 },
  { 4977, 24, 41, 33, 3, -41 },
  { 5100, 31, 41, 33, 2, -41 },
  { 5259, 32, 41, 33, 1, -41 },
  { 5423, 28, 42, 33, 3, -41 },
  { 5570, 30, 41, 33, 3, -41 },
  { 5724, 29, 48, 33, 3, -41 },
  { 5898, 29, 41, 33, 3, -41 },
  { 6047, 29, 42, 33, 3, -41 },
  { 6200, 29, 41, 33, 6, -41 },
  { 6349, 30, 42, 33, 3, -41 },
  { 6507, 28, 41, 33, 6, -41 },
  { 6651, 31, 41, 33, 5, -41 },
  { 6810, 35, 41, 33, 0, -41 },
  { 6990, 29, 41, 33, 6, -41 },
  { 7139, 31, 41, 33, 1, -41 },
  { 7298, 18, 55, 33, 8, -46 },
  { 7422, 12, 44, 33, 11, -41 },
  { 7488, 18, 55, 33, 8, -46 },
  { 7612, 20, 22, 33, 7, -41 },
  { 7667, 25, 3, 33, 1, 0 },
  { 7677, 8, 8, 33, 16, -42 },
  { 7685, 26, 32, 33, 3, -31 },
  { 7789, 27, 44, 33, 2, -43 },
  { 7938, 25, 32, 33, 4, -31 },
  { 8038, 28, 44, 33, 4, -43 },
  { 8192, 27, 32, 33, 3, -31 },
  { 8300, 28, 44, 33, 7, -44 },
  { 8454, 28, 43, 33, 2, -31 },
  { 8605, 27, 43, 33, 2, -43 },
  { 8751, 24, 41, 33, 3, -41 },
  { 8874, 26, 53, 33, 0, -41 },
  { 9047, 28, 43, 33, 3, -43 },
  { 9198, 24, 43, 33, 3, -43 },
  { 9327, 32, 31, 33, 0, -31 },
  { 9451, 27, 31, 33, 2, -31 },
  { 9556, 27, 32, 33, 3, -31 },
  { 9664, 29, 43, 33, 0, -31 },
  { 9820, 26, 43, 33, 4, -31 },
  { 9960, 24, 31, 33, 7, -31 },
  { 10053, 26, 32, 33, 4, -31 },
  { 10157, 23, 39, 33, 6, -38 },
  { 10270, 26, 31, 33, 4, -30 },
  { 10371, 27, 30, 33, 5, -30 },
  { 10473, 30, 30, 33, 4, -30 },
  { 10586, 31, 30, 33, 1, -30 },
  { 10703, 34, 42, 33, -1, -30 },
  { 10882, 29, 30, 33, 1, -30 },
  { 10991, 22, 56, 33, 9, -45 },
  { 11145, 11, 50, 33, 11, -41 },
  { 11214, 22, 55, 33, 5, -44 },
  { 11366, 31, 10, 33, 1, -22 },
};

const GFXfont RobotoMono_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic57pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_LIGHTITALIC57PT7B_H_
