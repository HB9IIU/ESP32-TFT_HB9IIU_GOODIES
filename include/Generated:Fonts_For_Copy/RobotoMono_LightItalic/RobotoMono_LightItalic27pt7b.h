#ifndef _ROBOTOMONO_LIGHTITALIC27PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x88, 0x42, 0x20, 0x00, 0x03,
  0x30, 0x45, 0x14, 0x53, 0xCA, 0x20, 0x00, 0xC2, 0x00, 0x86, 0x00, 0x84,
  0x01, 0x8C, 0x01, 0x08, 0x1F, 0xFF, 0x1F, 0xFF, 0x02, 0x10, 0x06, 0x10,
  0x04, 0x30, 0x04, 0x20, 0x0C, 0x20, 0x7F, 0xFC, 0xFF, 0xFC, 0x18, 0x40,
  0x10, 0xC0, 0x10, 0x80, 0x31, 0x80, 0x21, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x0F, 0xC1, 0xC3, 0x08, 0x08, 0xC0, 0x66, 0x03, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x04, 0x80, 0x24,
  0x01, 0x30, 0x19, 0x80, 0xC6, 0x1C, 0x1F, 0x80, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x7C, 0x06, 0x20, 0x21, 0x0D, 0x08, 0x48, 0x44, 0x42, 0x62, 0x22,
  0x0F, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x13, 0xE1, 0x91, 0x09, 0x8C,
  0x88, 0x6C, 0x42, 0x42, 0x10, 0x19, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0xC6, 0x03, 0x08, 0x08, 0x20, 0x61, 0x80, 0x84, 0x02, 0x60, 0x0F, 0x00,
  0x18, 0x01, 0xE0, 0x0C, 0xC3, 0x61, 0x09, 0x86, 0x2C, 0x09, 0xB0, 0x34,
  0xC0, 0x73, 0x01, 0x86, 0x1F, 0x0F, 0xC6, 0xFE, 0xA0, 0x01, 0x03, 0x06,
  0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x00, 0x03, 0x00, 0x20,
  0x02, 0x04, 0x21, 0xF2, 0xF1, 0xFC, 0x06, 0x00, 0xB0, 0x19, 0x03, 0x18,
  0x60, 0xC0, 0x08, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x32, 0x26, 0x48, 0xFF, 0xC0, 0xF0, 0x00, 0x18, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0xC1, 0x8C, 0x0C,
  0x40, 0x26, 0x01, 0x30, 0x1D, 0x01, 0xC8, 0x1A, 0xC3, 0x16, 0x31, 0xB3,
  0x0D, 0xB0, 0x6E, 0x02, 0x60, 0x12, 0x01, 0x98, 0x08, 0xC0, 0xC3, 0x0C,
  0x0F, 0xC0, 0x06, 0x3F, 0xDE, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x07, 0xF0, 0x30, 0x61, 0x81,
  0x84, 0x02, 0x30, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0xE1, 0x84, 0x04, 0x60, 0x32,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x7C, 0x00, 0x38, 0x00,
  0x40, 0x03, 0x00, 0x12, 0x00, 0x90, 0x0C, 0xC0, 0x43, 0x0E, 0x0F, 0xC0,
  0x00, 0x30, 0x03, 0x80, 0x3C, 0x01, 0x60, 0x13, 0x01, 0x90, 0x18, 0x81,
  0x8C, 0x18, 0x60, 0x83, 0x0C, 0x10, 0xC0, 0x8C, 0x04, 0x7F, 0xFC, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x0F, 0xFC, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xF0, 0x38, 0xE0, 0x81,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xCC, 0x02, 0x30, 0x18, 0x40,
  0xC1, 0x86, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0xC2, 0xFE, 0xF0, 0xDC, 0x0F, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1E, 0x02, 0xC0, 0xCC, 0x30, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x00, 0x07, 0xE0, 0xE1, 0x84, 0x06, 0x60, 0x32, 0x01, 0x90,
  0x0C, 0xC0, 0xC6, 0x0C, 0x1F, 0xC0, 0xFC, 0x0C, 0x18, 0xC0, 0x4C, 0x03,
  0x40, 0x1A, 0x00, 0xD0, 0x0C, 0xC0, 0x63, 0x0E, 0x0F, 0xC0, 0x1F, 0x86,
  0x19, 0x81, 0xA0, 0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x78, 0x1F,
  0x07, 0xBF, 0xA1, 0xCC, 0x01, 0x00, 0x60, 0x18, 0x06, 0x07, 0x83, 0xC0,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x70, 0x1C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x20, 0x86, 0x18, 0xC2, 0x00,
  0x00, 0x30, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x0C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x30, 0x00, 0x3F, 0x9C,
  0x34, 0x0F, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x03, 0xF0,
  0x0C, 0x10, 0x60, 0x10, 0x80, 0x22, 0x3E, 0x4C, 0xC4, 0xD1, 0x09, 0xA6,
  0x22, 0x88, 0x45, 0x10, 0x8A, 0x61, 0x14, 0xC4, 0x29, 0x98, 0x93, 0x73,
  0x23, 0x9C, 0x40, 0x00, 0x40, 0x00, 0xC1, 0x00, 0x7E, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x03, 0x40, 0x1A, 0x01, 0x90, 0x0C, 0xC0, 0xC6, 0x06,
  0x30, 0x20, 0x83, 0x04, 0x10, 0x21, 0xFF, 0x0F, 0xFC, 0xC0, 0x64, 0x03,
  0x60, 0x0A, 0x00, 0x70, 0x02, 0x1F, 0xE0, 0x60, 0xE1, 0x80, 0x84, 0x03,
  0x10, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x0C, 0x3F, 0xE0, 0xFF, 0x82, 0x03,
  0x18, 0x04, 0x60, 0x19, 0x80, 0x64, 0x01, 0x90, 0x0C, 0x40, 0x63, 0x07,
  0x8F, 0xF8, 0x00, 0x0F, 0xE0, 0xC1, 0x8C, 0x04, 0x40, 0x36, 0x01, 0xA0,
  0x0F, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x1A, 0x00, 0x98, 0x0C, 0xC0, 0xC3, 0x0C, 0x0F, 0xC0, 0x1F, 0xC0,
  0x41, 0xC1, 0x01, 0x84, 0x02, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03,
  0x20, 0x0C, 0x80, 0x36, 0x00, 0x98, 0x02, 0x60, 0x19, 0x00, 0x64, 0x03,
  0x30, 0x18, 0xC0, 0xC3, 0x1E, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xF0,
  0xFF, 0xC2, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0xE0, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x38, 0x61, 0x80, 0x84,
  0x03, 0x30, 0x0C, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x1F, 0xB0, 0x06, 0xC0, 0x19, 0x00, 0x64, 0x01, 0x18, 0x04, 0x60, 0x30,
  0xC1, 0x81, 0xFC, 0x00, 0x10, 0x06, 0x20, 0x08, 0x40, 0x11, 0x80, 0x23,
  0x00, 0xC4, 0x01, 0x88, 0x03, 0x10, 0x04, 0x7F, 0xF8, 0xFF, 0xF1, 0x80,
  0x62, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31,
  0x00, 0x62, 0x00, 0x80, 0x1F, 0xFC, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x0F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xCC, 0x02, 0x30, 0x18, 0x40, 0xC1, 0x86, 0x03, 0xF0, 0x00,
  0x18, 0x07, 0x18, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x10, 0x60, 0x10, 0xC0,
  0x31, 0x80, 0x33, 0x00, 0x36, 0x00, 0x2F, 0x00, 0x3B, 0x00, 0x71, 0x80,
  0x61, 0x80, 0x60, 0xC0, 0x60, 0x40, 0x40, 0x60, 0x40, 0x20, 0xC0, 0x30,
  0xC0, 0x18, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xF0, 0x18, 0x0E, 0x30, 0x1C, 0x70,
  0x71, 0xE0, 0xA3, 0xC3, 0x46, 0x85, 0x89, 0x1B, 0x12, 0x26, 0x26, 0xC8,
  0xCD, 0x11, 0x8E, 0x63, 0x18, 0xC4, 0x21, 0x88, 0x02, 0x10, 0x04, 0x60,
  0x08, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC0, 0x18, 0x06, 0x30, 0x08, 0x60,
  0x11, 0xE0, 0x63, 0x40, 0xC6, 0xC1, 0x89, 0x82, 0x11, 0x04, 0x23, 0x08,
  0xC6, 0x31, 0x84, 0x63, 0x0C, 0xC4, 0x09, 0x08, 0x12, 0x30, 0x34, 0x60,
  0x38, 0xC0, 0x71, 0x80, 0xE2, 0x00, 0x80, 0x0F, 0xE0, 0xE3, 0x0C, 0x0C,
  0x40, 0x26, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xA0,
  0x05, 0x00, 0x68, 0x03, 0x40, 0x12, 0x01, 0x98, 0x08, 0xC0, 0xC3, 0x1C,
  0x0F, 0xC0, 0x0F, 0xF0, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x21, 0x00, 0x62,
  0x00, 0x84, 0x01, 0x18, 0x06, 0x30, 0x18, 0x60, 0xE0, 0xFF, 0x81, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0x84, 0x03, 0x30, 0x0C, 0x80,
  0x36, 0x00, 0x58, 0x03, 0x40, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0,
  0x1B, 0x00, 0x64, 0x01, 0x10, 0x0C, 0x60, 0x60, 0xC3, 0x01, 0xF8, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0xE0, 0x60, 0xE1, 0x80, 0x84, 0x03,
  0x10, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x30, 0x83, 0x83, 0xFC,
  0x08, 0x30, 0x60, 0xC1, 0x81, 0x06, 0x06, 0x10, 0x18, 0x40, 0x23, 0x00,
  0xCC, 0x03, 0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x03, 0x30, 0x0C,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x6C, 0x01, 0x90, 0x04, 0x60, 0x30, 0xC3, 0x81, 0xFC,
  0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x00, 0x20,
  0x0C, 0x80, 0x22, 0x00, 0x98, 0x02, 0x60, 0x19, 0x00, 0x64, 0x01, 0x90,
  0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x88,
  0x06, 0x20, 0x18, 0xC0, 0xC1, 0x8E, 0x03, 0xF0, 0x00, 0xC0, 0x1E, 0x00,
  0xB0, 0x0D, 0x80, 0x64, 0x06, 0x20, 0x31, 0x01, 0x0C, 0x18, 0x60, 0x83,
  0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x1B, 0x00, 0xD0, 0x07, 0x80, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x41, 0x86, 0x83, 0x09, 0x0E, 0x12, 0x1C, 0x64,
  0x38, 0x88, 0xF1, 0x11, 0x66, 0x22, 0xCC, 0x4D, 0x90, 0x93, 0x21, 0x26,
  0xC2, 0xC5, 0x05, 0x0A, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x60, 0x60, 0xC0,
  0xC1, 0x83, 0x02, 0x00, 0x18, 0x03, 0x0C, 0x06, 0x04, 0x0C, 0x06, 0x0C,
  0x06, 0x18, 0x02, 0x30, 0x03, 0x20, 0x01, 0x60, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x18, 0x30,
  0x30, 0x10, 0x60, 0x18, 0xC0, 0x0C, 0xC0, 0x1E, 0x01, 0x90, 0x0C, 0xC0,
  0xC6, 0x0C, 0x10, 0x60, 0xC6, 0x06, 0x20, 0x13, 0x00, 0xF0, 0x07, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x0F, 0xFE, 0x20, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x13, 0xFF,
  0xC0, 0x0F, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0xC8, 0xF0, 0xC1, 0x04, 0x10, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x04,
  0x10, 0x41, 0x86, 0x08, 0x20, 0x83, 0x0C, 0x0F, 0x13, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0xF0, 0x03, 0x01, 0xC0,
  0x50, 0x34, 0x09, 0x04, 0x63, 0x18, 0x82, 0x60, 0xB0, 0x30, 0xFF, 0xE0,
  0xD9, 0x90, 0x01, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x23, 0x01, 0x80, 0x08,
  0x00, 0x43, 0xFE, 0x30, 0x33, 0x01, 0x90, 0x0D, 0x80, 0x44, 0x06, 0x30,
  0xD0, 0xFC, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x40, 0x5F, 0x87, 0x86, 0x30, 0x11, 0x80, 0xC8, 0x06, 0x40, 0x36, 0x01,
  0xB0, 0x09, 0x80, 0x4C, 0x06, 0x40, 0x23, 0x03, 0x3C, 0x31, 0xBF, 0x00,
  0x02, 0x00, 0xFC, 0x38, 0x62, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x06, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x01, 0x08, 0x7E, 0x46, 0x0E,
  0x60, 0x33, 0x01, 0xB0, 0x09, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01, 0x90,
  0x0C, 0xC0, 0x46, 0x06, 0x18, 0xD0, 0x7D, 0x80, 0x02, 0x00, 0xFC, 0x38,
  0x62, 0x02, 0x60, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x66, 0x1C, 0x3F, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x1F, 0xFC, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x46, 0x0E, 0x60,
  0x33, 0x01, 0xB0, 0x09, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01, 0x90, 0x0C,
  0xC0, 0x46, 0x06, 0x18, 0xD0, 0x7D, 0x80, 0x0C, 0x00, 0x44, 0x06, 0x30,
  0x60, 0xFE, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x40, 0xCF, 0xC7, 0x86, 0x38, 0x19, 0x80, 0xC8, 0x06, 0x40,
  0x36, 0x01, 0x30, 0x09, 0x80, 0xC8, 0x06, 0x40, 0x32, 0x01, 0xB0, 0x09,
  0x80, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x1F, 0xC0, 0xF0, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x11, 0x01,
  0x84, 0x1C, 0x30, 0xC0, 0xC6, 0x03, 0x30, 0x09, 0x80, 0x3E, 0x00, 0xCC,
  0x06, 0x30, 0x18, 0x60, 0x60, 0x81, 0x03, 0x04, 0x06, 0x30, 0x0C, 0x0F,
  0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x08, 0x7F, 0x7C, 0xC7, 0x19, 0x04,
  0x12, 0x08, 0x2C, 0x30, 0xD8, 0x61, 0xB0, 0xC3, 0x41, 0x04, 0x82, 0x09,
  0x04, 0x16, 0x18, 0x6C, 0x30, 0xD0, 0x41, 0x20, 0x82, 0x00, 0x00, 0x81,
  0xBF, 0x0F, 0x0C, 0x70, 0x33, 0x01, 0x90, 0x0C, 0x80, 0x4C, 0x02, 0x60,
  0x13, 0x01, 0x90, 0x0C, 0x80, 0x64, 0x02, 0x60, 0x13, 0x01, 0x80, 0x01,
  0x00, 0x7F, 0x06, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x0D, 0x00, 0x68, 0x03,
  0xC0, 0x1E, 0x00, 0xD0, 0x04, 0x80, 0x66, 0x06, 0x18, 0x60, 0x7E, 0x00,
  0x00, 0xC0, 0x6F, 0xC1, 0xE1, 0x86, 0x02, 0x18, 0x0C, 0x40, 0x31, 0x00,
  0xCC, 0x03, 0x30, 0x08, 0xC0, 0x22, 0x01, 0x88, 0x04, 0x30, 0x31, 0xE3,
  0x86, 0xFC, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x02,
  0x01, 0xF9, 0x30, 0x76, 0x03, 0x60, 0x3C, 0x02, 0xC0, 0x2C, 0x02, 0x80,
  0x68, 0x06, 0x80, 0x6C, 0x04, 0xC0, 0xC6, 0x34, 0x3E, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x00, 0x41, 0x3F, 0x36, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xFC, 0x30, 0x62, 0x03, 0x60, 0x36,
  0x00, 0x30, 0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x68, 0x06, 0xC0, 0x66,
  0x1C, 0x3F, 0x80, 0x04, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFE, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0xF0, 0x60, 0x16, 0x01, 0x60, 0x36, 0x03, 0x40, 0x34,
  0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0x63, 0x43,
  0xEC, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0xC0, 0x42, 0x06, 0x10, 0x60, 0xC3,
  0x06, 0x30, 0x11, 0x00, 0x98, 0x06, 0x80, 0x3C, 0x00, 0xC0, 0x06, 0x00,
  0x83, 0x0E, 0x0C, 0x38, 0x70, 0xA1, 0x46, 0x85, 0x12, 0x24, 0x4C, 0x93,
  0x36, 0x48, 0xD1, 0x23, 0xC5, 0x0E, 0x14, 0x38, 0x70, 0xC1, 0x83, 0x06,
  0x00, 0x18, 0x06, 0x18, 0x18, 0x10, 0x60, 0x31, 0x80, 0x26, 0x00, 0x78,
  0x00, 0x60, 0x01, 0xC0, 0x06, 0xC0, 0x18, 0x80, 0x31, 0x80, 0xC1, 0x83,
  0x03, 0x1C, 0x03, 0x00, 0x30, 0x03, 0x10, 0x06, 0x18, 0x0C, 0x18, 0x0C,
  0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x60, 0x04, 0x60, 0x04, 0xC0,
  0x06, 0x80, 0x07, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0x60, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x0F,
  0x01, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x08, 0x42, 0x31, 0x88, 0x42,
  0x11, 0x8C, 0x42, 0x10, 0x84, 0x63, 0x10, 0x84, 0x23, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x0E, 0x01, 0xC0, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x3E, 0x02,
  0xC6, 0x0D, 0x07, 0x16, 0x07, 0xE0,
};

const GFXglyph RobotoMono_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 5, -19 },
  { 13, 6, 6, 16, 6, -20 },
  { 18, 16, 19, 16, 0, -19 },
  { 56, 13, 25, 16, 2, -22 },
  { 97, 13, 19, 16, 2, -19 },
  { 128, 14, 20, 16, 1, -20 },
  { 163, 2, 6, 16, 8, -20 },
  { 165, 8, 28, 16, 5, -22 },
  { 193, 9, 28, 16, 2, -22 },
  { 225, 12, 12, 16, 3, -19 },
  { 243, 13, 14, 16, 2, -16 },
  { 266, 4, 6, 16, 3, -2 },
  { 269, 10, 1, 16, 3, -9 },
  { 271, 2, 2, 16, 6, -2 },
  { 272, 13, 21, 16, 2, -19 },
  { 307, 13, 19, 16, 2, -19 },
  { 338, 7, 19, 16, 4, -19 },
  { 355, 14, 19, 16, 0, -19 },
  { 389, 13, 19, 16, 1, -19 },
  { 420, 13, 19, 16, 1, -19 },
  { 451, 14, 19, 16, 2, -19 },
  { 485, 11, 19, 16, 2, -19 },
  { 512, 13, 19, 16, 3, -19 },
  { 543, 13, 19, 16, 2, -19 },
  { 574, 11, 19, 16, 3, -19 },
  { 601, 5, 14, 16, 6, -14 },
  { 610, 6, 18, 16, 5, -14 },
  { 624, 12, 11, 16, 2, -14 },
  { 641, 12, 7, 16, 2, -12 },
  { 652, 13, 11, 16, 1, -14 },
  { 670, 10, 19, 16, 4, -19 },
  { 694, 15, 19, 16, 1, -19 },
  { 730, 13, 19, 16, 0, -19 },
  { 761, 14, 19, 16, 1, -19 },
  { 795, 13, 19, 16, 2, -19 },
  { 826, 14, 19, 16, 1, -19 },
  { 860, 14, 19, 16, 1, -19 },
  { 894, 15, 19, 16, 1, -19 },
  { 930, 14, 19, 16, 1, -19 },
  { 964, 15, 19, 16, 1, -19 },
  { 1000, 14, 19, 16, 1, -19 },
  { 1034, 14, 19, 16, 1, -19 },
  { 1068, 16, 19, 16, 1, -19 },
  { 1106, 12, 19, 16, 1, -19 },
  { 1135, 15, 19, 16, 1, -19 },
  { 1171, 15, 19, 16, 1, -19 },
  { 1207, 13, 19, 16, 2, -19 },
  { 1238, 15, 19, 16, 1, -19 },
  { 1274, 14, 22, 16, 1, -19 },
  { 1313, 14, 19, 16, 1, -19 },
  { 1347, 14, 19, 16, 1, -19 },
  { 1381, 14, 19, 16, 3, -19 },
  { 1415, 14, 19, 16, 2, -19 },
  { 1449, 13, 19, 16, 3, -19 },
  { 1480, 15, 19, 16, 2, -19 },
  { 1516, 16, 19, 16, 0, -19 },
  { 1554, 13, 19, 16, 3, -19 },
  { 1585, 15, 19, 16, 0, -19 },
  { 1621, 8, 26, 16, 4, -22 },
  { 1647, 6, 21, 16, 5, -19 },
  { 1663, 8, 26, 16, 4, -22 },
  { 1689, 10, 10, 16, 3, -19 },
  { 1702, 11, 1, 16, 1, 0 },
  { 1704, 3, 4, 16, 8, -20 },
  { 1706, 13, 15, 16, 1, -15 },
  { 1731, 13, 20, 16, 1, -20 },
  { 1764, 12, 15, 16, 2, -15 },
  { 1787, 13, 20, 16, 2, -20 },
  { 1820, 12, 15, 16, 2, -15 },
  { 1843, 13, 21, 16, 3, -21 },
  { 1878, 13, 21, 16, 1, -15 },
  { 1913, 13, 20, 16, 1, -20 },
  { 1946, 12, 19, 16, 1, -19 },
  { 1975, 13, 25, 16, 0, -19 },
  { 2016, 14, 20, 16, 1, -20 },
  { 2051, 12, 20, 16, 1, -20 },
  { 2081, 15, 15, 16, 0, -15 },
  { 2110, 13, 15, 16, 1, -15 },
  { 2135, 13, 15, 16, 1, -15 },
  { 2160, 14, 20, 16, 0, -15 },
  { 2195, 12, 20, 16, 2, -15 },
  { 2225, 12, 15, 16, 3, -15 },
  { 2248, 12, 15, 16, 2, -15 },
  { 2271, 11, 18, 16, 3, -18 },
  { 2296, 12, 14, 16, 2, -14 },
  { 2317, 13, 14, 16, 2, -14 },
  { 2340, 14, 14, 16, 2, -14 },
  { 2365, 15, 14, 16, 0, -14 },
  { 2392, 16, 20, 16, 0, -14 },
  { 2432, 13, 14, 16, 1, -14 },
  { 2455, 11, 26, 16, 4, -21 },
  { 2491, 5, 23, 16, 5, -19 },
  { 2506, 11, 26, 16, 2, -21 },
  { 2542, 15, 4, 16, 0, -10 },
};

const GFXfont RobotoMono_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_LIGHTITALIC27PT7B_H_
