#ifndef _ROBOTOMONO_LIGHTITALIC48PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xF0, 0xE0, 0x30,
  0xEE, 0x1D, 0xC3, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0x37, 0x0E, 0xC1, 0x98,
  0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C,
  0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xC1,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x18, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0xE0, 0x7C, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0x83, 0x00, 0x07, 0x07, 0x00, 0x0C, 0x06, 0x03,
  0x38, 0x0C, 0x0E, 0x70, 0x18, 0x18, 0xC0, 0x70, 0x61, 0x80, 0xE1, 0xC3,
  0x01, 0x83, 0x06, 0x03, 0x0C, 0x0E, 0x0C, 0x38, 0x0E, 0x78, 0xE0, 0x0F,
  0xE1, 0x80, 0x0F, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x18, 0x7F, 0x00, 0x71,
  0xC7, 0x01, 0xC7, 0x07, 0x03, 0x0C, 0x06, 0x0C, 0x18, 0x0C, 0x38, 0x70,
  0x18, 0x60, 0xC0, 0x31, 0x81, 0x80, 0xE7, 0x03, 0x01, 0x8C, 0x06, 0x03,
  0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x83, 0xC0, 0x03, 0x87, 0x80, 0x01, 0xCF, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xB8, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x1C, 0x07, 0x3C, 0x1C, 0x07, 0x38, 0x0E, 0x06,
  0x70, 0x07, 0x0E, 0x70, 0x07, 0x0E, 0xE0, 0x03, 0x9C, 0xE0, 0x03, 0x9C,
  0xE0, 0x01, 0xF8, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0xF0, 0x70, 0x01, 0xF0,
  0x70, 0x03, 0xF8, 0x3C, 0x0F, 0xB8, 0x1F, 0xFE, 0x1C, 0x0F, 0xF8, 0x1E,
  0x76, 0x66, 0x6E, 0xEC, 0xCC, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02,
  0x00, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x00, 0xC0, 0x5E, 0x06, 0x1F, 0xFE, 0x73, 0xF9, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xDC, 0x00, 0x1C, 0x60,
  0x01, 0xC3, 0x80, 0x1E, 0x0E, 0x01, 0xE0, 0x70, 0x1E, 0x01, 0xC0, 0x60,
  0x0E, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C,
  0x71, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x60, 0x00, 0x79, 0xC0, 0x01, 0xF3, 0x80, 0x07, 0xE7,
  0x00, 0x1D, 0xCC, 0x00, 0xF3, 0x98, 0x03, 0x86, 0x70, 0x0E, 0x1C, 0xE0,
  0x38, 0x39, 0xC1, 0xE0, 0x73, 0x87, 0x00, 0xE6, 0x1C, 0x01, 0xCC, 0x70,
  0x03, 0x3B, 0xC0, 0x0E, 0x7E, 0x00, 0x1C, 0xF8, 0x00, 0x39, 0xE0, 0x00,
  0x63, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F,
  0xF7, 0xF3, 0xFC, 0x1B, 0x81, 0xD0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0x03, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x07, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x01,
  0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x8F, 0xF0, 0x1D, 0xFF, 0xE0, 0xDE,
  0x0F, 0x8F, 0xC0, 0x1C, 0x7C, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x0D,
  0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0xC1, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0xF0,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x0E, 0x01, 0xC0, 0x78, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80,
  0xF0, 0x3C, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0x70, 0x01, 0xE7, 0x00, 0x36, 0x38, 0x0E, 0xE3, 0xFF, 0xCE, 0x0F,
  0xF8, 0xC0, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE1, 0xF0, 0x78,
  0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0xF0,
  0x03, 0x9C, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x1C, 0x00, 0x78, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30,
  0x3F, 0x06, 0x0E, 0x0F, 0xF8, 0x61, 0x83, 0x86, 0x0C, 0x60, 0xE0, 0xC1,
  0x8C, 0x18, 0x18, 0x33, 0x06, 0x03, 0x06, 0x60, 0xC0, 0x40, 0xCC, 0x30,
  0x18, 0x13, 0x06, 0x03, 0x06, 0x60, 0xC0, 0x60, 0xCC, 0x30, 0x18, 0x19,
  0x86, 0x03, 0x03, 0x30, 0xC0, 0x60, 0x4C, 0x18, 0x1C, 0x19, 0x83, 0x03,
  0x03, 0x30, 0x60, 0xE0, 0xC6, 0x0C, 0x3C, 0x18, 0xC1, 0xCC, 0xC6, 0x0C,
  0x3F, 0x1F, 0x81, 0x83, 0xC1, 0xE0, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x00, 0xF0, 0x1C, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0xFC, 0x07, 0x00, 0x1E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x18, 0x00, 0x78, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x60, 0x01, 0xE0, 0xE0, 0x1F, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x01, 0xC0, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x0E,
  0x07, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x06, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0xE0,
  0x0F, 0xFC, 0xC0, 0x10, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x1E,
  0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x38, 0x00, 0x3C, 0x03,
  0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x07, 0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x06, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0xC3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x1D, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x9C, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x78, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1D,
  0x81, 0xF8, 0x03, 0xF0, 0x3B, 0x00, 0xEE, 0x06, 0x60, 0x1D, 0xC0, 0xCC,
  0x07, 0x30, 0x39, 0xC0, 0xC6, 0x07, 0x38, 0x38, 0xC0, 0xE3, 0x06, 0x38,
  0x1C, 0x61, 0xC7, 0x03, 0x0C, 0x30, 0xE0, 0x61, 0x8E, 0x18, 0x1C, 0x3B,
  0x83, 0x03, 0x87, 0x70, 0xE0, 0x70, 0x7C, 0x1C, 0x0E, 0x0F, 0x83, 0x81,
  0x81, 0xE0, 0x70, 0x30, 0x3C, 0x0C, 0x0E, 0x07, 0x01, 0x81, 0xC0, 0xC0,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0xE0, 0x7C, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0x81, 0xF8, 0x00, 0x70, 0x3B,
  0x80, 0x0C, 0x06, 0x70, 0x01, 0x81, 0xC6, 0x00, 0x70, 0x38, 0xE0, 0x0E,
  0x07, 0x1C, 0x01, 0xC0, 0xE1, 0x80, 0x38, 0x1C, 0x38, 0x06, 0x03, 0x07,
  0x01, 0xC0, 0xE0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x1C, 0x0E, 0x03, 0x83, 0x01, 0x80, 0x70, 0xE0, 0x70, 0x07,
  0x1C, 0x0E, 0x00, 0xE3, 0x81, 0xC0, 0x1C, 0x70, 0x38, 0x01, 0xCE, 0x06,
  0x00, 0x39, 0x80, 0xC0, 0x03, 0x70, 0x38, 0x00, 0x7E, 0x07, 0x00, 0x0F,
  0xC0, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x03, 0x00, 0x03, 0xC0, 0x60,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB0, 0x00, 0x07,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x3E, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0x03, 0xE0,
  0x0E, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x18, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x30, 0x00, 0x78, 0x0C, 0x00, 0x3C, 0x07, 0x00, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x3E, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x87, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x38, 0x00,
  0x01, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0x07, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x1F, 0x00,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x30, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x1C, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3E,
  0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xE0, 0x78, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x86, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x78, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x18,
  0x03, 0x80, 0x18, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xDC,
  0x03, 0x80, 0x67, 0x01, 0xE0, 0x19, 0xC0, 0x78, 0x0E, 0x70, 0x1E, 0x03,
  0x9C, 0x0F, 0x80, 0xC6, 0x03, 0x60, 0x71, 0x80, 0xD8, 0x1C, 0x60, 0x76,
  0x06, 0x18, 0x19, 0x81, 0x86, 0x06, 0x60, 0xE1, 0x83, 0x98, 0x38, 0x60,
  0xC6, 0x0C, 0x18, 0x31, 0x87, 0x06, 0x1C, 0x61, 0xC1, 0x86, 0x18, 0x60,
  0x61, 0x86, 0x18, 0x18, 0xE1, 0x8E, 0x06, 0x30, 0x63, 0x01, 0x8C, 0x18,
  0xC0, 0x67, 0x06, 0x70, 0x19, 0x81, 0x9C, 0x06, 0x60, 0x66, 0x01, 0xB8,
  0x19, 0x80, 0x6C, 0x06, 0xE0, 0x1B, 0x01, 0xB0, 0x07, 0xC0, 0x6C, 0x01,
  0xE0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xE0, 0x06,
  0x70, 0x07, 0x18, 0x07, 0x0C, 0x03, 0x87, 0x03, 0x83, 0x81, 0x80, 0xC1,
  0xC0, 0x60, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0x70, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xC7, 0x0E, 0x18, 0x70,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xE0, 0x1E, 0x07,
  0x00, 0x3C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xC0, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0,
  0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0xF1, 0xC0, 0x07,
  0xC7, 0x00, 0x3F, 0x0F, 0x07, 0xDC, 0x3F, 0xFC, 0x70, 0x3F, 0xE1, 0xC0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0xF8, 0x03, 0x8F, 0xF8, 0x0E, 0xFF, 0xF0,
  0x3F, 0x01, 0xE0, 0xF8, 0x03, 0x83, 0xC0, 0x07, 0x1E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1E, 0x00, 0x38, 0x7C, 0x01, 0xC1, 0xBC, 0x1F, 0x0E, 0x7F, 0xF0,
  0x38, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0,
  0x01, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x3C, 0x07, 0x83, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x3C, 0x0C, 0x01, 0xFF, 0x9C, 0x03, 0xFF, 0xDC,
  0x07, 0x80, 0xFC, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x60, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x38, 0x07, 0xE0,
  0x3C, 0x1E, 0xC0, 0x1F, 0xFC, 0xC0, 0x0F, 0xF1, 0xC0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x70, 0x78,
  0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x07, 0x30, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0x83, 0x80, 0x1E,
  0x07, 0x81, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x8C, 0x07, 0xFF, 0xB8, 0x1E, 0x03, 0xF0, 0x70,
  0x03, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x01,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x1E, 0x07, 0x00, 0xFC, 0x0F, 0x07, 0xB0, 0x0F, 0xFE, 0x60, 0x0F,
  0xF1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x10, 0x00, 0xE0, 0x60, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF8, 0x7C,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x7C, 0x03, 0x8F, 0xFC, 0x0E, 0x7F, 0xF8, 0x33, 0x80, 0xE0, 0xD8, 0x01,
  0xC3, 0xC0, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x60,
  0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x08, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01,
  0x07, 0x00, 0x1E, 0x06, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0,
  0x0E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0C, 0x0F, 0x00, 0x0C, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x30, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xF0,
  0xE0, 0x00, 0x78, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x0F,
  0x01, 0x9F, 0xC7, 0xF8, 0x37, 0xFD, 0xFF, 0x0F, 0x83, 0xE0, 0x71, 0xE0,
  0x78, 0x0E, 0x38, 0x07, 0x01, 0xC7, 0x00, 0xC0, 0x38, 0xC0, 0x38, 0x07,
  0x18, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x18, 0xE0, 0x1C, 0x03, 0x1C, 0x03,
  0x00, 0xE3, 0x80, 0x60, 0x1C, 0x60, 0x1C, 0x03, 0x8C, 0x03, 0x80, 0x63,
  0x80, 0x70, 0x0C, 0x70, 0x0C, 0x01, 0x8E, 0x01, 0x80, 0x71, 0xC0, 0x30,
  0x0E, 0x30, 0x0E, 0x01, 0xC6, 0x01, 0xC0, 0x31, 0xC0, 0x38, 0x06, 0x38,
  0x06, 0x00, 0xC7, 0x00, 0xC0, 0x38, 0xC0, 0x18, 0x07, 0x18, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x38, 0xFF, 0xC0, 0xE7, 0xFF, 0x83, 0x38, 0x0E,
  0x0D, 0x80, 0x1C, 0x7C, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x31, 0xC0,
  0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03,
  0xC0, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x60,
  0x00, 0x1C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0F, 0x03, 0xE0, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x9F,
  0xF8, 0x03, 0xBF, 0xFC, 0x03, 0x70, 0x1E, 0x03, 0xE0, 0x0E, 0x03, 0x80,
  0x0F, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x1F, 0x00, 0x70, 0x3B, 0x81, 0xE0, 0x39, 0xFF, 0xC0, 0x38, 0xFF,
  0x80, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE,
  0x30, 0x3F, 0xFD, 0xC1, 0xE0, 0x3F, 0x0E, 0x00, 0x7C, 0x70, 0x00, 0xF1,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x38,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x3E, 0x0F, 0x03,
  0xB0, 0x1F, 0xFC, 0xC0, 0x3F, 0xE7, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xF0, 0xE1, 0xFF, 0x0C, 0x7F, 0xF0, 0xCF, 0x00, 0x1D, 0xC0, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xE0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x71, 0xC0, 0x03, 0xC7, 0x80, 0x1E, 0x0F, 0x01, 0xF0, 0x1F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x17,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0xC3, 0xC0, 0x3F, 0x07, 0x83, 0xDC, 0x0F, 0xFE, 0x60, 0x1F,
  0xE1, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x86, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x01, 0xF8, 0x07, 0x00, 0x66,
  0x01, 0xC0, 0x39, 0x80, 0xF0, 0x0C, 0x60, 0x3C, 0x07, 0x18, 0x0F, 0x01,
  0xC6, 0x06, 0xE0, 0x61, 0x81, 0xB8, 0x38, 0x60, 0xEE, 0x0C, 0x18, 0x31,
  0x83, 0x06, 0x0C, 0x61, 0xC1, 0x86, 0x18, 0x60, 0x61, 0x86, 0x38, 0x18,
  0xE1, 0x8C, 0x06, 0x30, 0x63, 0x01, 0x9C, 0x19, 0xC0, 0x66, 0x06, 0x60,
  0x19, 0x81, 0x98, 0x06, 0xC0, 0x6E, 0x01, 0xB0, 0x1B, 0x00, 0x7C, 0x06,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x33, 0xFF, 0x00, 0x0C, 0xE1, 0xE0, 0x07, 0x70, 0x1E,
  0x01, 0x98, 0x03, 0xC0, 0xEE, 0x00, 0x7D, 0xF3, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 11, 10, 28, 11, -36 },
  { 49, 28, 34, 28, 1, -34 },
  { 168, 23, 44, 28, 3, -39 },
  { 295, 23, 36, 28, 3, -35 },
  { 399, 24, 35, 28, 2, -35 },
  { 504, 4, 10, 28, 14, -36 },
  { 509, 15, 49, 28, 8, -38 },
  { 601, 15, 49, 28, 4, -38 },
  { 693, 21, 21, 28, 6, -34 },
  { 749, 23, 25, 28, 3, -28 },
  { 821, 7, 11, 28, 5, -4 },
  { 831, 18, 2, 28, 5, -16 },
  { 836, 5, 4, 28, 10, -4 },
  { 839, 23, 37, 28, 3, -34 },
  { 946, 23, 36, 28, 3, -35 },
  { 1050, 13, 34, 28, 7, -34 },
  { 1106, 23, 35, 28, 1, -35 },
  { 1207, 24, 36, 28, 1, -35 },
  { 1315, 24, 34, 28, 1, -34 },
  { 1417, 24, 35, 28, 4, -34 },
  { 1522, 21, 35, 28, 3, -34 },
  { 1614, 23, 34, 28, 5, -34 },
  { 1712, 23, 36, 28, 3, -35 },
  { 1816, 20, 35, 28, 5, -35 },
  { 1904, 9, 25, 28, 11, -25 },
  { 1933, 11, 32, 28, 9, -25 },
  { 1977, 21, 20, 28, 4, -25 },
  { 2030, 23, 13, 28, 3, -22 },
  { 2068, 22, 20, 28, 3, -25 },
  { 2123, 19, 35, 28, 7, -35 },
  { 2207, 27, 34, 28, 1, -34 },
  { 2322, 24, 34, 28, 0, -34 },
  { 2424, 24, 34, 28, 2, -34 },
  { 2526, 24, 36, 28, 3, -35 },
  { 2634, 25, 34, 28, 2, -34 },
  { 2741, 26, 34, 28, 2, -34 },
  { 2852, 26, 34, 28, 2, -34 },
  { 2963, 24, 36, 28, 3, -35 },
  { 3071, 27, 34, 28, 1, -34 },
  { 3186, 25, 34, 28, 2, -34 },
  { 3293, 25, 34, 28, 2, -34 },
  { 3400, 28, 34, 28, 2, -34 },
  { 3519, 20, 34, 28, 3, -34 },
  { 3604, 27, 34, 28, 1, -34 },
  { 3719, 27, 34, 28, 1, -34 },
  { 3834, 23, 36, 28, 3, -35 },
  { 3938, 26, 34, 28, 2, -34 },
  { 4049, 25, 41, 28, 2, -35 },
  { 4178, 25, 34, 28, 2, -34 },
  { 4285, 25, 36, 28, 2, -35 },
  { 4398, 24, 34, 28, 5, -34 },
  { 4500, 25, 35, 28, 3, -34 },
  { 4610, 24, 34, 28, 5, -34 },
  { 4712, 26, 34, 28, 4, -34 },
  { 4823, 29, 34, 28, 0, -34 },
  { 4947, 24, 34, 28, 5, -34 },
  { 5049, 26, 34, 28, 1, -34 },
  { 5160, 15, 46, 28, 7, -39 },
  { 5247, 10, 37, 28, 9, -34 },
  { 5294, 16, 46, 28, 6, -39 },
  { 5386, 17, 18, 28, 6, -34 },
  { 5425, 21, 2, 28, 1, 0 },
  { 5431, 6, 6, 28, 14, -35 },
  { 5436, 22, 26, 28, 2, -26 },
  { 5508, 22, 37, 28, 2, -36 },
  { 5610, 22, 27, 28, 3, -26 },
  { 5685, 24, 36, 28, 3, -36 },
  { 5793, 22, 27, 28, 3, -26 },
  { 5868, 23, 37, 28, 6, -37 },
  { 5975, 23, 36, 28, 2, -26 },
  { 6079, 22, 36, 28, 2, -36 },
  { 6178, 20, 34, 28, 3, -34 },
  { 6263, 22, 45, 28, 0, -35 },
  { 6387, 24, 36, 28, 2, -36 },
  { 6495, 20, 36, 28, 3, -36 },
  { 6585, 27, 26, 28, 0, -26 },
  { 6673, 22, 26, 28, 2, -26 },
  { 6745, 23, 27, 28, 2, -26 },
  { 6823, 24, 36, 28, 0, -26 },
  { 6931, 22, 36, 28, 3, -26 },
  { 7030, 20, 26, 28, 6, -26 },
  { 7095, 22, 27, 28, 3, -26 },
  { 7170, 20, 33, 28, 5, -32 },
  { 7253, 22, 26, 28, 4, -25 },
  { 7325, 23, 25, 28, 4, -25 },
  { 7397, 26, 25, 28, 3, -25 },
  { 7479, 26, 25, 28, 1, -25 },
  { 7561, 29, 35, 28, -1, -25 },
  { 7688, 25, 25, 28, 1, -25 },
  { 7767, 19, 46, 28, 7, -37 },
  { 7877, 9, 42, 28, 9, -34 },
  { 7925, 19, 47, 28, 4, -37 },
  { 8037, 26, 9, 28, 1, -19 },
};

const GFXfont RobotoMono_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_LIGHTITALIC48PT7B_H_
