#ifndef _ROBOTOMONO_LIGHTITALIC69PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0,
  0x3C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x20, 0xF0, 0x07, 0x00, 0x18, 0x70, 0x03, 0x80, 0x1E, 0x38,
  0x01, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x0F, 0x0F,
  0x00, 0x38, 0x0F, 0x07, 0x80, 0x1C, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x01,
  0xE0, 0x0E, 0x07, 0x80, 0x70, 0x0F, 0x07, 0x80, 0x38, 0x07, 0x03, 0x80,
  0x1E, 0x07, 0x83, 0xC0, 0x07, 0xFF, 0x83, 0xC0, 0x01, 0xFF, 0x81, 0xC0,
  0x00, 0x7F, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x78,
  0x1F, 0xE0, 0x00, 0x38, 0x1F, 0xF8, 0x00, 0x38, 0x1F, 0x3E, 0x00, 0x3C,
  0x1E, 0x07, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x1E,
  0x0F, 0x00, 0x70, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0x0F,
  0x03, 0xC0, 0x0E, 0x0F, 0x01, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x03, 0x87,
  0x00, 0x70, 0x03, 0xC7, 0x80, 0x38, 0x01, 0xC1, 0x80, 0x1C, 0x00, 0xE0,
  0x40, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x01, 0xC3, 0xE0, 0x7C, 0x00,
  0xF1, 0xF0, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x0F, 0x3E, 0x00, 0x7C,
  0x03, 0x9F, 0x00, 0x0F, 0x01, 0xE7, 0x80, 0x01, 0xE0, 0x79, 0xE0, 0x00,
  0x7C, 0x3C, 0xF0, 0x00, 0x0F, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0x8F, 0x00,
  0x00, 0x79, 0xE3, 0xC0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xF8, 0x3C,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0x01, 0xF8, 0x07, 0xF3,
  0xC0, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0x7F, 0xF0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0x8E,
  0x39, 0xE7, 0x9C, 0x71, 0xCF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x37, 0xC0, 0x3C, 0x07, 0xDF, 0xC0,
  0xE0, 0x7F, 0xFF, 0xE3, 0x8F, 0xFC, 0x7F, 0xEF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC0, 0xC0, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFB,
  0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3F, 0x1E,
  0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x03, 0xEF, 0x3C,
  0x00, 0x07, 0xCF, 0x3C, 0x00, 0x0F, 0x8F, 0x3C, 0x00, 0x1F, 0x0F, 0x78,
  0x00, 0x7C, 0x1E, 0x78, 0x00, 0xF8, 0x1E, 0x78, 0x01, 0xF0, 0x1E, 0x78,
  0x03, 0xE0, 0x1E, 0x78, 0x0F, 0x80, 0x1E, 0x78, 0x1F, 0x00, 0x1E, 0xF0,
  0x3E, 0x00, 0x3C, 0xF0, 0x7C, 0x00, 0x3C, 0xF1, 0xF0, 0x00, 0x3C, 0xF3,
  0xE0, 0x00, 0x3C, 0xF7, 0xC0, 0x00, 0x3C, 0xFF, 0x80, 0x00, 0x38, 0xFE,
  0x00, 0x00, 0x78, 0xFC, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x8F, 0xF8, 0xF3,
  0xFC, 0x1E, 0x7C, 0x03, 0xDE, 0x00, 0x7A, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x23,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x71, 0xFF, 0xC0, 0x00, 0x1D, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x01,
  0xE1, 0xFF, 0xF0, 0x07, 0x8F, 0xFF, 0xF0, 0x1C, 0xFE, 0x1F, 0xE0, 0xF7,
  0xC0, 0x0F, 0x83, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x79, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x1F, 0x9E, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0xE3, 0xE0,
  0x01, 0xEF, 0x0F, 0x80, 0x3E, 0x70, 0x3F, 0xFF, 0xE7, 0x80, 0xFF, 0xFE,
  0x3C, 0x03, 0xFF, 0xC1, 0xC0, 0x07, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0xFC, 0x03, 0x80, 0xF0, 0x0F, 0xFC,
  0x06, 0x07, 0x80, 0xFF, 0xF8, 0x1C, 0x1C, 0x07, 0xC1, 0xE0, 0x70, 0xF0,
  0x1C, 0x03, 0x81, 0xC3, 0x80, 0xE0, 0x0C, 0x07, 0x1E, 0x07, 0x80, 0x70,
  0x1C, 0x70, 0x1C, 0x01, 0xC0, 0x71, 0xC0, 0xE0, 0x07, 0x01, 0xCE, 0x03,
  0x80, 0x18, 0x07, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0xE0, 0x70, 0x03, 0x80,
  0x67, 0x01, 0xC0, 0x0E, 0x01, 0x9C, 0x0E, 0x00, 0x30, 0x0E, 0x70, 0x38,
  0x01, 0xC0, 0x39, 0xC0, 0xE0, 0x07, 0x00, 0xEE, 0x03, 0x80, 0x1C, 0x03,
  0x38, 0x1C, 0x00, 0xE0, 0x1C, 0xE0, 0x70, 0x03, 0x80, 0x73, 0x81, 0xC0,
  0x0E, 0x01, 0xCE, 0x07, 0x00, 0x78, 0x0E, 0x38, 0x1C, 0x03, 0xC0, 0x38,
  0xE0, 0x70, 0x0F, 0x00, 0xC3, 0x81, 0xC0, 0x7C, 0x07, 0x0E, 0x07, 0x83,
  0xB0, 0x38, 0x38, 0x0F, 0x3C, 0xE1, 0xE0, 0xE0, 0x3F, 0xE3, 0xFF, 0x03,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x0F, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0x80,
  0x07, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0xFF, 0x3C, 0x00, 0x1F, 0xFF,
  0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00,
  0x01, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFB, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xC0, 0x00,
  0x00, 0x7F, 0x87, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x01, 0xEE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0x38, 0x00, 0x3D, 0xE0, 0x1C, 0xE0, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x07,
  0x9C, 0x03, 0xCF, 0x00, 0x3C, 0x70, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x07, 0x8F, 0x00, 0xE1, 0xC0, 0x1E, 0x3C, 0x03, 0x87, 0x00, 0xF0,
  0xF0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x78, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x78, 0x78, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0x1E, 0x0E, 0x1E, 0x07,
  0x80, 0x70, 0x38, 0x78, 0x1E, 0x03, 0xC0, 0xF3, 0xC0, 0x70, 0x0F, 0x03,
  0xCF, 0x03, 0xC0, 0x3C, 0x0F, 0x78, 0x0F, 0x00, 0xF0, 0x1D, 0xE0, 0x3C,
  0x03, 0xC0, 0x7F, 0x00, 0xF0, 0x0E, 0x01, 0xFC, 0x03, 0xC0, 0x78, 0x07,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x00,
  0x01, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x1E, 0x01,
  0xFE, 0x00, 0x00, 0xF0, 0x07, 0xB8, 0x00, 0x03, 0xC0, 0x3C, 0xF0, 0x00,
  0x0F, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x0F,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x07, 0x80, 0xE0, 0x03,
  0xC0, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x78, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x01, 0xE3, 0xC0,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0xF0, 0x00, 0x0E, 0x78, 0x03, 0xC0, 0x00,
  0x3D, 0xE0, 0x1E, 0x00, 0x00, 0xF7, 0x80, 0x78, 0x00, 0x01, 0xFE, 0x01,
  0xE0, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00,
  0x1F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1C, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x07, 0xE0,
  0x0F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0x00,
  0x1C, 0xF0, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x80, 0x0F, 0x3C, 0x00,
  0xFC, 0x00, 0x71, 0xE0, 0x07, 0xE0, 0x07, 0x8F, 0x00, 0x3F, 0x00, 0x3C,
  0x78, 0x03, 0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0xC0, 0x0E, 0x1E, 0x00, 0xEE,
  0x00, 0xF0, 0xF0, 0x0F, 0x70, 0x07, 0x87, 0x80, 0x7B, 0x80, 0x38, 0x3C,
  0x03, 0x9C, 0x03, 0xC1, 0xE0, 0x3C, 0xE0, 0x1E, 0x0F, 0x01, 0xE7, 0x00,
  0xF0, 0x78, 0x0E, 0x38, 0x07, 0x03, 0xC0, 0xF1, 0xC0, 0x78, 0x1E, 0x07,
  0x8E, 0x03, 0xC0, 0xF0, 0x38, 0x70, 0x1C, 0x07, 0x03, 0xC3, 0x81, 0xE0,
  0x38, 0x1E, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0xE0, 0x70, 0x0E, 0x0F, 0x07,
  0x83, 0x80, 0x70, 0x78, 0x3C, 0x3C, 0x03, 0x83, 0x81, 0xE1, 0xE0, 0x1C,
  0x3C, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x78, 0xF0, 0x07, 0x0E, 0x03, 0xC7,
  0x80, 0x38, 0xF0, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x0E, 0x38,
  0x07, 0x9E, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x03, 0x9E, 0x01, 0xE7, 0x00,
  0x1C, 0xE0, 0x0F, 0x78, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xA0, 0x00, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0xFE,
  0xF0, 0x1F, 0xFF, 0xF8, 0xF0, 0x0F, 0xFF, 0xF0, 0xF0, 0x03, 0xFF, 0x80,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x00, 0x03, 0xC3, 0xFF,
  0xE0, 0x03, 0xCF, 0xFF, 0xF0, 0x03, 0xDF, 0xE7, 0xF8, 0x03, 0xBE, 0x00,
  0xFC, 0x07, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x07,
  0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0x7B, 0xE0, 0x3F, 0x80, 0xF1, 0xFF, 0xFF,
  0x00, 0xF0, 0xFF, 0xFE, 0x00, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x3F, 0xFE, 0x1E,
  0x00, 0x3F, 0xFF, 0xC7, 0x80, 0x1F, 0xF1, 0xF9, 0xE0, 0x0F, 0xC0, 0x0F,
  0x78, 0x07, 0xE0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0xFB, 0xC0, 0x07, 0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0xFE, 0x38,
  0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x3E, 0x00,
  0x00, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x20, 0x00, 0xFF, 0xF8,
  0x38, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x1F, 0xF1, 0xF9, 0xE0, 0x07, 0xE0,
  0x07, 0xBC, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x07, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xEF, 0x00, 0x0F, 0xFF, 0xF9,
  0xE0, 0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x07, 0xFF, 0x0F, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x10, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x03, 0xC1, 0xFF, 0xF0,
  0x03, 0xC3, 0xFF, 0xF8, 0x03, 0x8F, 0xF3, 0xFC, 0x07, 0x9F, 0x00, 0x7E,
  0x07, 0xBC, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x07,
  0x80, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x3F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0x07, 0x87, 0xE0, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x00, 0x79, 0xF8,
  0x00, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0xF8, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xC7, 0xFE, 0x1F, 0xF8, 0x03, 0xDF,
  0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x7F, 0x7E, 0x7E, 0x03, 0xB8, 0x1F, 0xF0,
  0x1E, 0x03, 0xE0, 0x0F, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xC1, 0xFF,
  0xF0, 0x03, 0x83, 0xFF, 0xF8, 0x03, 0x8F, 0xF3, 0xFC, 0x07, 0x9F, 0x00,
  0x7C, 0x07, 0xBC, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x1E, 0x07, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x0F,
  0xFF, 0x00, 0x01, 0xE7, 0xFF, 0xF8, 0x00, 0x39, 0xFC, 0xFF, 0x80, 0x07,
  0x7C, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x79, 0xFF,
  0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0xC0, 0x01, 0xE0, 0xFF, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x1C, 0x03, 0xFF, 0xFC,
  0x78, 0x0F, 0xF0, 0xFC, 0xF0, 0x3F, 0x00, 0x3D, 0xE0, 0xFC, 0x00, 0x3F,
  0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x7E, 0x01, 0xF7,
  0x80, 0x7F, 0xFF, 0xCF, 0x00, 0x7F, 0xFF, 0x1C, 0x00, 0x3F, 0xF8, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F,
  0x01, 0xFF, 0xF0, 0x3C, 0x1F, 0xFF, 0x80, 0xF1, 0xFF, 0xFE, 0x03, 0xCF,
  0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x1F,
  0xC0, 0x3C, 0x00, 0x3D, 0xC0, 0x3F, 0x01, 0xFB, 0xC0, 0x1F, 0xFF, 0xF3,
  0xC0, 0x0F, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xEF, 0x00, 0x1F, 0x00, 0x1E,
  0xF0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x03, 0xF0,
  0x03, 0xCF, 0x00, 0x77, 0x00, 0x38, 0xF0, 0x07, 0x70, 0x07, 0x8F, 0x00,
  0x77, 0x00, 0x78, 0xF0, 0x0E, 0x70, 0x07, 0x0F, 0x00, 0xE7, 0x00, 0xF0,
  0xF0, 0x1E, 0x70, 0x0E, 0x0F, 0x01, 0xC7, 0x00, 0xE0, 0x70, 0x3C, 0x78,
  0x1E, 0x07, 0x03, 0x87, 0x81, 0xC0, 0x70, 0x38, 0x38, 0x3C, 0x07, 0x07,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x38, 0x38, 0x07, 0x0F, 0x03, 0x87, 0x80,
  0x70, 0xE0, 0x38, 0x70, 0x07, 0x1E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x38,
  0xF0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x39, 0xE0, 0x07, 0x38,
  0x03, 0x9C, 0x00, 0x77, 0x80, 0x39, 0xC0, 0x07, 0x70, 0x03, 0xBC, 0x00,
  0x77, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xC3, 0xFF, 0xF0, 0x00, 0x0F, 0x1F, 0x87, 0xF0, 0x00, 0x38, 0xF8, 0x07,
  0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0xC0, 0x07, 0x1E, 0x00, 0x1F, 0x80, 0x3C,
  0x70, 0x00, 0x3F, 0x83, 0xE1, 0xC0, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x00,
  0x7F, 0xF8, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoMono_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 12, 49, 41, 14, -49 },
  { 75, 16, 15, 41, 16, -52 },
  { 105, 40, 49, 41, 1, -49 },
  { 350, 34, 64, 41, 4, -57 },
  { 622, 33, 51, 41, 4, -50 },
  { 833, 34, 51, 41, 3, -50 },
  { 1050, 6, 15, 41, 19, -52 },
  { 1062, 21, 71, 41, 12, -55 },
  { 1249, 22, 71, 41, 6, -55 },
  { 1445, 30, 30, 41, 8, -49 },
  { 1558, 33, 36, 41, 4, -41 },
  { 1707, 9, 16, 41, 8, -6 },
  { 1725, 25, 4, 41, 7, -24 },
  { 1738, 7, 6, 41, 15, -6 },
  { 1744, 33, 53, 41, 5, -49 },
  { 1963, 32, 51, 41, 5, -50 },
  { 2167, 19, 49, 41, 10, -49 },
  { 2284, 34, 50, 41, 1, -50 },
  { 2497, 33, 51, 41, 2, -50 },
  { 2708, 35, 49, 41, 1, -49 },
  { 2923, 34, 50, 41, 6, -49 },
  { 3136, 30, 50, 41, 4, -49 },
  { 3324, 32, 49, 41, 8, -49 },
  { 3520, 34, 51, 41, 4, -50 },
  { 3737, 29, 50, 41, 7, -50 },
  { 3919, 12, 36, 41, 16, -36 },
  { 3973, 16, 46, 41, 12, -36 },
  { 4065, 31, 29, 41, 5, -37 },
  { 4178, 32, 17, 41, 5, -31 },
  { 4246, 31, 29, 41, 4, -37 },
  { 4359, 27, 50, 41, 10, -50 },
  { 4528, 38, 49, 41, 2, -49 },
  { 4761, 34, 49, 41, 0, -49 },
  { 4970, 35, 49, 41, 3, -49 },
  { 5185, 34, 51, 41, 4, -50 },
  { 5402, 36, 49, 41, 2, -49 },
  { 5623, 37, 49, 41, 3, -49 },
  { 5850, 37, 49, 41, 3, -49 },
  { 6077, 34, 51, 41, 4, -50 },
  { 6294, 38, 49, 41, 2, -49 },
  { 6527, 36, 49, 41, 3, -49 },
  { 6748, 36, 50, 41, 2, -49 },
  { 6973, 39, 49, 41, 3, -49 },
  { 7212, 28, 49, 41, 4, -49 },
  { 7384, 38, 49, 41, 2, -49 },
  { 7617, 38, 49, 41, 2, -49 },
  { 7850, 34, 51, 41, 4, -50 },
  { 8067, 36, 49, 41, 4, -49 },
  { 8288, 35, 59, 41, 3, -50 },
  { 8547, 35, 49, 41, 3, -49 },
  { 8762, 36, 51, 41, 3, -50 },
  { 8992, 35, 49, 41, 7, -49 },
  { 9207, 36, 50, 41, 4, -49 },
  { 9432, 35, 49, 41, 7, -49 },
  { 9647, 37, 49, 41, 6, -49 },
  { 9874, 42, 49, 41, 0, -49 },
  { 10132, 34, 49, 41, 8, -49 },
  { 10341, 37, 49, 41, 1, -49 },
  { 10568, 22, 67, 41, 10, -56 },
  { 10753, 15, 53, 41, 13, -49 },
  { 10853, 22, 67, 41, 9, -56 },
  { 11038, 25, 27, 41, 8, -49 },
  { 11123, 29, 3, 41, 2, 0 },
  { 11134, 9, 9, 41, 20, -51 },
  { 11145, 32, 38, 41, 3, -37 },
  { 11297, 32, 53, 41, 3, -52 },
  { 11509, 30, 38, 41, 5, -37 },
  { 11652, 34, 53, 41, 5, -52 },
  { 11878, 32, 38, 41, 4, -37 },
  { 12030, 34, 53, 41, 8, -53 },
  { 12256, 35, 52, 41, 2, -37 },
  { 12484, 32, 52, 41, 3, -52 },
  { 12692, 29, 50, 41, 4, -50 },
  { 12874, 31, 65, 41, 1, -50 },
  { 13126, 34, 52, 41, 4, -52 },
  { 13347, 29, 52, 41, 4, -52 },
  { 13536, 40, 37, 41, -1, -37 },
  { 13721, 32, 37, 41, 3, -37 },
  { 13869, 32, 38, 41, 4, -37 },
  { 14021, 35, 51, 41, 0, -37 },
  { 14245, 31, 51, 41, 5, -37 },
  { 14443, 30, 37, 41, 8, -37 },
  { 14582, 31, 38, 41, 5, -37 },
  { 14730, 27, 47, 41, 8, -46 },
  { 14889, 32, 37, 41, 5, -36 },
  { 15037, 33, 36, 41, 6, -36 },
  { 15186, 36, 36, 41, 5, -36 },
  { 15348, 38, 36, 41, 1, -36 },
  { 15519, 42, 51, 41, -1, -36 },
  { 15787, 35, 36, 41, 2, -36 },
  { 15945, 26, 68, 41, 11, -54 },
  { 16166, 12, 60, 41, 14, -49 },
  { 16256, 27, 68, 41, 6, -54 },
  { 16486, 38, 13, 41, 1, -27 },
};

const GFXfont RobotoMono_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic69pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_LIGHTITALIC69PT7B_H_
