#ifndef _ROBOTOMONO_LIGHTITALIC10PT7B_H_
#define _ROBOTOMONO_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x14, 0xA7, 0xCA, 0xF9, 0x46, 0x00, 0x25,
  0x98, 0x61, 0x9A, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x3A, 0x4C, 0x45, 0xC5,
  0xE0, 0xE0, 0x2A, 0x49, 0x24, 0x90, 0x44, 0x92, 0x4A, 0x50, 0x27, 0xC9,
  0xA0, 0x22, 0xF4, 0x40, 0x60, 0xF0, 0x80, 0x11, 0x22, 0x44, 0x88, 0x79,
  0x9F, 0x99, 0xE0, 0x74, 0x92, 0x90, 0x7A, 0x42, 0x22, 0x23, 0xE0, 0x3A,
  0x42, 0x60, 0xC5, 0xC0, 0x08, 0xCA, 0x9F, 0x88, 0x40, 0x7A, 0x38, 0x21,
  0x4B, 0x80, 0x78, 0xE9, 0x99, 0xE0, 0xF8, 0x84, 0x44, 0x22, 0x00, 0x74,
  0x64, 0xC9, 0x4B, 0x80, 0x79, 0x99, 0x72, 0xC0, 0x40, 0x80, 0x40, 0xA0,
  0x3C, 0x43, 0xFF, 0xC3, 0x68, 0x79, 0x12, 0x40, 0x40, 0x39, 0x5A, 0xF5,
  0xD6, 0xA7, 0x00, 0x11, 0x8A, 0x97, 0xC6, 0x20, 0x7A, 0x52, 0xE4, 0xC7,
  0xC0, 0x74, 0x61, 0x08, 0x4B, 0x80, 0x79, 0x14, 0x51, 0x4A, 0x2F, 0x00,
  0x7D, 0x04, 0x1E, 0x42, 0x0F, 0x80, 0x7D, 0x04, 0x1E, 0x41, 0x08, 0x00,
  0x74, 0x61, 0x49, 0x4B, 0x80, 0x45, 0x14, 0x5E, 0x8A, 0x28, 0x80, 0x3C,
  0x41, 0x08, 0x20, 0x8F, 0x80, 0x04, 0x10, 0x82, 0x0A, 0x27, 0x00, 0x45,
  0x25, 0x18, 0x52, 0x48, 0x80, 0x88, 0x88, 0x88, 0xF0, 0x45, 0xB7, 0x5E,
  0xAA, 0x28, 0x80, 0x45, 0x96, 0x56, 0x9A, 0x68, 0x80, 0x79, 0x99, 0x99,
  0xE0, 0xF4, 0x63, 0xE8, 0x42, 0x00, 0x39, 0x14, 0x61, 0x8A, 0x27, 0x06,
  0x79, 0x14, 0x5E, 0x52, 0x28, 0x80, 0x39, 0x14, 0x0C, 0x0A, 0x27, 0x00,
  0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x63, 0x29, 0x4B, 0x80, 0x8C, 0xA5,
  0x26, 0x21, 0x00, 0xAD, 0x7B, 0xE9, 0x4A, 0x80, 0x44, 0xA3, 0x04, 0x31,
  0x28, 0x80, 0x8C, 0x94, 0xC4, 0x21, 0x00, 0x7C, 0x21, 0x08, 0x21, 0x0F,
  0x80, 0x34, 0x44, 0x44, 0x44, 0x8C, 0xAA, 0x55, 0x32, 0x22, 0x22, 0x22,
  0x4C, 0x26, 0x59, 0xF8, 0x80, 0xF1, 0xF9, 0xF0, 0x22, 0x14, 0xD4, 0xA6,
  0x3E, 0xF9, 0x89, 0xE0, 0x08, 0x4B, 0xA9, 0x4A, 0x5C, 0xF9, 0xE8, 0xF0,
  0x19, 0x3C, 0x84, 0x21, 0x08, 0x7A, 0x63, 0x17, 0x0B, 0xC0, 0x42, 0x14,
  0xD4, 0xA6, 0x31, 0x2C, 0x22, 0x24, 0xF0, 0x09, 0x04, 0x21, 0x08, 0x44,
  0xE0, 0x48, 0x89, 0xEC, 0xA9, 0x62, 0x22, 0x22, 0x4F, 0x7E, 0x9A, 0x6A,
  0xA8, 0x7A, 0x53, 0x18, 0x80, 0xF9, 0x99, 0xE0, 0x7A, 0x53, 0x17, 0x42,
  0x00, 0xF9, 0x99, 0xE1, 0x20, 0x7A, 0x21, 0x08, 0x00, 0xF8, 0x61, 0xE0,
  0x2F, 0x44, 0x44, 0x70, 0x99, 0x99, 0xF0, 0x9C, 0xA8, 0xC4, 0x00, 0xAF,
  0x6D, 0x6A, 0x00, 0x4C, 0xC2, 0x14, 0x88, 0x45, 0x25, 0x0C, 0x20, 0x8C,
  0x00, 0x78, 0x88, 0x8F, 0x80, 0x29, 0x29, 0x24, 0x88, 0x56, 0xAA, 0x80,
  0x42, 0x22, 0x23, 0x44, 0x48, 0x66, 0x60,
};

const GFXglyph RobotoMono_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 4, 9, 6, 1, -8 },
  { 16, 4, 7, 6, 1, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 1, 3, 6, 3, -8 },
  { 26, 3, 10, 6, 2, -8 },
  { 30, 3, 10, 6, 1, -8 },
  { 34, 5, 4, 6, 1, -7 },
  { 37, 4, 5, 6, 1, -6 },
  { 40, 2, 2, 6, 1, -1 },
  { 41, 4, 1, 6, 1, -4 },
  { 42, 1, 1, 6, 2, -1 },
  { 43, 4, 8, 6, 1, -7 },
  { 47, 4, 7, 6, 1, -7 },
  { 51, 3, 7, 6, 1, -7 },
  { 54, 5, 7, 6, 0, -7 },
  { 59, 5, 7, 6, 0, -7 },
  { 64, 5, 7, 6, 0, -7 },
  { 69, 5, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 5, 7, 6, 1, -7 },
  { 83, 5, 7, 6, 1, -7 },
  { 88, 4, 7, 6, 1, -7 },
  { 92, 2, 5, 6, 2, -5 },
  { 94, 2, 6, 6, 2, -5 },
  { 96, 4, 4, 6, 1, -5 },
  { 98, 4, 2, 6, 1, -4 },
  { 99, 4, 4, 6, 1, -5 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 6, 7, 6, 0, -7 },
  { 111, 5, 7, 6, 0, -7 },
  { 116, 5, 7, 6, 0, -7 },
  { 121, 5, 7, 6, 1, -7 },
  { 126, 6, 7, 6, 0, -7 },
  { 132, 6, 7, 6, 0, -7 },
  { 138, 6, 7, 6, 0, -7 },
  { 144, 5, 7, 6, 1, -7 },
  { 149, 6, 7, 6, 0, -7 },
  { 155, 6, 7, 6, 0, -7 },
  { 161, 6, 7, 6, 0, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 6, 7, 6, 0, -7 },
  { 189, 4, 7, 6, 1, -7 },
  { 193, 5, 7, 6, 1, -7 },
  { 198, 6, 8, 6, 0, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 5, 7, 6, 1, -7 },
  { 221, 5, 7, 6, 1, -7 },
  { 226, 5, 7, 6, 1, -7 },
  { 231, 5, 7, 6, 1, -7 },
  { 236, 6, 7, 6, 0, -7 },
  { 242, 5, 7, 6, 1, -7 },
  { 247, 6, 7, 6, 0, -7 },
  { 253, 4, 10, 6, 1, -8 },
  { 258, 2, 8, 6, 2, -7 },
  { 260, 4, 10, 6, 1, -8 },
  { 265, 4, 4, 6, 1, -7 },
  { 267, 5, 1, 6, 0, 0 },
  { 268, 1, 1, 6, 3, -7 },
  { 269, 4, 5, 6, 1, -5 },
  { 272, 5, 8, 6, 0, -8 },
  { 277, 4, 5, 6, 1, -5 },
  { 280, 5, 8, 6, 1, -8 },
  { 285, 4, 5, 6, 1, -5 },
  { 288, 5, 8, 6, 1, -8 },
  { 293, 5, 7, 6, 0, -5 },
  { 298, 5, 8, 6, 0, -8 },
  { 303, 4, 7, 6, 1, -7 },
  { 307, 5, 9, 6, 0, -7 },
  { 313, 4, 8, 6, 1, -8 },
  { 317, 4, 8, 6, 1, -8 },
  { 321, 6, 5, 6, 0, -5 },
  { 325, 5, 5, 6, 0, -5 },
  { 329, 4, 5, 6, 1, -5 },
  { 332, 5, 7, 6, 0, -5 },
  { 337, 4, 7, 6, 1, -5 },
  { 341, 5, 5, 6, 1, -5 },
  { 345, 4, 5, 6, 1, -5 },
  { 348, 4, 7, 6, 1, -7 },
  { 352, 4, 5, 6, 1, -5 },
  { 355, 5, 5, 6, 1, -5 },
  { 359, 5, 5, 6, 1, -5 },
  { 363, 6, 5, 6, 0, -5 },
  { 367, 6, 7, 6, 0, -5 },
  { 373, 5, 5, 6, 0, -5 },
  { 377, 3, 10, 6, 2, -8 },
  { 381, 2, 9, 6, 2, -7 },
  { 384, 4, 10, 6, 1, -8 },
  { 389, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_LightItalic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_LIGHTITALIC10PT7B_H_
