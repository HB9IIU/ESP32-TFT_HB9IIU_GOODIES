#ifndef _ROBOTOCONDENSED_ITALIC16PT7B_H_
#define _ROBOTOCONDENSED_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x64, 0x00, 0x44, 0xB6, 0xD0, 0x0A, 0x1A, 0x12,
  0x14, 0x7F, 0x24, 0x2C, 0xFC, 0x48, 0x58, 0x50, 0x90, 0x08, 0x23, 0x9B,
  0x45, 0x14, 0x1C, 0x18, 0x28, 0xE2, 0xD9, 0xC4, 0x00, 0x70, 0x50, 0x52,
  0x54, 0x74, 0x08, 0x10, 0x16, 0x29, 0x49, 0x49, 0x0E, 0x1C, 0x16, 0x32,
  0x26, 0x3C, 0x18, 0x38, 0x4B, 0x4E, 0x46, 0x46, 0x3A, 0x56, 0x08, 0x88,
  0xC4, 0x23, 0x18, 0x84, 0x21, 0x08, 0x42, 0x08, 0x40, 0x10, 0x84, 0x10,
  0x84, 0x21, 0x08, 0xC4, 0x21, 0x10, 0x88, 0x80, 0x10, 0x4D, 0x5E, 0x71,
  0x41, 0x00, 0x10, 0x41, 0x3F, 0x30, 0x82, 0x08, 0x6D, 0x40, 0xF0, 0x70,
  0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x00,
  0x39, 0x94, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x2D, 0x9C, 0x1F, 0xB2, 0x22,
  0x26, 0x64, 0x44, 0x1C, 0x4D, 0x88, 0x10, 0x60, 0x83, 0x0C, 0x30, 0x41,
  0x07, 0xE0, 0x1C, 0x6C, 0x88, 0x10, 0x63, 0x01, 0x02, 0x05, 0x89, 0x33,
  0xC0, 0x06, 0x0C, 0x38, 0xF1, 0x44, 0x99, 0x22, 0xFE, 0x18, 0x20, 0x40,
  0x3E, 0x41, 0x82, 0x07, 0x89, 0x83, 0x02, 0x0D, 0x1B, 0x63, 0x80, 0x1C,
  0xC6, 0x10, 0xFB, 0x28, 0xE3, 0x8E, 0x2D, 0x9C, 0x7E, 0x0C, 0x10, 0x60,
  0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x00, 0x39, 0x94, 0x51, 0x4D, 0xEC,
  0xA2, 0x8A, 0x29, 0x9C, 0x39, 0xB4, 0x71, 0xC7, 0x34, 0xDF, 0x08, 0x63,
  0x38, 0x24, 0x00, 0x02, 0xC0, 0x13, 0x00, 0x00, 0x06, 0x64, 0xC0, 0x08,
  0xD9, 0x0E, 0x18, 0x40, 0x7C, 0x00, 0x3E, 0x20, 0x60, 0x30, 0x31, 0xCE,
  0x10, 0x00, 0x39, 0x2C, 0xC3, 0x08, 0x63, 0x08, 0x60, 0x04, 0x10, 0x0F,
  0x04, 0x22, 0x05, 0x39, 0x4B, 0x64, 0x99, 0x26, 0xC9, 0xA6, 0x6D, 0xA9,
  0xB2, 0x00, 0x80, 0x30, 0x03, 0xC0, 0x02, 0x03, 0x01, 0xC1, 0xE0, 0x90,
  0xC8, 0x44, 0x22, 0x3F, 0x10, 0x98, 0x68, 0x30, 0x3E, 0x33, 0x21, 0x23,
  0x22, 0x7C, 0x62, 0x62, 0x42, 0x42, 0x46, 0xFC, 0x1C, 0x22, 0x43, 0x43,
  0xC0, 0xC0, 0x80, 0x80, 0x86, 0x84, 0xCC, 0x78, 0x3E, 0x33, 0x21, 0x21,
  0x21, 0x61, 0x61, 0x63, 0x43, 0x42, 0x4C, 0xF8, 0x3F, 0x30, 0x20, 0x20,
  0x20, 0x7E, 0x60, 0x60, 0x40, 0x40, 0x40, 0xFC, 0x3F, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x7C, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x1E, 0x22, 0x43, 0x40,
  0xC0, 0xC0, 0x8E, 0x82, 0x86, 0x86, 0xCC, 0x78, 0x30, 0x8C, 0x22, 0x08,
  0x82, 0x21, 0x9F, 0xE6, 0x19, 0x84, 0x41, 0x10, 0x44, 0x33, 0x0C, 0x33,
  0x22, 0x22, 0x66, 0x44, 0x44, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x04, 0xCC, 0xC8, 0x78, 0x31, 0x99, 0x88, 0x84, 0x82, 0xC3, 0xC1,
  0xE0, 0xD8, 0x44, 0x23, 0x11, 0x98, 0x40, 0x30, 0xC2, 0x08, 0x21, 0x86,
  0x18, 0x41, 0x04, 0x3F, 0x30, 0x33, 0x06, 0x30, 0x63, 0x8E, 0x38, 0xA6,
  0x9E, 0x69, 0x66, 0xB4, 0x4A, 0x44, 0xA4, 0x4C, 0x4C, 0xCC, 0x30, 0x8C,
  0x23, 0x88, 0xA2, 0x29, 0x9A, 0x66, 0x59, 0x94, 0x45, 0x11, 0xC4, 0x33,
  0x0C, 0x1C, 0x22, 0x43, 0x43, 0xC3, 0xC3, 0x82, 0x82, 0x82, 0x86, 0xCC,
  0x78, 0x3E, 0x18, 0x88, 0x64, 0x32, 0x13, 0x19, 0xF8, 0xC0, 0x40, 0x20,
  0x10, 0x18, 0x00, 0x1C, 0x26, 0x43, 0x43, 0xC3, 0xC3, 0x82, 0x82, 0x82,
  0x86, 0xCC, 0x78, 0x0C, 0x04, 0x3E, 0x33, 0x21, 0x21, 0x23, 0x62, 0x7C,
  0x64, 0x44, 0x46, 0x46, 0xC2, 0x1E, 0x33, 0x21, 0x20, 0x20, 0x38, 0x0C,
  0x06, 0x02, 0xC2, 0x46, 0x38, 0x7F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x43, 0x43, 0x43, 0x42, 0xC2, 0xC2, 0x86,
  0x86, 0x86, 0x84, 0xCC, 0x78, 0xC1, 0x43, 0x42, 0x46, 0x46, 0x44, 0x6C,
  0x68, 0x38, 0x30, 0x30, 0x20, 0x8C, 0x63, 0x18, 0xCE, 0x52, 0x94, 0xAD,
  0x6A, 0x52, 0x94, 0xE7, 0x31, 0x8C, 0x62, 0x18, 0x21, 0x99, 0x84, 0xC2,
  0xC1, 0xC0, 0x60, 0x60, 0x38, 0x34, 0x32, 0x11, 0x98, 0x40, 0x43, 0x42,
  0x46, 0x64, 0x28, 0x38, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x3F, 0x03,
  0x02, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xFE, 0x39, 0x08,
  0x42, 0x31, 0x88, 0x42, 0x11, 0x8C, 0x63, 0x80, 0x92, 0x49, 0xB2, 0x49,
  0x24, 0x38, 0xC6, 0x31, 0x08, 0x42, 0x31, 0x88, 0x42, 0x13, 0x80, 0x33,
  0x75, 0xD9, 0xFC, 0xD0, 0x1C, 0x49, 0x98, 0x23, 0xCC, 0xB1, 0x26, 0x7C,
  0x30, 0x40, 0x81, 0xE6, 0x6C, 0x50, 0xA1, 0x46, 0x8B, 0xB7, 0xC0, 0x39,
  0x38, 0xE0, 0x82, 0x08, 0xA6, 0x70, 0x06, 0x0C, 0x13, 0xAC, 0xD0, 0xA3,
  0x46, 0x89, 0x12, 0x67, 0x40, 0x39, 0x28, 0xE3, 0xFE, 0x08, 0x22, 0x70,
  0x19, 0x19, 0xE4, 0x21, 0x08, 0xC6, 0x21, 0x00, 0x3A, 0xCD, 0x0A, 0x34,
  0x68, 0x91, 0x26, 0x74, 0x1A, 0x23, 0x80, 0x30, 0x40, 0x81, 0xE6, 0x6C,
  0xD1, 0xA2, 0x44, 0x8B, 0x16, 0x60, 0x23, 0x02, 0x26, 0x64, 0x44, 0x4C,
  0x08, 0x20, 0x02, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x86, 0x00,
  0x30, 0x40, 0x81, 0x32, 0xCF, 0x1C, 0x38, 0x58, 0x93, 0x26, 0x60, 0x32,
  0x22, 0x26, 0x64, 0x44, 0x4C, 0x3D, 0xCC, 0xCD, 0x99, 0xA3, 0x34, 0x46,
  0x88, 0x91, 0x16, 0x22, 0xCC, 0x40, 0x3C, 0xCD, 0x9A, 0x34, 0x48, 0x91,
  0x62, 0xCC, 0x39, 0x3C, 0x61, 0x86, 0x38, 0xE6, 0x70, 0x3C, 0xCD, 0x8A,
  0x14, 0x28, 0xD1, 0x66, 0xF9, 0x02, 0x04, 0x00, 0x77, 0x38, 0x63, 0x8E,
  0x28, 0xA6, 0xE8, 0x61, 0x84, 0x3B, 0x98, 0x84, 0x21, 0x18, 0xC0, 0x3C,
  0x49, 0x9B, 0x03, 0x81, 0xB1, 0x26, 0x78, 0x66, 0xF4, 0x44, 0xCC, 0x88,
  0xC0, 0x47, 0x1C, 0xE3, 0x8A, 0x28, 0xA6, 0xF8, 0x8E, 0x2C, 0xB4, 0x51,
  0xC6, 0x18, 0x40, 0x88, 0xC4, 0xE6, 0x53, 0x2E, 0xF7, 0x33, 0x98, 0x88,
  0x44, 0x00, 0x66, 0x58, 0xA1, 0xC1, 0x06, 0x1E, 0x24, 0xC8, 0x23, 0x22,
  0x36, 0x34, 0x34, 0x18, 0x18, 0x18, 0x10, 0x30, 0x20, 0xC0, 0x7E, 0x08,
  0x20, 0xC1, 0x04, 0x18, 0x60, 0xF8, 0x08, 0x61, 0x04, 0x30, 0xC2, 0x08,
  0x41, 0x82, 0x18, 0x61, 0x82, 0x08, 0x22, 0x22, 0x22, 0x64, 0x44, 0x44,
  0xC8, 0x30, 0x86, 0x31, 0x08, 0x61, 0x11, 0x88, 0x42, 0x33, 0x00, 0x63,
  0xA6, 0x30,
};

const GFXglyph RobotoCondensed_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 3, 4, 5, 2, -12 },
  { 9, 8, 12, 9, 1, -12 },
  { 21, 6, 15, 8, 1, -14 },
  { 33, 8, 12, 10, 1, -12 },
  { 45, 8, 12, 8, 0, -12 },
  { 57, 2, 4, 3, 1, -12 },
  { 58, 5, 17, 5, 1, -13 },
  { 69, 5, 17, 5, -1, -13 },
  { 80, 6, 7, 7, 1, -12 },
  { 86, 6, 8, 8, 1, -9 },
  { 92, 3, 4, 3, -1, -2 },
  { 94, 4, 1, 4, 0, -5 },
  { 95, 2, 2, 4, 0, -2 },
  { 96, 7, 13, 6, -1, -12 },
  { 108, 6, 12, 8, 1, -12 },
  { 117, 4, 12, 8, 2, -12 },
  { 123, 7, 12, 8, 0, -12 },
  { 134, 7, 12, 8, 0, -12 },
  { 145, 7, 12, 8, 0, -12 },
  { 156, 7, 12, 8, 1, -12 },
  { 167, 6, 12, 8, 1, -12 },
  { 176, 7, 12, 8, 1, -12 },
  { 187, 6, 12, 8, 1, -12 },
  { 196, 6, 12, 8, 1, -12 },
  { 205, 3, 9, 4, 0, -9 },
  { 209, 4, 11, 3, -1, -9 },
  { 215, 5, 7, 7, 1, -9 },
  { 220, 6, 4, 7, 1, -7 },
  { 223, 7, 7, 7, 0, -9 },
  { 230, 6, 12, 7, 1, -12 },
  { 239, 10, 15, 12, 1, -11 },
  { 258, 9, 12, 9, -1, -12 },
  { 272, 8, 12, 8, 0, -12 },
  { 284, 8, 12, 9, 1, -12 },
  { 296, 8, 12, 9, 0, -12 },
  { 308, 8, 12, 8, 0, -12 },
  { 320, 8, 12, 7, 0, -12 },
  { 332, 8, 12, 9, 1, -12 },
  { 344, 10, 12, 10, 0, -12 },
  { 359, 4, 12, 4, 0, -12 },
  { 365, 8, 12, 8, 0, -12 },
  { 377, 9, 12, 8, 0, -12 },
  { 391, 6, 12, 7, 0, -12 },
  { 400, 12, 12, 12, 0, -12 },
  { 418, 10, 12, 10, 0, -12 },
  { 433, 8, 12, 9, 1, -12 },
  { 445, 9, 12, 9, 0, -12 },
  { 459, 8, 14, 9, 1, -12 },
  { 473, 8, 12, 8, 0, -12 },
  { 485, 8, 12, 8, 0, -12 },
  { 497, 8, 12, 8, 1, -12 },
  { 509, 8, 12, 9, 1, -12 },
  { 521, 8, 12, 9, 1, -12 },
  { 533, 10, 12, 12, 2, -12 },
  { 548, 9, 12, 9, 0, -12 },
  { 562, 8, 12, 8, 1, -12 },
  { 574, 8, 12, 8, 0, -12 },
  { 586, 5, 15, 4, 0, -13 },
  { 596, 3, 13, 6, 2, -12 },
  { 601, 5, 15, 4, -1, -13 },
  { 611, 4, 6, 6, 1, -12 },
  { 614, 6, 1, 6, -1, 0 },
  { 615, 2, 2, 5, 2, -12 },
  { 616, 7, 9, 7, 0, -9 },
  { 624, 7, 12, 8, 0, -12 },
  { 635, 6, 9, 7, 1, -9 },
  { 642, 7, 12, 8, 1, -12 },
  { 653, 6, 9, 7, 1, -9 },
  { 660, 5, 12, 5, 1, -12 },
  { 668, 7, 12, 8, 0, -9 },
  { 679, 7, 12, 8, 0, -12 },
  { 690, 4, 12, 4, 0, -12 },
  { 696, 6, 15, 3, -2, -12 },
  { 708, 7, 12, 7, 0, -12 },
  { 719, 4, 12, 4, 0, -12 },
  { 725, 11, 9, 12, 0, -9 },
  { 738, 7, 9, 8, 0, -9 },
  { 746, 6, 9, 8, 1, -9 },
  { 753, 7, 12, 8, 0, -9 },
  { 764, 6, 12, 8, 1, -9 },
  { 773, 5, 9, 5, 0, -9 },
  { 779, 7, 9, 7, 0, -9 },
  { 787, 4, 11, 5, 1, -11 },
  { 793, 6, 9, 8, 1, -9 },
  { 800, 6, 9, 7, 1, -9 },
  { 807, 9, 9, 10, 1, -9 },
  { 818, 7, 9, 7, 0, -9 },
  { 826, 8, 12, 6, -1, -9 },
  { 838, 7, 9, 7, 0, -9 },
  { 846, 6, 16, 5, 0, -13 },
  { 858, 4, 14, 4, 0, -12 },
  { 865, 5, 15, 5, -1, -12 },
  { 875, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Italic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_ITALIC16PT7B_H_
