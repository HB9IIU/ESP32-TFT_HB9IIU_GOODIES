#ifndef _ROBOTOCONDENSED_ITALIC14PT7B_H_
#define _ROBOTOCONDENSED_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x96, 0x92, 0x18, 0x56, 0xA0, 0x14, 0x28, 0x93, 0xF2, 0x89,
  0x3F, 0x28, 0x91, 0x40, 0x11, 0xD2, 0x94, 0x30, 0xC3, 0x8C, 0xBC, 0x80,
  0x61, 0x22, 0x54, 0xC7, 0x03, 0x8C, 0xA9, 0x52, 0x18, 0x18, 0x48, 0x91,
  0x43, 0x0E, 0x53, 0x66, 0x4C, 0xE8, 0x68, 0x12, 0x64, 0xC8, 0x88, 0x88,
  0x88, 0x84, 0x20, 0x84, 0x21, 0x0C, 0x42, 0x10, 0x88, 0x44, 0x40, 0x21,
  0x3E, 0xC5, 0x48, 0x31, 0x09, 0xF2, 0x11, 0x80, 0x69, 0x40, 0xE0, 0x30,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x20, 0x81, 0x00, 0x3A, 0x73,
  0x18, 0xC6, 0x33, 0x97, 0x00, 0x3C, 0x94, 0x92, 0x58, 0x3C, 0x94, 0x41,
  0x0C, 0x61, 0x08, 0x43, 0xF0, 0x1C, 0x96, 0x41, 0x38, 0x20, 0xF3, 0x49,
  0xC0, 0x04, 0x31, 0x47, 0x29, 0xA4, 0xBF, 0x08, 0x60, 0x7D, 0x04, 0x1C,
  0xD8, 0x20, 0xA2, 0x91, 0xC0, 0x1B, 0x11, 0xED, 0xC6, 0x31, 0x93, 0x00,
  0xFC, 0x30, 0x86, 0x10, 0x82, 0x10, 0x42, 0x00, 0x1C, 0x92, 0x49, 0x39,
  0x24, 0x53, 0x49, 0xC0, 0x32, 0x63, 0x18, 0xED, 0xE2, 0x36, 0x00, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x64, 0x48, 0x04, 0x67, 0x10, 0x60, 0x60,
  0x80, 0xF8, 0x01, 0xF0, 0x40, 0xC0, 0xC7, 0x72, 0x00, 0x76, 0xC2, 0x23,
  0x31, 0x00, 0x06, 0x00, 0x0F, 0x04, 0x22, 0x04, 0x99, 0x4A, 0x54, 0x95,
  0x26, 0x49, 0x96, 0xA6, 0xC4, 0x01, 0x00, 0x3C, 0x00, 0x0C, 0x18, 0x50,
  0xA2, 0x44, 0x9F, 0x22, 0xC7, 0x04, 0x3C, 0x44, 0x8B, 0x37, 0x88, 0x91,
  0x22, 0x4D, 0xF0, 0x3C, 0xC9, 0x1C, 0x08, 0x10, 0x20, 0x42, 0x88, 0xE0,
  0x3C, 0x4C, 0x8B, 0x16, 0x28, 0x50, 0xA2, 0x4D, 0xF0, 0x3E, 0x40, 0x83,
  0x07, 0xC8, 0x10, 0x20, 0x41, 0xF8, 0x3E, 0x40, 0x83, 0x06, 0x0F, 0x90,
  0x20, 0x41, 0x80, 0x3C, 0xC9, 0x1C, 0x08, 0x13, 0xA1, 0x42, 0xCC, 0xF0,
  0x21, 0x21, 0x21, 0x61, 0x7F, 0x42, 0x42, 0x42, 0x42, 0xC2, 0x24, 0x96,
  0x92, 0x58, 0x06, 0x08, 0x10, 0x20, 0x41, 0x82, 0x44, 0xC8, 0xE0, 0x23,
  0x26, 0x2C, 0x68, 0x70, 0x78, 0x48, 0x4C, 0x44, 0xC4, 0x20, 0x82, 0x18,
  0x61, 0x04, 0x10, 0x43, 0xE0, 0x30, 0xCC, 0x33, 0x1D, 0xC7, 0x53, 0x94,
  0xA5, 0x29, 0x32, 0x4C, 0xB2, 0x60, 0x21, 0x31, 0x31, 0x71, 0x6B, 0x4A,
  0x4A, 0x46, 0x46, 0xC6, 0x3C, 0xC9, 0x1C, 0x38, 0x70, 0xA1, 0x42, 0xC8,
  0xE0, 0x3E, 0x22, 0x23, 0x62, 0x62, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x3C,
  0xC9, 0x1C, 0x38, 0x50, 0xA1, 0x42, 0x88, 0xE0, 0x20, 0x40, 0x3C, 0x44,
  0x8B, 0x16, 0x6F, 0x92, 0x26, 0x45, 0x88, 0x1C, 0x4D, 0x8B, 0x03, 0x01,
  0x81, 0x62, 0x4C, 0xF0, 0xFE, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60,
  0xC0, 0x42, 0x8F, 0x16, 0x28, 0x50, 0xA3, 0x46, 0x88, 0xE0, 0xC3, 0x8D,
  0x12, 0x64, 0x89, 0x14, 0x28, 0x60, 0x40, 0xCC, 0x73, 0x2C, 0xC9, 0x52,
  0x55, 0x15, 0x46, 0x51, 0x98, 0x46, 0x11, 0x80, 0x23, 0x22, 0x34, 0x1C,
  0x18, 0x18, 0x38, 0x68, 0x44, 0xC4, 0xC6, 0x89, 0x22, 0x47, 0x06, 0x08,
  0x10, 0x60, 0xC0, 0x3E, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x30, 0xC1, 0xF8,
  0x32, 0x26, 0x44, 0x44, 0x44, 0xC8, 0xC0, 0xC9, 0x24, 0x92, 0x24, 0x80,
  0x30, 0x84, 0x21, 0x18, 0xC4, 0x21, 0x08, 0xCE, 0x00, 0x26, 0x6A, 0x90,
  0xFC, 0x4C, 0x39, 0xB0, 0x4F, 0x4B, 0x2C, 0x9E, 0x20, 0x82, 0x1E, 0x65,
  0x14, 0x51, 0x47, 0x2B, 0x80, 0x39, 0x94, 0x50, 0x43, 0x04, 0x9C, 0x02,
  0x04, 0x19, 0xE6, 0x48, 0x91, 0x22, 0xCC, 0x91, 0xE0, 0x39, 0x94, 0x5F,
  0x43, 0x04, 0x9E, 0x36, 0x4E, 0x44, 0xC8, 0x88, 0x80, 0x3D, 0x94, 0x51,
  0x47, 0x34, 0x9E, 0x0A, 0x67, 0x00, 0x20, 0x82, 0x1E, 0x65, 0x14, 0x53,
  0x4B, 0x28, 0x80, 0x21, 0xA4, 0x92, 0x58, 0x10, 0x32, 0x22, 0x22, 0x64,
  0x44, 0xC0, 0x20, 0x82, 0x1B, 0x49, 0x46, 0x14, 0x53, 0x68, 0x80, 0x24,
  0x96, 0x92, 0x4B, 0x00, 0x7B, 0x9B, 0x24, 0x49, 0x12, 0x4C, 0x92, 0x2C,
  0x8A, 0x22, 0x79, 0x94, 0x51, 0x4D, 0x2C, 0xA2, 0x39, 0x94, 0x51, 0x45,
  0x14, 0x9C, 0x59, 0x94, 0x51, 0x45, 0x1C, 0xAE, 0x82, 0x08, 0x00, 0x3D,
  0x94, 0x51, 0x4F, 0x34, 0x9E, 0x08, 0x20, 0x80, 0x76, 0x44, 0x44, 0xC8,
  0x39, 0xB4, 0x18, 0x18, 0x2C, 0x9C, 0x5D, 0x2D, 0x24, 0xC0, 0xCC, 0x63,
  0x19, 0xCA, 0x5E, 0x8C, 0xA5, 0x6A, 0x31, 0x08, 0x91, 0x9B, 0xBA, 0xAA,
  0xAC, 0xCC, 0xCC, 0xC8, 0x4D, 0xA3, 0x0C, 0x31, 0xC5, 0x26, 0x22, 0x48,
  0x91, 0x62, 0x85, 0x04, 0x08, 0x20, 0x43, 0x00, 0x7C, 0x21, 0x84, 0x21,
  0x0C, 0x3E, 0x08, 0x8C, 0x42, 0x10, 0x98, 0x42, 0x10, 0x84, 0x10, 0x24,
  0x94, 0x92, 0x4A, 0x40, 0x20, 0x84, 0x21, 0x08, 0x66, 0x21, 0x08, 0x44,
  0x40, 0x66, 0xD9, 0x80,
};

const GFXglyph RobotoCondensed_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 4, 3, 4, 1, -11 },
  { 7, 7, 10, 7, 1, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 7, 10, 9, 1, -10 },
  { 33, 7, 10, 7, 0, -10 },
  { 42, 2, 3, 2, 1, -11 },
  { 43, 4, 14, 4, 1, -11 },
  { 50, 5, 14, 4, -1, -11 },
  { 59, 5, 6, 6, 1, -10 },
  { 63, 5, 7, 7, 1, -8 },
  { 68, 3, 4, 3, -1, -2 },
  { 70, 3, 1, 3, 0, -5 },
  { 71, 2, 2, 4, 0, -2 },
  { 72, 7, 11, 5, -1, -10 },
  { 82, 5, 10, 7, 1, -10 },
  { 89, 3, 10, 7, 2, -10 },
  { 93, 6, 10, 7, 0, -10 },
  { 101, 6, 10, 7, 0, -10 },
  { 109, 6, 10, 7, 0, -10 },
  { 117, 6, 10, 7, 1, -10 },
  { 125, 5, 10, 7, 1, -10 },
  { 132, 6, 10, 7, 1, -10 },
  { 140, 6, 10, 7, 0, -10 },
  { 148, 5, 10, 7, 1, -10 },
  { 155, 3, 8, 3, 0, -8 },
  { 158, 4, 10, 3, -1, -8 },
  { 163, 6, 7, 6, 0, -8 },
  { 169, 5, 4, 7, 1, -7 },
  { 172, 6, 6, 6, 0, -7 },
  { 177, 5, 10, 6, 1, -10 },
  { 184, 10, 13, 10, 0, -10 },
  { 201, 7, 10, 8, 0, -10 },
  { 210, 7, 10, 7, 0, -10 },
  { 219, 7, 10, 8, 1, -10 },
  { 228, 7, 10, 8, 0, -10 },
  { 237, 7, 10, 7, 0, -10 },
  { 246, 7, 10, 7, 0, -10 },
  { 255, 7, 10, 8, 1, -10 },
  { 264, 8, 10, 8, 0, -10 },
  { 274, 3, 10, 3, 0, -10 },
  { 278, 7, 10, 7, 0, -10 },
  { 287, 8, 10, 7, 0, -10 },
  { 297, 6, 10, 6, 0, -10 },
  { 305, 10, 10, 10, 0, -10 },
  { 318, 8, 10, 8, 0, -10 },
  { 328, 7, 10, 8, 1, -10 },
  { 337, 8, 10, 8, 0, -10 },
  { 347, 7, 12, 8, 1, -10 },
  { 358, 7, 10, 7, 0, -10 },
  { 367, 7, 10, 7, 0, -10 },
  { 376, 7, 10, 7, 1, -10 },
  { 385, 7, 10, 8, 1, -10 },
  { 394, 7, 10, 8, 1, -10 },
  { 403, 10, 10, 10, 1, -10 },
  { 416, 8, 10, 7, 0, -10 },
  { 426, 7, 10, 7, 1, -10 },
  { 435, 7, 10, 7, 0, -10 },
  { 444, 4, 13, 3, 0, -11 },
  { 451, 3, 11, 5, 1, -10 },
  { 456, 5, 13, 3, -1, -11 },
  { 465, 4, 5, 5, 1, -10 },
  { 468, 6, 1, 6, -1, 0 },
  { 469, 3, 2, 4, 1, -10 },
  { 470, 6, 8, 7, 0, -8 },
  { 476, 6, 11, 7, 0, -11 },
  { 485, 6, 8, 6, 0, -8 },
  { 491, 7, 11, 7, 0, -11 },
  { 501, 6, 8, 6, 0, -8 },
  { 507, 4, 11, 4, 1, -11 },
  { 513, 6, 11, 7, 0, -8 },
  { 522, 6, 11, 7, 0, -11 },
  { 531, 3, 10, 3, 0, -10 },
  { 535, 4, 13, 3, -1, -10 },
  { 542, 6, 11, 6, 0, -11 },
  { 551, 3, 11, 3, 0, -11 },
  { 556, 10, 8, 10, 0, -8 },
  { 566, 6, 8, 7, 0, -8 },
  { 572, 6, 8, 7, 0, -8 },
  { 578, 6, 11, 7, 0, -8 },
  { 587, 6, 11, 7, 0, -8 },
  { 596, 4, 8, 4, 0, -8 },
  { 600, 6, 8, 6, 0, -8 },
  { 606, 3, 9, 4, 1, -9 },
  { 610, 5, 8, 7, 1, -8 },
  { 615, 5, 8, 6, 1, -8 },
  { 620, 8, 8, 9, 1, -8 },
  { 628, 6, 8, 6, 0, -8 },
  { 634, 7, 11, 6, -1, -8 },
  { 644, 6, 8, 6, 0, -8 },
  { 650, 5, 14, 4, 0, -11 },
  { 659, 3, 12, 3, 0, -10 },
  { 664, 5, 14, 4, -1, -11 },
  { 673, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Italic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_ITALIC14PT7B_H_
