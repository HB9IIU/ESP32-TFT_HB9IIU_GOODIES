#ifndef _ROBOTOCONDENSED_ITALIC29PT7B_H_
#define _ROBOTOCONDENSED_ITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0x86,
  0x00, 0x00, 0x0C, 0x38, 0xC0, 0x66, 0xD9, 0x36, 0x6C, 0xD9, 0x32, 0x00,
  0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x31, 0x80, 0x63, 0x07,
  0xFF, 0x9F, 0xFF, 0x06, 0x30, 0x0C, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC4,
  0x0F, 0xFF, 0x3F, 0xFC, 0x0C, 0x40, 0x11, 0x80, 0x63, 0x00, 0xC4, 0x01,
  0x18, 0x06, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x7C, 0x0F, 0xE1,
  0xEF, 0x18, 0x73, 0x83, 0x38, 0x33, 0x83, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xC7,
  0x3C, 0x7F, 0x81, 0xF0, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x38, 0x03, 0xE0,
  0x31, 0x81, 0x8C, 0x6C, 0x67, 0x63, 0x33, 0x1B, 0x19, 0xB0, 0xFD, 0x83,
  0xD8, 0x01, 0x80, 0x0D, 0xC0, 0xDF, 0x0D, 0x8C, 0x6C, 0x66, 0x63, 0x63,
  0x1F, 0x18, 0xD0, 0xCC, 0x07, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0x03,
  0x98, 0x38, 0xC1, 0x86, 0x0C, 0x30, 0x63, 0x83, 0xB8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x7E, 0x37, 0x31, 0xF1, 0xDF, 0x86, 0xD8, 0x3E, 0xC0, 0xE7,
  0x07, 0x1C, 0x78, 0xFF, 0xE1, 0xE3, 0x00, 0x76, 0x66, 0x66, 0x40, 0x00,
  0x80, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x08, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70,
  0xE0, 0xC0, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x43, 0x1E, 0xDF, 0xFF, 0xC7,
  0xC0, 0xF0, 0x36, 0x0E, 0x63, 0x8C, 0x21, 0x00, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0xCE, 0x77, 0x31, 0x00,
  0xFB, 0xE0, 0xFF, 0x00, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x87,
  0x38, 0x33, 0x03, 0x30, 0x37, 0x03, 0x70, 0x76, 0x07, 0x60, 0x76, 0x06,
  0x60, 0x66, 0x06, 0xE0, 0x6E, 0x0E, 0x60, 0xC6, 0x1C, 0x73, 0x83, 0xF8,
  0x1E, 0x00, 0x03, 0x0F, 0x3F, 0x7E, 0x46, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x03,
  0xE0, 0x7F, 0x83, 0x8E, 0x38, 0x71, 0x81, 0x9C, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xC0,
  0xFE, 0x1C, 0xE3, 0x87, 0x30, 0x73, 0x07, 0x00, 0x70, 0x06, 0x01, 0xE0,
  0xF8, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xEC, 0x0C, 0xC0, 0xCE,
  0x1C, 0xF3, 0x87, 0xF0, 0x3E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xD8, 0x0D, 0xC0, 0xEE, 0x0E, 0x70, 0x63, 0x07, 0x18,
  0x70, 0xC3, 0x0E, 0x38, 0x73, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xC1, 0xEF, 0x04, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x8C, 0x0C, 0x60, 0xE3, 0x06, 0x1C, 0x70,
  0x7F, 0x01, 0xF0, 0x00, 0x01, 0xC1, 0xF1, 0xF0, 0x70, 0x38, 0x0C, 0x07,
  0x01, 0xBC, 0xFF, 0xBC, 0x7E, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF8, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x87,
  0x38, 0x33, 0x83, 0x38, 0x73, 0x87, 0x18, 0xE0, 0xFC, 0x1F, 0x83, 0x1C,
  0x60, 0xCE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0x73, 0xC7, 0xF8,
  0x1E, 0x00, 0x0F, 0x03, 0xF0, 0xE7, 0x38, 0x66, 0x0E, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x39, 0xE7, 0xFC, 0x7B, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xE0, 0x78, 0x3E, 0x07, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x73, 0x98, 0x0C, 0x3C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x70, 0xC3, 0x86, 0x00, 0x00,
  0x20, 0x18, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x38, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xC0, 0x08, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x20, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x38, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1F, 0x0F,
  0xE7, 0xBD, 0x87, 0xE1, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x00, 0x60, 0xC0,
  0x06, 0x30, 0x00, 0xC6, 0x1E, 0x09, 0x87, 0xF1, 0x31, 0xCC, 0x2C, 0x31,
  0x85, 0x8C, 0x30, 0xB1, 0x86, 0x1C, 0x71, 0x87, 0x8C, 0x30, 0xF1, 0x86,
  0x1E, 0x30, 0xC2, 0xC6, 0x38, 0xD8, 0xCF, 0x33, 0x1F, 0x7E, 0x61, 0xC7,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x81, 0x00, 0x1F, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x0D,
  0x80, 0x3B, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x38, 0x1C, 0x70,
  0x30, 0x60, 0xE0, 0xC1, 0xFF, 0x87, 0xFF, 0x0C, 0x06, 0x38, 0x0E, 0x60,
  0x1D, 0xC0, 0x3B, 0x00, 0x7E, 0x00, 0x60, 0x1F, 0xE0, 0x7F, 0xC1, 0x83,
  0x86, 0x06, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x30, 0x70, 0xFF,
  0x87, 0xFE, 0x1C, 0x1C, 0x70, 0x31, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0xE0,
  0x73, 0x81, 0xCE, 0x1E, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xC1,
  0xE7, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x76, 0x01, 0xD8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0x30, 0x1C,
  0xC0, 0x73, 0x83, 0x87, 0x1E, 0x1F, 0xF0, 0x1F, 0x00, 0x1F, 0xC0, 0x7F,
  0xC1, 0x87, 0x86, 0x06, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x30,
  0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x19, 0xC0, 0x66, 0x03, 0x98,
  0x0E, 0xE0, 0x73, 0x83, 0x8E, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xFF, 0x87, 0xFE, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0xFC, 0x7F, 0xE1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0xC1, 0xE7, 0x8E, 0x06, 0x70, 0x1D, 0xC0, 0x76, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x7E, 0xC3, 0xFB, 0x00,
  0xEC, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x81, 0xC7, 0x1F, 0x1F, 0xF8, 0x1F,
  0x00, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x06, 0x38, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x3F, 0xFE, 0x7F, 0xFE, 0x70,
  0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0,
  0x18, 0xE0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0x1C, 0x71, 0xC6, 0x18, 0xE3,
  0x8E, 0x30, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xC0, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x38, 0x38, 0xE0, 0xE1, 0x83, 0x07, 0x3C, 0x1F, 0xE0, 0x1F, 0x00,
  0x1C, 0x0F, 0x1C, 0x1E, 0x18, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x38, 0xE0,
  0x39, 0xC0, 0x3B, 0x80, 0x37, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7B, 0x80, 0x71, 0x80, 0x61, 0xC0, 0x60, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0xC0, 0x70, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x71,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0x63, 0x60, 0x76, 0x37, 0x06, 0xE3, 0x30, 0xEE, 0x73, 0x0C,
  0xC7, 0x31, 0xCC, 0x73, 0x18, 0xC6, 0x33, 0x9C, 0x63, 0x31, 0xC6, 0x3B,
  0x1C, 0xE1, 0xE1, 0x8E, 0x1E, 0x18, 0xE1, 0xC1, 0x8C, 0x1C, 0x38, 0xC1,
  0x83, 0x80, 0x1C, 0x03, 0x1C, 0x03, 0x1E, 0x07, 0x1E, 0x07, 0x3E, 0x07,
  0x3E, 0x06, 0x3B, 0x06, 0x3B, 0x06, 0x33, 0x0E, 0x31, 0x8E, 0x71, 0x8E,
  0x71, 0x8C, 0x70, 0xCC, 0x70, 0xDC, 0x60, 0xDC, 0x60, 0x7C, 0xE0, 0x7C,
  0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x38, 0xC0, 0x38, 0x07, 0xE0, 0x3F, 0xC1,
  0xE7, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x76, 0x01, 0xD8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0xB0, 0x0C,
  0xC0, 0x73, 0x81, 0x87, 0x1E, 0x1F, 0xF0, 0x1F, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x60, 0xF0, 0xC0, 0x63, 0x80, 0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x06,
  0x30, 0x1C, 0x60, 0x39, 0xC1, 0xE3, 0xFF, 0x87, 0xFE, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0x63, 0x80, 0xE7, 0x01,
  0xCC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x33, 0x00, 0x66,
  0x00, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x38, 0xE0, 0xE0, 0xE3,
  0xC1, 0xFF, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x10, 0x1F, 0xE0,
  0x7F, 0xC1, 0x83, 0x86, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06,
  0x30, 0x38, 0xC1, 0xC7, 0xFE, 0x1F, 0xF0, 0x71, 0xC1, 0xC3, 0x06, 0x0C,
  0x18, 0x38, 0xE0, 0xE3, 0x81, 0x8E, 0x06, 0x38, 0x1C, 0xC0, 0x70, 0x03,
  0xE0, 0x3F, 0xC1, 0xE7, 0x8E, 0x06, 0x38, 0x18, 0xC0, 0x73, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x30, 0x1C, 0xC0, 0x73, 0x83, 0x87, 0x1E, 0x1F, 0xF0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xC7, 0x01, 0x8C, 0x03,
  0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x30, 0xC0, 0xE1, 0xE7, 0x81, 0xFE,
  0x01, 0xF8, 0x00, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x73,
  0x81, 0xCE, 0x06, 0x18, 0x38, 0x60, 0xC1, 0x87, 0x06, 0x18, 0x1C, 0xE0,
  0x73, 0x81, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x60, 0x6C, 0x0E, 0x06, 0xC0, 0xE0, 0xEC,
  0x1E, 0x0C, 0xC1, 0xE0, 0xCC, 0x1E, 0x1C, 0xE3, 0x61, 0x8E, 0x36, 0x18,
  0xE3, 0x63, 0x8E, 0x66, 0x30, 0xE6, 0x63, 0x0E, 0xE2, 0x70, 0xEC, 0x36,
  0x0E, 0xC3, 0x60, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x07, 0x03,
  0xC0, 0x70, 0x38, 0x07, 0x03, 0x80, 0x60, 0x38, 0x00, 0x1C, 0x07, 0x0C,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x06, 0x1C, 0x07, 0x38, 0x07, 0x70, 0x03,
  0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1C, 0x60, 0x3C, 0x70, 0x38, 0x70, 0x70, 0x30, 0x70,
  0x38, 0xE0, 0x38, 0xC0, 0x3B, 0x80, 0xEE, 0x07, 0x18, 0x18, 0x60, 0xE1,
  0xC7, 0x07, 0x1C, 0x0C, 0xE0, 0x33, 0x00, 0xDC, 0x03, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0x87, 0xC3, 0x01,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x3E, 0x1F, 0x00, 0xC6, 0x31, 0xCE, 0x31, 0x8C, 0x63, 0x18, 0xE3,
  0x18, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x60, 0x07, 0x83, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C,
  0x1E, 0x1F, 0x00, 0x06, 0x03, 0x03, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66,
  0x63, 0x70, 0xC0, 0x7F, 0xF7, 0xFE, 0xE3, 0x8C, 0x70, 0x0F, 0x83, 0xF8,
  0xE3, 0x98, 0x77, 0x0E, 0x01, 0xC3, 0xF9, 0xFE, 0x70, 0xDC, 0x1B, 0x03,
  0x60, 0xEC, 0x1D, 0xCF, 0x9F, 0xF1, 0xEE, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x67, 0x83, 0xFE, 0x1E, 0x71, 0xC1, 0x8E,
  0x0E, 0x70, 0x73, 0x03, 0x98, 0x1C, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0x83,
  0x9C, 0x18, 0xF3, 0xC6, 0xFC, 0x73, 0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0xB8,
  0x36, 0x06, 0xC0, 0xF8, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x6E,
  0x1C, 0xE7, 0x1F, 0xE0, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x3C, 0xC3, 0xF6, 0x38, 0xF3, 0x83, 0x98, 0x1C, 0xC0,
  0xCE, 0x06, 0x70, 0x33, 0x83, 0x98, 0x1C, 0xC0, 0xE7, 0x06, 0x38, 0x70,
  0xE7, 0x87, 0xFC, 0x1E, 0xE0, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x36, 0x06,
  0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x70, 0x0E, 0x08, 0xE3,
  0x9F, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0xF0, 0x30, 0x1C, 0x07, 0x07, 0xF1,
  0xFC, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x00, 0x07, 0x98, 0x7E, 0xC7, 0x1E,
  0x70, 0x73, 0x03, 0x98, 0x19, 0xC0, 0xCE, 0x06, 0x70, 0x73, 0x03, 0x98,
  0x1C, 0xE0, 0xC7, 0x0E, 0x1C, 0xF0, 0xFF, 0x83, 0xDC, 0x00, 0xE0, 0x06,
  0x00, 0x71, 0xC7, 0x07, 0xF8, 0x1F, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1B, 0xE1, 0xFE, 0x1E, 0x73, 0x87, 0x38, 0x33,
  0x83, 0x30, 0x73, 0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6,
  0x0E, 0x60, 0xEE, 0x0C, 0x18, 0x71, 0x80, 0x00, 0x03, 0x8C, 0x30, 0xC7,
  0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x3E, 0x1E, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0xE3, 0x0E, 0x18, 0xE0, 0xCE, 0x0E, 0xE0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x60, 0x73, 0x83, 0x9C, 0x18, 0x60,
  0xC3, 0x86, 0x0C, 0x70, 0x70, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30,
  0xC3, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x00, 0x1B, 0xC3,
  0xC1, 0xFE, 0xFE, 0x1C, 0x7C, 0xE3, 0x87, 0x87, 0x38, 0x30, 0x73, 0x83,
  0x07, 0x30, 0x70, 0x63, 0x07, 0x06, 0x30, 0x70, 0x67, 0x06, 0x0E, 0x70,
  0x60, 0xE7, 0x06, 0x0E, 0x60, 0xE0, 0xC6, 0x0E, 0x0C, 0x60, 0xE0, 0xCE,
  0x0C, 0x0C, 0x1B, 0xC1, 0xFE, 0x1E, 0x73, 0x87, 0x38, 0x33, 0x83, 0x30,
  0x73, 0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0x60,
  0xEE, 0x0C, 0x0F, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x70, 0x76, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x06, 0xC0, 0x6E, 0x0E, 0xE0, 0xC7, 0x1C, 0x7F,
  0x81, 0xE0, 0x0D, 0xF0, 0x3F, 0xE0, 0xE3, 0x87, 0x06, 0x1C, 0x1C, 0x70,
  0x71, 0x81, 0xC6, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x81, 0x8E, 0x0E, 0x38,
  0x30, 0xF1, 0xC3, 0x7E, 0x1C, 0xF0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x07, 0x60,
  0x66, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0xEC, 0x0E, 0xC0, 0xCE, 0x0C, 0xE0,
  0xCF, 0x3C, 0x7F, 0xC3, 0xDC, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x1B, 0x8F, 0xC7, 0xE7, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x0F, 0x83, 0xF8, 0xE7,
  0x38, 0x77, 0x0E, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x70, 0x07, 0x60,
  0xEC, 0x1D, 0xC7, 0x1F, 0xC1, 0xF0, 0x1C, 0x38, 0x67, 0xFF, 0xE7, 0x0E,
  0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x70, 0xF0, 0xE0, 0x30,
  0x73, 0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0x60,
  0xEE, 0x0C, 0xE0, 0xCE, 0x0C, 0xE1, 0xC7, 0x3C, 0x7F, 0xC3, 0xD8, 0xC0,
  0xF0, 0x7C, 0x1B, 0x06, 0xE3, 0xB8, 0xC6, 0x71, 0x98, 0x66, 0x1B, 0x06,
  0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0xC1, 0x83, 0xE0, 0xC1, 0xB0,
  0xE1, 0xD8, 0x78, 0xCC, 0x7C, 0x66, 0x36, 0x73, 0x9B, 0x31, 0xD9, 0x98,
  0xEC, 0xD8, 0x7E, 0x6C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x87,
  0x01, 0x83, 0x80, 0xC1, 0xC0, 0x1C, 0x38, 0x30, 0xE0, 0xC7, 0x03, 0x98,
  0x06, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x07, 0x70, 0x18, 0xC0, 0xE3, 0x07, 0x0E, 0x1C, 0x38, 0x18, 0x18, 0xC1,
  0xC6, 0x0C, 0x38, 0xE1, 0xC6, 0x0E, 0x70, 0x73, 0x81, 0x98, 0x0D, 0xC0,
  0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0x81, 0xC1,
  0xC1, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x87,
  0x83, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x01, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18,
  0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x60,
  0x08, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x70, 0x1C, 0x1E, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x38, 0x10, 0x00, 0x1C, 0x0C, 0xFC, 0x37,
  0x70, 0xD8, 0xE6, 0xE1, 0xF8, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 7, 7, 9, 3, -22 },
  { 24, 15, 21, 15, 1, -21 },
  { 64, 12, 27, 14, 1, -24 },
  { 105, 13, 21, 18, 3, -21 },
  { 140, 13, 21, 15, 1, -21 },
  { 175, 4, 7, 5, 2, -22 },
  { 179, 9, 30, 9, 1, -23 },
  { 213, 8, 30, 9, -1, -23 },
  { 243, 11, 12, 12, 2, -21 },
  { 260, 12, 15, 14, 1, -17 },
  { 283, 5, 7, 6, -2, -3 },
  { 288, 6, 2, 7, 1, -10 },
  { 290, 3, 3, 7, 1, -3 },
  { 292, 13, 23, 10, -1, -21 },
  { 330, 12, 21, 14, 1, -21 },
  { 362, 8, 21, 14, 3, -21 },
  { 383, 13, 21, 14, 0, -21 },
  { 418, 12, 21, 14, 1, -21 },
  { 450, 13, 21, 14, 0, -21 },
  { 485, 13, 21, 14, 1, -21 },
  { 520, 10, 21, 14, 2, -21 },
  { 547, 13, 21, 14, 2, -21 },
  { 582, 12, 21, 14, 1, -21 },
  { 614, 11, 21, 14, 2, -21 },
  { 643, 5, 16, 7, 1, -16 },
  { 653, 7, 20, 6, -1, -16 },
  { 671, 11, 13, 13, 1, -16 },
  { 689, 11, 8, 13, 2, -14 },
  { 700, 11, 13, 13, 1, -16 },
  { 718, 10, 21, 12, 2, -21 },
  { 745, 19, 26, 22, 1, -20 },
  { 807, 15, 21, 16, -1, -21 },
  { 847, 14, 21, 15, 1, -21 },
  { 884, 14, 21, 16, 2, -21 },
  { 921, 14, 21, 16, 1, -21 },
  { 958, 14, 21, 14, 1, -21 },
  { 995, 14, 21, 14, 1, -21 },
  { 1032, 14, 21, 17, 2, -21 },
  { 1069, 16, 21, 17, 1, -21 },
  { 1111, 6, 21, 7, 1, -21 },
  { 1127, 14, 21, 14, 0, -21 },
  { 1164, 16, 21, 15, 1, -21 },
  { 1206, 10, 21, 13, 1, -21 },
  { 1233, 20, 21, 21, 1, -21 },
  { 1286, 16, 21, 17, 1, -21 },
  { 1328, 14, 21, 17, 2, -21 },
  { 1365, 15, 21, 16, 1, -21 },
  { 1405, 15, 24, 17, 1, -21 },
  { 1450, 14, 21, 15, 1, -21 },
  { 1487, 14, 21, 15, 1, -21 },
  { 1524, 13, 21, 15, 3, -21 },
  { 1559, 15, 21, 16, 1, -21 },
  { 1599, 14, 21, 16, 3, -21 },
  { 1636, 20, 21, 21, 3, -21 },
  { 1689, 16, 21, 16, 0, -21 },
  { 1731, 14, 21, 15, 3, -21 },
  { 1768, 15, 21, 15, 0, -21 },
  { 1808, 9, 28, 7, 0, -24 },
  { 1840, 5, 23, 10, 3, -21 },
  { 1855, 9, 28, 7, -2, -24 },
  { 1887, 9, 10, 10, 1, -21 },
  { 1899, 12, 2, 11, -2, 0 },
  { 1902, 5, 4, 9, 3, -22 },
  { 1905, 11, 16, 13, 1, -16 },
  { 1927, 13, 22, 14, 0, -22 },
  { 1963, 11, 16, 13, 1, -16 },
  { 1985, 13, 22, 14, 1, -22 },
  { 2021, 11, 16, 13, 1, -16 },
  { 2043, 10, 22, 9, 1, -22 },
  { 2071, 13, 22, 14, 0, -16 },
  { 2107, 12, 22, 14, 0, -22 },
  { 2140, 6, 22, 6, 1, -22 },
  { 2157, 9, 28, 6, -3, -22 },
  { 2189, 13, 22, 13, 0, -22 },
  { 2225, 6, 22, 6, 1, -22 },
  { 2242, 20, 16, 21, 0, -16 },
  { 2282, 12, 16, 14, 0, -16 },
  { 2306, 12, 16, 14, 1, -16 },
  { 2330, 14, 22, 14, -1, -16 },
  { 2369, 12, 22, 14, 1, -16 },
  { 2402, 9, 16, 9, 0, -16 },
  { 2420, 11, 16, 13, 1, -16 },
  { 2442, 7, 19, 8, 1, -19 },
  { 2459, 12, 16, 14, 1, -16 },
  { 2483, 10, 16, 12, 2, -16 },
  { 2503, 17, 16, 18, 2, -16 },
  { 2537, 14, 16, 12, -1, -16 },
  { 2565, 13, 22, 12, -1, -16 },
  { 2601, 12, 16, 12, 0, -16 },
  { 2625, 9, 28, 9, 1, -23 },
  { 2657, 6, 25, 7, 0, -21 },
  { 2676, 9, 28, 9, -1, -23 },
  { 2708, 14, 6, 17, 1, -12 },
};

const GFXfont RobotoCondensed_Italic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_ITALIC29PT7B_H_
