#ifndef _ROBOTOCONDENSED_ITALIC38PT7B_H_
#define _ROBOTOCONDENSED_ITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x60, 0xF0, 0xF0, 0x60, 0x73, 0xB9, 0x98, 0xCC, 0xEE, 0x77, 0x33, 0x19,
  0x8C, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30,
  0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x38,
  0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x81, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00,
  0x30, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x8F,
  0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x1C,
  0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0x98, 0x01, 0xC7,
  0x04, 0x60, 0xC3, 0x98, 0x30, 0xC6, 0x1C, 0x71, 0x87, 0x38, 0x61, 0xCC,
  0x18, 0x66, 0x07, 0x3B, 0x80, 0xFD, 0xC0, 0x1E, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0xF0, 0x06, 0xFE, 0x03, 0x39, 0x81, 0xDC, 0x70, 0xE6, 0x1C, 0x31,
  0x87, 0x1C, 0x61, 0xCE, 0x38, 0x73, 0x06, 0x1D, 0x81, 0x86, 0x00, 0x73,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0xF1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C,
  0x07, 0xBE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F,
  0x06, 0x7B, 0xC7, 0x78, 0xE3, 0xB8, 0x79, 0xFC, 0x1D, 0xDE, 0x0F, 0xEE,
  0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x78, 0xF0, 0x7C, 0x7F, 0xFF, 0x1F, 0xF3,
  0x83, 0xF1, 0xE0, 0x37, 0x77, 0x66, 0x6E, 0xE0, 0x00, 0x20, 0x0C, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x0E,
  0x31, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x00, 0xEE,
  0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x18, 0x10, 0x20, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x71,
  0xCF, 0x39, 0xE7, 0x38, 0x40, 0xFF, 0xFE, 0xFE, 0x7F, 0xF6, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0x7F,
  0x80, 0x7E, 0x00, 0x00, 0x40, 0xF0, 0xFD, 0xFF, 0x7F, 0xDC, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0x38,
  0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x80, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C, 0x0F, 0x1C, 0x07, 0x3C,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x7F,
  0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xDC, 0x01, 0xDE, 0x00, 0xEE,
  0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xF0, 0x38,
  0x70, 0x38, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1D, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x18, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0x70,
  0x78, 0x70, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x07,
  0xE0, 0x3F, 0x81, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xEF, 0x87, 0xFF, 0x1F, 0xFE, 0x7C, 0x39, 0xE0, 0xF7, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0xC0, 0xE7,
  0x07, 0x9E, 0x3C, 0x7F, 0xE0, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1E, 0x0E, 0x0E, 0x1E, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3C,
  0x38, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x1C, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0x1E, 0x78, 0x39, 0xC0, 0xFF,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3B,
  0xC1, 0xE7, 0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0x7D, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x00,
  0x00, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF1, 0xE3, 0xC3, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xE0, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0x00, 0x04, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE0, 0x10, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x0F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xE7,
  0xE0, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x70,
  0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x07, 0x81, 0x87, 0x07, 0xF8, 0x61,
  0x83, 0xCF, 0x0C, 0xE0, 0xE1, 0x83, 0x38, 0x70, 0xE0, 0xCC, 0x18, 0x38,
  0x77, 0x0E, 0x0E, 0x1D, 0xC3, 0x83, 0x07, 0x60, 0xC1, 0xC1, 0x98, 0x70,
  0x70, 0x66, 0x1C, 0x1C, 0x1B, 0x87, 0x06, 0x06, 0xE1, 0xC3, 0x83, 0x38,
  0x70, 0xE0, 0xCE, 0x1C, 0x38, 0x73, 0x87, 0x1E, 0x18, 0xE1, 0xFD, 0x8C,
  0x38, 0x3E, 0x7F, 0x06, 0x0F, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB8,
  0x00, 0x3B, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x1E, 0x38, 0x01, 0xC1, 0x80, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1C,
  0x01, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0xF0, 0x00, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x07, 0x1C,
  0x03, 0xC7, 0x00, 0xE1, 0xC0, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0x80, 0xF0, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE3, 0xC0, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x3C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0,
  0x0F, 0x38, 0x01, 0xEF, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x1E, 0x70, 0x03, 0x8F, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03,
  0x83, 0xC1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0x03, 0xC0, 0xE0, 0x3C, 0x1C,
  0x03, 0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x00,
  0x70, 0xE0, 0x1E, 0x1C, 0x07, 0x87, 0x81, 0xE0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03,
  0x8F, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xFF, 0xBC, 0x1F, 0xE7, 0x83, 0xFC,
  0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0xCF, 0x00, 0x78,
  0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x07, 0x03,
  0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xE0, 0x78, 0x07,
  0x07, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0xC0,
  0x07, 0x3C, 0x00, 0x3B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xDE, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00,
  0xF0, 0x78, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x01,
  0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0x70, 0x07, 0xF0, 0xEE, 0x00, 0xFC,
  0x1D, 0xC0, 0x3F, 0x83, 0xB8, 0x07, 0x70, 0x77, 0x01, 0xEE, 0x0E, 0xE0,
  0x39, 0xC3, 0xCC, 0x0F, 0x78, 0x71, 0xC1, 0xCE, 0x0E, 0x38, 0x79, 0xC1,
  0xC7, 0x0E, 0x38, 0x38, 0xE3, 0xC7, 0x07, 0x1C, 0x71, 0xE1, 0xE3, 0x9E,
  0x3C, 0x3C, 0x33, 0x87, 0x07, 0x07, 0x70, 0xE0, 0xE0, 0xFC, 0x1C, 0x1C,
  0x1F, 0x83, 0x87, 0x83, 0xE0, 0xF0, 0xF0, 0x7C, 0x1E, 0x1C, 0x07, 0x03,
  0x83, 0x80, 0xE0, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF8,
  0x03, 0x83, 0xE0, 0x0E, 0x0F, 0x80, 0x38, 0x3F, 0x01, 0xE1, 0xFC, 0x07,
  0x87, 0xF0, 0x1C, 0x1C, 0xE0, 0x70, 0x73, 0x81, 0xC1, 0xCE, 0x07, 0x07,
  0x1C, 0x3C, 0x3C, 0x70, 0xF0, 0xF1, 0xC3, 0x83, 0x83, 0x8E, 0x0E, 0x0E,
  0x38, 0x38, 0x38, 0xE0, 0xE0, 0x77, 0x87, 0x81, 0xDE, 0x1E, 0x07, 0x70,
  0x70, 0x0F, 0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xFC, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8F, 0x00,
  0x79, 0xC0, 0x0F, 0x38, 0x00, 0xEF, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00,
  0xF7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x03,
  0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70, 0x01, 0xCF, 0x00, 0x78, 0xE0, 0x0E,
  0x1C, 0x03, 0xC3, 0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xE0, 0x3E, 0x0E,
  0x01, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x38, 0x03, 0x8F,
  0x00, 0x71, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xC0, 0x07, 0xB8,
  0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xE0,
  0x03, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xE0,
  0x1E, 0x1C, 0x03, 0x83, 0xC1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x20, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x01, 0xE0, 0xE0,
  0x1C, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x0F, 0x0E, 0x03, 0xC3, 0xC0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x3C, 0x1C, 0x07, 0x83, 0x80, 0x70, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3E, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C,
  0x3C, 0x07, 0x87, 0xC1, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00,
  0x38, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x38, 0x0F, 0x07, 0x01,
  0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x0F, 0x1E,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0xF0,
  0x01, 0xDC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0xB8, 0x07, 0x00,
  0xEE, 0x03, 0xC0, 0x7B, 0x80, 0xF0, 0x1C, 0xE0, 0x3C, 0x07, 0x38, 0x1F,
  0x03, 0xCE, 0x07, 0xC0, 0xE3, 0x83, 0xB8, 0x38, 0xE0, 0xEE, 0x1E, 0x38,
  0x3B, 0x87, 0x0E, 0x1C, 0xE1, 0xC3, 0x87, 0x38, 0xF0, 0xE1, 0x8E, 0x38,
  0x38, 0xE3, 0x8E, 0x0E, 0x38, 0xE7, 0x83, 0x9C, 0x39, 0xC0, 0xE7, 0x06,
  0x70, 0x39, 0x81, 0xBC, 0x0E, 0xE0, 0x6E, 0x01, 0xB8, 0x1B, 0x80, 0x6C,
  0x06, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1C, 0x0F,
  0x00, 0x38, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x80,
  0x01, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE0,
  0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xE0, 0x1E, 0x3C,
  0x03, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xE1, 0xE0, 0x1C,
  0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x00, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0x70, 0xE0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x87, 0x71, 0xCE, 0x39, 0xCE,
  0x19, 0xC3, 0x70, 0x7E, 0x0E, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xF1,
  0xC3, 0x87, 0x1C, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE3, 0xC1,
  0xE7, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x07, 0xFC, 0x3F, 0xF8, 0xFC, 0x73,
  0xC1, 0xEF, 0x03, 0xDE, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xF0, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE0, 0xF1, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x3E, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF0, 0xF0, 0xF0, 0x38, 0x70,
  0x1C, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3E, 0x1E,
  0x1F, 0xFF, 0x0E, 0xFF, 0x07, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF0, 0xF0, 0xF3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x03, 0xBC, 0x0F, 0x38,
  0x1C, 0x78, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0xF9, 0xC0, 0xFF, 0x70, 0x7F, 0xFC,
  0x3E, 0x1F, 0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x87, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x1C, 0x3C, 0x07, 0x0E, 0x01,
  0xC3, 0xC0, 0x70, 0x70, 0x3C, 0x1E, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0x38, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x80,
  0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x08, 0x78, 0x38, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x07, 0xFC, 0x7F, 0xCF, 0xF8, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x00, 0x01, 0xF3, 0x83, 0xFD, 0xC3, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x78,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03,
  0xCF, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x38, 0x70, 0x3C, 0x3C,
  0x3E, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xF3, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x80, 0xF0, 0x60, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x7C, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C,
  0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x06,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x03, 0xC3, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xC0, 0xE3,
  0xC0, 0x73, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xDE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF0, 0xE0, 0x70, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x87, 0x01, 0xC0, 0x07, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x0E, 0x78, 0x3E, 0x03, 0xFF, 0x9F, 0xE0, 0xFF, 0xEF, 0xF8,
  0x7C, 0x3F, 0x0E, 0x1E, 0x0F, 0x83, 0xC7, 0x01, 0xC0, 0xF1, 0xC0, 0x70,
  0x3C, 0x70, 0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0x8F, 0x03, 0x80, 0xE3, 0x80,
  0xE0, 0x38, 0xE0, 0x38, 0x0E, 0x38, 0x0E, 0x07, 0x8E, 0x07, 0x81, 0xE7,
  0x81, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x70, 0x1C, 0x07, 0x1C, 0x07, 0x01,
  0xC7, 0x01, 0xC0, 0xF1, 0xC0, 0xF0, 0x3C, 0x0E, 0x7C, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x03,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x78,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x38, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xC0, 0x07, 0x3E, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x1E,
  0x0F, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0x87,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE3, 0xC0,
  0x70, 0xF0, 0x3C, 0x3E, 0x1E, 0x0F, 0xFF, 0x83, 0xBF, 0xC0, 0xE7, 0xC0,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE7, 0x0F, 0xF7, 0x1F, 0xFF,
  0x3E, 0x1F, 0x3C, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xF0, 0x1C,
  0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x0E, 0xF0, 0xFF, 0x1F, 0xF1, 0xF8, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xF0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x1F, 0xF7, 0xFD, 0xFF, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x03, 0xE0, 0xF8, 0x1E, 0x00, 0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x7B,
  0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38,
  0xF1, 0xF1, 0xFF, 0xE1, 0xFD, 0xC1, 0xF3, 0x80, 0xE0, 0x1F, 0xC0, 0xF7,
  0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE0,
  0xC7, 0x03, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x38, 0x1C, 0xE0, 0x70,
  0x39, 0xC1, 0xE0, 0xF3, 0x83, 0xC1, 0xC7, 0x0F, 0x83, 0x8E, 0x1F, 0x0E,
  0x1C, 0x76, 0x1C, 0x38, 0xEC, 0x38, 0x73, 0x98, 0xE0, 0xE7, 0x39, 0xC1,
  0xCC, 0x77, 0x03, 0xB8, 0xEE, 0x07, 0x71, 0xD8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0xF0,
  0x1C, 0x78, 0x07, 0x1C, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xDC,
  0x00, 0xE7, 0x00, 0x78, 0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x07, 0x83, 0xC3,
  0xC0, 0x70, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x07,
  0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x73, 0xC0, 0x0C, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x30, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x0F, 0xC0,
  0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x02, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F,
  0x00, 0x70, 0x1F, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x40, 0x00, 0x1F, 0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x19,
  0xC7, 0x8E, 0xE0, 0xFF, 0x38, 0x1F, 0xC0, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 27, 9, 1, -27 },
  { 28, 9, 9, 12, 4, -29 },
  { 39, 19, 27, 20, 2, -27 },
  { 104, 16, 34, 18, 1, -31 },
  { 172, 18, 27, 23, 3, -27 },
  { 233, 17, 27, 20, 1, -27 },
  { 291, 4, 9, 6, 3, -29 },
  { 296, 11, 40, 12, 2, -31 },
  { 351, 12, 39, 12, -2, -30 },
  { 410, 15, 16, 16, 2, -27 },
  { 440, 15, 20, 18, 2, -22 },
  { 478, 6, 9, 7, -2, -4 },
  { 485, 8, 3, 9, 1, -13 },
  { 488, 4, 4, 10, 1, -4 },
  { 490, 17, 29, 14, -2, -27 },
  { 552, 15, 27, 18, 2, -27 },
  { 603, 10, 27, 18, 4, -27 },
  { 637, 17, 27, 18, 0, -27 },
  { 695, 16, 27, 18, 1, -27 },
  { 749, 17, 27, 18, 0, -27 },
  { 807, 16, 27, 18, 2, -27 },
  { 861, 14, 27, 18, 2, -27 },
  { 909, 17, 27, 18, 2, -27 },
  { 967, 16, 27, 18, 1, -27 },
  { 1021, 14, 27, 18, 3, -27 },
  { 1069, 7, 20, 9, 1, -20 },
  { 1087, 9, 25, 8, -2, -20 },
  { 1116, 14, 16, 16, 1, -20 },
  { 1144, 15, 11, 18, 2, -18 },
  { 1165, 15, 16, 17, 1, -20 },
  { 1195, 13, 27, 16, 3, -27 },
  { 1239, 26, 35, 28, 1, -27 },
  { 1353, 20, 27, 21, -1, -27 },
  { 1421, 18, 27, 20, 1, -27 },
  { 1482, 19, 27, 21, 2, -27 },
  { 1547, 19, 27, 21, 1, -27 },
  { 1612, 19, 27, 18, 1, -27 },
  { 1677, 18, 27, 18, 1, -27 },
  { 1738, 19, 27, 22, 2, -27 },
  { 1803, 22, 27, 23, 1, -27 },
  { 1878, 8, 27, 9, 1, -27 },
  { 1905, 18, 27, 18, 0, -27 },
  { 1966, 21, 27, 20, 1, -27 },
  { 2037, 14, 27, 18, 1, -27 },
  { 2085, 27, 27, 28, 1, -27 },
  { 2177, 22, 27, 23, 1, -27 },
  { 2252, 19, 27, 22, 2, -27 },
  { 2317, 20, 27, 20, 1, -27 },
  { 2385, 19, 32, 22, 2, -27 },
  { 2461, 19, 27, 20, 1, -27 },
  { 2526, 18, 27, 19, 1, -27 },
  { 2587, 18, 27, 19, 3, -27 },
  { 2648, 19, 27, 21, 2, -27 },
  { 2713, 19, 27, 21, 3, -27 },
  { 2778, 26, 27, 28, 4, -27 },
  { 2866, 23, 27, 20, -1, -27 },
  { 2944, 19, 27, 19, 3, -27 },
  { 3009, 20, 27, 19, 0, -27 },
  { 3077, 12, 37, 9, 0, -31 },
  { 3133, 7, 29, 14, 4, -27 },
  { 3159, 12, 37, 9, -2, -31 },
  { 3215, 11, 13, 14, 2, -27 },
  { 3233, 15, 3, 15, -2, 0 },
  { 3239, 6, 5, 11, 4, -28 },
  { 3243, 15, 20, 18, 1, -20 },
  { 3281, 17, 29, 18, 0, -29 },
  { 3343, 15, 20, 17, 1, -20 },
  { 3381, 18, 29, 18, 1, -29 },
  { 3447, 15, 20, 17, 1, -20 },
  { 3485, 12, 29, 12, 2, -29 },
  { 3529, 17, 28, 18, 0, -20 },
  { 3589, 16, 29, 18, 0, -29 },
  { 3647, 8, 27, 8, 1, -27 },
  { 3674, 12, 35, 8, -4, -27 },
  { 3727, 17, 29, 17, 0, -29 },
  { 3789, 8, 29, 8, 1, -29 },
  { 3818, 26, 20, 28, 0, -20 },
  { 3883, 16, 20, 18, 0, -20 },
  { 3923, 16, 20, 19, 1, -20 },
  { 3963, 18, 28, 18, -1, -20 },
  { 4026, 16, 28, 18, 1, -20 },
  { 4082, 12, 20, 11, 0, -20 },
  { 4112, 15, 20, 17, 1, -20 },
  { 4150, 10, 25, 11, 1, -25 },
  { 4182, 15, 20, 18, 2, -20 },
  { 4220, 14, 20, 16, 2, -20 },
  { 4255, 23, 20, 24, 2, -20 },
  { 4313, 18, 20, 16, -1, -20 },
  { 4358, 18, 28, 15, -2, -20 },
  { 4421, 16, 20, 16, 0, -20 },
  { 4461, 12, 37, 11, 1, -30 },
  { 4517, 7, 32, 9, 1, -27 },
  { 4545, 12, 37, 11, -2, -30 },
  { 4601, 18, 7, 22, 2, -14 },
};

const GFXfont RobotoCondensed_Italic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_ITALIC38PT7B_H_
