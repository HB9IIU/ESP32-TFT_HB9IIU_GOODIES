#ifndef _ROBOTOCONDENSED_ITALIC56PT7B_H_
#define _ROBOTOCONDENSED_ITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x38,
  0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xE3, 0x87, 0x1E, 0x1C,
  0x78, 0xF1, 0xC3, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x87, 0x83,
  0xC0, 0x71, 0xC0, 0x70, 0x3C, 0xF0, 0x1C, 0x0F, 0x3C, 0x0F, 0x07, 0x8F,
  0x03, 0xC3, 0xC3, 0xC0, 0xF0, 0xE0, 0xF0, 0x3C, 0x78, 0x3C, 0x0E, 0x3C,
  0x07, 0x07, 0x8E, 0x01, 0xE3, 0xE7, 0x80, 0x7F, 0xF3, 0xC0, 0x0F, 0xF8,
  0xE0, 0x01, 0xFC, 0x78, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0x79, 0xFF,
  0x00, 0x3C, 0xFF, 0xE0, 0x1E, 0x7C, 0x78, 0x07, 0x9E, 0x0E, 0x03, 0xC7,
  0x03, 0xC1, 0xE3, 0xC0, 0xF0, 0x70, 0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x1E,
  0x0F, 0x03, 0xC7, 0x03, 0xC0, 0xF3, 0xC0, 0xE0, 0x39, 0xE0, 0x3C, 0x1E,
  0x30, 0x0F, 0x07, 0x84, 0x01, 0xC3, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x0F, 0x3F,
  0x1F, 0x07, 0xBF, 0x0F, 0x83, 0xDF, 0x03, 0xE3, 0xFF, 0x81, 0xF1, 0xEF,
  0x80, 0x7C, 0xF7, 0xC0, 0x3E, 0xFB, 0xE0, 0x0F, 0xF9, 0xF0, 0x07, 0xFC,
  0xF8, 0x01, 0xFC, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x3F,
  0x87, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFE,
  0x7E, 0x07, 0xFC, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x3C, 0xF7, 0x9E, 0x79,
  0xE7, 0x9C, 0xF3, 0xCF, 0x3C, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x0E, 0x0E,
  0x7E, 0x39, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x9E,
  0x00, 0x7C, 0x7C, 0x03, 0xE0, 0xF0, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x80,
  0x60, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x07, 0x01,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x18, 0xF9, 0xF7, 0xF7, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3C, 0x7C,
  0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00,
  0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0x3E, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1,
  0xFE, 0x3F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0x3E, 0xF0, 0xFA, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3C, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x03, 0xF0, 0x06, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0xFC, 0x07, 0xDF, 0xF0, 0x3D, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF1, 0xF8,
  0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x78, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x83, 0xE0, 0x3F, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xC1, 0xF0, 0x7C, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0x80, 0x3F, 0x3E,
  0x01, 0xF9, 0xF0, 0x1F, 0xC7, 0xE3, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFE, 0xF8, 0x0F, 0xC7, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x1F, 0x07, 0xF0, 0x7C, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x80, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0x83, 0xE7, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x03, 0x83, 0x80, 0x3F, 0xE0, 0x1C, 0x3C,
  0x03, 0xFF, 0xC0, 0xE1, 0xC0, 0x3F, 0xFE, 0x07, 0x1E, 0x03, 0xE0, 0xF0,
  0x38, 0xF0, 0x1E, 0x07, 0x81, 0xCF, 0x01, 0xE0, 0x38, 0x0E, 0x78, 0x1E,
  0x03, 0xC0, 0x73, 0x80, 0xF0, 0x1E, 0x03, 0xBC, 0x07, 0x80, 0xF0, 0x1D,
  0xE0, 0x78, 0x07, 0x00, 0xEF, 0x03, 0xC0, 0x78, 0x07, 0x70, 0x1E, 0x03,
  0xC0, 0x3F, 0x81, 0xE0, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0xF0, 0x1D, 0xE0,
  0x78, 0x0F, 0x00, 0xEF, 0x03, 0xC0, 0x78, 0x07, 0x78, 0x1E, 0x03, 0xC0,
  0x7B, 0xC0, 0xF0, 0x1E, 0x03, 0x9C, 0x0F, 0x81, 0xE0, 0x1C, 0xE0, 0x7C,
  0x0F, 0x01, 0xE7, 0x01, 0xE0, 0xF8, 0x0E, 0x38, 0x0F, 0x0F, 0xC0, 0xF1,
  0xC0, 0x7E, 0xEF, 0x0F, 0x0F, 0x03, 0xFF, 0x7F, 0xF0, 0x78, 0x0F, 0xF1,
  0xFF, 0x03, 0xC0, 0x3F, 0x07, 0xF0, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x7C, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0F,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x0F, 0x80, 0x7F,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x03,
  0xF8, 0x3E, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0xFC, 0x7C, 0x03, 0xFF, 0xC7, 0x80, 0x3F, 0xFC, 0xF8,
  0x07, 0xFF, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xF0, 0x3F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x3F,
  0x00, 0x03, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0x8F, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xC0, 0x00, 0x1F, 0xE7, 0xC0,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xBC, 0x07, 0xDE, 0x00,
  0x0F, 0xFC, 0x07, 0xDE, 0x00, 0x0F, 0x7C, 0x07, 0x9E, 0x00, 0x1F, 0x7C,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x07, 0x9F, 0x00, 0x3E, 0x78, 0x0F, 0x9F,
  0x00, 0x3C, 0xF8, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x0F, 0x8F, 0x00, 0x78,
  0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x1F, 0x07, 0x87, 0xC1, 0xF0,
  0x1F, 0x07, 0x87, 0x83, 0xE0, 0x3E, 0x07, 0x8F, 0x83, 0xE0, 0x3E, 0x07,
  0x8F, 0x03, 0xE0, 0x3E, 0x07, 0x9F, 0x03, 0xE0, 0x3E, 0x07, 0xDE, 0x03,
  0xE0, 0x3E, 0x03, 0xFE, 0x03, 0xC0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7C,
  0x03, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x3F, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0xF8, 0x0F,
  0xF0, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x3E, 0x01,
  0xFF, 0x00, 0x1F, 0x01, 0xF7, 0x80, 0x0F, 0x80, 0xFB, 0xE0, 0x07, 0xC0,
  0x7C, 0xF0, 0x07, 0xC0, 0x3E, 0x78, 0x03, 0xE0, 0x1F, 0x3E, 0x01, 0xF0,
  0x0F, 0x0F, 0x00, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x03, 0xE0, 0xF0, 0x3E, 0x01, 0xF0, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x0F,
  0x80, 0xF8, 0x0F, 0x07, 0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xE1,
  0xE0, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0xC0, 0x3E,
  0x7C, 0x07, 0xC0, 0x0F, 0x3E, 0x03, 0xE0, 0x07, 0x9F, 0x01, 0xF0, 0x03,
  0xEF, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xC0, 0x3E, 0x00,
  0x3F, 0xE0, 0x3E, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0x80,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E,
  0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x1E,
  0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xE0,
  0x03, 0xEF, 0x00, 0x0F, 0x80, 0x0F, 0xBC, 0x00, 0x7E, 0x00, 0x3E, 0xF0,
  0x01, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x80,
  0x1E, 0x3E, 0x00, 0xFE, 0x00, 0xF8, 0xF8, 0x07, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0xE0, 0x0F, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x3E, 0x03, 0xCE, 0x01,
  0xF0, 0xF8, 0x0F, 0x38, 0x07, 0x83, 0xE0, 0x3C, 0xE0, 0x3E, 0x0F, 0x81,
  0xE3, 0xC0, 0xF8, 0x3E, 0x07, 0x8F, 0x03, 0xC0, 0xF8, 0x3E, 0x3C, 0x1F,
  0x03, 0xE0, 0xF0, 0xF0, 0x7C, 0x0F, 0x83, 0xC3, 0xC1, 0xE0, 0x3E, 0x1E,
  0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x3C, 0x3E, 0x03, 0xE3, 0xE0, 0xF0, 0xF0,
  0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x3E, 0x3C, 0x0F, 0x1F, 0x00, 0xF9, 0xE0,
  0x3C, 0x78, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x07, 0x9E, 0x01, 0xCF, 0x00,
  0x1E, 0xF0, 0x07, 0x3C, 0x00, 0x7B, 0xC0, 0x1D, 0xF0, 0x01, 0xEF, 0x00,
  0x77, 0x80, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0x1F, 0xE0, 0x07, 0x78, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0xC0, 0x03, 0xC1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x1E, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x9F, 0x01,
  0xEF, 0x00, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0x83, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x03,
  0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xE0,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xEF, 0x80, 0xFF, 0x1F,
  0x00, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7D, 0xFF, 0x00, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x00,
  0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xE0,
  0x1F, 0x9F, 0xE0, 0x7E, 0x3F, 0xFF, 0xF8, 0x7D, 0xFF, 0xF0, 0xF1, 0xFF,
  0xC1, 0xE1, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0x1F, 0x00, 0xFF, 0xE7, 0x80, 0x7F, 0xFB, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x83, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xE0,
  0x03, 0xFC, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x07, 0xE1,
  0xF0, 0x0F, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0,
  0x07, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x81, 0xF0, 0x07, 0x07, 0xE0, 0x3E, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE, 0x78, 0x07, 0xFF,
  0x9E, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE0, 0x7C, 0x03, 0xF8, 0x3E,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xBE, 0x00, 0x3F, 0xCF, 0x80, 0x01, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x0F, 0x80, 0x70, 0x07, 0xE0,
  0x1F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xDF, 0xE0, 0x1E, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E,
  0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xC0, 0x0F,
  0x80, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0x3F, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0x80, 0x7E,
  0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xE0,
  0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0xFF, 0x03, 0xFE,
  0x01, 0xEF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0xE0, 0xF8, 0x3E, 0x01, 0xFC, 0x07, 0xE1,
  0xF0, 0x0F, 0xE0, 0x1F, 0x0F, 0x00, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0x07, 0xC7, 0xC0, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x78, 0x01, 0xF1, 0xF0, 0x07,
  0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xC0,
  0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x03, 0xE3, 0xC0,
  0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xE0, 0x0F,
  0x8F, 0x80, 0x1E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x03, 0xE3, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0x80, 0x7B, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x1F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0,
  0x0F, 0x8F, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x07, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x78, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x7B, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3E, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0xF0,
  0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xEF, 0xFF, 0x81, 0xF3, 0xFF, 0x80, 0xF0,
  0xFF, 0x00, 0xF8, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1E, 0x03, 0xFF, 0x9E, 0x07, 0xFF,
  0xDE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF3, 0xC0, 0x01, 0x83,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x03, 0xCF, 0xC1,
  0xEF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xC8, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0x71, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xF0, 0x0F,
  0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x08, 0x00,
  0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1,
  0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x07, 0xE0,
  0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xBC, 0x03,
  0xFE, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0,
  0x1E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0,
  0x7C, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0x78, 0xF8, 0x3F, 0xC0,
  0xF8, 0xF8, 0x3D, 0xE0, 0xF0, 0xF8, 0x7D, 0xE0, 0xF0, 0xF8, 0x79, 0xE1,
  0xF0, 0xF8, 0x79, 0xE1, 0xE0, 0x78, 0xF1, 0xE3, 0xE0, 0x78, 0xF1, 0xE3,
  0xC0, 0x79, 0xF1, 0xE3, 0xC0, 0x79, 0xE1, 0xE7, 0xC0, 0x7B, 0xE1, 0xE7,
  0x80, 0x7B, 0xC1, 0xE7, 0x80, 0x7B, 0xC1, 0xEF, 0x00, 0x7F, 0x80, 0xEF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x01,
  0xE3, 0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xBF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x04, 0x00, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0xF1, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x0F, 0x7E, 0xFE, 0x07, 0x9E, 0x0F,
  0xC1, 0xE7, 0x81, 0xFD, 0xFB, 0xC0, 0x3F, 0xFC, 0xF0, 0x07, 0xFE, 0x3C,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoCondensed_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 41, 13, 2, -40 },
  { 58, 14, 13, 17, 5, -42 },
  { 81, 27, 40, 30, 3, -40 },
  { 216, 24, 53, 27, 2, -47 },
  { 375, 26, 42, 34, 5, -41 },
  { 512, 25, 42, 30, 2, -41 },
  { 644, 6, 13, 9, 5, -42 },
  { 654, 17, 58, 17, 3, -45 },
  { 778, 17, 58, 17, -3, -45 },
  { 902, 22, 23, 23, 3, -40 },
  { 966, 23, 30, 27, 2, -34 },
  { 1053, 9, 14, 11, -3, -6 },
  { 1069, 12, 4, 13, 1, -19 },
  { 1075, 7, 7, 14, 1, -6 },
  { 1082, 26, 43, 20, -3, -40 },
  { 1222, 22, 42, 27, 3, -41 },
  { 1338, 14, 40, 27, 7, -40 },
  { 1408, 25, 41, 27, 1, -41 },
  { 1537, 23, 42, 27, 2, -41 },
  { 1658, 25, 40, 27, 0, -40 },
  { 1783, 24, 41, 27, 3, -40 },
  { 1906, 21, 41, 27, 3, -40 },
  { 2014, 24, 40, 27, 4, -40 },
  { 2134, 24, 42, 27, 2, -41 },
  { 2260, 21, 41, 27, 4, -41 },
  { 2368, 11, 31, 13, 1, -30 },
  { 2411, 14, 38, 11, -3, -30 },
  { 2478, 21, 24, 24, 2, -30 },
  { 2541, 21, 15, 26, 3, -26 },
  { 2581, 21, 25, 25, 2, -30 },
  { 2647, 18, 42, 23, 5, -41 },
  { 2742, 37, 51, 42, 2, -39 },
  { 2978, 29, 40, 31, -2, -40 },
  { 3123, 27, 40, 30, 1, -40 },
  { 3258, 27, 42, 31, 3, -41 },
  { 3400, 28, 40, 31, 1, -40 },
  { 3540, 28, 40, 27, 1, -40 },
  { 3680, 27, 40, 26, 1, -40 },
  { 3815, 28, 42, 32, 3, -41 },
  { 3962, 33, 40, 34, 1, -40 },
  { 4127, 12, 40, 14, 1, -40 },
  { 4187, 26, 41, 26, 0, -40 },
  { 4321, 32, 40, 30, 1, -40 },
  { 4481, 21, 40, 26, 1, -40 },
  { 4586, 40, 40, 41, 1, -40 },
  { 4786, 33, 40, 34, 1, -40 },
  { 4951, 28, 42, 33, 3, -41 },
  { 5098, 29, 40, 30, 1, -40 },
  { 5243, 28, 48, 33, 3, -41 },
  { 5411, 28, 40, 29, 1, -40 },
  { 5551, 27, 42, 28, 1, -41 },
  { 5693, 26, 40, 28, 5, -40 },
  { 5823, 29, 41, 31, 2, -40 },
  { 5972, 28, 40, 30, 5, -40 },
  { 6112, 38, 40, 41, 6, -40 },
  { 6302, 33, 40, 30, -1, -40 },
  { 6467, 27, 40, 29, 5, -40 },
  { 6602, 30, 40, 28, 0, -40 },
  { 6752, 17, 55, 14, 0, -46 },
  { 6869, 10, 43, 20, 6, -40 },
  { 6923, 17, 55, 14, -3, -46 },
  { 7040, 17, 20, 20, 2, -40 },
  { 7083, 22, 4, 22, -3, 0 },
  { 7094, 9, 8, 17, 6, -42 },
  { 7103, 22, 32, 26, 1, -31 },
  { 7191, 23, 43, 27, 1, -42 },
  { 7315, 22, 32, 25, 2, -31 },
  { 7403, 26, 43, 27, 2, -42 },
  { 7543, 22, 32, 25, 2, -31 },
  { 7631, 18, 43, 17, 3, -43 },
  { 7728, 26, 42, 27, 0, -31 },
  { 7865, 22, 42, 26, 1, -42 },
  { 7981, 12, 41, 12, 1, -41 },
  { 8043, 17, 52, 12, -5, -41 },
  { 8154, 24, 42, 24, 1, -42 },
  { 8280, 12, 42, 12, 1, -42 },
  { 8343, 37, 31, 41, 1, -31 },
  { 8487, 22, 31, 26, 1, -31 },
  { 8573, 23, 32, 27, 2, -31 },
  { 8665, 25, 42, 27, -1, -31 },
  { 8797, 24, 42, 27, 2, -31 },
  { 8923, 17, 31, 17, 1, -31 },
  { 8989, 22, 32, 25, 1, -31 },
  { 9077, 14, 38, 16, 2, -37 },
  { 9144, 23, 31, 26, 2, -30 },
  { 9234, 21, 30, 23, 3, -30 },
  { 9313, 32, 30, 35, 4, -30 },
  { 9433, 25, 30, 24, -1, -30 },
  { 9527, 26, 41, 23, -2, -30 },
  { 9661, 23, 30, 24, 0, -30 },
  { 9748, 17, 54, 17, 2, -44 },
  { 9863, 11, 47, 13, 1, -40 },
  { 9928, 18, 54, 17, -3, -44 },
  { 10050, 26, 11, 32, 3, -22 },
};

const GFXfont RobotoCondensed_Italic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_ITALIC56PT7B_H_
