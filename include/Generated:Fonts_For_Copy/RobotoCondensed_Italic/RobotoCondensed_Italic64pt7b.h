#ifndef _ROBOTOCONDENSED_ITALIC64PT7B_H_
#define _ROBOTOCONDENSED_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x1E, 0x1E, 0x7C, 0x3C, 0xF8, 0xF9,
  0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0E, 0x3C, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF3, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x03, 0x0F, 0x01, 0xE0, 0x1E, 0xF0, 0x0F,
  0x01, 0xE7, 0x80, 0x78, 0x1F, 0x3C, 0x03, 0xC1, 0xF1, 0xE0, 0x1E, 0x0F,
  0x0F, 0x01, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x83, 0xC0, 0x78, 0x78, 0x1E,
  0x07, 0xC7, 0xC0, 0x78, 0x3C, 0x7C, 0x03, 0xFF, 0xE3, 0xC0, 0x0F, 0xFE,
  0x3E, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x07,
  0xC7, 0xFE, 0x00, 0x3C, 0x7F, 0xF8, 0x03, 0xC3, 0xEF, 0xC0, 0x3E, 0x3E,
  0x1F, 0x01, 0xE3, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC1, 0xF0, 0xF0, 0x1E,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x07, 0x8F, 0x83, 0xE0, 0x3C, 0x78,
  0x1E, 0x01, 0xE7, 0x80, 0xF0, 0x0F, 0x7C, 0x07, 0x80, 0xFB, 0xC0, 0x1E,
  0x07, 0x8C, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFB, 0xF0,
  0x3E, 0x3F, 0x9F, 0x81, 0xF3, 0xF8, 0x7E, 0x0F, 0x9F, 0x83, 0xF0, 0x7D,
  0xF8, 0x0F, 0xC7, 0xCF, 0xC0, 0x7E, 0x3E, 0x7C, 0x01, 0xF9, 0xF7, 0xE0,
  0x0F, 0xDF, 0x3F, 0x00, 0x3F, 0xF9, 0xF8, 0x01, 0xFF, 0x8F, 0xC0, 0x07,
  0xFC, 0x7E, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0xE3, 0xF0, 0x0F, 0xFE,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E,
  0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x0F,
  0x03, 0x9F, 0x0F, 0x8F, 0xDF, 0xF7, 0x9F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x87, 0xE0,
  0xF8, 0x0E, 0x00, 0x80, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0x79, 0xFB, 0xFF, 0xFF, 0xDF, 0x8C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xBE, 0x7F, 0x3F, 0x3E, 0x1F, 0x18, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7B, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x30,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x01,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x1F, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x03, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x3F,
  0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7E, 0x7C, 0x01, 0xFC, 0xFC, 0x07, 0xF9, 0xFC, 0x1F,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0x3E,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC3,
  0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0xFC, 0x00, 0x70, 0x1E, 0x00, 0x7F, 0xE0, 0x0F, 0x07, 0x80, 0x1F,
  0xFE, 0x01, 0xE0, 0xF0, 0x07, 0xFF, 0xF0, 0x3C, 0x3E, 0x01, 0xF8, 0x3C,
  0x07, 0x87, 0x80, 0x7C, 0x07, 0x80, 0xF1, 0xF0, 0x0F, 0x80, 0xF0, 0x1E,
  0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x80, 0x79, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE7, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0xBC, 0x03, 0xC0, 0x1E,
  0x00, 0xF7, 0x80, 0xF8, 0x03, 0xC0, 0x1C, 0xF0, 0x1F, 0x00, 0xF8, 0x03,
  0x9E, 0x03, 0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0xF8,
  0x1F, 0x00, 0x78, 0x03, 0xDE, 0x03, 0xE0, 0x1F, 0x00, 0x73, 0xC0, 0x7C,
  0x03, 0xE0, 0x1E, 0x78, 0x0F, 0x80, 0x78, 0x03, 0xCF, 0x01, 0xF0, 0x1F,
  0x00, 0x71, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x3C, 0x07, 0xC0, 0xFC, 0x03,
  0x87, 0x80, 0xF8, 0x1F, 0x80, 0xF0, 0xF0, 0x1F, 0x87, 0xF0, 0x3C, 0x1E,
  0x01, 0xFF, 0xDF, 0x0F, 0x83, 0xC0, 0x3F, 0xF9, 0xFF, 0xE0, 0x78, 0x03,
  0xFE, 0x3F, 0xF8, 0x07, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF,
  0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0xFF,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x01, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3E, 0x0F,
  0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00,
  0x00, 0x7D, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0x00, 0x00, 0x0F,
  0xF9, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xF0, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0x0F, 0xDF, 0x80, 0x7E, 0x7C, 0x00, 0x3E, 0x7E,
  0x01, 0xF1, 0xF0, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x03,
  0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x80, 0x7E, 0x07,
  0x83, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7C,
  0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xCF,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x3D, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xF7, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0xFF, 0x80, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0x00,
  0x7E, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x7F,
  0xE0, 0x00, 0xFC, 0x07, 0xEF, 0x80, 0x07, 0xC0, 0x3F, 0x7C, 0x00, 0x3E,
  0x01, 0xFB, 0xE0, 0x03, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x80, 0x7C, 0x7C,
  0x00, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0xFC,
  0x03, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0xFC, 0x03,
  0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0xF8, 0x00, 0x7D,
  0xF8, 0x0F, 0xC0, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x1F, 0x7C, 0x03, 0xF0,
  0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFE, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x7F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0xFF, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x78, 0x03, 0xF0, 0x7C, 0x01, 0xF7,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x78, 0x03, 0xE0, 0x7C, 0x03, 0xE7, 0x80,
  0x7E, 0x07, 0xC0, 0x3E, 0x78, 0x07, 0xE0, 0x7C, 0x03, 0xC7, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x07,
  0xC0, 0x78, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0,
  0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x3C,
  0x3E, 0x00, 0x7C, 0x3E, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x3C, 0x7C,
  0x00, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x00,
  0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x80, 0x03, 0xDF, 0x00, 0x3D, 0xF0, 0x00, 0x3D, 0xF0,
  0x03, 0xDF, 0x00, 0x03, 0xDE, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D,
  0xF8, 0x07, 0xBE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x0F, 0x87, 0xF0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0xC3, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7C, 0x03, 0xFE, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF9, 0xFF, 0x80, 0x3F, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xE0, 0x07, 0xE1,
  0xFE, 0x01, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xDF, 0xFF, 0xC1, 0xF3, 0xFF,
  0xF0, 0x3E, 0x3F, 0xFC, 0x07, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0xFC,
  0x3E, 0x00, 0x7F, 0xF8, 0xF8, 0x03, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xE1,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF7,
  0xC0, 0x01, 0xFF, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x02,
  0x07, 0xE0, 0x03, 0x03, 0xF0, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF,
  0xF9, 0xF0, 0x1F, 0xFF, 0xEF, 0x81, 0xFE, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xCF, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x20, 0x00, 0xFC, 0x01, 0xC0, 0x0F, 0xC0, 0x1F, 0x01, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7C, 0x03,
  0xF8, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x07, 0xC1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x8F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF9, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xFF,
  0x81, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x7E, 0x01, 0xFF, 0x80, 0xFC, 0x1F,
  0x00, 0x3F, 0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xC3, 0xF0, 0x03,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF9, 0xFF, 0x00, 0x7E, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x3F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE3, 0xFF,
  0x00, 0x0F, 0xBF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFF, 0x83,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x00, 0x7C, 0x7F, 0xF8,
  0x01, 0xF0, 0xFF, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x7C,
  0x07, 0xFF, 0x8F, 0x81, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFF, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xF3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x7D, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0x87,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xF0, 0x07,
  0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0x7D, 0xF8, 0x03, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x3E,
  0x01, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xE0, 0x0F, 0x8F, 0x80, 0xFF, 0x00,
  0xF8, 0x7C, 0x07, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0xE0, 0x7E, 0x1F, 0x03,
  0xFF, 0x03, 0xE0, 0xF8, 0x1E, 0xF8, 0x1F, 0x07, 0xC1, 0xF7, 0xC1, 0xF0,
  0x3E, 0x0F, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0xF0, 0x7C, 0x0F, 0x87, 0xC7,
  0x87, 0xC0, 0x7C, 0x7C, 0x3C, 0x3E, 0x03, 0xE3, 0xE1, 0xE3, 0xE0, 0x1F,
  0x1E, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x78, 0xF8, 0x07, 0xCF, 0x03, 0xEF,
  0x80, 0x1E, 0xF8, 0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0xFF, 0xC0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xE0,
  0x03, 0xC7, 0xFF, 0xC0, 0x0F, 0x3F, 0xFF, 0x80, 0x7C, 0xFC, 0x7F, 0x01,
  0xE7, 0xE0, 0xFC, 0x0F, 0x9F, 0x01, 0xFC, 0x7E, 0x7C, 0x03, 0xFF, 0xF1,
  0xE0, 0x07, 0xFF, 0x8F, 0x80, 0x0F, 0xFE, 0x3E, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 47, 15, 2, -46 },
  { 78, 15, 15, 20, 6, -48 },
  { 107, 32, 46, 34, 3, -46 },
  { 291, 27, 61, 31, 2, -54 },
  { 497, 29, 48, 39, 6, -47 },
  { 671, 29, 48, 34, 2, -47 },
  { 845, 7, 15, 11, 5, -48 },
  { 859, 19, 66, 20, 3, -51 },
  { 1016, 19, 66, 20, -3, -51 },
  { 1173, 25, 27, 27, 3, -46 },
  { 1258, 26, 32, 31, 3, -37 },
  { 1362, 11, 16, 12, -4, -7 },
  { 1384, 14, 5, 15, 1, -22 },
  { 1393, 7, 7, 16, 2, -6 },
  { 1400, 29, 50, 23, -3, -46 },
  { 1582, 26, 48, 31, 3, -47 },
  { 1738, 17, 46, 31, 7, -46 },
  { 1836, 28, 47, 31, 1, -47 },
  { 2001, 27, 48, 31, 2, -47 },
  { 2163, 29, 46, 31, 0, -46 },
  { 2330, 28, 47, 31, 3, -46 },
  { 2495, 24, 47, 31, 3, -46 },
  { 2636, 28, 46, 31, 4, -46 },
  { 2797, 27, 48, 31, 2, -47 },
  { 2959, 23, 47, 31, 5, -47 },
  { 3095, 12, 35, 15, 1, -34 },
  { 3148, 16, 43, 13, -3, -34 },
  { 3234, 24, 29, 28, 2, -35 },
  { 3321, 25, 17, 30, 3, -30 },
  { 3375, 25, 28, 29, 2, -34 },
  { 3463, 22, 48, 26, 5, -47 },
  { 3595, 43, 59, 48, 2, -45 },
  { 3913, 33, 46, 36, -2, -46 },
  { 4103, 31, 46, 34, 1, -46 },
  { 4282, 32, 48, 35, 3, -47 },
  { 4474, 32, 46, 35, 1, -46 },
  { 4658, 32, 46, 31, 1, -46 },
  { 4842, 31, 46, 30, 1, -46 },
  { 5021, 32, 48, 37, 3, -47 },
  { 5213, 37, 46, 39, 1, -46 },
  { 5426, 13, 46, 16, 2, -46 },
  { 5501, 30, 47, 30, 0, -46 },
  { 5678, 36, 46, 34, 1, -46 },
  { 5885, 24, 46, 30, 1, -46 },
  { 6023, 46, 46, 47, 1, -46 },
  { 6288, 37, 46, 38, 1, -46 },
  { 6501, 32, 48, 37, 3, -47 },
  { 6693, 34, 46, 34, 1, -46 },
  { 6889, 32, 55, 37, 3, -47 },
  { 7109, 31, 46, 33, 2, -46 },
  { 7288, 31, 48, 32, 1, -47 },
  { 7474, 29, 46, 32, 6, -46 },
  { 7641, 33, 47, 35, 3, -46 },
  { 7835, 32, 46, 35, 6, -46 },
  { 8019, 44, 46, 47, 6, -46 },
  { 8272, 37, 46, 34, -1, -46 },
  { 8485, 30, 46, 33, 6, -46 },
  { 8658, 35, 46, 32, -1, -46 },
  { 8860, 19, 62, 16, 0, -52 },
  { 9008, 12, 50, 23, 6, -46 },
  { 9083, 20, 62, 16, -4, -52 },
  { 9238, 19, 23, 23, 3, -46 },
  { 9293, 24, 5, 25, -3, 0 },
  { 9308, 11, 9, 19, 6, -48 },
  { 9321, 25, 36, 30, 2, -35 },
  { 9434, 27, 49, 31, 1, -48 },
  { 9600, 25, 36, 29, 2, -35 },
  { 9713, 30, 49, 31, 2, -48 },
  { 9897, 25, 36, 29, 2, -35 },
  { 10010, 21, 49, 20, 3, -49 },
  { 10139, 29, 48, 31, 0, -35 },
  { 10313, 26, 48, 30, 1, -48 },
  { 10469, 14, 47, 14, 1, -47 },
  { 10552, 20, 60, 14, -6, -47 },
  { 10702, 28, 48, 28, 1, -48 },
  { 10870, 14, 48, 14, 1, -48 },
  { 10954, 42, 35, 47, 1, -35 },
  { 11138, 26, 35, 30, 1, -35 },
  { 11252, 26, 36, 31, 2, -35 },
  { 11369, 30, 48, 31, -2, -35 },
  { 11549, 27, 48, 31, 2, -35 },
  { 11711, 19, 35, 19, 1, -35 },
  { 11795, 25, 36, 28, 1, -35 },
  { 11908, 17, 43, 18, 2, -42 },
  { 12000, 26, 35, 30, 3, -34 },
  { 12114, 24, 34, 27, 4, -34 },
  { 12216, 37, 34, 40, 4, -34 },
  { 12374, 30, 34, 27, -2, -34 },
  { 12502, 30, 47, 26, -3, -34 },
  { 12679, 27, 34, 27, 0, -34 },
  { 12794, 20, 61, 19, 2, -50 },
  { 12947, 13, 54, 15, 1, -46 },
  { 13035, 20, 62, 19, -3, -50 },
  { 13190, 30, 13, 37, 3, -26 },
};

const GFXfont RobotoCondensed_Italic64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_ITALIC64PT7B_H_
