#ifndef _ROBOTOCONDENSED_ITALIC53PT7B_H_
#define _ROBOTOCONDENSED_ITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x79, 0xE3, 0x8E, 0x1C,
  0x71, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x71, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0xC1, 0xC0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF8, 0x3E, 0x07,
  0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80,
  0x3E, 0x1E, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x78,
  0x70, 0x00, 0x70, 0x78, 0x0C, 0x70, 0x38, 0x1E, 0xF0, 0x38, 0x1C, 0xE0,
  0x38, 0x3C, 0xE0, 0x38, 0x78, 0xE0, 0x38, 0x70, 0xE0, 0x78, 0xF0, 0xE0,
  0x71, 0xE0, 0xF0, 0x71, 0xC0, 0x70, 0xF3, 0xC0, 0x7F, 0xE7, 0x80, 0x3F,
  0xC7, 0x00, 0x1F, 0x8F, 0x00, 0x04, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x20, 0x00, 0x71, 0xFC, 0x00, 0xF3, 0xFE, 0x01,
  0xE7, 0xFE, 0x01, 0xCF, 0x0F, 0x03, 0xCE, 0x07, 0x07, 0x8E, 0x07, 0x0F,
  0x1E, 0x07, 0x0E, 0x1E, 0x07, 0x1E, 0x1E, 0x07, 0x3C, 0x1C, 0x07, 0x38,
  0x1C, 0x0F, 0x78, 0x1C, 0x0F, 0x70, 0x1E, 0x0E, 0x20, 0x0E, 0x1E, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFB, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07,
  0xC1, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xCF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x3E, 0x0F, 0x3E, 0x3E, 0x0F, 0x7C,
  0x1F, 0x1E, 0x7C, 0x1F, 0x1E, 0xF8, 0x0F, 0x9E, 0xF8, 0x0F, 0xBC, 0xF0,
  0x07, 0xFC, 0xF0, 0x07, 0xFC, 0xF0, 0x03, 0xF8, 0xF0, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xF8, 0x7F, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFE, 0x7C, 0x0F, 0xF8, 0x3E, 0x00, 0xC0, 0x00, 0x3C,
  0xF3, 0xCF, 0x39, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x60, 0x78, 0x17, 0x87, 0x0F, 0xFF, 0x77, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFB, 0xC0, 0x1F, 0x3C, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x07,
  0x80, 0xF0, 0x38, 0x0E, 0x01, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x3E, 0x1E,
  0x0E, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x7E, 0x7F, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78,
  0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x0F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x07,
  0xC0, 0xFC, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9E, 0x3E, 0xE0, 0xFA, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0xFE,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0x80, 0xFC, 0x0F, 0x81,
  0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x3C,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C,
  0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xFC,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xF0, 0x3C, 0x01, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x1F, 0xC0, 0xF8,
  0x0F, 0x80, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xFD, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE7, 0xE0, 0x3D,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF8, 0x7C, 0x7E, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0xC0,
  0xF8, 0x3F, 0x7F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFB, 0xF8, 0x1F, 0x83,
  0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF8,
  0x0F, 0x81, 0xE0, 0x7C, 0x07, 0xC3, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7E, 0x1F, 0x03, 0xE0, 0x3C, 0x0F,
  0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD, 0xFC, 0x3E, 0x0F,
  0x8F, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xF7, 0xC0, 0xFC,
  0xFC, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xF7, 0xC0, 0xF8, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0x83,
  0xE7, 0xC0, 0x79, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x1F, 0x00, 0x70, 0xF0, 0x0F,
  0xF8, 0x0E, 0x1E, 0x03, 0xFF, 0x81, 0xC7, 0x80, 0xF8, 0xF8, 0x38, 0xF0,
  0x3C, 0x0E, 0x07, 0x1C, 0x07, 0x83, 0xC0, 0xE7, 0x81, 0xE0, 0x78, 0x1C,
  0xE0, 0x38, 0x0F, 0x03, 0x9C, 0x0F, 0x01, 0xC0, 0x77, 0x81, 0xE0, 0x78,
  0x0E, 0xF0, 0x78, 0x0F, 0x01, 0xDC, 0x0F, 0x01, 0xE0, 0x3B, 0x81, 0xE0,
  0x38, 0x07, 0xF0, 0x38, 0x07, 0x01, 0xFE, 0x0F, 0x01, 0xE0, 0x3B, 0xC1,
  0xE0, 0x3C, 0x07, 0x70, 0x3C, 0x07, 0x00, 0xEE, 0x07, 0x80, 0xE0, 0x3D,
  0xC0, 0xF0, 0x3C, 0x07, 0x38, 0x1E, 0x07, 0x80, 0xE7, 0x03, 0xC1, 0xF0,
  0x38, 0xE0, 0x78, 0x3E, 0x0F, 0x1C, 0x0F, 0x9D, 0xC1, 0xC3, 0x81, 0xFF,
  0xBF, 0xF0, 0x70, 0x1F, 0xE7, 0xFC, 0x0E, 0x01, 0xF8, 0x7F, 0x01, 0xE0,
  0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3E, 0x07, 0xF0,
  0x07, 0x80, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C,
  0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0xCF,
  0x80, 0x7F, 0xF3, 0xE0, 0x3F, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0,
  0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x7E, 0x00,
  0x3C, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xE0, 0xFC, 0x00, 0x07, 0x87,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xBE, 0x00, 0x01,
  0xFC, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xE0,
  0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x7B,
  0xC0, 0x01, 0xEF, 0x01, 0xEF, 0x00, 0x0F, 0xFC, 0x07, 0xBC, 0x00, 0x3D,
  0xF0, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0xFB, 0xE0, 0x07, 0x9E, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x3C, 0x78, 0x07, 0xCF,
  0x80, 0xF1, 0xE0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E,
  0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x1F, 0x1F, 0x01, 0xF0, 0xF0, 0x78, 0x7C,
  0x07, 0x83, 0xC3, 0xE1, 0xF0, 0x1E, 0x0F, 0x0F, 0x07, 0xC0, 0xF8, 0x3C,
  0x7C, 0x1E, 0x03, 0xE0, 0xF1, 0xE0, 0x78, 0x0F, 0x83, 0xCF, 0x83, 0xE0,
  0x3E, 0x07, 0xBC, 0x0F, 0x80, 0xF0, 0x1E, 0xF0, 0x3E, 0x03, 0xC0, 0x7F,
  0x80, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xC0, 0x7C, 0x07, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF0,
  0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0x7F, 0x00, 0x0F, 0x80,
  0xFE, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x78, 0x0F,
  0xF8, 0x01, 0xF0, 0x1F, 0x78, 0x03, 0xE0, 0x3C, 0xF0, 0x07, 0xC0, 0x79,
  0xE0, 0x0F, 0x81, 0xF1, 0xE0, 0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0x07, 0xC7,
  0x80, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0x3C, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x0F, 0x01, 0xF0, 0x3C, 0x1E, 0x03, 0xE0, 0x78,
  0x7C, 0x07, 0xC0, 0x78, 0xF8, 0x0F, 0x00, 0xF1, 0xF0, 0x1E, 0x01, 0xE3,
  0xE0, 0x7C, 0x01, 0xE7, 0x80, 0xF8, 0x03, 0xCF, 0x01, 0xF0, 0x07, 0xBE,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0x80, 0x0F, 0xF8, 0x0F, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x3F, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3C, 0x00, 0x7E, 0x03,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x9F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x83, 0xC0, 0x0F, 0xC0, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0x80,
  0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F,
  0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x3D,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0x80, 0x3C, 0x78, 0x03, 0xF8, 0x07, 0xC7, 0x80, 0x3F, 0x80, 0x7C, 0x78,
  0x07, 0xF8, 0x07, 0x87, 0x80, 0x7F, 0x80, 0x78, 0x78, 0x0F, 0x78, 0x0F,
  0x87, 0x80, 0xF7, 0x80, 0xF0, 0x78, 0x0F, 0x78, 0x0F, 0x07, 0x81, 0xE7,
  0x81, 0xF0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0x81, 0xE0, 0x78,
  0x3C, 0x38, 0x3E, 0x07, 0x83, 0xC3, 0x83, 0xC0, 0x78, 0x78, 0x38, 0x3C,
  0x07, 0x87, 0x83, 0x87, 0xC0, 0x78, 0x78, 0x38, 0x78, 0x07, 0x8F, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x3C, 0xF8, 0x07, 0x8E, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x3C, 0xF0, 0x07, 0x9E, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x3D, 0xE0,
  0x07, 0xBC, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF1, 0xF8,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0x9C, 0x07, 0x9C, 0x0F, 0x9C, 0x0F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x0E, 0x78, 0x0F, 0xF8, 0x0F,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7C,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x04, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xE0, 0x7C,
  0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFE, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x7C,
  0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF7, 0x80, 0xFE, 0x3C,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x79, 0xF0,
  0x01, 0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x3F, 0x80, 0xF8, 0xFF, 0xFF, 0xE3, 0xCF, 0xFF, 0x0F,
  0x3F, 0xF8, 0x3C, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFE, 0x7E, 0x0F, 0x80, 0xF8,
  0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x7C,
  0x0F, 0x83, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x01, 0xFE, 0x3C, 0x07, 0xFF, 0x7C, 0x0F, 0xFF, 0x7C,
  0x1F, 0xFF, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xE7, 0x80, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3,
  0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x18, 0x7C, 0x07, 0x87, 0xF1, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0x01, 0xFF, 0xCF, 0x03, 0xFF,
  0xEF, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xF9, 0xF0, 0x00, 0x41, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0x78, 0x1F,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF9, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0x00, 0x80,
  0x38, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0x81,
  0xF8, 0x0F, 0x07, 0xE0, 0x1E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xE3, 0xE0, 0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xF7, 0xC0, 0x0F, 0xC7, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x78,
  0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0x78, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x08, 0x01, 0xF7, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFB, 0xFF, 0xE0, 0xFF,
  0x7F, 0x7F, 0xFC, 0x1F, 0x83, 0xFE, 0x0F, 0xC3, 0xE0, 0x3F, 0x80, 0xF8,
  0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x00,
  0x7C, 0x78, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x01, 0xF1, 0xE0, 0x0F,
  0x80, 0x3C, 0x7C, 0x01, 0xE0, 0x07, 0x8F, 0x80, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x80, 0x3E, 0x3C, 0x01, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xC0, 0x1E, 0x3E, 0x00, 0xF0, 0x03, 0xC7, 0xC0, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0x03, 0xE3, 0xC0, 0x1F,
  0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0x01, 0xE3, 0xE0,
  0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C,
  0x07, 0xC0, 0xFC, 0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xF8, 0x03, 0xDF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x1F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3C, 0xFF, 0xE0, 0x3C, 0x7F, 0x80, 0x3C, 0x0C, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xF0, 0x7F, 0xF3,
  0xC3, 0xFF, 0xFF, 0x1F, 0xE7, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x9E, 0x00,
  0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C,
  0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0,
  0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x7C, 0x0F,
  0xC1, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xF7, 0x80,
  0x04, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xBF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC3, 0xE0,
  0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x0C, 0x00, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8,
  0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0xFC, 0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0x78,
  0x07, 0xF9, 0xE0, 0x03, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78,
  0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0x80, 0xF0, 0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0,
  0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF0, 0x0F, 0x80, 0x7D,
  0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x7E, 0x03, 0xE7, 0x80, 0xFC, 0x07, 0xCF,
  0x01, 0xF8, 0x0F, 0x1E, 0x07, 0xF0, 0x3E, 0x3C, 0x0F, 0xE0, 0x78, 0x78,
  0x3F, 0xC0, 0xF0, 0xF0, 0x7B, 0x83, 0xC1, 0xE1, 0xE7, 0x07, 0x83, 0xC3,
  0xCF, 0x1F, 0x07, 0x87, 0x9E, 0x3C, 0x0F, 0x1E, 0x3C, 0x78, 0x1E, 0x3C,
  0x79, 0xE0, 0x3C, 0xF0, 0xF3, 0xC0, 0x39, 0xE1, 0xE7, 0x80, 0x7F, 0x83,
  0xDE, 0x00, 0xFF, 0x07, 0xBC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x03,
  0xC0, 0x7C, 0x03, 0xC0, 0xFC, 0x03, 0xE0, 0xF8, 0x01, 0xE1, 0xF0, 0x01,
  0xE1, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xF7, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0x87, 0x80, 0x0F,
  0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x03, 0xE0,
  0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x78,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x03, 0x80, 0x01, 0x00, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xCF, 0xFF, 0x81,
  0xE7, 0xC7, 0xE0, 0xF7, 0xC1, 0xF8, 0xF3, 0xC0, 0x7F, 0xF9, 0xE0, 0x1F,
  0xF8, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 39, 13, 2, -38 },
  { 55, 13, 13, 16, 5, -40 },
  { 77, 27, 38, 28, 2, -38 },
  { 206, 22, 51, 25, 2, -45 },
  { 347, 24, 40, 33, 5, -39 },
  { 467, 24, 40, 28, 2, -39 },
  { 587, 6, 12, 9, 4, -40 },
  { 596, 16, 55, 16, 3, -43 },
  { 706, 16, 55, 16, -3, -43 },
  { 816, 20, 22, 22, 3, -38 },
  { 871, 22, 28, 26, 2, -32 },
  { 948, 9, 13, 10, -3, -6 },
  { 963, 11, 4, 13, 1, -18 },
  { 969, 6, 6, 14, 1, -5 },
  { 974, 24, 41, 19, -3, -38 },
  { 1097, 21, 40, 25, 3, -39 },
  { 1202, 14, 38, 25, 6, -38 },
  { 1269, 24, 39, 25, 0, -39 },
  { 1386, 23, 40, 25, 1, -39 },
  { 1501, 24, 38, 25, 0, -38 },
  { 1615, 23, 39, 25, 3, -38 },
  { 1728, 20, 39, 25, 3, -38 },
  { 1826, 24, 38, 25, 3, -38 },
  { 1940, 22, 40, 25, 2, -39 },
  { 2050, 19, 39, 25, 4, -39 },
  { 2143, 10, 29, 12, 1, -28 },
  { 2180, 13, 35, 11, -3, -28 },
  { 2237, 19, 24, 23, 2, -29 },
  { 2294, 20, 14, 25, 3, -25 },
  { 2329, 20, 23, 24, 2, -28 },
  { 2387, 18, 40, 22, 4, -39 },
  { 2477, 35, 49, 40, 2, -37 },
  { 2692, 28, 38, 30, -2, -38 },
  { 2825, 26, 38, 28, 1, -38 },
  { 2949, 26, 40, 29, 3, -39 },
  { 3079, 27, 38, 29, 1, -38 },
  { 3208, 26, 38, 26, 1, -38 },
  { 3332, 26, 38, 25, 1, -38 },
  { 3456, 26, 40, 30, 3, -39 },
  { 3586, 31, 38, 32, 1, -38 },
  { 3734, 12, 38, 13, 1, -38 },
  { 3791, 25, 39, 25, 0, -38 },
  { 3913, 30, 38, 28, 1, -38 },
  { 4056, 20, 38, 24, 1, -38 },
  { 4151, 38, 38, 39, 1, -38 },
  { 4332, 31, 38, 32, 1, -38 },
  { 4480, 26, 40, 31, 3, -39 },
  { 4610, 28, 38, 29, 1, -38 },
  { 4743, 26, 45, 31, 3, -39 },
  { 4890, 26, 38, 27, 1, -38 },
  { 5014, 26, 40, 27, 1, -39 },
  { 5144, 24, 38, 27, 5, -38 },
  { 5258, 28, 39, 29, 2, -38 },
  { 5395, 26, 38, 29, 5, -38 },
  { 5519, 36, 38, 39, 5, -38 },
  { 5690, 31, 38, 28, -1, -38 },
  { 5838, 25, 38, 27, 5, -38 },
  { 5957, 28, 38, 27, 0, -38 },
  { 6090, 16, 51, 13, 0, -43 },
  { 6192, 10, 41, 19, 5, -38 },
  { 6244, 16, 51, 13, -3, -43 },
  { 6346, 16, 19, 19, 2, -38 },
  { 6384, 21, 4, 21, -3, 0 },
  { 6395, 9, 8, 16, 5, -40 },
  { 6404, 21, 30, 25, 1, -29 },
  { 6483, 22, 41, 25, 1, -40 },
  { 6596, 21, 30, 24, 2, -29 },
  { 6675, 24, 41, 26, 2, -40 },
  { 6798, 20, 30, 24, 2, -29 },
  { 6873, 17, 41, 16, 3, -41 },
  { 6961, 24, 40, 25, 0, -29 },
  { 7081, 21, 40, 25, 1, -40 },
  { 7186, 11, 39, 12, 1, -39 },
  { 7240, 17, 50, 12, -5, -39 },
  { 7347, 23, 40, 23, 1, -40 },
  { 7462, 11, 40, 12, 1, -40 },
  { 7517, 35, 29, 39, 1, -29 },
  { 7644, 21, 29, 25, 1, -29 },
  { 7721, 22, 30, 26, 2, -29 },
  { 7804, 24, 40, 25, -1, -29 },
  { 7924, 22, 40, 26, 2, -29 },
  { 8034, 16, 29, 16, 1, -29 },
  { 8092, 21, 30, 23, 1, -29 },
  { 8171, 13, 36, 15, 2, -35 },
  { 8230, 22, 29, 25, 2, -28 },
  { 8310, 20, 28, 22, 3, -28 },
  { 8380, 31, 28, 33, 3, -28 },
  { 8489, 24, 28, 23, -1, -28 },
  { 8573, 25, 39, 21, -2, -28 },
  { 8695, 22, 28, 23, 0, -28 },
  { 8772, 16, 50, 16, 2, -41 },
  { 8872, 11, 45, 13, 1, -38 },
  { 8934, 16, 51, 16, -2, -41 },
  { 9036, 25, 10, 30, 3, -20 },
};

const GFXfont RobotoCondensed_Italic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_ITALIC53PT7B_H_
