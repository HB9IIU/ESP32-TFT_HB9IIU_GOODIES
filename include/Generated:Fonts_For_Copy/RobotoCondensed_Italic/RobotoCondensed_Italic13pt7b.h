#ifndef _ROBOTOCONDENSED_ITALIC13PT7B_H_
#define _ROBOTOCONDENSED_ITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0xC0, 0x76, 0x80, 0x14, 0x97, 0xCA, 0x51, 0x4F,
  0xA8, 0xA0, 0x08, 0xE2, 0x59, 0x20, 0xC0, 0x92, 0x49, 0xC2, 0x00, 0x62,
  0x5A, 0x9C, 0x10, 0xB5, 0x65, 0x1C, 0x18, 0x92, 0x8E, 0x31, 0x5C, 0xD2,
  0x74, 0xA8, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11,
  0x11, 0x12, 0x24, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x21, 0x09, 0xF6, 0x21,
  0x00, 0x58, 0xE0, 0xC0, 0x04, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x00,
  0x72, 0x63, 0x18, 0xCA, 0x52, 0xE0, 0x75, 0x24, 0x96, 0x80, 0x39, 0x94,
  0x43, 0x08, 0x42, 0x10, 0xF8, 0x38, 0x94, 0x42, 0x30, 0x28, 0x92, 0x70,
  0x0C, 0x31, 0x8A, 0x69, 0x2F, 0xC4, 0x10, 0x7A, 0x10, 0xE1, 0x0E, 0x52,
  0x60, 0x32, 0x11, 0xE9, 0x4E, 0x52, 0xE0, 0xF8, 0x21, 0x04, 0x20, 0x84,
  0x10, 0x80, 0x38, 0x96, 0x4B, 0x39, 0x24, 0x92, 0x70, 0x76, 0xE3, 0x19,
  0xB8, 0x44, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x00, 0x44, 0xC0, 0x09,
  0xD9, 0x83, 0x08, 0xF8, 0x3C, 0x41, 0x86, 0x36, 0x40, 0x79, 0x13, 0x64,
  0x00, 0xC0, 0x0F, 0x08, 0x48, 0x29, 0xD5, 0x2A, 0x96, 0x53, 0x29, 0x9F,
  0x20, 0x10, 0x07, 0x80, 0x08, 0x61, 0x89, 0x25, 0x17, 0xF1, 0x84, 0x3C,
  0x49, 0x9A, 0x27, 0x88, 0x91, 0x26, 0xF8, 0x39, 0x1C, 0x60, 0x82, 0x08,
  0xA2, 0x70, 0x3C, 0x49, 0x8A, 0x14, 0x68, 0x91, 0x26, 0xF0, 0x3E, 0x41,
  0x82, 0x07, 0x88, 0x10, 0x20, 0xF8, 0x3C, 0x41, 0x82, 0x07, 0x88, 0x10,
  0x20, 0xC0, 0x39, 0x18, 0x60, 0x9E, 0x38, 0xA2, 0x70, 0x21, 0x23, 0x62,
  0x42, 0x7E, 0x42, 0x46, 0x44, 0xC4, 0x24, 0xA4, 0x92, 0xC0, 0x04, 0x10,
  0x43, 0x08, 0x28, 0xA6, 0x70, 0x22, 0x24, 0x68, 0x50, 0x70, 0x58, 0x48,
  0x48, 0xC4, 0x21, 0x18, 0x84, 0x21, 0x08, 0xF8, 0x20, 0x8C, 0x67, 0x19,
  0x4A, 0x52, 0x95, 0x65, 0x51, 0x64, 0xC9, 0x00, 0x21, 0x33, 0x72, 0x52,
  0x4A, 0x4A, 0x4E, 0x44, 0xC4, 0x39, 0x1C, 0x61, 0x86, 0x18, 0xA2, 0x70,
  0x3C, 0x45, 0x8A, 0x37, 0xC8, 0x10, 0x20, 0xC0, 0x39, 0x18, 0x61, 0x86,
  0x18, 0xA2, 0x70, 0x60, 0x80, 0x3C, 0x4D, 0x9A, 0x27, 0x89, 0x12, 0x24,
  0xC4, 0x3C, 0x49, 0x1B, 0x03, 0x81, 0xA1, 0x26, 0x78, 0xFC, 0xC2, 0x08,
  0x20, 0x82, 0x10, 0x40, 0x47, 0x18, 0x63, 0x8A, 0x28, 0xA6, 0xF0, 0x85,
  0x8B, 0x32, 0x45, 0x8A, 0x14, 0x30, 0x60, 0x88, 0xC4, 0xE6, 0x53, 0x2E,
  0x73, 0x31, 0x98, 0x88, 0x44, 0x00, 0x22, 0x48, 0xB0, 0xC1, 0x07, 0x0A,
  0x24, 0xCC, 0xC5, 0x24, 0x94, 0x70, 0x82, 0x10, 0x40, 0x7E, 0x08, 0x30,
  0xC1, 0x04, 0x18, 0x60, 0xFC, 0x32, 0x24, 0x44, 0x44, 0x4C, 0x88, 0xC0,
  0x91, 0x24, 0x92, 0x44, 0x31, 0x11, 0x12, 0x22, 0x22, 0x26, 0xC0, 0x2D,
  0xDA, 0xF8, 0x48, 0x3A, 0x42, 0xF4, 0xED, 0xA0, 0x20, 0x86, 0x1E, 0x4D,
  0x14, 0xD2, 0xCA, 0xC0, 0x39, 0x24, 0x10, 0xC1, 0x27, 0x00, 0x04, 0x10,
  0x4D, 0x4D, 0x34, 0xB2, 0x49, 0xE0, 0x3A, 0x52, 0xFC, 0x25, 0xC0, 0x34,
  0x4E, 0x48, 0x88, 0x88, 0x35, 0x34, 0xD2, 0xC9, 0x27, 0x82, 0x93, 0xC0,
  0x21, 0x18, 0xF4, 0xA5, 0x29, 0xCC, 0x40, 0x21, 0x24, 0x96, 0x80, 0x10,
  0x22, 0x22, 0x26, 0x44, 0x4C, 0x20, 0x86, 0x12, 0x59, 0xC6, 0x14, 0xD2,
  0x60, 0x24, 0xA4, 0x92, 0xD0, 0x7B, 0x26, 0x52, 0x29, 0x14, 0x96, 0x4A,
  0x24, 0x7A, 0x52, 0x94, 0xE6, 0x20, 0x39, 0x34, 0x51, 0xCD, 0x27, 0x00,
  0x79, 0x34, 0x53, 0x4B, 0x2B, 0x20, 0x82, 0x00, 0x35, 0x34, 0xD2, 0xC9,
  0x27, 0x82, 0x18, 0x40, 0x76, 0x44, 0x4C, 0x80, 0x3A, 0x50, 0x60, 0xE5,
  0xC0, 0x4B, 0xE9, 0x24, 0xC0, 0x8C, 0xE5, 0x29, 0x4B, 0xC0, 0x94, 0xAD,
  0x4A, 0x21, 0x00, 0x93, 0x26, 0xD5, 0xAD, 0x59, 0x22, 0x00, 0x49, 0xE3,
  0x08, 0x71, 0x49, 0x00, 0x24, 0x48, 0xA1, 0x42, 0x86, 0x0C, 0x10, 0x21,
  0x80, 0x78, 0x44, 0x46, 0x23, 0xC0, 0x13, 0x22, 0x2C, 0x44, 0x44, 0x42,
  0x24, 0xA4, 0x92, 0x52, 0x00, 0x21, 0x11, 0x11, 0x22, 0x22, 0x4C, 0x66,
  0x99, 0x80,
};

const GFXglyph RobotoCondensed_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -10 },
  { 7, 6, 9, 7, 1, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 8, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 2, 3, 2, 1, -10 },
  { 38, 4, 13, 4, 1, -10 },
  { 45, 4, 13, 4, -1, -10 },
  { 52, 5, 5, 5, 1, -9 },
  { 56, 5, 7, 6, 1, -8 },
  { 61, 2, 3, 2, -1, -1 },
  { 62, 3, 1, 3, 0, -4 },
  { 63, 2, 1, 3, 0, -1 },
  { 64, 6, 10, 5, -1, -9 },
  { 72, 5, 9, 6, 1, -9 },
  { 78, 3, 9, 6, 2, -9 },
  { 82, 6, 9, 6, 0, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 5, 9, 6, 1, -9 },
  { 109, 5, 9, 6, 1, -9 },
  { 115, 6, 9, 6, 1, -9 },
  { 122, 6, 9, 6, 0, -9 },
  { 129, 5, 9, 6, 1, -9 },
  { 135, 3, 7, 3, 0, -7 },
  { 138, 4, 9, 3, -1, -7 },
  { 143, 5, 6, 6, 0, -7 },
  { 147, 5, 3, 6, 1, -6 },
  { 149, 5, 6, 6, 0, -7 },
  { 153, 4, 9, 5, 1, -9 },
  { 158, 9, 12, 10, 0, -9 },
  { 172, 6, 9, 7, 0, -9 },
  { 179, 7, 9, 7, 0, -9 },
  { 187, 6, 9, 7, 1, -9 },
  { 194, 7, 9, 7, 0, -9 },
  { 202, 7, 9, 6, 0, -9 },
  { 210, 7, 9, 6, 0, -9 },
  { 218, 6, 9, 7, 1, -9 },
  { 225, 8, 9, 8, 0, -9 },
  { 234, 3, 9, 3, 0, -9 },
  { 238, 6, 9, 6, 0, -9 },
  { 245, 8, 9, 7, 0, -9 },
  { 254, 5, 9, 6, 0, -9 },
  { 260, 10, 9, 10, 0, -9 },
  { 272, 8, 9, 8, 0, -9 },
  { 281, 6, 9, 8, 1, -9 },
  { 288, 7, 9, 7, 0, -9 },
  { 296, 6, 11, 8, 1, -9 },
  { 305, 7, 9, 7, 0, -9 },
  { 313, 7, 9, 7, 0, -9 },
  { 321, 6, 9, 7, 1, -9 },
  { 328, 6, 9, 7, 1, -9 },
  { 335, 7, 9, 7, 1, -9 },
  { 343, 9, 9, 10, 1, -9 },
  { 354, 7, 9, 7, 0, -9 },
  { 362, 6, 9, 7, 1, -9 },
  { 369, 7, 9, 7, 0, -9 },
  { 377, 4, 13, 3, 0, -11 },
  { 384, 3, 10, 5, 1, -9 },
  { 388, 4, 13, 3, -1, -11 },
  { 395, 3, 5, 5, 1, -9 },
  { 397, 5, 1, 5, -1, 0 },
  { 398, 3, 2, 4, 1, -10 },
  { 399, 5, 7, 6, 0, -7 },
  { 404, 6, 10, 6, 0, -10 },
  { 412, 6, 7, 6, 0, -7 },
  { 418, 6, 10, 6, 0, -10 },
  { 426, 5, 7, 6, 0, -7 },
  { 431, 4, 10, 4, 1, -10 },
  { 436, 6, 10, 6, 0, -7 },
  { 444, 5, 10, 6, 0, -10 },
  { 451, 3, 9, 3, 0, -9 },
  { 455, 4, 12, 3, -1, -9 },
  { 461, 6, 10, 6, 0, -10 },
  { 469, 3, 10, 3, 0, -10 },
  { 473, 9, 7, 10, 0, -7 },
  { 481, 5, 7, 6, 0, -7 },
  { 486, 6, 7, 6, 0, -7 },
  { 492, 6, 10, 6, 0, -7 },
  { 500, 6, 10, 6, 0, -7 },
  { 508, 4, 7, 4, 0, -7 },
  { 512, 5, 7, 6, 0, -7 },
  { 517, 3, 9, 4, 1, -9 },
  { 521, 5, 7, 6, 1, -7 },
  { 526, 5, 7, 5, 1, -7 },
  { 531, 7, 7, 8, 1, -7 },
  { 538, 6, 7, 6, 0, -7 },
  { 544, 7, 10, 5, -1, -7 },
  { 553, 5, 7, 6, 0, -7 },
  { 558, 4, 12, 4, 0, -10 },
  { 564, 3, 11, 3, 0, -9 },
  { 569, 4, 12, 4, -1, -10 },
  { 575, 6, 3, 7, 1, -6 },
};

const GFXfont RobotoCondensed_Italic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_ITALIC13PT7B_H_
