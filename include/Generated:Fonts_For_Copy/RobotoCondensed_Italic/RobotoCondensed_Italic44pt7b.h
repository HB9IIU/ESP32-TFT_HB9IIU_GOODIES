#ifndef _ROBOTOCONDENSED_ITALIC44PT7B_H_
#define _ROBOTOCONDENSED_ITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x0F, 0x87, 0x81, 0xC0,
  0x38, 0xE7, 0x38, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x9C, 0x63,
  0x8C, 0x73, 0x8C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x3C,
  0x03, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x6E, 0x0E, 0x0E, 0xE0, 0xE1, 0xCE, 0x0E, 0x38, 0xE0, 0xE3, 0x8E, 0x0E,
  0x70, 0xE1, 0xCE, 0x06, 0x1C, 0xE0, 0x7F, 0x9C, 0x03, 0xFB, 0x80, 0x1E,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE7, 0xC0, 0x1C, 0xFE, 0x01, 0xDF, 0xE0,
  0x3B, 0x87, 0x07, 0x38, 0x70, 0xE3, 0x07, 0x0E, 0x70, 0x71, 0xC7, 0x07,
  0x38, 0x70, 0x77, 0x87, 0x07, 0x70, 0x70, 0x72, 0x03, 0x8E, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3E, 0x78, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x03, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x3B, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x71, 0xF7, 0x87, 0x3C, 0x78, 0x77, 0xC3, 0xCF, 0x78, 0x3C, 0xE7, 0x81,
  0xEE, 0xF0, 0x1F, 0xEF, 0x00, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x78,
  0x0F, 0x87, 0xE3, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0x9E, 0x07, 0xE1, 0xE0,
  0x77, 0x77, 0x7E, 0xEE, 0xEE, 0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x00, 0x0C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x07, 0x05, 0xF3, 0x9E,
  0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF7,
  0x00, 0xF3, 0x80, 0xF0, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x08, 0x08, 0x00,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0xF1,
  0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0x80,
  0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x1E, 0x70,
  0x07, 0x9C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x1C, 0x07, 0x87, 0x83, 0xC1,
  0xF1, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x1E,
  0x07, 0xE3, 0xFE, 0x7F, 0xE7, 0xDE, 0xF1, 0xC8, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE3, 0xE0,
  0xF0, 0x3C, 0x1E, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xF0,
  0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x78, 0x3E, 0x3F, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xDC,
  0x00, 0x3B, 0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3,
  0x80, 0x3C, 0x38, 0x03, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x7C, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xF0, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0x70, 0x0F, 0x0E, 0x01, 0xE1,
  0xE0, 0x78, 0x1E, 0x3E, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x9F, 0x03, 0xBF, 0xC1, 0xFF, 0xF1, 0xFC, 0x7C, 0xFC, 0x1E, 0x7C, 0x0F,
  0x3C, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3B, 0xC0,
  0x1C, 0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0xCF, 0x83,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xF3, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x81,
  0xE0, 0xF0, 0x78, 0x0F, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xC3, 0xE0, 0xF0, 0x3C, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x7C,
  0x1E, 0x1F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x78, 0x3F, 0x7C, 0x7E, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0x9E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x78, 0x00,
  0x06, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70,
  0x01, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x7E, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x08, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xBE,
  0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x18, 0x1C, 0x07,
  0xC0, 0x60, 0xE0, 0x3F, 0xC1, 0xC3, 0x81, 0xFF, 0x87, 0x1C, 0x0E, 0x0E,
  0x1C, 0x70, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC1, 0xCE, 0x0E, 0x07, 0x07,
  0x38, 0x38, 0x1C, 0x1C, 0xE1, 0xE0, 0xE0, 0x77, 0x07, 0x03, 0x81, 0xDC,
  0x1C, 0x0E, 0x07, 0x70, 0x70, 0x38, 0x19, 0xC3, 0xC1, 0xC0, 0x67, 0x0E,
  0x07, 0x03, 0x98, 0x38, 0x1C, 0x0E, 0xE0, 0xE0, 0x70, 0x33, 0x83, 0x83,
  0xC1, 0xCE, 0x0E, 0x1F, 0x06, 0x38, 0x3C, 0xFC, 0x38, 0xE0, 0xFF, 0x7F,
  0xC1, 0x81, 0xF8, 0xFE, 0x06, 0x03, 0xC1, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00,
  0xF3, 0x80, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x07, 0xE0, 0x78,
  0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x7E, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x07, 0xC0, 0x78,
  0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC7, 0x00,
  0x1E, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x03, 0xC0, 0x7C,
  0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xE1, 0xFC, 0x07,
  0x80, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0E, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07,
  0x80, 0xF8, 0x1C, 0x1F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC,
  0xFC, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x1F,
  0xF9, 0xE0, 0x7F, 0xC7, 0x01, 0xFF, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x83, 0xC0, 0x3E, 0x0F, 0xE7, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0x80, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0x87, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xDE, 0x00, 0x0F, 0xCF,
  0x00, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xE0,
  0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1D, 0xE0, 0x07, 0x78, 0x3B, 0xC0, 0x1E, 0xE0,
  0xF7, 0x80, 0x3B, 0xC1, 0xE7, 0x00, 0xF7, 0x83, 0xCE, 0x01, 0xCF, 0x07,
  0x9C, 0x07, 0x9E, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x78, 0x3C, 0xF0, 0x78,
  0xF0, 0x71, 0xE0, 0xF0, 0xE1, 0xE3, 0xC1, 0xE1, 0xC3, 0x87, 0x83, 0xC3,
  0x8F, 0x0F, 0x07, 0x87, 0x1C, 0x1C, 0x0E, 0x0E, 0x78, 0x78, 0x3C, 0x1E,
  0xE0, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0x3F, 0x03, 0xC1, 0xE0, 0x7E,
  0x07, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x01, 0xF0, 0x3C, 0x1E, 0x03, 0xC0,
  0x78, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0x7F, 0x00,
  0x38, 0x3F, 0x80, 0x3C, 0x1F, 0xE0, 0x1E, 0x0F, 0x70, 0x0F, 0x07, 0xB8,
  0x07, 0x83, 0xDE, 0x03, 0x83, 0xC7, 0x03, 0xC1, 0xE3, 0x81, 0xE0, 0xF1,
  0xE0, 0xF0, 0x78, 0x70, 0x78, 0x3C, 0x38, 0x3C, 0x1C, 0x1E, 0x1C, 0x1E,
  0x07, 0x1E, 0x0F, 0x03, 0x8F, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0x73, 0xC1,
  0xE0, 0x39, 0xE0, 0xE0, 0x1E, 0xE0, 0xF0, 0x07, 0xF0, 0x78, 0x03, 0xF8,
  0x3C, 0x01, 0xFC, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x3F, 0x0F, 0x00, 0x1F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x01, 0xE1,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0x39, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0x9C,
  0x00, 0x1E, 0xF0, 0x00, 0x79, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0xEF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x0F, 0xC0, 0x78, 0x07, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x01, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x73, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xE0, 0xFC, 0x07, 0x80, 0xF8, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x78, 0x1E, 0x01, 0xE0,
  0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0,
  0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x01, 0xE0, 0x7E, 0x7F, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1,
  0xE0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xF9, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x78,
  0x0E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E,
  0x00, 0x1C, 0x78, 0x00, 0x73, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0x9C, 0x03, 0xE0, 0x1E, 0x70,
  0x0F, 0x80, 0x79, 0xC0, 0x3E, 0x01, 0xC7, 0x01, 0xF8, 0x0F, 0x1C, 0x07,
  0xE0, 0x3C, 0x70, 0x1F, 0x80, 0xE1, 0xC0, 0xE7, 0x07, 0x87, 0x03, 0x9C,
  0x1E, 0x1C, 0x1E, 0x70, 0x70, 0x70, 0x71, 0xC3, 0xC1, 0xC1, 0xC7, 0x0F,
  0x07, 0x0E, 0x1C, 0x38, 0x1C, 0x38, 0x71, 0xE0, 0x71, 0xE1, 0xC7, 0x81,
  0xE7, 0x07, 0x1C, 0x07, 0x9C, 0x1C, 0xF0, 0x1E, 0xF0, 0x73, 0x80, 0x7B,
  0x81, 0xCE, 0x01, 0xEE, 0x07, 0x78, 0x07, 0xF0, 0x1D, 0xC0, 0x1F, 0xC0,
  0x77, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C,
  0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0,
  0x07, 0x0F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x07, 0x3C, 0x00, 0x3B,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xC0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xCC, 0x0E, 0x70, 0xE3,
  0x87, 0x1C, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF3, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x70, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE3, 0xE0, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78,
  0x0F, 0x3C, 0x0F, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFE, 0xF0, 0x7C, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE7,
  0xE0, 0x7B, 0xFC, 0x1F, 0xFF, 0x87, 0xF3, 0xE1, 0xF0, 0x3C, 0x78, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0xCE,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0x9E, 0x01, 0xE7, 0x00,
  0x7B, 0xE0, 0x3C, 0xF8, 0x0F, 0x3F, 0x8F, 0x8F, 0xFF, 0xE3, 0x9F, 0xF0,
  0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7E, 0x3E,
  0x1E, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x81, 0xE1, 0xF0, 0xF0,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x78,
  0x0F, 0xFB, 0xC0, 0xFF, 0xDE, 0x0F, 0xC7, 0xE0, 0x78, 0x1F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07,
  0x80, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0xF0, 0x07,
  0x83, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3F,
  0x3F, 0x80, 0xFF, 0xF8, 0x03, 0xFD, 0xC0, 0x0F, 0xCE, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xF1, 0xF1, 0xE0, 0x79, 0xE0, 0x1C, 0xF0,
  0x0E, 0x70, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x02,
  0x1E, 0x03, 0x87, 0xC7, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x20, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x70, 0x3F, 0xEF, 0x07, 0xFE, 0xF0, 0xFC, 0x7F, 0x0F,
  0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C,
  0x38, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x0F,
  0x83, 0xF3, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0x70, 0x07, 0xE7, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x06, 0x03, 0xE0, 0xF8,
  0x7C, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x9F, 0x83, 0xDF, 0xE1, 0xFF,
  0xF8, 0xFC, 0x7C, 0x7C, 0x1E, 0x3C, 0x0F, 0x3C, 0x03, 0x9E, 0x01, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E,
  0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xE7, 0x80,
  0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0x00, 0x02, 0x03, 0xC1, 0xE0,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x10, 0x00, 0xE0,
  0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x02, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x0F, 0x03,
  0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x0F, 0x80, 0xE3, 0xE0, 0x3C, 0xF8,
  0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xE7, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF0,
  0xE0, 0x1E, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x1E, 0x7C, 0x0F, 0xC0, 0xFF, 0xF8, 0xFF,
  0x07, 0xFF, 0xCF, 0xFC, 0x3F, 0x1F, 0xF3, 0xE1, 0xE0, 0x7E, 0x0F, 0x8F,
  0x03, 0xE0, 0x3C, 0xF0, 0x0F, 0x01, 0xE7, 0x80, 0x78, 0x0F, 0x3C, 0x07,
  0x80, 0x79, 0xE0, 0x3C, 0x03, 0x8E, 0x01, 0xE0, 0x1C, 0x70, 0x0F, 0x01,
  0xE7, 0x80, 0x78, 0x0F, 0x3C, 0x03, 0x80, 0x79, 0xE0, 0x3C, 0x03, 0xCF,
  0x01, 0xE0, 0x1C, 0x70, 0x0F, 0x00, 0xE7, 0x80, 0x78, 0x0F, 0x3C, 0x03,
  0x80, 0x79, 0xE0, 0x1C, 0x03, 0xCF, 0x01, 0xE0, 0x1E, 0x78, 0x0F, 0x00,
  0xE3, 0x80, 0x78, 0x0F, 0x00, 0x1E, 0x7E, 0x0F, 0x7F, 0x87, 0xFF, 0xE3,
  0xF9, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x07,
  0x9E, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x39, 0xE0,
  0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x01, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0x80, 0x78, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xC7, 0xC1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0x71, 0xC0,
  0x0E, 0x78, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00,
  0x3C, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x3C, 0x1F, 0x1F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x07, 0x9F, 0x80, 0x7B, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x3E, 0x07,
  0x81, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x3C, 0x3E, 0x07,
  0xC3, 0xF8, 0xF8, 0x3F, 0xFF, 0x83, 0xDF, 0xF0, 0x38, 0xFC, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0xE0,
  0xFF, 0xBC, 0x3F, 0xFF, 0x8F, 0xC7, 0xE1, 0xE0, 0x7C, 0x78, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x38,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0x70,
  0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3E, 0x1F, 0x83, 0xFF, 0xE0, 0x3F,
  0xDC, 0x03, 0xF7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x78, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xE1,
  0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x9F, 0x87, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0x00, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xCF, 0x00,
  0xE3, 0xC0, 0x38, 0xF0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0,
  0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F,
  0x8F, 0x07, 0xC3, 0xE7, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xF3, 0xC0,
  0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38,
  0x70, 0x78, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0,
  0x79, 0xC0, 0x79, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x1C,
  0x03, 0xBC, 0x0F, 0x01, 0xEF, 0x03, 0xC0, 0x73, 0xC0, 0xF0, 0x3C, 0xF0,
  0x7C, 0x0F, 0x3C, 0x1F, 0x83, 0x8F, 0x0F, 0xE1, 0xE3, 0xC3, 0xB8, 0x70,
  0xF1, 0xEE, 0x3C, 0x3C, 0x73, 0x8F, 0x07, 0x3C, 0xE3, 0x81, 0xCE, 0x39,
  0xE0, 0x73, 0x8E, 0x70, 0x1D, 0xC3, 0x9C, 0x07, 0x70, 0xEF, 0x01, 0xFC,
  0x3B, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x70,
  0x00, 0x0F, 0x01, 0xF0, 0x70, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x03,
  0x87, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x00, 0xF1, 0xC0, 0x1E, 0x1E,
  0x03, 0xE1, 0xE0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x00, 0x07,
  0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x03, 0x87, 0x80, 0x1C,
  0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x39, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x0B, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x01, 0xCF, 0xF8, 0x0E, 0xFF, 0xE0, 0xE7,
  0x8F, 0x87, 0x38, 0x3F, 0xFB, 0xC0, 0xFF, 0x9C, 0x03, 0xF8, 0x00, 0x0F,
  0x80,
};

const GFXglyph RobotoCondensed_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 31, 11, 1, -31 },
  { 36, 11, 11, 14, 4, -33 },
  { 52, 22, 31, 23, 2, -31 },
  { 138, 18, 40, 21, 2, -36 },
  { 228, 20, 31, 27, 4, -31 },
  { 306, 20, 31, 23, 1, -31 },
  { 384, 4, 10, 7, 4, -33 },
  { 389, 13, 45, 13, 2, -35 },
  { 463, 13, 45, 14, -2, -35 },
  { 537, 17, 18, 18, 2, -31 },
  { 576, 18, 23, 21, 2, -26 },
  { 628, 7, 11, 8, -2, -5 },
  { 638, 9, 3, 11, 1, -15 },
  { 642, 5, 5, 11, 1, -5 },
  { 646, 20, 34, 16, -2, -31 },
  { 731, 18, 31, 21, 2, -31 },
  { 801, 12, 31, 21, 5, -31 },
  { 848, 20, 31, 21, 0, -31 },
  { 926, 19, 31, 21, 1, -31 },
  { 1000, 20, 31, 21, 0, -31 },
  { 1078, 19, 31, 21, 2, -31 },
  { 1152, 17, 31, 21, 2, -31 },
  { 1218, 19, 31, 21, 3, -31 },
  { 1292, 19, 31, 21, 1, -31 },
  { 1366, 16, 31, 21, 3, -31 },
  { 1428, 8, 24, 10, 1, -24 },
  { 1452, 11, 30, 9, -2, -24 },
  { 1494, 16, 20, 19, 2, -24 },
  { 1534, 17, 11, 20, 2, -20 },
  { 1558, 17, 20, 20, 1, -24 },
  { 1601, 14, 31, 18, 4, -31 },
  { 1656, 30, 41, 33, 1, -31 },
  { 1810, 22, 31, 25, -1, -31 },
  { 1896, 21, 31, 23, 1, -31 },
  { 1978, 22, 31, 24, 2, -31 },
  { 2064, 22, 31, 24, 1, -31 },
  { 2150, 22, 31, 21, 1, -31 },
  { 2236, 21, 31, 21, 1, -31 },
  { 2318, 22, 31, 25, 2, -31 },
  { 2404, 25, 31, 26, 1, -31 },
  { 2501, 9, 31, 11, 1, -31 },
  { 2536, 21, 31, 21, 0, -31 },
  { 2618, 25, 31, 23, 1, -31 },
  { 2715, 16, 31, 20, 1, -31 },
  { 2777, 31, 31, 32, 1, -31 },
  { 2898, 25, 31, 26, 1, -31 },
  { 2995, 22, 31, 26, 2, -31 },
  { 3081, 23, 31, 24, 1, -31 },
  { 3171, 22, 36, 26, 2, -31 },
  { 3270, 22, 31, 23, 1, -31 },
  { 3356, 21, 31, 22, 1, -31 },
  { 3438, 20, 31, 22, 4, -31 },
  { 3516, 23, 31, 24, 2, -31 },
  { 3606, 22, 31, 24, 4, -31 },
  { 3692, 30, 31, 33, 4, -31 },
  { 3809, 26, 31, 24, -1, -31 },
  { 3910, 21, 31, 22, 4, -31 },
  { 3992, 23, 31, 22, 0, -31 },
  { 4082, 13, 43, 11, 0, -36 },
  { 4152, 8, 34, 16, 4, -31 },
  { 4186, 13, 43, 11, -2, -36 },
  { 4256, 13, 16, 16, 2, -31 },
  { 4282, 17, 3, 17, -2, 0 },
  { 4289, 8, 6, 13, 4, -33 },
  { 4295, 17, 23, 20, 1, -23 },
  { 4344, 18, 33, 21, 1, -33 },
  { 4419, 18, 23, 20, 1, -23 },
  { 4471, 21, 33, 21, 1, -33 },
  { 4558, 17, 23, 20, 1, -23 },
  { 4607, 15, 33, 14, 2, -33 },
  { 4669, 20, 32, 21, 0, -23 },
  { 4749, 17, 33, 21, 1, -33 },
  { 4820, 9, 32, 10, 1, -32 },
  { 4856, 14, 41, 10, -4, -32 },
  { 4928, 19, 33, 19, 1, -33 },
  { 5007, 9, 33, 10, 1, -33 },
  { 5045, 29, 23, 32, 1, -23 },
  { 5129, 17, 23, 21, 1, -23 },
  { 5178, 19, 23, 21, 1, -23 },
  { 5233, 20, 32, 21, -1, -23 },
  { 5313, 19, 32, 21, 1, -23 },
  { 5389, 13, 23, 13, 1, -23 },
  { 5427, 17, 23, 19, 1, -23 },
  { 5476, 11, 29, 13, 2, -29 },
  { 5516, 18, 23, 21, 2, -23 },
  { 5568, 16, 23, 18, 3, -23 },
  { 5614, 26, 23, 28, 3, -23 },
  { 5689, 20, 23, 19, -1, -23 },
  { 5747, 21, 32, 18, -2, -23 },
  { 5831, 18, 23, 19, 0, -23 },
  { 5883, 14, 42, 13, 1, -34 },
  { 5957, 9, 37, 10, 1, -31 },
  { 5999, 14, 42, 13, -2, -34 },
  { 6073, 21, 9, 25, 2, -18 },
};

const GFXfont RobotoCondensed_Italic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_ITALIC44PT7B_H_
