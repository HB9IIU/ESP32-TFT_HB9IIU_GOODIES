#ifndef _ROBOTOCONDENSED_ITALIC50PT7B_H_
#define _ROBOTOCONDENSED_ITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x38, 0xF3,
  0x8E, 0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE1, 0x8E, 0x38, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x1E, 0x00,
  0x0E, 0x0E, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x1E,
  0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x78, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0x81,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3E, 0x01, 0xF0, 0xF0, 0x1F, 0x07, 0xC1, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x07, 0x01,
  0x1E, 0x0E, 0x07, 0x38, 0x1C, 0x1E, 0x70, 0x38, 0x38, 0xE0, 0x70, 0xE1,
  0xC0, 0xE3, 0xC3, 0x83, 0xC7, 0x07, 0x07, 0x1C, 0x0E, 0x0E, 0x78, 0x1E,
  0x3C, 0xE0, 0x1F, 0xF3, 0x80, 0x1F, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x7F, 0x80, 0x39,
  0xFF, 0x00, 0xF3, 0x8F, 0x01, 0xCE, 0x0E, 0x07, 0x1C, 0x1C, 0x1E, 0x78,
  0x38, 0x78, 0xE0, 0x70, 0xE1, 0xC0, 0xE3, 0xC3, 0x81, 0xCF, 0x07, 0x03,
  0x9C, 0x0E, 0x07, 0x30, 0x1E, 0x1E, 0x20, 0x1C, 0x78, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F,
  0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFB, 0xE1, 0xE3, 0xE7, 0xC3, 0xCF, 0x87, 0xC7,
  0xBE, 0x0F, 0x8F, 0x7C, 0x0F, 0xBC, 0xF0, 0x1F, 0x79, 0xE0, 0x1F, 0xE3,
  0xC0, 0x3F, 0xC7, 0x80, 0x3F, 0x0F, 0x00, 0x7E, 0x1E, 0x00, 0x7C, 0x3E,
  0x01, 0xF8, 0x3F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xF9, 0xF0, 0x3F,
  0xE1, 0xE0, 0x0C, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x71,
  0xCF, 0x38, 0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x18, 0x3C, 0x1F, 0xC7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0xF3, 0xC0,
  0x3E, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0x78, 0x18, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1C, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C,
  0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE7, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1,
  0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFC, 0x1F, 0xE7, 0xFF,
  0x7F, 0xFB, 0xF3, 0xDE, 0x3E, 0x81, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x03,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x07,
  0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0x80,
  0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x0F, 0xC0, 0xE0, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x83,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7E, 0x0F, 0x9F, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBE, 0x03, 0xE7, 0x80, 0xF1, 0xF0, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7C,
  0x1F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3E, 0x1F, 0x03, 0xC0, 0x78, 0x3E, 0x01, 0xE1, 0xE0, 0x0F,
  0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xE0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x0F, 0x8F, 0x01,
  0xE7, 0xC0, 0x7D, 0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xEF, 0x81, 0xF9, 0xF0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFD,
  0xE1, 0xFE, 0xF0, 0x3F, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0xFC,
  0x7C, 0x1C, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE1, 0xF3,
  0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x1F, 0x80, 0x70, 0xE0, 0x1F, 0xE0, 0x38,
  0xF0, 0x1F, 0xFC, 0x1C, 0x70, 0x1F, 0x1E, 0x0E, 0x78, 0x1E, 0x0F, 0x07,
  0x38, 0x1E, 0x07, 0x03, 0x9C, 0x0F, 0x03, 0x81, 0xDE, 0x07, 0x03, 0xC0,
  0xEE, 0x07, 0x81, 0xE0, 0x77, 0x03, 0x80, 0xE0, 0x3B, 0x83, 0xC0, 0x70,
  0x1F, 0xC1, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x3C, 0x06, 0xE0, 0x70, 0x1C,
  0x07, 0x70, 0x78, 0x0E, 0x03, 0xB8, 0x3C, 0x07, 0x01, 0xDC, 0x1E, 0x07,
  0x81, 0xCE, 0x0F, 0x03, 0xC0, 0xE7, 0x07, 0x83, 0xC0, 0x73, 0x83, 0xC1,
  0xE0, 0x71, 0xC1, 0xF1, 0xF8, 0x70, 0xE0, 0x7F, 0xDE, 0xF8, 0x70, 0x3F,
  0xCF, 0xF8, 0x38, 0x0F, 0xC3, 0xF0, 0x1C, 0x01, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1E, 0x00,
  0xF8, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x78, 0x03,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3C, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E,
  0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0xFE, 0xF8, 0x0F, 0xFE, 0xF0,
  0x0F, 0xFC, 0xF0, 0x0F, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x3C, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x3C,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x78, 0x0F, 0xC0, 0x07, 0x81, 0xF8, 0x00, 0x78, 0x3F, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF,
  0x00, 0x01, 0xF8, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0,
  0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0xF3, 0x80,
  0x0F, 0xBC, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x1F, 0x78, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x3E, 0x78, 0x1F, 0x3C, 0x03, 0xC7,
  0x81, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE1, 0xE0,
  0x78, 0xF0, 0x1E, 0x1E, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0xF0, 0x3E,
  0x1E, 0x1E, 0x1F, 0x03, 0xE1, 0xE1, 0xE1, 0xF0, 0x3E, 0x1E, 0x3C, 0x1E,
  0x03, 0xC0, 0xE3, 0xC1, 0xE0, 0x3C, 0x0E, 0x78, 0x1E, 0x03, 0xC0, 0xF7,
  0x83, 0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7C,
  0x0F, 0xE0, 0x3C, 0x07, 0x80, 0x7E, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x3C,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x78,
  0x1F, 0xE0, 0x07, 0xC0, 0xFF, 0x00, 0x3E, 0x07, 0xB8, 0x01, 0xE0, 0x3D,
  0xE0, 0x0F, 0x01, 0xEF, 0x00, 0x78, 0x1F, 0x78, 0x03, 0xC0, 0xF9, 0xE0,
  0x3E, 0x07, 0x8F, 0x01, 0xF0, 0x3C, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x78,
  0x1F, 0x0F, 0x03, 0xC0, 0xF8, 0x78, 0x1E, 0x07, 0xC1, 0xE1, 0xF0, 0x3C,
  0x0F, 0x0F, 0x81, 0xE0, 0x78, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0xF8, 0x0F,
  0x1E, 0x07, 0xC0, 0x78, 0xF0, 0x3E, 0x01, 0xEF, 0x81, 0xE0, 0x0F, 0x7C,
  0x0F, 0x00, 0x7B, 0xC0, 0x78, 0x01, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x3E,
  0x00, 0x7F, 0x81, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x78, 0x00,
  0x7E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3C, 0x03,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x0F,
  0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x80,
  0x3E, 0xF0, 0x07, 0xE0, 0x0F, 0x3C, 0x01, 0xF8, 0x03, 0xCF, 0x00, 0x7E,
  0x01, 0xF3, 0xC0, 0x3F, 0x80, 0x78, 0xF0, 0x0F, 0xE0, 0x1E, 0x3C, 0x03,
  0xB8, 0x0F, 0x8F, 0x01, 0xEE, 0x03, 0xC3, 0xC0, 0x7B, 0x80, 0xF0, 0xF8,
  0x3C, 0xF0, 0x7C, 0x3E, 0x0F, 0x3C, 0x1E, 0x07, 0x83, 0x8F, 0x07, 0x81,
  0xE1, 0xE3, 0xC3, 0xE0, 0x78, 0x78, 0xF0, 0xF0, 0x1E, 0x1C, 0x3C, 0x3C,
  0x07, 0x8F, 0x07, 0x0F, 0x01, 0xE3, 0xC1, 0xC7, 0x80, 0x79, 0xE0, 0x71,
  0xE0, 0x1E, 0x78, 0x1C, 0x78, 0x07, 0x9C, 0x07, 0x3C, 0x01, 0xEF, 0x01,
  0xCF, 0x00, 0x7B, 0xC0, 0x73, 0xC0, 0x1E, 0xE0, 0x1D, 0xE0, 0x07, 0xF8,
  0x07, 0x78, 0x01, 0xFC, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0xFC, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xF0, 0x78, 0x3C,
  0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0xB8,
  0x1E, 0x70, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x83, 0x8F, 0x07, 0x3C,
  0x0E, 0x78, 0x1F, 0xE0, 0x3C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83, 0xE0,
  0xF0, 0x1E, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x3E, 0x3E, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x78, 0x1F,
  0xE7, 0x80, 0xFC, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF1, 0xF8, 0x07, 0xBF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC1,
  0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F,
  0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0,
  0x07, 0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xE7, 0xF0, 0x7E, 0x3D, 0xFF, 0xE1,
  0xEF, 0xFF, 0x0F, 0x3F, 0xE0, 0x78, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0xCF, 0x00,
  0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF0, 0xF0, 0x3E,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x8F, 0x80,
  0xFF, 0x9E, 0x03, 0xFF, 0xBC, 0x0F, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x3C,
  0x7C, 0x07, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x70, 0xF8, 0x1E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x7E, 0x1E, 0x03, 0xFF, 0x3C, 0x0F, 0xFE, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x18, 0x03, 0xE0, 0x38, 0x0F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x1F, 0x80, 0xF7, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xC1, 0xE1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF8, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x3C, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x7E, 0x01,
  0xE3, 0xF0, 0x07, 0x9F, 0x80, 0x1E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xDF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0x9E, 0x00, 0x7C, 0x7C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x1F, 0x01, 0xF8, 0x07, 0xBF, 0xE1, 0xFF, 0x03, 0xFF, 0xFB, 0xFF,
  0xC1, 0xFF, 0xFD, 0xFF, 0xE1, 0xF8, 0x3F, 0xE1, 0xF0, 0xF8, 0x0F, 0xE0,
  0x7C, 0x78, 0x07, 0xE0, 0x3E, 0x3C, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x03, 0xE7, 0x80, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x78, 0xF0, 0x07,
  0x80, 0x3C, 0xF8, 0x07, 0xC0, 0x3E, 0x7C, 0x03, 0xC0, 0x1E, 0x3C, 0x01,
  0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x3C, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x1F, 0x00, 0xF7, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC1,
  0xE1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xF7, 0xC0,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xC7,
  0xE0, 0x07, 0xBF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07,
  0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xF0,
  0x7E, 0x0F, 0xFF, 0xF8, 0x1E, 0xFF, 0xF0, 0x3C, 0xFF, 0x80, 0x78, 0x7E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x78, 0x3F, 0xF3, 0xC3,
  0xFF, 0xBC, 0x3F, 0xFF, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x7E, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x3E, 0x1E, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF3, 0xC0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x78, 0xF8, 0x3F, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF,
  0x83, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x8F, 0x83, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xEF, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE1, 0xE0, 0x38, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x7C,
  0x03, 0xFC, 0x03, 0xE0, 0x3D, 0xE0, 0x3F, 0x01, 0xE7, 0x81, 0xF8, 0x1F,
  0x3C, 0x0F, 0xC0, 0xF1, 0xE0, 0xFE, 0x07, 0x8F, 0x07, 0xF0, 0x78, 0x78,
  0x7B, 0x83, 0xC3, 0xC3, 0xDC, 0x3C, 0x1E, 0x3C, 0xE1, 0xE0, 0xF1, 0xE7,
  0x0F, 0x07, 0x8E, 0x38, 0xF0, 0x3C, 0xF1, 0xE7, 0x81, 0xE7, 0x0F, 0x38,
  0x0F, 0x78, 0x7B, 0xC0, 0x7B, 0xC3, 0xDE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xEF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F,
  0x03, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x78,
  0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x38, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x80, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0,
  0x07, 0x1F, 0xF8, 0x0F, 0x3F, 0xFC, 0x0F, 0x3C, 0x7C, 0x0E, 0x78, 0x3E,
  0x1E, 0x78, 0x1F, 0xFC, 0x70, 0x0F, 0xFC, 0xF0, 0x07, 0xF8, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 36, 12, 2, -36 },
  { 46, 12, 12, 16, 5, -38 },
  { 64, 25, 36, 27, 2, -36 },
  { 177, 21, 46, 24, 2, -41 },
  { 298, 23, 36, 31, 5, -36 },
  { 402, 23, 37, 26, 1, -36 },
  { 509, 6, 12, 8, 4, -38 },
  { 518, 14, 51, 15, 3, -40 },
  { 608, 15, 52, 15, -2, -40 },
  { 706, 19, 21, 21, 3, -36 },
  { 756, 21, 25, 24, 2, -29 },
  { 822, 9, 12, 10, -3, -5 },
  { 836, 10, 4, 12, 1, -17 },
  { 841, 6, 5, 13, 1, -5 },
  { 845, 22, 39, 18, -2, -36 },
  { 953, 21, 36, 24, 2, -36 },
  { 1048, 13, 36, 24, 6, -36 },
  { 1107, 23, 36, 24, 0, -36 },
  { 1211, 21, 36, 24, 1, -36 },
  { 1306, 22, 36, 24, 0, -36 },
  { 1405, 21, 36, 24, 3, -36 },
  { 1500, 18, 36, 24, 3, -36 },
  { 1581, 22, 36, 24, 3, -36 },
  { 1680, 21, 36, 24, 2, -36 },
  { 1775, 18, 36, 24, 4, -36 },
  { 1856, 9, 27, 12, 1, -27 },
  { 1887, 12, 34, 10, -2, -27 },
  { 1938, 18, 22, 22, 2, -27 },
  { 1988, 19, 14, 23, 3, -24 },
  { 2022, 20, 22, 22, 1, -27 },
  { 2077, 17, 36, 20, 4, -36 },
  { 2154, 33, 46, 37, 2, -35 },
  { 2344, 26, 36, 28, -2, -36 },
  { 2461, 24, 36, 26, 1, -36 },
  { 2569, 24, 36, 27, 3, -36 },
  { 2677, 25, 36, 28, 1, -36 },
  { 2790, 25, 36, 24, 1, -36 },
  { 2903, 24, 36, 23, 1, -36 },
  { 3011, 24, 36, 29, 3, -36 },
  { 3119, 29, 36, 30, 1, -36 },
  { 3250, 11, 36, 12, 1, -36 },
  { 3300, 24, 36, 23, 0, -36 },
  { 3408, 28, 36, 26, 1, -36 },
  { 3534, 19, 36, 23, 1, -36 },
  { 3620, 36, 36, 37, 1, -36 },
  { 3782, 29, 36, 30, 1, -36 },
  { 3913, 25, 36, 29, 3, -36 },
  { 4026, 26, 36, 27, 1, -36 },
  { 4143, 24, 42, 29, 3, -36 },
  { 4269, 25, 36, 26, 1, -36 },
  { 4382, 24, 36, 25, 1, -36 },
  { 4490, 24, 36, 25, 4, -36 },
  { 4598, 26, 36, 27, 2, -36 },
  { 4715, 26, 36, 27, 4, -36 },
  { 4832, 34, 36, 37, 5, -36 },
  { 4985, 29, 36, 27, -1, -36 },
  { 5116, 24, 36, 25, 4, -36 },
  { 5224, 26, 36, 25, 0, -36 },
  { 5341, 15, 49, 12, 0, -41 },
  { 5433, 9, 39, 18, 5, -36 },
  { 5477, 16, 49, 12, -3, -41 },
  { 5575, 15, 18, 18, 2, -36 },
  { 5609, 20, 4, 20, -3, 0 },
  { 5619, 9, 7, 15, 5, -37 },
  { 5627, 20, 26, 23, 1, -26 },
  { 5692, 21, 38, 24, 1, -38 },
  { 5792, 19, 26, 22, 2, -26 },
  { 5854, 23, 38, 24, 2, -38 },
  { 5964, 19, 26, 23, 2, -26 },
  { 6026, 17, 39, 15, 2, -39 },
  { 6109, 23, 36, 24, 0, -26 },
  { 6213, 20, 38, 23, 1, -38 },
  { 6308, 10, 35, 11, 1, -35 },
  { 6352, 16, 45, 11, -5, -35 },
  { 6442, 22, 38, 22, 1, -38 },
  { 6547, 11, 38, 11, 1, -38 },
  { 6600, 33, 26, 37, 1, -26 },
  { 6708, 20, 26, 23, 1, -26 },
  { 6773, 20, 26, 24, 2, -26 },
  { 6838, 23, 36, 24, -1, -26 },
  { 6942, 21, 36, 24, 2, -26 },
  { 7037, 15, 26, 15, 1, -26 },
  { 7086, 19, 26, 22, 1, -26 },
  { 7148, 13, 33, 14, 2, -33 },
  { 7202, 20, 26, 23, 2, -26 },
  { 7267, 18, 26, 21, 3, -26 },
  { 7326, 29, 26, 32, 3, -26 },
  { 7421, 23, 26, 21, -1, -26 },
  { 7496, 23, 36, 20, -2, -26 },
  { 7600, 21, 26, 21, 0, -26 },
  { 7669, 15, 48, 15, 2, -39 },
  { 7759, 10, 43, 12, 1, -36 },
  { 7813, 15, 48, 15, -2, -39 },
  { 7903, 24, 10, 29, 2, -20 },
};

const GFXfont RobotoCondensed_Italic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_ITALIC50PT7B_H_
