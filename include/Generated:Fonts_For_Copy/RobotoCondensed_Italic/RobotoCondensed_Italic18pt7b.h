#ifndef _ROBOTOCONDENSED_ITALIC18PT7B_H_
#define _ROBOTOCONDENSED_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x96, 0xC0, 0x48, 0xDB, 0xAA, 0x0D, 0x04, 0x82, 0x43,
  0x47, 0xF8, 0x90, 0xD8, 0x48, 0xFE, 0x36, 0x12, 0x09, 0x0D, 0x80, 0x0C,
  0x10, 0x71, 0xB6, 0x2C, 0x58, 0x30, 0x38, 0x18, 0x14, 0x28, 0x5B, 0x9E,
  0x10, 0x20, 0x60, 0x90, 0x92, 0x96, 0x94, 0xE8, 0x10, 0x36, 0x29, 0x49,
  0xD9, 0x8B, 0x0E, 0x1C, 0x36, 0x26, 0x66, 0x2C, 0x38, 0x70, 0xDB, 0x8A,
  0x8E, 0x84, 0xCE, 0x7A, 0xF0, 0x08, 0xCC, 0x46, 0x21, 0x18, 0xC6, 0x21,
  0x08, 0x43, 0x08, 0x41, 0x00, 0x10, 0x40, 0x82, 0x08, 0x20, 0xC2, 0x08,
  0x20, 0x86, 0x10, 0x43, 0x18, 0x42, 0x00, 0x18, 0x23, 0x5B, 0xE3, 0x09,
  0x12, 0x00, 0x18, 0x30, 0x60, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0x40, 0x6D,
  0x60, 0xF0, 0x70, 0x01, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x1C, 0x4D, 0x8A, 0x14, 0x38, 0xF1, 0xE3,
  0x85, 0x0A, 0x36, 0x47, 0x00, 0x1B, 0xF4, 0x21, 0x18, 0xC6, 0x21, 0x18,
  0xC6, 0x00, 0x1E, 0x33, 0x21, 0x21, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0xFE, 0x1E, 0x33, 0x23, 0x23, 0x03, 0x06, 0x1C, 0x06, 0x02,
  0x42, 0x46, 0x6C, 0x38, 0x03, 0x07, 0x07, 0x0A, 0x1A, 0x12, 0x26, 0x66,
  0x46, 0xFF, 0x04, 0x04, 0x0C, 0x3F, 0x3F, 0x20, 0x60, 0x5C, 0x6C, 0x06,
  0x06, 0x06, 0x86, 0xC4, 0xCC, 0x78, 0x0C, 0x70, 0x83, 0x07, 0xCD, 0xB1,
  0xE3, 0xC7, 0x8B, 0x12, 0x67, 0x80, 0x7F, 0x03, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x1C, 0x6D, 0x8A, 0x16, 0x6C,
  0x9E, 0x66, 0x85, 0x0A, 0x36, 0xE7, 0x00, 0x3C, 0xC9, 0x1A, 0x3C, 0x78,
  0xF1, 0xB6, 0x74, 0x18, 0x21, 0xC6, 0x00, 0x33, 0x00, 0x00, 0x00, 0x4C,
  0x10, 0x80, 0x00, 0x00, 0x00, 0x23, 0x11, 0x80, 0x04, 0x77, 0xB8, 0xC1,
  0xC1, 0x82, 0x7E, 0x00, 0x07, 0xE0, 0x40, 0xC0, 0xE0, 0x60, 0xCF, 0x38,
  0x40, 0x39, 0xB4, 0x41, 0x0C, 0x61, 0x08, 0x20, 0x00, 0x10, 0x40, 0x07,
  0x81, 0x84, 0x30, 0x22, 0x02, 0x47, 0x14, 0xD9, 0xC9, 0x19, 0x91, 0x91,
  0x29, 0x32, 0x92, 0x29, 0x74, 0x9D, 0x88, 0x00, 0x80, 0x04, 0x20, 0x3C,
  0x00, 0x03, 0x00, 0xC0, 0x70, 0x14, 0x0D, 0x83, 0x60, 0x98, 0x62, 0x10,
  0x8F, 0xE2, 0x09, 0x83, 0x40, 0xC0, 0x1F, 0x18, 0xCC, 0x66, 0x32, 0x19,
  0x18, 0xF8, 0xC6, 0x61, 0x30, 0x90, 0xC8, 0xC7, 0xC0, 0x1E, 0x19, 0x98,
  0x6C, 0x34, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xB0, 0x8C, 0xC3, 0xC0,
  0x1E, 0x19, 0xCC, 0x66, 0x12, 0x09, 0x04, 0x82, 0xC3, 0x61, 0xB0, 0x90,
  0xC8, 0xC7, 0xC0, 0x1F, 0x98, 0x0C, 0x06, 0x02, 0x01, 0x00, 0xF8, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x07, 0xE0, 0x1F, 0x98, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0xF8, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x00, 0x1E, 0x19, 0x98,
  0x68, 0x34, 0x06, 0x03, 0x01, 0x9E, 0xC3, 0x61, 0xB0, 0xCC, 0xC3, 0xC0,
  0x10, 0x66, 0x0C, 0xC1, 0x18, 0x22, 0x0C, 0x41, 0x8F, 0xF3, 0x04, 0x60,
  0x8C, 0x11, 0x06, 0x20, 0xC4, 0x18, 0x13, 0x33, 0x32, 0x26, 0x66, 0x44,
  0x40, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x63,
  0x31, 0x8D, 0x87, 0x80, 0x10, 0xC6, 0x30, 0xCC, 0x19, 0x02, 0x60, 0x58,
  0x0F, 0x03, 0xE0, 0x66, 0x0C, 0xC1, 0x08, 0x21, 0x84, 0x10, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x07, 0xE0, 0x18, 0x19,
  0xC1, 0xCE, 0x0E, 0x50, 0xF2, 0x85, 0x14, 0x68, 0xB3, 0x4D, 0x96, 0x6D,
  0xB3, 0x29, 0x91, 0xC8, 0x8C, 0x44, 0x66, 0x00, 0x10, 0x67, 0x0C, 0xE1,
  0x1C, 0x22, 0xCC, 0x49, 0x89, 0x33, 0x34, 0x62, 0x8C, 0x51, 0x0E, 0x20,
  0xC4, 0x18, 0x1E, 0x1D, 0x98, 0x6C, 0x34, 0x1E, 0x0F, 0x07, 0x82, 0xC1,
  0x61, 0xB0, 0xCD, 0xC3, 0xC0, 0x1F, 0x0C, 0x63, 0x0C, 0xC3, 0x20, 0xC8,
  0x22, 0x39, 0xFC, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x00, 0x1E, 0x19,
  0x98, 0x68, 0x34, 0x1E, 0x0F, 0x07, 0x82, 0xC1, 0x61, 0xB0, 0x8D, 0xC3,
  0xC0, 0x30, 0x08, 0x1F, 0x18, 0xCC, 0x66, 0x12, 0x19, 0x0C, 0x8C, 0xFC,
  0x66, 0x31, 0x10, 0x88, 0x64, 0x30, 0x0F, 0x0D, 0x8C, 0x64, 0x33, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x61, 0x90, 0xCC, 0xC3, 0xC0, 0xFF, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x61, 0xB0,
  0xD8, 0x68, 0x24, 0x16, 0x0B, 0x0D, 0x86, 0xC3, 0x41, 0x31, 0x9D, 0xC7,
  0x80, 0x81, 0x41, 0xB0, 0xD8, 0xCC, 0x66, 0x23, 0x30, 0x90, 0x58, 0x28,
  0x1C, 0x0C, 0x06, 0x00, 0x86, 0x38, 0x63, 0x8E, 0x28, 0xA6, 0x8A, 0x69,
  0xA4, 0x92, 0xCB, 0x28, 0xE2, 0x8A, 0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x00,
  0x30, 0xCC, 0x61, 0x18, 0x6C, 0x1E, 0x03, 0x80, 0xC0, 0x70, 0x16, 0x0D,
  0x86, 0x21, 0x8C, 0xC3, 0x00, 0x83, 0xC2, 0xC6, 0x4C, 0x4C, 0x58, 0x70,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x3F, 0x80, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xFF, 0x00, 0x19,
  0x8C, 0x62, 0x10, 0x84, 0x63, 0x18, 0x84, 0x23, 0x18, 0xC7, 0x00, 0x92,
  0x6C, 0x92, 0x49, 0xB2, 0x40, 0x1C, 0x20, 0x82, 0x18, 0x61, 0x84, 0x10,
  0x43, 0x0C, 0x30, 0xC2, 0x08, 0x23, 0x80, 0x11, 0x8C, 0xB4, 0xC4, 0xFE,
  0xC9, 0x80, 0x1E, 0x6D, 0x88, 0x13, 0xEC, 0xD1, 0xA3, 0x6E, 0xEC, 0x30,
  0x30, 0x30, 0x20, 0x2E, 0x33, 0x63, 0x63, 0x63, 0x43, 0x42, 0x42, 0xE6,
  0xDC, 0x3C, 0xCB, 0x1E, 0x08, 0x10, 0x20, 0x46, 0xC8, 0xE0, 0x03, 0x03,
  0x02, 0x02, 0x3A, 0x6E, 0xC6, 0x86, 0x84, 0x84, 0x84, 0x8C, 0xDC, 0x7C,
  0x3C, 0xDB, 0x1E, 0x3F, 0xD0, 0x20, 0x40, 0xCC, 0xF0, 0x1C, 0xC2, 0x08,
  0xF9, 0x86, 0x10, 0x41, 0x0C, 0x30, 0xC2, 0x00, 0x1D, 0x37, 0x63, 0x63,
  0x43, 0x42, 0x42, 0x46, 0x6E, 0x3E, 0x06, 0x04, 0xCC, 0x78, 0x30, 0x30,
  0x30, 0x20, 0x2E, 0x36, 0x62, 0x62, 0x62, 0x42, 0x46, 0x46, 0xC6, 0xC6,
  0x13, 0x00, 0x22, 0x26, 0x66, 0x44, 0x4C, 0x0C, 0x30, 0x00, 0x08, 0x20,
  0x86, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x0C, 0x63, 0x80, 0x30, 0x30, 0x30,
  0x30, 0x23, 0x26, 0x6C, 0x78, 0x78, 0x78, 0x48, 0x4C, 0xC4, 0xC6, 0x13,
  0x33, 0x22, 0x26, 0x66, 0x44, 0x4C, 0x2E, 0xE3, 0x7B, 0x63, 0x16, 0x21,
  0x62, 0x34, 0x23, 0x46, 0x34, 0x62, 0xC6, 0x2C, 0x62, 0x2E, 0x36, 0x62,
  0x62, 0x62, 0x42, 0x46, 0x46, 0xC6, 0xC6, 0x3C, 0xCB, 0x1E, 0x38, 0x70,
  0xE1, 0xC2, 0xCC, 0xF0, 0x2E, 0x37, 0x63, 0x63, 0x63, 0x43, 0x42, 0x42,
  0xE6, 0xDC, 0xC0, 0xC0, 0x80, 0x80, 0x3A, 0xDF, 0x1E, 0x38, 0x50, 0xA1,
  0x46, 0xDC, 0xF8, 0x20, 0x40, 0x83, 0x00, 0x2C, 0xF6, 0x18, 0x61, 0x04,
  0x10, 0xC3, 0x00, 0x1C, 0x6D, 0x8B, 0x03, 0x83, 0x81, 0xE3, 0x6C, 0x70,
  0x26, 0xF6, 0x44, 0x4C, 0xCC, 0xC6, 0x46, 0x8F, 0x1E, 0x2C, 0x50, 0xA3,
  0x46, 0xDC, 0xF0, 0xC7, 0x8B, 0x32, 0x45, 0x8A, 0x14, 0x38, 0x60, 0xC0,
  0xC4, 0x59, 0x8B, 0x33, 0x6E, 0x4D, 0x48, 0xAB, 0x19, 0xC3, 0x38, 0x66,
  0x08, 0x40, 0x63, 0x26, 0x34, 0x3C, 0x18, 0x18, 0x28, 0x68, 0x4C, 0xC4,
  0x31, 0x19, 0x8C, 0xC6, 0x41, 0x60, 0xA0, 0x70, 0x30, 0x18, 0x0C, 0x04,
  0x06, 0x06, 0x06, 0x00, 0x7E, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x60,
  0xC0, 0xFC, 0x08, 0x8C, 0x42, 0x11, 0x88, 0x86, 0x10, 0x8C, 0x63, 0x08,
  0x20, 0x13, 0x32, 0x22, 0x26, 0x64, 0x44, 0x44, 0xC0, 0x10, 0x61, 0x86,
  0x18, 0x61, 0x82, 0x0C, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x80, 0x71, 0x59,
  0x8B, 0x86,
};

const GFXglyph RobotoCondensed_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 4, 1, -13 },
  { 6, 4, 4, 6, 2, -14 },
  { 8, 9, 13, 10, 1, -13 },
  { 23, 7, 17, 9, 1, -15 },
  { 38, 8, 13, 11, 2, -13 },
  { 51, 8, 13, 10, 1, -13 },
  { 64, 1, 4, 3, 2, -14 },
  { 65, 5, 18, 5, 1, -14 },
  { 77, 6, 18, 6, -1, -14 },
  { 91, 7, 7, 8, 1, -13 },
  { 98, 7, 10, 9, 1, -11 },
  { 107, 3, 4, 3, -1, -2 },
  { 109, 4, 1, 4, 0, -6 },
  { 110, 2, 2, 5, 0, -2 },
  { 111, 8, 14, 6, -1, -13 },
  { 125, 7, 13, 9, 1, -13 },
  { 137, 5, 13, 9, 2, -13 },
  { 146, 8, 13, 9, 0, -13 },
  { 159, 8, 13, 9, 0, -13 },
  { 172, 8, 13, 9, 0, -13 },
  { 185, 8, 13, 9, 1, -13 },
  { 198, 7, 13, 9, 1, -13 },
  { 210, 8, 13, 9, 1, -13 },
  { 223, 7, 13, 9, 1, -13 },
  { 235, 7, 13, 9, 1, -13 },
  { 247, 4, 10, 4, 0, -10 },
  { 252, 5, 12, 4, -1, -10 },
  { 260, 6, 8, 8, 1, -10 },
  { 266, 7, 4, 8, 1, -8 },
  { 270, 7, 8, 8, 1, -10 },
  { 277, 6, 13, 7, 1, -13 },
  { 287, 12, 17, 13, 1, -13 },
  { 313, 10, 13, 10, -1, -13 },
  { 330, 9, 13, 10, 0, -13 },
  { 345, 9, 13, 10, 1, -13 },
  { 360, 9, 13, 10, 0, -13 },
  { 375, 9, 13, 9, 0, -13 },
  { 390, 9, 13, 8, 0, -13 },
  { 405, 9, 13, 10, 1, -13 },
  { 420, 11, 13, 11, 0, -13 },
  { 438, 4, 13, 4, 0, -13 },
  { 445, 9, 13, 8, 0, -13 },
  { 460, 11, 13, 10, 0, -13 },
  { 478, 7, 13, 8, 0, -13 },
  { 490, 13, 13, 13, 0, -13 },
  { 512, 11, 13, 11, 0, -13 },
  { 530, 9, 13, 11, 1, -13 },
  { 545, 10, 13, 10, 0, -13 },
  { 562, 9, 15, 11, 1, -13 },
  { 579, 9, 13, 9, 0, -13 },
  { 594, 9, 13, 9, 0, -13 },
  { 609, 8, 13, 9, 2, -13 },
  { 622, 9, 13, 10, 1, -13 },
  { 637, 9, 13, 10, 2, -13 },
  { 652, 12, 13, 13, 2, -13 },
  { 672, 10, 13, 10, 0, -13 },
  { 689, 8, 13, 9, 2, -13 },
  { 702, 10, 13, 9, 0, -13 },
  { 719, 5, 18, 4, 0, -15 },
  { 731, 3, 14, 6, 2, -13 },
  { 737, 6, 18, 4, -1, -15 },
  { 751, 5, 6, 6, 1, -13 },
  { 755, 7, 1, 7, -1, 0 },
  { 756, 3, 3, 5, 2, -14 },
  { 758, 7, 10, 8, 0, -10 },
  { 767, 8, 14, 9, 0, -14 },
  { 781, 7, 10, 8, 1, -10 },
  { 790, 8, 14, 9, 1, -14 },
  { 804, 7, 10, 8, 1, -10 },
  { 813, 6, 14, 6, 1, -14 },
  { 824, 8, 14, 9, 0, -10 },
  { 838, 8, 14, 8, 0, -14 },
  { 852, 4, 14, 4, 0, -14 },
  { 859, 6, 18, 4, -2, -14 },
  { 873, 8, 14, 8, 0, -14 },
  { 887, 4, 14, 4, 0, -14 },
  { 894, 12, 10, 13, 0, -10 },
  { 909, 8, 10, 8, 0, -10 },
  { 919, 7, 10, 9, 1, -10 },
  { 928, 8, 14, 9, 0, -10 },
  { 942, 7, 14, 9, 1, -10 },
  { 955, 6, 10, 5, 0, -10 },
  { 963, 7, 10, 8, 0, -10 },
  { 972, 4, 12, 5, 1, -12 },
  { 978, 7, 10, 8, 1, -10 },
  { 987, 7, 10, 7, 1, -10 },
  { 996, 11, 10, 11, 1, -10 },
  { 1010, 8, 10, 8, 0, -10 },
  { 1020, 9, 14, 7, -1, -10 },
  { 1036, 8, 10, 8, 0, -10 },
  { 1046, 5, 17, 5, 1, -14 },
  { 1057, 4, 15, 4, 0, -13 },
  { 1065, 6, 17, 5, -1, -14 },
  { 1078, 8, 4, 10, 1, -8 },
};

const GFXfont RobotoCondensed_Italic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_ITALIC18PT7B_H_
