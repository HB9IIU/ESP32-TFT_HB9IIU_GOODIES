#ifndef _ROBOTOCONDENSED_ITALIC46PT7B_H_
#define _ROBOTOCONDENSED_ITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x1E, 0x0F, 0x81, 0xE0, 0x70, 0x00, 0x71, 0xDC, 0x77, 0x1D, 0xC7,
  0x73, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0x30, 0xCC, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE1, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x1C,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x1E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78,
  0xF0, 0x0F, 0x0F, 0x03, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xF1, 0xC0, 0x07, 0x06,
  0x02, 0x38, 0x38, 0x3B, 0x81, 0xC3, 0x9C, 0x0E, 0x1C, 0xE0, 0x61, 0xC7,
  0x07, 0x1C, 0x38, 0x39, 0xE0, 0xE3, 0xCE, 0x07, 0xFC, 0xE0, 0x1F, 0xCF,
  0x00, 0x7C, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0xF8, 0x03, 0x9F, 0xE0, 0x3C, 0xFF, 0x01, 0xCE, 0x1C, 0x1C, 0x70,
  0xE1, 0xE7, 0x07, 0x0E, 0x38, 0x38, 0xE1, 0xC1, 0xCE, 0x0E, 0x0E, 0x70,
  0x70, 0x77, 0x03, 0x83, 0x90, 0x1C, 0x38, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xEF, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x9F, 0x00, 0x3D,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC1, 0xC7, 0xDE, 0x0E, 0x7C, 0x78, 0xF3, 0xC3, 0xC7, 0xBC, 0x0F,
  0x39, 0xE0, 0x7B, 0xCF, 0x01, 0xFE, 0xF0, 0x0F, 0xE7, 0x80, 0x3F, 0x1E,
  0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x9F, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0x1E, 0x07, 0xE0, 0xF0, 0x7B, 0xDC, 0xE7, 0x39, 0xDC, 0xE7,
  0x38, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x08, 0x1C, 0x17, 0x8E, 0x1D, 0xFF, 0xBF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xDE, 0x01, 0xE3, 0x80, 0xF0,
  0xF0, 0x7C, 0x1C, 0x0E, 0x07, 0x01, 0x01, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x3E,
  0x3C, 0x78, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xE7, 0xE0, 0xF8, 0x3C, 0x1E, 0x03, 0x87, 0x80, 0x78, 0xF0,
  0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80,
  0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x38, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x0F,
  0x07, 0x83, 0xE0, 0xFC, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0xF7, 0xEE, 0x79, 0xE6,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xE7, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7E, 0x7C, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0x80,
  0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3,
  0xC0, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78,
  0x3C, 0x03, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE7, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xE0, 0xF8,
  0x04, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x03, 0xF7, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x73, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xF9, 0xF1, 0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x79, 0xC0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x3C, 0x1E,
  0x0F, 0xDF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC3,
  0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xE7, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0xC0, 0xF8, 0x78, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xE0, 0xFD, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF7,
  0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDC, 0x01, 0xEE, 0x00, 0xFF, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E,
  0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x0F, 0x8F, 0xDF, 0xC7, 0xFF, 0xE1, 0xFE,
  0xF0, 0x7E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x01, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC3, 0xDF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x03, 0xE0,
  0x38, 0x70, 0x1F, 0xF0, 0x30, 0xE0, 0x7F, 0xF0, 0x63, 0x81, 0xE0, 0xE0,
  0xC7, 0x03, 0x83, 0x81, 0x8E, 0x0E, 0x07, 0x03, 0x38, 0x1C, 0x0E, 0x06,
  0x70, 0x78, 0x1C, 0x0C, 0xE0, 0xE0, 0x70, 0x3B, 0x83, 0xC0, 0xE0, 0x77,
  0x07, 0x81, 0xC0, 0xEE, 0x0E, 0x03, 0x81, 0xDC, 0x1C, 0x0E, 0x03, 0x38,
  0x38, 0x1C, 0x0E, 0x70, 0xF0, 0x38, 0x1C, 0xE1, 0xE0, 0xF0, 0x33, 0x83,
  0xC1, 0xE0, 0xE7, 0x07, 0x87, 0xC1, 0x86, 0x07, 0x9F, 0x87, 0x0C, 0x0F,
  0xF7, 0xFC, 0x1C, 0x1F, 0xCF, 0xF0, 0x38, 0x1F, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0x38, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF8,
  0x78, 0x07, 0xC1, 0xE0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xE0, 0x3E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07,
  0x83, 0xE0, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x81,
  0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83,
  0xC0, 0x1F, 0x07, 0x80, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7C,
  0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0xFC,
  0xF0, 0x1F, 0xF9, 0xE0, 0x3F, 0xE3, 0xC0, 0xFF, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xE0, 0x3F, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0xF0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x03,
  0xC0, 0x7C, 0x1F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x78, 0x01,
  0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFB, 0xC0, 0x00, 0xFC, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0x80,
  0x1E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xB8, 0x00, 0xFF, 0x03, 0xDC, 0x00, 0xF7, 0x81,
  0xEE, 0x00, 0x7B, 0xC0, 0xE7, 0x80, 0x79, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0,
  0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C,
  0x0F, 0x1C, 0x0F, 0x1E, 0x07, 0x8E, 0x0F, 0x1E, 0x07, 0x87, 0x07, 0x8F,
  0x03, 0xC3, 0xC3, 0x87, 0x81, 0xE1, 0xE3, 0xC3, 0xC0, 0xF0, 0xF1, 0xC1,
  0xE0, 0x78, 0x39, 0xE0, 0xF0, 0x3C, 0x1C, 0xE0, 0xF0, 0x3C, 0x0E, 0xF0,
  0x78, 0x1E, 0x07, 0x70, 0x3C, 0x0F, 0x03, 0xF8, 0x1E, 0x07, 0x81, 0xF8,
  0x0F, 0x03, 0xC0, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x1E,
  0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF8,
  0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3C,
  0x0F, 0xC0, 0x07, 0x81, 0xFC, 0x01, 0xE0, 0x7F, 0x80, 0x3C, 0x0F, 0x70,
  0x07, 0x81, 0xEF, 0x00, 0xF0, 0x3C, 0xE0, 0x1E, 0x07, 0x9C, 0x03, 0xC0,
  0xF3, 0xC0, 0xF0, 0x3C, 0x38, 0x1E, 0x07, 0x87, 0x03, 0xC0, 0xF0, 0xF0,
  0x78, 0x1E, 0x0E, 0x0F, 0x03, 0xC1, 0xC3, 0xE0, 0x78, 0x3C, 0x78, 0x1E,
  0x03, 0x8F, 0x03, 0xC0, 0x71, 0xE0, 0x78, 0x0F, 0x3C, 0x0F, 0x01, 0xE7,
  0x81, 0xE0, 0x1D, 0xF0, 0x3C, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x81, 0xE0,
  0x07, 0xF0, 0x3C, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0xC0, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x07, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x03, 0xE0, 0x7E, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0x80,
  0x3E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x03, 0xE0, 0x7C,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80,
  0x3E, 0x0F, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C, 0x07,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x03,
  0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x78,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x00,
  0x7B, 0xC0, 0x1E, 0x00, 0xF7, 0x80, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x07,
  0x9E, 0x03, 0xF0, 0x0F, 0x3C, 0x07, 0xE0, 0x1E, 0x78, 0x0F, 0xC0, 0x78,
  0xF0, 0x3F, 0x80, 0xF1, 0xE0, 0x77, 0x01, 0xE3, 0xC0, 0xEF, 0x07, 0x87,
  0x83, 0xDE, 0x0F, 0x0F, 0x07, 0x1C, 0x1E, 0x1E, 0x1E, 0x38, 0x78, 0x3C,
  0x3C, 0x70, 0xF0, 0x78, 0x70, 0xE1, 0xE0, 0xF1, 0xE1, 0xC7, 0x81, 0xE3,
  0x83, 0x8F, 0x03, 0xC7, 0x07, 0x1C, 0x07, 0x9E, 0x0E, 0x78, 0x0F, 0x38,
  0x1C, 0xF0, 0x1E, 0xF0, 0x39, 0xC0, 0x3D, 0xC0, 0x77, 0x80, 0x7B, 0x80,
  0xEF, 0x00, 0xFF, 0x01, 0xDC, 0x00, 0xFC, 0x03, 0xB8, 0x01, 0xF8, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x03,
  0xC0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80,
  0x0F, 0x9E, 0x00, 0x7C, 0x78, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C,
  0x0F, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x07,
  0x87, 0x80, 0x1E, 0x3E, 0x00, 0x38, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xE0, 0xE0, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x38, 0x38,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0x87,
  0x1E, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xF1, 0xE1, 0xE1, 0xC3, 0xC3, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x3E, 0x1F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC1, 0xE7, 0xC0, 0x79, 0xE0, 0x1C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFE, 0xF0, 0x3E, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x1F, 0x01, 0xEF, 0xF8,
  0x3F, 0xFF, 0x87, 0xFB, 0xF0, 0xF8, 0x1F, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x7D, 0xF0, 0x0F, 0x3F, 0x03, 0xE7, 0xFF, 0xF8, 0xF7, 0xFE, 0x1E,
  0xFF, 0x83, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xE7, 0xC1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0x71, 0xE0, 0x0E,
  0x78, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x83, 0xE3, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x7E, 0x3C, 0x07,
  0xFC, 0xF0, 0x3F, 0xFB, 0x80, 0xFD, 0xFE, 0x07, 0xC0, 0xF8, 0x3E, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0,
  0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3E,
  0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFC, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x3E,
  0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0xDE,
  0x00, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDE, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x21, 0xF0, 0x3C,
  0x3F, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0xFC, 0x78, 0x1F, 0xF3, 0xC1, 0xFF, 0xDE, 0x0F,
  0xFF, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x78, 0x38, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x7C, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x06, 0x01, 0xE0, 0x7E, 0x7F, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0xF8, 0x1E, 0xFF, 0x87,
  0xFF, 0xE1, 0xFE, 0xFC, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xE0, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x3E, 0x1E,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x3E, 0x01,
  0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7E, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0E, 0x3E, 0x07, 0xE0, 0x3B, 0xFC, 0x3F,
  0xC1, 0xFF, 0xF9, 0xFF, 0x87, 0xF7, 0xFF, 0xFF, 0x1F, 0x07, 0xF0, 0x7C,
  0x78, 0x0F, 0x80, 0xF1, 0xE0, 0x3E, 0x03, 0xCF, 0x00, 0xF0, 0x0F, 0x3C,
  0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x03, 0xCF, 0x00,
  0xF0, 0x0F, 0x38, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78,
  0x07, 0x9E, 0x01, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x01,
  0xC7, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xF3,
  0xC0, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0x80, 0x38, 0x0E,
  0x3E, 0x07, 0xBF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x38, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xE7, 0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x38, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xF3, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0x80, 0x03, 0x8F, 0x80, 0x3D, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07,
  0x8F, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x8F, 0x80, 0x78, 0x7E, 0x07, 0xC3, 0xFC, 0xFC, 0x1F, 0xFF, 0xC0,
  0xF7, 0xFC, 0x07, 0x8F, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x7F, 0xCF, 0x0F, 0xFE,
  0xF0, 0xFC, 0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x7E, 0x3F, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x0E, 0x78, 0xF7, 0xC7, 0xFE, 0x3F, 0xF1, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0x7E, 0x1F, 0x07, 0x87, 0x80, 0xF1, 0xC0, 0x3C, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF1, 0xE0, 0x78, 0x7E, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xFC, 0x3F, 0x83, 0xE0, 0x3C, 0x00, 0x1C, 0x01, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xF7, 0x80, 0xFC, 0xE0, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03,
  0xCF, 0x01, 0xE3, 0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00,
  0x77, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x0E, 0x01, 0xFE, 0x03,
  0xC0, 0x7B, 0xC0, 0x78, 0x0F, 0x78, 0x1F, 0x01, 0xCF, 0x03, 0xE0, 0x79,
  0xE0, 0xFC, 0x0F, 0x3C, 0x1F, 0x83, 0xC7, 0x87, 0xF0, 0x78, 0x70, 0xEF,
  0x0E, 0x0E, 0x1D, 0xE3, 0xC1, 0xC7, 0xBC, 0x70, 0x38, 0xE3, 0x9E, 0x07,
  0x3C, 0x73, 0xC0, 0xE7, 0x0E, 0x70, 0x1D, 0xE1, 0xDE, 0x03, 0xB8, 0x3B,
  0x80, 0x7F, 0x07, 0x70, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0x07, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x07, 0x3E, 0x00, 0x3D,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x9C,
  0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x1C, 0x03, 0xE0, 0xF0, 0x1E,
  0x07, 0x81, 0xF0, 0x3E, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0x80,
  0x78, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xE0,
  0x00, 0x77, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00,
  0x04, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x80, 0x01, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x73, 0xFF, 0x01, 0xCF, 0xFE, 0x0F, 0x78, 0x7C,
  0x79, 0xC0, 0xFF, 0xEF, 0x03, 0xFF, 0x3C, 0x03, 0xF8, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 33, 11, 1, -33 },
  { 43, 10, 11, 14, 5, -35 },
  { 57, 23, 33, 24, 2, -33 },
  { 152, 19, 42, 22, 2, -38 },
  { 252, 21, 33, 28, 4, -33 },
  { 339, 21, 33, 24, 1, -33 },
  { 426, 5, 11, 8, 4, -35 },
  { 433, 14, 48, 14, 2, -37 },
  { 517, 14, 48, 14, -2, -37 },
  { 601, 18, 19, 19, 2, -33 },
  { 644, 19, 24, 22, 2, -28 },
  { 701, 8, 11, 9, -3, -5 },
  { 712, 9, 3, 11, 1, -15 },
  { 716, 5, 5, 12, 1, -5 },
  { 720, 20, 36, 17, -2, -33 },
  { 810, 19, 33, 22, 2, -33 },
  { 889, 12, 33, 22, 5, -33 },
  { 939, 21, 33, 22, 0, -33 },
  { 1026, 20, 33, 22, 1, -33 },
  { 1109, 21, 33, 22, 0, -33 },
  { 1196, 20, 33, 22, 2, -33 },
  { 1279, 18, 33, 22, 2, -33 },
  { 1354, 20, 33, 22, 3, -33 },
  { 1437, 19, 33, 22, 2, -33 },
  { 1516, 17, 33, 22, 3, -33 },
  { 1587, 9, 25, 11, 1, -25 },
  { 1616, 11, 31, 9, -2, -25 },
  { 1659, 17, 20, 20, 2, -25 },
  { 1702, 18, 13, 21, 2, -22 },
  { 1732, 18, 21, 21, 1, -25 },
  { 1780, 15, 33, 19, 4, -33 },
  { 1842, 31, 42, 34, 1, -32 },
  { 2005, 23, 33, 26, -1, -33 },
  { 2100, 22, 33, 24, 1, -33 },
  { 2191, 23, 33, 25, 2, -33 },
  { 2286, 23, 33, 25, 1, -33 },
  { 2381, 23, 33, 22, 1, -33 },
  { 2476, 22, 33, 21, 1, -33 },
  { 2567, 23, 33, 26, 2, -33 },
  { 2662, 27, 33, 28, 1, -33 },
  { 2774, 10, 33, 11, 1, -33 },
  { 2816, 22, 33, 22, 0, -33 },
  { 2907, 26, 33, 24, 1, -33 },
  { 3015, 17, 33, 21, 1, -33 },
  { 3086, 33, 33, 34, 1, -33 },
  { 3223, 27, 33, 28, 1, -33 },
  { 3335, 23, 33, 27, 2, -33 },
  { 3430, 24, 33, 25, 1, -33 },
  { 3529, 23, 39, 27, 2, -33 },
  { 3642, 23, 33, 24, 1, -33 },
  { 3737, 22, 33, 23, 1, -33 },
  { 3828, 21, 33, 23, 4, -33 },
  { 3915, 24, 33, 25, 2, -33 },
  { 4014, 23, 33, 25, 4, -33 },
  { 4109, 31, 33, 34, 5, -33 },
  { 4237, 27, 33, 25, -1, -33 },
  { 4349, 22, 33, 23, 4, -33 },
  { 4440, 24, 33, 23, 0, -33 },
  { 4539, 14, 44, 11, 0, -37 },
  { 4616, 8, 36, 16, 5, -33 },
  { 4652, 15, 44, 11, -3, -37 },
  { 4735, 13, 16, 17, 2, -33 },
  { 4761, 17, 3, 18, -2, 0 },
  { 4768, 7, 7, 14, 5, -35 },
  { 4775, 18, 24, 21, 1, -24 },
  { 4829, 19, 35, 22, 1, -35 },
  { 4913, 19, 24, 21, 1, -24 },
  { 4970, 22, 35, 22, 1, -35 },
  { 5067, 18, 24, 21, 1, -24 },
  { 5121, 15, 35, 14, 2, -35 },
  { 5187, 21, 33, 22, 0, -24 },
  { 5274, 18, 35, 22, 1, -35 },
  { 5353, 9, 33, 10, 1, -33 },
  { 5391, 14, 42, 10, -4, -33 },
  { 5465, 20, 35, 20, 1, -35 },
  { 5553, 10, 35, 10, 1, -35 },
  { 5597, 30, 24, 34, 1, -24 },
  { 5687, 18, 24, 22, 1, -24 },
  { 5741, 19, 24, 22, 1, -24 },
  { 5798, 21, 33, 22, -1, -24 },
  { 5885, 20, 33, 22, 1, -24 },
  { 5968, 13, 24, 14, 1, -24 },
  { 6007, 18, 24, 20, 1, -24 },
  { 6061, 11, 30, 13, 2, -30 },
  { 6103, 19, 24, 22, 2, -24 },
  { 6160, 17, 24, 19, 3, -24 },
  { 6211, 27, 24, 29, 3, -24 },
  { 6292, 21, 24, 20, -1, -24 },
  { 6355, 22, 33, 19, -2, -24 },
  { 6446, 19, 24, 20, 0, -24 },
  { 6503, 15, 44, 14, 1, -36 },
  { 6586, 9, 39, 11, 1, -33 },
  { 6630, 14, 44, 14, -2, -36 },
  { 6707, 22, 9, 26, 2, -18 },
};

const GFXfont RobotoCondensed_Italic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_ITALIC46PT7B_H_
