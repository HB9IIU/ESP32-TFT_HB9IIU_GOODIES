#ifndef _ROBOTOCONDENSED_ITALIC17PT7B_H_
#define _ROBOTOCONDENSED_ITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0xB6, 0x02, 0x40, 0xBA, 0xAA, 0x09, 0x0B, 0x1A, 0x12,
  0x7F, 0x34, 0x24, 0xFE, 0x68, 0x48, 0x58, 0x90, 0x08, 0x10, 0xF3, 0x26,
  0x68, 0xD8, 0x18, 0x18, 0x1A, 0x14, 0x6D, 0x8E, 0x08, 0x10, 0x61, 0x22,
  0x5C, 0xAA, 0x9E, 0x07, 0x9D, 0x53, 0xA6, 0x48, 0x60, 0x1E, 0x12, 0x32,
  0x36, 0x1C, 0x18, 0x39, 0x6D, 0x47, 0x46, 0x66, 0x3B, 0x55, 0x08, 0xCC,
  0x46, 0x21, 0x18, 0xC4, 0x21, 0x08, 0x42, 0x08, 0x42, 0x00, 0x10, 0x86,
  0x10, 0x84, 0x21, 0x08, 0x46, 0x31, 0x08, 0x8C, 0x44, 0x00, 0x10, 0x23,
  0x53, 0xE3, 0x0B, 0x02, 0x00, 0x18, 0x20, 0x40, 0x8F, 0xE6, 0x0C, 0x10,
  0x20, 0x6D, 0x40, 0xF0, 0x50, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x3C, 0xC9, 0x1A, 0x3C, 0x78, 0xA1,
  0x42, 0x85, 0x1B, 0x63, 0x80, 0x1F, 0x93, 0x32, 0x22, 0x26, 0x64, 0x1E,
  0x32, 0x23, 0x63, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xFE, 0x1E,
  0x32, 0x23, 0x02, 0x06, 0x1C, 0x06, 0x06, 0x06, 0x46, 0x4C, 0x38, 0x03,
  0x06, 0x0E, 0x0A, 0x16, 0x36, 0x64, 0x44, 0xFE, 0x0C, 0x0C, 0x0C, 0x3E,
  0x40, 0x83, 0x07, 0x8D, 0x81, 0x02, 0x05, 0x1B, 0x23, 0x80, 0x1C, 0xC6,
  0x10, 0x7B, 0xBC, 0x61, 0x86, 0x3C, 0x9C, 0x7E, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x3C, 0xC9, 0x1A, 0x36, 0xCF,
  0x33, 0x46, 0x8D, 0x1B, 0x63, 0x80, 0x38, 0xD9, 0x16, 0x2C, 0x58, 0x93,
  0x3A, 0x0C, 0x10, 0xC3, 0x00, 0x22, 0x00, 0x00, 0x04, 0xC0, 0x11, 0x00,
  0x00, 0x02, 0x64, 0xC0, 0x04, 0x77, 0x20, 0xE0, 0xE0, 0x80, 0x7C, 0x00,
  0x3F, 0x20, 0x70, 0x30, 0x31, 0xCE, 0x10, 0x00, 0x39, 0xB4, 0x43, 0x08,
  0x42, 0x18, 0x00, 0x04, 0x10, 0x0F, 0x83, 0x18, 0x81, 0x30, 0x14, 0x73,
  0x92, 0x64, 0x4C, 0x99, 0x92, 0x32, 0x4A, 0x59, 0x4D, 0xC8, 0x01, 0x00,
  0x10, 0x01, 0xE0, 0x03, 0x01, 0x81, 0x40, 0xA0, 0xD0, 0x48, 0x66, 0x23,
  0x3F, 0x90, 0x58, 0x28, 0x10, 0x3F, 0x18, 0x8C, 0x64, 0x22, 0x31, 0xF1,
  0x8C, 0xC6, 0x63, 0x21, 0x91, 0x9F, 0x80, 0x1E, 0x33, 0x61, 0x41, 0xC0,
  0xC0, 0xC0, 0x80, 0x82, 0xC6, 0x4C, 0x78, 0x3E, 0x19, 0x8C, 0x64, 0x32,
  0x19, 0x0D, 0x86, 0xC2, 0x61, 0x21, 0x91, 0x9F, 0x80, 0x3F, 0x98, 0x0C,
  0x04, 0x02, 0x01, 0xF1, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x1F, 0xC0, 0x3F,
  0x98, 0x0C, 0x04, 0x02, 0x01, 0x01, 0xF8, 0xC0, 0x60, 0x20, 0x10, 0x18,
  0x00, 0x1E, 0x33, 0x61, 0x41, 0xC0, 0xC0, 0xCF, 0x83, 0x82, 0xC2, 0x66,
  0x7C, 0x30, 0x4C, 0x33, 0x0C, 0x83, 0x20, 0x8F, 0xE6, 0x09, 0x86, 0x61,
  0x90, 0x64, 0x13, 0x04, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0x03, 0x03,
  0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0xC6, 0xC4, 0x4C, 0x78, 0x30, 0x8C,
  0x63, 0x30, 0x98, 0x2C, 0x0E, 0x07, 0xC1, 0xB0, 0x66, 0x11, 0x84, 0x23,
  0x0C, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x07, 0xF0,
  0x30, 0x33, 0x83, 0x38, 0x72, 0x87, 0x28, 0xF2, 0x8A, 0x69, 0xA6, 0x92,
  0x4F, 0x64, 0xE6, 0x46, 0x6C, 0x44, 0x30, 0x4C, 0x33, 0x8C, 0xA3, 0x28,
  0x8B, 0x26, 0x49, 0x96, 0x67, 0x90, 0xE4, 0x33, 0x0C, 0x1E, 0x33, 0x61,
  0x41, 0xC1, 0xC1, 0xC1, 0x83, 0x83, 0xC2, 0x6E, 0x78, 0x3F, 0x18, 0xCC,
  0x24, 0x12, 0x19, 0x19, 0xF8, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x00, 0x1E,
  0x33, 0x61, 0x41, 0xC1, 0xC1, 0xC3, 0x83, 0x82, 0xC2, 0xCC, 0x7C, 0x04,
  0x04, 0x3E, 0x19, 0x8C, 0x64, 0x32, 0x11, 0x19, 0xF8, 0xC8, 0x66, 0x23,
  0x10, 0x98, 0x60, 0x1E, 0x19, 0x88, 0x44, 0x33, 0x00, 0xC0, 0x38, 0x04,
  0xC3, 0x21, 0x19, 0x87, 0x80, 0x7F, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x61, 0x30, 0x90, 0x48, 0x6C, 0x36, 0x1B,
  0x09, 0x04, 0x82, 0x43, 0x33, 0x0F, 0x00, 0x41, 0xA0, 0x90, 0xC8, 0x46,
  0x63, 0x31, 0x90, 0x58, 0x28, 0x1C, 0x0C, 0x06, 0x00, 0x84, 0x31, 0x8E,
  0x31, 0x46, 0x29, 0x4D, 0x29, 0x2D, 0x25, 0x3C, 0xA7, 0x18, 0x63, 0x0C,
  0x61, 0x00, 0x30, 0x8C, 0x61, 0x30, 0x68, 0x1E, 0x03, 0x01, 0xC0, 0x50,
  0x34, 0x19, 0x86, 0x23, 0x0C, 0x82, 0x86, 0xCC, 0xCC, 0x58, 0x50, 0x70,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x1F, 0xC0, 0x39, 0x8C, 0x42, 0x10, 0x8C,
  0x62, 0x10, 0x84, 0x63, 0x18, 0xE0, 0x92, 0x4D, 0x92, 0x49, 0x36, 0x18,
  0x42, 0x31, 0x88, 0x42, 0x11, 0x8C, 0x62, 0x10, 0x84, 0xE0, 0x11, 0x9C,
  0xAD, 0x4C, 0xFE, 0xC8, 0x1C, 0x6D, 0x88, 0x33, 0xEC, 0xD1, 0x26, 0x74,
  0x30, 0x60, 0x81, 0x03, 0xEE, 0xD8, 0xB1, 0x42, 0x85, 0x1F, 0x2F, 0xC0,
  0x39, 0x3C, 0x60, 0x82, 0x08, 0xF6, 0x70, 0x02, 0x04, 0x08, 0x37, 0xE9,
  0xB1, 0x42, 0x85, 0x1A, 0x36, 0xC7, 0x80, 0x39, 0x3C, 0x61, 0xFE, 0x08,
  0x32, 0x70, 0x19, 0x88, 0xCF, 0x31, 0x08, 0x46, 0x31, 0x88, 0x00, 0x3F,
  0x27, 0x62, 0x42, 0x42, 0x46, 0x46, 0x6C, 0x3C, 0x04, 0xCC, 0x78, 0x30,
  0x60, 0x81, 0x03, 0xCE, 0xD8, 0xB1, 0x46, 0x8D, 0x16, 0x2C, 0x40, 0x33,
  0x00, 0x22, 0x66, 0x64, 0x44, 0xC0, 0x0C, 0x30, 0x00, 0x08, 0x21, 0x86,
  0x10, 0x41, 0x0C, 0x30, 0xC2, 0x38, 0x30, 0x30, 0x20, 0x20, 0x26, 0x64,
  0x68, 0x70, 0x70, 0x78, 0x48, 0xCC, 0xC4, 0x33, 0x32, 0x22, 0x66, 0x64,
  0x44, 0xC0, 0x3C, 0xE3, 0x72, 0x62, 0x26, 0x22, 0x46, 0x24, 0x62, 0x44,
  0x6C, 0x46, 0xC4, 0x60, 0x3C, 0x6D, 0x8B, 0x14, 0x68, 0xD1, 0x62, 0xC4,
  0x38, 0xDB, 0x14, 0x38, 0x50, 0xA3, 0x64, 0x70, 0x3E, 0xED, 0x8B, 0x14,
  0x28, 0x51, 0xF2, 0xFD, 0x02, 0x04, 0x00, 0x7E, 0x9B, 0x14, 0x28, 0x51,
  0xA3, 0x6C, 0x78, 0x10, 0x60, 0xC0, 0x39, 0x98, 0xC4, 0x21, 0x18, 0xC0,
  0x1C, 0x4D, 0x99, 0x03, 0x81, 0xB1, 0x26, 0x78, 0x66, 0xF4, 0x44, 0xCC,
  0xCC, 0xC0, 0x47, 0x8B, 0x16, 0x28, 0xD1, 0xA2, 0x6C, 0xE8, 0x87, 0x3C,
  0xB6, 0x51, 0x46, 0x18, 0x60, 0xCC, 0xF3, 0x2D, 0xCB, 0x56, 0xD5, 0x39,
  0xC6, 0x61, 0x18, 0x46, 0x00, 0x66, 0x48, 0xB1, 0xC1, 0x07, 0x1A, 0x24,
  0xCC, 0x33, 0x33, 0x32, 0x36, 0x14, 0x1C, 0x18, 0x18, 0x10, 0x30, 0x20,
  0xC0, 0x7E, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x60, 0xFC, 0x08, 0x88, 0x42,
  0x31, 0x88, 0x86, 0x11, 0x8C, 0x61, 0x08, 0x32, 0x22, 0x22, 0x66, 0x44,
  0x44, 0x4C, 0x10, 0x41, 0x86, 0x18, 0x61, 0x06, 0x0C, 0x43, 0x0C, 0x20,
  0x86, 0x30, 0x71, 0xDA, 0x8E,
};

const GFXglyph RobotoCondensed_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 4, 4, 5, 2, -13 },
  { 8, 8, 12, 9, 1, -12 },
  { 20, 7, 16, 8, 1, -14 },
  { 34, 7, 12, 10, 2, -12 },
  { 45, 8, 12, 9, 0, -12 },
  { 57, 2, 4, 3, 1, -13 },
  { 58, 5, 18, 5, 1, -14 },
  { 70, 5, 18, 5, -1, -14 },
  { 82, 7, 7, 7, 1, -12 },
  { 89, 7, 9, 8, 1, -10 },
  { 97, 3, 4, 3, -1, -2 },
  { 99, 4, 1, 4, 0, -6 },
  { 100, 2, 2, 4, 0, -2 },
  { 101, 8, 13, 6, -1, -12 },
  { 114, 7, 12, 8, 1, -12 },
  { 125, 4, 12, 8, 2, -12 },
  { 131, 8, 12, 8, 0, -12 },
  { 143, 8, 12, 8, 0, -12 },
  { 155, 8, 12, 8, 0, -12 },
  { 167, 7, 12, 8, 1, -12 },
  { 178, 6, 12, 8, 1, -12 },
  { 187, 8, 12, 8, 1, -12 },
  { 199, 7, 12, 8, 1, -12 },
  { 210, 7, 12, 8, 1, -12 },
  { 221, 4, 9, 4, 0, -9 },
  { 226, 4, 11, 3, -1, -9 },
  { 232, 6, 7, 7, 1, -9 },
  { 238, 6, 4, 8, 1, -8 },
  { 241, 7, 7, 8, 0, -9 },
  { 248, 6, 12, 7, 1, -12 },
  { 257, 11, 16, 13, 1, -12 },
  { 279, 9, 12, 10, -1, -12 },
  { 293, 9, 12, 9, 0, -12 },
  { 307, 8, 12, 9, 1, -12 },
  { 319, 9, 12, 9, 0, -12 },
  { 333, 9, 12, 8, 0, -12 },
  { 347, 9, 12, 8, 0, -12 },
  { 361, 8, 12, 10, 1, -12 },
  { 373, 10, 12, 10, 0, -12 },
  { 388, 4, 12, 4, 0, -12 },
  { 394, 8, 12, 8, 0, -12 },
  { 406, 10, 12, 9, 0, -12 },
  { 421, 7, 12, 8, 0, -12 },
  { 432, 12, 12, 12, 0, -12 },
  { 450, 10, 12, 10, 0, -12 },
  { 465, 8, 12, 10, 1, -12 },
  { 477, 9, 12, 9, 0, -12 },
  { 491, 8, 14, 10, 1, -12 },
  { 505, 9, 12, 9, 0, -12 },
  { 519, 9, 12, 9, 0, -12 },
  { 533, 8, 12, 9, 1, -12 },
  { 545, 9, 12, 9, 1, -12 },
  { 559, 9, 12, 9, 1, -12 },
  { 573, 11, 12, 13, 2, -12 },
  { 590, 10, 12, 9, 0, -12 },
  { 605, 8, 12, 9, 2, -12 },
  { 617, 9, 12, 9, 0, -12 },
  { 631, 5, 17, 4, 0, -14 },
  { 642, 3, 13, 6, 2, -12 },
  { 647, 5, 17, 4, -1, -14 },
  { 658, 5, 6, 6, 1, -12 },
  { 662, 7, 1, 7, -1, 0 },
  { 663, 3, 2, 5, 2, -12 },
  { 664, 7, 9, 8, 0, -9 },
  { 672, 7, 13, 8, 0, -13 },
  { 684, 6, 9, 8, 1, -9 },
  { 691, 7, 13, 8, 1, -13 },
  { 703, 6, 9, 8, 1, -9 },
  { 710, 5, 13, 5, 1, -13 },
  { 719, 8, 12, 8, 0, -9 },
  { 731, 7, 13, 8, 0, -13 },
  { 743, 4, 13, 4, 0, -13 },
  { 750, 6, 16, 4, -2, -13 },
  { 762, 8, 13, 7, 0, -13 },
  { 775, 4, 13, 4, 0, -13 },
  { 782, 12, 9, 12, 0, -9 },
  { 796, 7, 9, 8, 0, -9 },
  { 804, 7, 9, 8, 1, -9 },
  { 812, 7, 12, 8, 0, -9 },
  { 823, 7, 12, 8, 1, -9 },
  { 834, 5, 9, 5, 0, -9 },
  { 840, 7, 9, 8, 0, -9 },
  { 848, 4, 11, 5, 1, -11 },
  { 854, 7, 9, 8, 1, -9 },
  { 862, 6, 9, 7, 1, -9 },
  { 869, 10, 9, 11, 1, -9 },
  { 881, 7, 9, 7, 0, -9 },
  { 889, 8, 12, 7, -1, -9 },
  { 901, 7, 9, 7, 0, -9 },
  { 909, 5, 16, 5, 1, -13 },
  { 919, 4, 14, 4, 0, -12 },
  { 926, 6, 16, 5, -1, -13 },
  { 938, 8, 3, 10, 1, -6 },
};

const GFXfont RobotoCondensed_Italic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_ITALIC17PT7B_H_
