#ifndef _ROBOTOCONDENSED_ITALIC24PT7B_H_
#define _ROBOTOCONDENSED_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x19, 0x8C, 0x63, 0x18, 0xC0, 0x03, 0x18, 0xC0,
  0x6D, 0xB4, 0xD2, 0x4B, 0x60, 0x03, 0x30, 0x22, 0x02, 0x60, 0x66, 0x3F,
  0xF3, 0xFF, 0x0C, 0xC0, 0x88, 0x09, 0x81, 0x98, 0x11, 0x0F, 0xFC, 0xFF,
  0xC2, 0x20, 0x26, 0x06, 0x60, 0x44, 0x00, 0x03, 0x00, 0xC0, 0x20, 0x3C,
  0x1F, 0x8E, 0x73, 0x0C, 0xC3, 0x30, 0x0C, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xE0, 0x1B, 0x06, 0xC1, 0xB8, 0xC7, 0xF0, 0xF0, 0x10, 0x04, 0x00, 0x38,
  0x0D, 0x81, 0x11, 0x62, 0x6C, 0x49, 0x9B, 0x1E, 0xC3, 0xD0, 0x06, 0x01,
  0xB8, 0x6D, 0x89, 0x13, 0x62, 0xCC, 0x51, 0x98, 0x1E, 0x03, 0xC0, 0x0F,
  0x03, 0xF0, 0x66, 0x18, 0xC3, 0x18, 0x67, 0x07, 0xC0, 0xE0, 0x3C, 0x0F,
  0x8F, 0x99, 0x63, 0x6C, 0x3D, 0x87, 0x30, 0xE3, 0xFE, 0x3C, 0xC0, 0x69,
  0x6D, 0x80, 0x02, 0x0C, 0x30, 0x61, 0x82, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0x80, 0x06, 0x01,
  0x00, 0x41, 0xB6, 0xFF, 0xC7, 0x81, 0xC0, 0xD8, 0x66, 0x00, 0x80, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x37, 0x66, 0xC8, 0x7B, 0xC0, 0x7C, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x00, 0x0F, 0x07, 0xE3,
  0x1C, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x61, 0xB0, 0x6C, 0x1B, 0x06,
  0xC1, 0xB0, 0xCE, 0x31, 0xF8, 0x3C, 0x00, 0x0C, 0xFF, 0xF6, 0x18, 0x61,
  0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x60, 0x07, 0x83, 0xF8, 0x63,
  0x98, 0x33, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0x07, 0xE3, 0x19,
  0xC3, 0x60, 0xC0, 0x60, 0x18, 0x7C, 0x1E, 0x00, 0xC0, 0x38, 0x06, 0xC3,
  0xB0, 0xCC, 0x31, 0xF8, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x6C, 0x0D, 0x83, 0x30, 0xCC, 0x19, 0x86, 0x31, 0x86, 0x7F, 0xFF, 0xFC,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1F, 0xE3, 0xF8, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0F, 0xC1, 0xFC, 0x71, 0x80, 0x30, 0x06, 0x00, 0xCC, 0x19,
  0x83, 0x18, 0xC3, 0xF8, 0x3C, 0x00, 0x03, 0x87, 0xC7, 0x07, 0x03, 0x03,
  0x01, 0xBC, 0xFE, 0x71, 0xB0, 0xF0, 0x78, 0x3C, 0x1F, 0x0D, 0x8C, 0xFC,
  0x3C, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x00,
  0x0F, 0x07, 0xE3, 0x9C, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0xFC, 0x3E, 0x18,
  0xCC, 0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x31, 0xF8, 0x3C, 0x00, 0x1E, 0x1F,
  0x98, 0xD8, 0x6C, 0x1E, 0x0F, 0x0F, 0x86, 0xC7, 0x3F, 0x9E, 0xC0, 0x40,
  0x60, 0x70, 0x71, 0xF0, 0xE0, 0x00, 0x27, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x61, 0x8C,
  0x30, 0x00, 0x81, 0x83, 0xC7, 0x8F, 0x06, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x00, 0x80, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x40, 0x38,
  0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x3C, 0x7C, 0xF8, 0x70, 0x20, 0x00, 0x3C,
  0x7E, 0xE7, 0xC3, 0x03, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x60, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x02,
  0x10, 0x02, 0x31, 0xE3, 0x63, 0xF3, 0x62, 0x31, 0x46, 0x23, 0xC4, 0x23,
  0xCC, 0x63, 0xCC, 0x62, 0x8C, 0x62, 0x8C, 0x46, 0x8C, 0xC4, 0x8F, 0x6C,
  0x87, 0x78, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x01, 0xB0, 0x19, 0x80,
  0xCC, 0x0C, 0x30, 0x61, 0x87, 0x0C, 0x3F, 0xE3, 0xFF, 0x18, 0x19, 0xC0,
  0xCC, 0x06, 0xE0, 0x18, 0x3F, 0x87, 0xF8, 0xC1, 0x98, 0x33, 0x06, 0x60,
  0xDC, 0x33, 0xFC, 0x7F, 0x8C, 0x39, 0x83, 0x30, 0x6C, 0x0D, 0x83, 0xB0,
  0x67, 0xFC, 0xFE, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x63, 0x03, 0x30, 0x36,
  0x03, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0xC0, 0xC6,
  0x0C, 0x61, 0xC3, 0xF8, 0x1E, 0x00, 0x3F, 0x83, 0xFC, 0x30, 0xE3, 0x06,
  0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E,
  0xC0, 0xCC, 0x1C, 0xC3, 0x8F, 0xF0, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x07, 0xC1, 0xFE, 0x18,
  0x73, 0x03, 0x30, 0x36, 0x00, 0x60, 0x06, 0x00, 0x63, 0xE6, 0x3E, 0xC0,
  0x6C, 0x06, 0xC0, 0x66, 0x0E, 0x60, 0xC3, 0xFC, 0x1F, 0x00, 0x38, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x98, 0x19, 0x80, 0xCF, 0xFE, 0x7F,
  0xF3, 0x01, 0x98, 0x1C, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C,
  0xC0, 0xE0, 0x19, 0x8C, 0x63, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0x63, 0x18,
  0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xCC, 0x19, 0x83, 0x18, 0xC3, 0xF8, 0x3C,
  0x00, 0x38, 0x39, 0x83, 0x8C, 0x38, 0x63, 0x83, 0x38, 0x19, 0x81, 0x98,
  0x0D, 0x80, 0x7E, 0x03, 0xB0, 0x19, 0xC0, 0xC6, 0x0C, 0x30, 0x60, 0xC3,
  0x06, 0x18, 0x38, 0xC0, 0xC0, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0x38, 0x03,
  0x1C, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xD9, 0xB0,
  0x78, 0xD8, 0x6C, 0x64, 0x36, 0x32, 0x33, 0x19, 0x99, 0x8C, 0xD9, 0xCC,
  0x6C, 0xC6, 0x3C, 0x63, 0x1E, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x00, 0x38,
  0x19, 0xC0, 0xCE, 0x06, 0x78, 0x33, 0xC3, 0x9A, 0x19, 0xD8, 0xCC, 0xC6,
  0x62, 0x33, 0x19, 0x98, 0xDC, 0xC2, 0xCC, 0x1E, 0x60, 0xF3, 0x03, 0x98,
  0x1C, 0xC0, 0xE0, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x36, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0xE0, 0x6C, 0x06, 0xC0, 0x66, 0x0C,
  0x61, 0xC3, 0xF8, 0x1F, 0x00, 0x3F, 0xC3, 0xFE, 0x30, 0x73, 0x03, 0x30,
  0x33, 0x03, 0x70, 0x76, 0x0E, 0x7F, 0xC7, 0xF8, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xC1, 0xFE, 0x18, 0x63,
  0x03, 0x70, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x3E, 0x07, 0xC0, 0x6C,
  0x06, 0xC0, 0x66, 0x0C, 0x61, 0xC7, 0xF8, 0x1F, 0x00, 0x18, 0x01, 0xC0,
  0x08, 0x3F, 0x87, 0xF8, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xDC, 0x1B, 0x06,
  0x7F, 0xCF, 0xE1, 0x8C, 0x31, 0x8C, 0x39, 0x83, 0x30, 0x66, 0x0C, 0xC1,
  0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x37, 0x06, 0xE0, 0x0C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x06, 0x00, 0x6C, 0x0D, 0x83, 0x30, 0xE3, 0xF8, 0x3E,
  0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x70, 0x36, 0x06, 0x60, 0x66,
  0x06, 0x60, 0x66, 0x06, 0xE0, 0xEC, 0x0C, 0xC0, 0xCC, 0x0C, 0xE1, 0x87,
  0xF8, 0x3E, 0x00, 0xC0, 0x3C, 0x07, 0xE0, 0x66, 0x0E, 0x60, 0xC6, 0x1C,
  0x61, 0x86, 0x18, 0x63, 0x06, 0x30, 0x36, 0x03, 0x60, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x00, 0xC1, 0x83, 0xE0, 0xE1, 0xB0, 0x70, 0xCC,
  0x78, 0xE6, 0x3C, 0x63, 0x16, 0x31, 0x9B, 0x30, 0xCD, 0x98, 0x6C, 0xCC,
  0x36, 0x6C, 0x1A, 0x36, 0x0F, 0x0B, 0x07, 0x87, 0x03, 0x83, 0x81, 0xC1,
  0xC0, 0xE0, 0xC0, 0x60, 0x60, 0x00, 0x18, 0x18, 0x60, 0xE1, 0xC7, 0x03,
  0x18, 0x0C, 0xE0, 0x3B, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0x60, 0x19, 0x80, 0xC7, 0x07, 0x0C, 0x18, 0x30, 0xE0, 0xE0,
  0xE0, 0x66, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0x83, 0x30, 0x37, 0x03, 0x60,
  0x3C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x1E, 0x3C, 0x60, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C,
  0x18, 0x3C, 0x78, 0xC2, 0x18, 0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x63, 0x18,
  0xC2, 0x18, 0xC0, 0x1E, 0x3C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x3C, 0x78,
  0x0C, 0x18, 0x70, 0xA3, 0x46, 0xD9, 0xB3, 0xC6, 0xFF, 0xFF, 0xC0, 0x61,
  0x8C, 0x1E, 0x1F, 0x9C, 0x6C, 0x30, 0x18, 0xFD, 0xFD, 0xC6, 0xC3, 0x61,
  0xB1, 0xDF, 0xE7, 0xB0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0D, 0xE3,
  0xFC, 0xE3, 0x30, 0xCC, 0x33, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x86,
  0x7F, 0xB3, 0xC0, 0x1E, 0x1F, 0x98, 0x6C, 0x3C, 0x1E, 0x03, 0x01, 0x80,
  0xC0, 0x61, 0xB0, 0xCF, 0xC3, 0xC0, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x3D, 0x8F, 0xB3, 0x0E, 0x61, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19,
  0x83, 0x30, 0xC6, 0x18, 0x7F, 0x0F, 0x60, 0x1E, 0x1F, 0x98, 0x6C, 0x3C,
  0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0xCF, 0xE3, 0xC0, 0x07, 0x0F,
  0x18, 0x18, 0x38, 0x7C, 0x7C, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0x0F, 0x63, 0xEC, 0xC3, 0x98, 0x66, 0x0C, 0xC1,
  0x98, 0x33, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x1F, 0xC3, 0xD8, 0x03, 0x00,
  0xC2, 0x18, 0xFE, 0x07, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0D,
  0xE3, 0xFC, 0xE3, 0x30, 0xCC, 0x33, 0x0D, 0x83, 0x61, 0x98, 0x66, 0x19,
  0x86, 0x61, 0xB0, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC6, 0x31, 0x8C, 0x66,
  0x31, 0x8C, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x1C, 0x38,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x71, 0x8C, 0x71, 0x9C,
  0x37, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x60, 0xCC, 0x19, 0xC3, 0x18, 0x63,
  0x18, 0x30, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x61,
  0x86, 0x18, 0x61, 0x80, 0x37, 0x9E, 0x3F, 0xFF, 0x38, 0xE3, 0x30, 0xC3,
  0x30, 0xC3, 0x30, 0xC3, 0x60, 0xC3, 0x61, 0x83, 0x61, 0x87, 0x61, 0x86,
  0x61, 0x86, 0x61, 0x86, 0xC1, 0x86, 0x37, 0x8F, 0xF3, 0x8C, 0xC3, 0x30,
  0xCC, 0x36, 0x0D, 0x86, 0x61, 0x98, 0x66, 0x19, 0x86, 0xC1, 0x80, 0x1F,
  0x0F, 0xE7, 0x19, 0x86, 0xC0, 0xF0, 0x3C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C,
  0x31, 0xF8, 0x3C, 0x00, 0x1B, 0xC3, 0xFC, 0x71, 0x8C, 0x31, 0x86, 0x30,
  0xCC, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x1F, 0xE6, 0x78, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x1E, 0xCF, 0xF6, 0x1D, 0x86, 0xC1, 0xB0,
  0x6C, 0x1B, 0x06, 0xC3, 0xB0, 0xCC, 0x33, 0xFC, 0x7B, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x37, 0x3E, 0x38, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0x0F, 0x07, 0xE3, 0x1C, 0xC3, 0x30, 0x0F,
  0x01, 0xE0, 0x1C, 0x01, 0x98, 0x66, 0x39, 0xFC, 0x3E, 0x00, 0x18, 0xC3,
  0x3F, 0xFC, 0xC3, 0x18, 0x61, 0x86, 0x18, 0x61, 0x87, 0x1C, 0x60, 0xD8,
  0x76, 0x19, 0x86, 0x61, 0x98, 0x6C, 0x1B, 0x0C, 0xC3, 0x30, 0xCC, 0x73,
  0xFC, 0x7B, 0x00, 0x41, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0x98, 0xD8,
  0x2C, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0xC6, 0x1B, 0x18, 0x6C, 0x71, 0xB3,
  0xCC, 0xCF, 0x33, 0x6D, 0x8D, 0xB6, 0x34, 0xD8, 0xF3, 0xC3, 0x8F, 0x0E,
  0x18, 0x38, 0x60, 0xC1, 0x80, 0x18, 0x63, 0x18, 0x37, 0x06, 0xC0, 0xF0,
  0x0E, 0x01, 0x80, 0x70, 0x1F, 0x03, 0x60, 0xCE, 0x38, 0xC6, 0x18, 0x38,
  0x63, 0x1C, 0x63, 0x0C, 0x61, 0x98, 0x33, 0x06, 0xC0, 0xD8, 0x1B, 0x03,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0xF0, 0x1C, 0x00,
  0x3F, 0xCF, 0xF0, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0xFC, 0xFF, 0x00, 0x02, 0x1C, 0x30, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0x63, 0x86, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06,
  0x04, 0x00, 0x18, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x42, 0x31, 0x8C,
  0x63, 0x11, 0x80, 0x18, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x1C, 0x20, 0x00,
  0x38, 0x27, 0xC2, 0x66, 0x6C, 0x7C, 0xC3, 0xC0,
};

const GFXglyph RobotoCondensed_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 17, 6, 1, -17 },
  { 12, 6, 6, 7, 2, -18 },
  { 17, 12, 17, 13, 1, -17 },
  { 43, 10, 22, 12, 1, -20 },
  { 71, 11, 17, 15, 2, -17 },
  { 95, 11, 17, 13, 1, -17 },
  { 119, 3, 6, 4, 2, -18 },
  { 122, 7, 25, 7, 1, -19 },
  { 144, 7, 25, 7, -1, -19 },
  { 166, 10, 10, 10, 1, -17 },
  { 179, 10, 12, 12, 1, -14 },
  { 194, 4, 6, 5, -1, -3 },
  { 197, 5, 2, 6, 0, -8 },
  { 199, 2, 3, 6, 1, -3 },
  { 200, 11, 18, 9, -1, -17 },
  { 225, 10, 17, 12, 1, -17 },
  { 247, 6, 17, 12, 3, -17 },
  { 260, 11, 17, 12, 0, -17 },
  { 284, 10, 17, 12, 1, -17 },
  { 306, 11, 17, 12, 0, -17 },
  { 330, 11, 17, 12, 1, -17 },
  { 354, 9, 17, 12, 1, -17 },
  { 374, 10, 17, 12, 2, -17 },
  { 396, 10, 17, 12, 1, -17 },
  { 418, 9, 17, 12, 2, -17 },
  { 438, 4, 13, 6, 1, -13 },
  { 445, 6, 16, 5, -1, -13 },
  { 457, 9, 11, 10, 1, -13 },
  { 470, 9, 7, 11, 1, -12 },
  { 478, 9, 11, 11, 1, -13 },
  { 491, 8, 17, 10, 2, -17 },
  { 508, 16, 22, 18, 1, -17 },
  { 552, 13, 17, 13, -1, -17 },
  { 580, 11, 17, 13, 1, -17 },
  { 604, 12, 17, 13, 1, -17 },
  { 630, 12, 17, 13, 1, -17 },
  { 656, 11, 17, 12, 1, -17 },
  { 680, 11, 17, 11, 1, -17 },
  { 704, 12, 17, 14, 1, -17 },
  { 730, 13, 17, 14, 1, -17 },
  { 758, 5, 17, 6, 1, -17 },
  { 769, 11, 17, 11, 0, -17 },
  { 793, 13, 17, 13, 1, -17 },
  { 821, 8, 17, 11, 1, -17 },
  { 838, 17, 17, 18, 1, -17 },
  { 875, 13, 17, 14, 1, -17 },
  { 903, 12, 17, 14, 1, -17 },
  { 929, 12, 17, 13, 1, -17 },
  { 955, 12, 20, 14, 1, -17 },
  { 985, 11, 17, 12, 1, -17 },
  { 1009, 11, 17, 12, 1, -17 },
  { 1033, 11, 17, 12, 2, -17 },
  { 1057, 12, 17, 13, 1, -17 },
  { 1083, 12, 17, 13, 2, -17 },
  { 1109, 17, 17, 18, 2, -17 },
  { 1146, 14, 17, 13, 0, -17 },
  { 1176, 12, 17, 12, 2, -17 },
  { 1202, 13, 17, 12, 0, -17 },
  { 1230, 7, 24, 6, 0, -20 },
  { 1251, 5, 18, 9, 2, -17 },
  { 1263, 7, 24, 6, -1, -20 },
  { 1284, 7, 9, 9, 1, -17 },
  { 1292, 9, 2, 9, -1, 0 },
  { 1295, 5, 3, 7, 2, -18 },
  { 1297, 9, 13, 11, 1, -13 },
  { 1312, 10, 18, 11, 0, -18 },
  { 1335, 9, 13, 11, 1, -13 },
  { 1350, 11, 18, 12, 1, -18 },
  { 1375, 9, 13, 11, 1, -13 },
  { 1390, 8, 18, 7, 1, -18 },
  { 1408, 11, 18, 11, 0, -13 },
  { 1433, 10, 18, 11, 0, -18 },
  { 1456, 5, 18, 5, 0, -18 },
  { 1468, 7, 23, 5, -2, -18 },
  { 1489, 11, 18, 10, 0, -18 },
  { 1514, 6, 18, 5, 0, -18 },
  { 1528, 16, 13, 18, 0, -13 },
  { 1554, 10, 13, 11, 0, -13 },
  { 1571, 10, 13, 12, 1, -13 },
  { 1588, 11, 18, 11, -1, -13 },
  { 1613, 10, 18, 12, 1, -13 },
  { 1636, 8, 13, 7, 0, -13 },
  { 1649, 10, 13, 11, 0, -13 },
  { 1666, 6, 16, 7, 1, -16 },
  { 1678, 10, 13, 11, 1, -13 },
  { 1695, 9, 13, 10, 1, -13 },
  { 1710, 14, 13, 15, 2, -13 },
  { 1733, 11, 13, 10, -1, -13 },
  { 1751, 11, 18, 10, -1, -13 },
  { 1776, 10, 13, 10, 0, -13 },
  { 1793, 7, 23, 7, 1, -19 },
  { 1814, 5, 20, 6, 0, -17 },
  { 1827, 7, 23, 7, -1, -19 },
  { 1848, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Italic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_ITALIC24PT7B_H_
