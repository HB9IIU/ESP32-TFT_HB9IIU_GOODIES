#ifndef _ROBOTOCONDENSED_ITALIC22PT7B_H_
#define _ROBOTOCONDENSED_ITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x26, 0x66, 0x66, 0x44, 0x00, 0xCC, 0x4A, 0x57, 0xB9,
  0x00, 0x02, 0x60, 0xC8, 0x11, 0x02, 0x63, 0xFE, 0x7F, 0xC2, 0x60, 0xC8,
  0x11, 0x02, 0x63, 0xFE, 0x11, 0x02, 0x60, 0xC8, 0x19, 0x02, 0x60, 0x06,
  0x03, 0x03, 0x83, 0xE3, 0x19, 0x0D, 0x86, 0x40, 0x30, 0x1E, 0x03, 0x80,
  0xE0, 0x36, 0x1B, 0x0D, 0x8E, 0x7E, 0x1E, 0x0C, 0x06, 0x00, 0x78, 0x12,
  0x0C, 0x8E, 0x26, 0x89, 0x36, 0xC7, 0x60, 0x10, 0x08, 0x06, 0xE1, 0x6C,
  0x91, 0x64, 0x51, 0x30, 0x4C, 0x0E, 0x0E, 0x07, 0xC3, 0x10, 0xC4, 0x33,
  0x0D, 0xC1, 0xE0, 0x60, 0x7C, 0x1B, 0x3C, 0x6B, 0x1E, 0xC3, 0x30, 0xCF,
  0xF9, 0xF6, 0x7F, 0x80, 0x02, 0x0C, 0x30, 0xC1, 0x06, 0x08, 0x30, 0x60,
  0xC1, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x04, 0x08,
  0x00, 0x10, 0x30, 0x20, 0x60, 0x40, 0x81, 0x03, 0x06, 0x08, 0x10, 0x60,
  0xC1, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x20, 0x00, 0x0C, 0x06,
  0x03, 0x1D, 0x73, 0xF0, 0xE0, 0xF0, 0xCC, 0x44, 0x00, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x00, 0x26,
  0x6C, 0x80, 0x7F, 0xC0, 0xF0, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x00, 0x0E, 0x1F, 0x8C, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0x83,
  0xC1, 0x60, 0xB0, 0xD8, 0x6C, 0x36, 0x31, 0xF8, 0x70, 0x0B, 0xFF, 0x31,
  0x88, 0xC6, 0x31, 0x8C, 0x46, 0x31, 0x8C, 0x0F, 0x07, 0xE3, 0x8C, 0xC3,
  0x30, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x0F, 0xFB, 0xFE, 0x1E, 0x1F, 0x98, 0x6C, 0x30, 0x18, 0x0C, 0x0C, 0x3C,
  0x1E, 0x03, 0x00, 0xC0, 0x68, 0x36, 0x33, 0xF8, 0xF0, 0x01, 0xC0, 0x70,
  0x38, 0x1E, 0x05, 0x83, 0x61, 0x98, 0x46, 0x31, 0x18, 0xC7, 0xFF, 0xFF,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x1F, 0xC7, 0xE3, 0x00, 0xC0, 0x30, 0x0B,
  0x87, 0xF0, 0x8C, 0x03, 0x00, 0x40, 0x10, 0x0C, 0xC3, 0x30, 0xC7, 0xE0,
  0xF0, 0x07, 0x0F, 0x18, 0x30, 0x20, 0x7E, 0x7F, 0x63, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x66, 0x7E, 0x3C, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x0E, 0x0F, 0x8C, 0x64, 0x36, 0x1B, 0x0C, 0x8C, 0x7E, 0x3E, 0x31,
  0x30, 0xD8, 0x6C, 0x36, 0x33, 0xF8, 0xF8, 0x3C, 0x7E, 0x66, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC2, 0xC6, 0xFE, 0x7E, 0x04, 0x0C, 0x18, 0xF0, 0xE0, 0x39,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x18, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x98, 0xC6, 0x60, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xC0, 0x70, 0x3C, 0x0C,
  0x04, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x40, 0x70, 0x38,
  0x0E, 0x03, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x3C, 0xFF, 0x1E, 0x30, 0x61,
  0xC3, 0x0C, 0x30, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x03, 0xE0, 0x1C,
  0xE0, 0x80, 0x84, 0x01, 0x30, 0x05, 0x87, 0x16, 0x76, 0x51, 0x19, 0xCC,
  0x47, 0x31, 0x18, 0x8C, 0x62, 0x23, 0x89, 0x8A, 0x3F, 0x68, 0xEF, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x07, 0x10, 0x07, 0xC0, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x40, 0x64, 0x06, 0x40, 0xC6, 0x0C, 0x61, 0x86, 0x1F,
  0xE3, 0xFE, 0x30, 0x66, 0x02, 0x60, 0x36, 0x03, 0x3F, 0x0F, 0xE3, 0x0C,
  0xC3, 0x60, 0xD8, 0x36, 0x19, 0xFC, 0x7F, 0x18, 0x6C, 0x1B, 0x06, 0xC1,
  0xB0, 0xEF, 0xF3, 0xF8, 0x0F, 0x83, 0xF8, 0xC1, 0x98, 0x36, 0x06, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x6C, 0x18, 0xC3, 0x1F,
  0xC1, 0xF0, 0x3F, 0x0F, 0xE3, 0x0C, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x83,
  0x60, 0xD8, 0x3C, 0x0F, 0x06, 0xC1, 0xB0, 0xCF, 0xE3, 0xF0, 0x3F, 0xCF,
  0xF3, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xFC, 0x7F, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0xFC, 0x7F, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x98, 0x36, 0x06, 0xC0, 0x18, 0x03,
  0x00, 0xC3, 0xD8, 0xFB, 0x03, 0x60, 0x6C, 0x0C, 0xC3, 0x9F, 0xE1, 0xF0,
  0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x60, 0x66, 0x06, 0x60, 0x67, 0xFE,
  0x7F, 0xE6, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C,
  0x33, 0x33, 0x26, 0x66, 0x66, 0x4C, 0xCC, 0xCC, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1B, 0x04, 0xC3,
  0x38, 0xC7, 0xE0, 0xF0, 0x30, 0x63, 0x0E, 0x31, 0xC3, 0x38, 0x63, 0x06,
  0x60, 0x6C, 0x07, 0xC0, 0x7C, 0x06, 0x60, 0xC6, 0x0C, 0x60, 0xC3, 0x0C,
  0x30, 0xC1, 0x8C, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFE, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x79, 0xC0, 0xE6, 0x83, 0x4D, 0x07, 0x9B, 0x1B, 0x36, 0x36, 0x6C,
  0x4C, 0xD9, 0x93, 0x32, 0x66, 0x2C, 0xCC, 0x51, 0x98, 0xE3, 0x31, 0x86,
  0x63, 0x08, 0x30, 0x33, 0x83, 0x38, 0x33, 0x83, 0x6C, 0x66, 0xC6, 0x64,
  0x66, 0x66, 0x66, 0x66, 0x66, 0xC2, 0xCC, 0x3C, 0xC3, 0xCC, 0x1C, 0xC1,
  0xCC, 0x1C, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x0C, 0xC3, 0x1F, 0xC1, 0xF0,
  0x3F, 0x87, 0xF8, 0xC3, 0x18, 0x36, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0x7F,
  0x8F, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x0F, 0x83,
  0xF8, 0xC3, 0x18, 0x36, 0x06, 0xC0, 0xD8, 0x1A, 0x03, 0xC0, 0x78, 0x0B,
  0x03, 0x60, 0x6C, 0x0C, 0xC3, 0x1F, 0xC1, 0xF8, 0x03, 0x00, 0x30, 0x04,
  0x00, 0x3F, 0x0F, 0xE3, 0x0C, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x86, 0x7F,
  0x9F, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0xCC, 0x3B, 0x06, 0x07, 0x83, 0xF8,
  0x61, 0x98, 0x33, 0x06, 0x60, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x03,
  0x20, 0x66, 0x0C, 0xC3, 0x0F, 0xE0, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x30, 0x66, 0x0C, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0x98,
  0x33, 0x06, 0x40, 0xD8, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x87, 0x1F, 0xC1,
  0xF0, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0xC4, 0x18, 0xC3, 0x18, 0xC3, 0x18,
  0x66, 0x0C, 0xC1, 0xB0, 0x16, 0x02, 0x80, 0x70, 0x0E, 0x01, 0x80, 0xC1,
  0x07, 0x87, 0x0F, 0x0E, 0x36, 0x1C, 0x6C, 0x78, 0xD8, 0xB3, 0x33, 0x66,
  0x66, 0xCC, 0xC9, 0xB0, 0xB1, 0x61, 0x62, 0xC2, 0x85, 0x07, 0x0E, 0x0C,
  0x1C, 0x18, 0x30, 0x30, 0x60, 0x38, 0x30, 0xC3, 0x86, 0x18, 0x39, 0x80,
  0xDC, 0x06, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x78, 0x06, 0xC0, 0x36,
  0x03, 0x18, 0x38, 0xC1, 0x86, 0x18, 0x18, 0xC0, 0xD8, 0x39, 0x86, 0x31,
  0x86, 0x30, 0xCC, 0x09, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x1E, 0x38, 0x60, 0xC1, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x07, 0x8E, 0x00,
  0xCC, 0x44, 0x46, 0x66, 0x66, 0x22, 0x33, 0x33, 0x30, 0x1E, 0x38, 0x30,
  0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30,
  0x60, 0xC7, 0x8E, 0x00, 0x08, 0x61, 0xCF, 0x2D, 0xB4, 0x71, 0xFF, 0xFF,
  0x66, 0x30, 0x1E, 0x3F, 0x63, 0x03, 0x03, 0x3F, 0x73, 0xC2, 0xC6, 0xC6,
  0xFE, 0x76, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0D, 0xC3, 0xF8, 0xC6,
  0x30, 0xC8, 0x36, 0x09, 0x82, 0x61, 0x98, 0x66, 0x39, 0x7C, 0xDE, 0x00,
  0x1E, 0x3F, 0x63, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xFE, 0x78,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x8F, 0x67, 0xF9, 0x8E, 0xC1, 0x30,
  0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x63, 0xF8, 0x7E, 0x00, 0x1E, 0x3F,
  0x63, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0xC2, 0xFE, 0x7C, 0x0E, 0x3C,
  0x61, 0x83, 0x0F, 0xBF, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60,
  0xC0, 0x1E, 0xCF, 0xF3, 0x1D, 0x82, 0x61, 0x98, 0x66, 0x19, 0x86, 0x61,
  0x98, 0xC7, 0xF0, 0xFC, 0x03, 0x01, 0x8F, 0xE1, 0xF0, 0x18, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0xB8, 0xFE, 0x63, 0x31, 0x90, 0xD8, 0x6C, 0x36, 0x1B,
  0x09, 0x8C, 0x86, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0xC6, 0x33, 0x18,
  0xC6, 0x31, 0x98, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x63, 0x87, 0x00, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x73, 0x38, 0xDC, 0x36, 0x0B, 0x07, 0xC1, 0xF0,
  0x6C, 0x19, 0x86, 0x61, 0x0C, 0xC3, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6,
  0x31, 0x88, 0xC6, 0x31, 0x8C, 0xC0, 0x37, 0x3C, 0x7F, 0xFC, 0xC7, 0x19,
  0x8C, 0x32, 0x18, 0x6C, 0x30, 0xD8, 0x61, 0x30, 0xC6, 0x61, 0x0C, 0xC6,
  0x19, 0x0C, 0x36, 0x18, 0x60, 0x37, 0x1F, 0xCC, 0x66, 0x32, 0x1B, 0x0D,
  0x86, 0xC3, 0x61, 0x31, 0x90, 0xD8, 0x60, 0x1E, 0x1F, 0x98, 0xD8, 0x3C,
  0x1E, 0x0F, 0x07, 0x82, 0xC3, 0x61, 0x9F, 0x87, 0x80, 0x1B, 0x83, 0xF8,
  0x63, 0x0C, 0x33, 0x06, 0x60, 0x8C, 0x11, 0x86, 0x30, 0xC6, 0x39, 0xFE,
  0x37, 0x86, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x3D, 0xBF, 0xD8, 0xF8, 0x2C,
  0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x3F, 0x8F, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x3E, 0x7C, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x00,
  0x0E, 0x1F, 0x8C, 0x66, 0x33, 0x00, 0xE0, 0x38, 0x06, 0xC3, 0x31, 0x9F,
  0x87, 0x80, 0x31, 0xBF, 0xF2, 0x31, 0x8C, 0x63, 0x11, 0x8F, 0x30, 0x61,
  0xB0, 0xD8, 0x4C, 0x64, 0x36, 0x1B, 0x0D, 0x86, 0xC2, 0x63, 0x3F, 0x8F,
  0xC0, 0xC3, 0x43, 0x42, 0x46, 0x66, 0x6C, 0x6C, 0x68, 0x78, 0x30, 0x30,
  0x20, 0xC3, 0x1A, 0x38, 0xD1, 0xCC, 0x8E, 0x64, 0xF2, 0x25, 0xB1, 0xE5,
  0x8F, 0x28, 0x71, 0xC3, 0x8C, 0x18, 0x60, 0xC3, 0x00, 0x18, 0xC3, 0x38,
  0x66, 0x05, 0x80, 0xF0, 0x0C, 0x03, 0x80, 0x70, 0x1A, 0x06, 0x61, 0xCC,
  0x30, 0xC0, 0x30, 0xCC, 0x31, 0x18, 0x66, 0x1B, 0x06, 0xC1, 0xA0, 0x78,
  0x1E, 0x07, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x0F, 0x03, 0x80, 0x3F, 0x9F,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x3F, 0xDF, 0xC0,
  0x04, 0x18, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x31, 0xC3, 0x03, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x81, 0x83, 0x02, 0x00, 0x18, 0xC4, 0x21, 0x18, 0xC6,
  0x31, 0x08, 0x46, 0x31, 0x88, 0x42, 0x30, 0x10, 0x30, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x1C, 0x38, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x61, 0x87,
  0x08, 0x00, 0x38, 0x4F, 0x8B, 0x1F, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 5, 7, 2, -17 },
  { 13, 11, 16, 12, 1, -16 },
  { 35, 9, 20, 11, 1, -18 },
  { 58, 10, 16, 14, 2, -16 },
  { 78, 10, 16, 12, 1, -16 },
  { 98, 2, 5, 4, 2, -17 },
  { 100, 7, 23, 7, 1, -18 },
  { 121, 7, 23, 7, -1, -18 },
  { 142, 9, 9, 9, 1, -16 },
  { 153, 9, 12, 11, 1, -14 },
  { 167, 4, 5, 4, -1, -2 },
  { 170, 5, 2, 5, 0, -8 },
  { 172, 2, 2, 6, 1, -2 },
  { 173, 10, 17, 8, -1, -16 },
  { 195, 9, 16, 11, 1, -16 },
  { 213, 5, 16, 11, 3, -16 },
  { 223, 10, 16, 11, 0, -16 },
  { 243, 9, 16, 11, 1, -16 },
  { 261, 10, 16, 11, 0, -16 },
  { 281, 10, 16, 11, 1, -16 },
  { 301, 8, 16, 11, 1, -16 },
  { 317, 10, 16, 11, 1, -16 },
  { 337, 9, 16, 11, 1, -16 },
  { 355, 8, 16, 11, 2, -16 },
  { 371, 5, 11, 5, 0, -11 },
  { 378, 5, 14, 4, -1, -11 },
  { 387, 8, 10, 10, 1, -12 },
  { 397, 9, 7, 10, 1, -11 },
  { 405, 8, 10, 10, 1, -12 },
  { 415, 7, 16, 9, 2, -16 },
  { 429, 14, 20, 16, 1, -15 },
  { 464, 12, 16, 12, -1, -16 },
  { 488, 10, 16, 12, 1, -16 },
  { 508, 11, 16, 12, 1, -16 },
  { 530, 10, 16, 12, 1, -16 },
  { 550, 10, 16, 11, 1, -16 },
  { 570, 10, 16, 10, 1, -16 },
  { 590, 11, 16, 13, 1, -16 },
  { 612, 12, 16, 13, 1, -16 },
  { 636, 4, 16, 5, 1, -16 },
  { 644, 10, 16, 10, 0, -16 },
  { 664, 12, 16, 12, 1, -16 },
  { 688, 8, 16, 10, 1, -16 },
  { 704, 15, 16, 16, 1, -16 },
  { 734, 12, 16, 13, 1, -16 },
  { 758, 11, 16, 13, 1, -16 },
  { 780, 11, 16, 12, 1, -16 },
  { 802, 11, 19, 13, 1, -16 },
  { 829, 10, 16, 11, 1, -16 },
  { 849, 11, 16, 11, 0, -16 },
  { 871, 10, 16, 11, 2, -16 },
  { 891, 11, 16, 12, 1, -16 },
  { 913, 11, 16, 12, 2, -16 },
  { 935, 15, 16, 16, 2, -16 },
  { 965, 13, 16, 12, 0, -16 },
  { 991, 11, 16, 11, 2, -16 },
  { 1013, 12, 16, 11, 0, -16 },
  { 1037, 7, 21, 5, 0, -18 },
  { 1056, 4, 17, 8, 2, -16 },
  { 1065, 7, 21, 5, -1, -18 },
  { 1084, 6, 8, 8, 1, -16 },
  { 1090, 8, 2, 9, -1, 0 },
  { 1092, 4, 3, 7, 2, -16 },
  { 1094, 8, 12, 10, 1, -12 },
  { 1106, 10, 17, 11, 0, -17 },
  { 1128, 8, 12, 10, 1, -12 },
  { 1140, 10, 17, 11, 1, -17 },
  { 1162, 8, 12, 10, 1, -12 },
  { 1174, 7, 17, 7, 1, -17 },
  { 1189, 10, 16, 11, 0, -12 },
  { 1209, 9, 17, 10, 0, -17 },
  { 1229, 5, 16, 5, 0, -16 },
  { 1239, 7, 20, 5, -2, -16 },
  { 1257, 10, 17, 10, 0, -17 },
  { 1279, 5, 17, 5, 0, -17 },
  { 1290, 15, 12, 16, 0, -12 },
  { 1313, 9, 12, 10, 0, -12 },
  { 1327, 9, 12, 11, 1, -12 },
  { 1341, 11, 16, 11, -1, -12 },
  { 1363, 9, 16, 11, 1, -12 },
  { 1381, 7, 12, 7, 0, -12 },
  { 1392, 9, 12, 10, 0, -12 },
  { 1406, 5, 14, 6, 1, -14 },
  { 1415, 9, 12, 10, 1, -12 },
  { 1429, 8, 12, 9, 1, -12 },
  { 1441, 13, 12, 14, 1, -12 },
  { 1461, 11, 12, 9, -1, -12 },
  { 1478, 10, 16, 9, -1, -12 },
  { 1498, 9, 12, 9, 0, -12 },
  { 1512, 7, 21, 7, 1, -17 },
  { 1531, 5, 19, 5, 0, -16 },
  { 1543, 7, 21, 7, -1, -17 },
  { 1562, 11, 4, 13, 1, -8 },
};

const GFXfont RobotoCondensed_Italic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_ITALIC22PT7B_H_
