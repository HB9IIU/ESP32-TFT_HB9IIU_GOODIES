#ifndef _ROBOTOCONDENSED_ITALIC25PT7B_H_
#define _ROBOTOCONDENSED_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCC, 0x63, 0x18, 0xCC, 0x63, 0x18, 0xC0, 0x00, 0x18, 0xC6,
  0x00, 0x65, 0xB6, 0xD3, 0x49, 0x20, 0x01, 0x10, 0x19, 0x80, 0xCC, 0x04,
  0x40, 0x66, 0x1F, 0xFC, 0xFF, 0xC1, 0x98, 0x0C, 0xC0, 0x44, 0x06, 0x61,
  0xFF, 0xCF, 0xFE, 0x19, 0x80, 0xCC, 0x04, 0x40, 0x66, 0x03, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x30, 0x3C, 0x1F, 0x8E, 0x33, 0x0C, 0xC3, 0x30, 0xCC,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x18, 0x06, 0xC1, 0xB0, 0x6E, 0x39,
  0xFC, 0x3C, 0x06, 0x01, 0x00, 0x38, 0x07, 0xC0, 0x44, 0x2C, 0x66, 0xC4,
  0xCC, 0x48, 0x7D, 0x83, 0xB0, 0x02, 0x00, 0x60, 0x0D, 0xE1, 0xBE, 0x13,
  0x33, 0x23, 0x62, 0x34, 0x22, 0x03, 0x60, 0x1C, 0x0F, 0x03, 0xF0, 0x67,
  0x1C, 0x63, 0x0C, 0x63, 0x06, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0x99, 0xF3,
  0x3C, 0x37, 0x87, 0xB0, 0x67, 0x1C, 0x7F, 0xC7, 0x9C, 0x6D, 0x6D, 0x80,
  0x01, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20,
  0x30, 0x10, 0x08, 0x30, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0xC1,
  0x00, 0x06, 0x01, 0x80, 0x41, 0x93, 0xFF, 0xC3, 0x81, 0xE0, 0xD8, 0x63,
  0x00, 0x80, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x3F, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x37, 0x66, 0xC8, 0x7D, 0xE0,
  0xFC, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x00, 0x0F, 0x87, 0xE3, 0x8C, 0xC3, 0x70, 0xD8,
  0x36, 0x0D, 0x83, 0x60, 0xD8, 0x3E, 0x0F, 0x06, 0xC1, 0xB0, 0x6C, 0x19,
  0x8C, 0x7E, 0x0F, 0x00, 0x04, 0xFF, 0xF3, 0x0C, 0x61, 0x86, 0x18, 0x61,
  0x8C, 0x30, 0xC3, 0x0C, 0x31, 0x80, 0x07, 0x81, 0xFC, 0x61, 0x9C, 0x33,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xDF, 0xF8, 0x0F, 0x07, 0xE3, 0x1C, 0xC3,
  0x60, 0xC0, 0x30, 0x1C, 0x06, 0x1F, 0x07, 0xC0, 0x38, 0x06, 0x01, 0xB0,
  0x6C, 0x3B, 0x0C, 0x7E, 0x0F, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xF0,
  0x3C, 0x0D, 0x83, 0xB0, 0x66, 0x18, 0xC7, 0x38, 0xC6, 0x30, 0xCF, 0xFF,
  0xFF, 0xC0, 0x60, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xFC, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0F, 0xC1, 0xFC, 0x31, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x1D, 0x83, 0x30, 0x63, 0x1C, 0x7F, 0x07, 0xC0, 0x03, 0x83, 0xE1, 0xC0,
  0x60, 0x30, 0x0C, 0x06, 0xF1, 0xFE, 0x71, 0x98, 0x66, 0x1F, 0x87, 0xE1,
  0xB8, 0x66, 0x19, 0x8C, 0x7F, 0x0F, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x0F, 0x07, 0xF3, 0x8C,
  0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC6, 0x1F, 0x8F, 0xC6, 0x3B, 0x86, 0xC1,
  0xB0, 0x6C, 0x1B, 0x8C, 0x7F, 0x0F, 0x00, 0x1E, 0x1F, 0x98, 0xEC, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xF3, 0xDF, 0xC7, 0x60, 0x30, 0x30, 0x38,
  0x38, 0xF8, 0x70, 0x00, 0x37, 0x30, 0x00, 0x00, 0x00, 0x0C, 0xCC, 0x08,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x31, 0xC6, 0x38, 0xC0,
  0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x86, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x00,
  0x80, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x20, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x0C, 0x1E, 0x7C, 0xF8, 0x70, 0x20, 0x00, 0x3E,
  0x7F, 0x63, 0xC3, 0x03, 0x03, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0x81, 0x81,
  0x80, 0x61, 0x80, 0x11, 0x87, 0x08, 0x87, 0xC4, 0xC6, 0x23, 0x66, 0x31,
  0xA3, 0x18, 0xB1, 0x0C, 0x59, 0x84, 0x2C, 0xC6, 0x34, 0x63, 0x1A, 0x33,
  0x89, 0x1F, 0xD8, 0x87, 0x38, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x01, 0x90, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C,
  0x3F, 0xE1, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0x60, 0x1F, 0x00, 0xC0,
  0x1F, 0xC3, 0xFE, 0x30, 0x63, 0x06, 0x30, 0x73, 0x06, 0x30, 0x67, 0x0E,
  0x7F, 0xC7, 0xF8, 0x60, 0xC6, 0x0C, 0x60, 0xCE, 0x0C, 0xC0, 0xCC, 0x1C,
  0xFF, 0x8F, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63, 0x03, 0x38,
  0x1D, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x06,
  0x70, 0x31, 0x83, 0x8E, 0x38, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xFC,
  0x30, 0xE3, 0x07, 0x30, 0x33, 0x03, 0x30, 0x37, 0x03, 0x60, 0x76, 0x07,
  0x60, 0x66, 0x06, 0x60, 0x6E, 0x0E, 0xC0, 0xCC, 0x38, 0xFF, 0x0F, 0xE0,
  0x1F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x7F, 0xC7, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x7F, 0x87, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70,
  0x63, 0x03, 0xB8, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F, 0xB8, 0xFD,
  0xC0, 0xEE, 0x06, 0x70, 0x31, 0x81, 0x8E, 0x1C, 0x3F, 0xC0, 0xF8, 0x00,
  0x18, 0x0C, 0xE0, 0x73, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01,
  0x9C, 0x0E, 0x7F, 0xF9, 0xFF, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x81,
  0xCC, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x80, 0x18, 0xCE, 0x63, 0x18,
  0xCE, 0x73, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xCC, 0x18, 0xE1, 0x86, 0x38, 0x7F, 0x03, 0xE0, 0x18,
  0x38, 0xE0, 0xC3, 0x06, 0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x18, 0xC0, 0x63, 0x03, 0x8E, 0x0C,
  0x18, 0x30, 0x70, 0xC0, 0xC3, 0x03, 0x80, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x80, 0xFF, 0xFF, 0xC0, 0x1C, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x6C, 0xC8, 0x36, 0x66, 0x33, 0x33,
  0x1B, 0x99, 0x99, 0x8C, 0xCC, 0xC6, 0x6C, 0x67, 0x36, 0x33, 0x0F, 0x19,
  0x87, 0x1C, 0xC3, 0x8C, 0x61, 0x86, 0x00, 0x18, 0x0C, 0xE0, 0x33, 0xC1,
  0xCF, 0x06, 0x3C, 0x18, 0xD8, 0x63, 0x61, 0x9D, 0x8E, 0x63, 0x39, 0x8C,
  0xC6, 0x33, 0x18, 0x6C, 0x61, 0xB3, 0x87, 0xCC, 0x0E, 0x30, 0x38, 0xC0,
  0xE3, 0x01, 0x80, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63, 0x03, 0xB8,
  0x0D, 0x80, 0xEC, 0x07, 0x60, 0x33, 0x01, 0x98, 0x0D, 0xC0, 0x6E, 0x07,
  0x30, 0x31, 0x83, 0x8E, 0x38, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC1, 0xFF,
  0x0C, 0x1C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xCE, 0x0E, 0x60, 0x63,
  0xFF, 0x1F, 0xE0, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63, 0x03, 0x38,
  0x1D, 0x80, 0xEC, 0x06, 0x60, 0x33, 0x01, 0xB8, 0x0D, 0xC0, 0x6C, 0x07,
  0x70, 0x31, 0x83, 0x8E, 0x38, 0x3F, 0x80, 0xFC, 0x00, 0x70, 0x01, 0xC0,
  0x04, 0x00, 0x1F, 0x83, 0xFE, 0x30, 0x63, 0x07, 0x30, 0x33, 0x07, 0x30,
  0x77, 0x06, 0x60, 0xE7, 0xFC, 0x7F, 0x06, 0x30, 0x61, 0x8E, 0x18, 0xC1,
  0x8C, 0x1C, 0xC0, 0xCC, 0x0C, 0x07, 0x81, 0xFC, 0x38, 0x63, 0x06, 0x30,
  0x77, 0x00, 0x30, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0x0C, 0x00,
  0xCC, 0x0C, 0xC1, 0xCE, 0x18, 0x7F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x19, 0x80, 0xCC, 0x0E, 0x60, 0x63, 0x03, 0x38, 0x19, 0x80, 0xCC, 0x0E,
  0x60, 0x73, 0x03, 0x18, 0x19, 0xC0, 0xCC, 0x06, 0x60, 0x73, 0x83, 0x0C,
  0x38, 0x7F, 0x81, 0xF0, 0x00, 0xE0, 0x3F, 0x01, 0x98, 0x1C, 0xC0, 0xC6,
  0x0E, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x61, 0x81, 0x9C, 0x0C, 0xC0, 0x6E,
  0x03, 0x60, 0x1B, 0x00, 0xF0, 0x07, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0xC1, 0x98, 0x30, 0x66, 0x1C, 0x39, 0x87, 0x0C, 0x63, 0xC3, 0x18, 0xD1,
  0xC6, 0x34, 0x61, 0x99, 0x18, 0x66, 0x4E, 0x19, 0x13, 0x06, 0xC6, 0xC1,
  0xB1, 0xB0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70,
  0x70, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x70, 0x61, 0xC3, 0x83, 0x1C, 0x0C,
  0x60, 0x1B, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x03,
  0x60, 0x1D, 0x80, 0x63, 0x03, 0x8C, 0x1C, 0x38, 0x60, 0xE3, 0x81, 0x80,
  0xE0, 0x76, 0x06, 0x60, 0xE6, 0x0C, 0x71, 0xC3, 0x18, 0x33, 0x03, 0x70,
  0x36, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0x1E, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xF0, 0xF0, 0x43, 0x18, 0xC6,
  0x31, 0x8C, 0x31, 0x8C, 0x63, 0x18, 0xC2, 0x18, 0xC6, 0x30, 0x1E, 0x3C,
  0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C,
  0x18, 0x70, 0xC1, 0x83, 0x06, 0x3C, 0x78, 0x0C, 0x18, 0x70, 0xF3, 0x66,
  0xD9, 0xB3, 0xC6, 0xFF, 0xFF, 0xC0, 0xCE, 0x63, 0x1F, 0x1F, 0xDC, 0x6C,
  0x30, 0x18, 0xFD, 0xFF, 0xC3, 0xC3, 0x61, 0xB1, 0xDF, 0xE7, 0xB0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0xE1, 0xFE, 0x38, 0xE6,
  0x0C, 0xC1, 0x98, 0x37, 0x06, 0xC1, 0xD8, 0x33, 0x06, 0x71, 0xCF, 0xF3,
  0x3C, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0xE0, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x6C, 0x31, 0xFC, 0x3C, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x87, 0xB1, 0xFE, 0x71, 0xCC, 0x1B, 0x87, 0x60, 0xCC,
  0x19, 0x83, 0x30, 0x66, 0x0C, 0xE3, 0x8F, 0xE0, 0xEC, 0x00, 0x1F, 0x0F,
  0xE7, 0x19, 0x86, 0xE1, 0xBF, 0xEF, 0xFB, 0x00, 0xC0, 0x30, 0x0E, 0x31,
  0xFC, 0x3E, 0x00, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x38, 0x7E, 0x7E, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x0F, 0x63,
  0xFC, 0xE3, 0x98, 0x37, 0x06, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19,
  0xC7, 0x1F, 0xC3, 0xD8, 0x03, 0x00, 0x62, 0x18, 0xFF, 0x07, 0x80, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xF8, 0xFF, 0x38, 0xCC, 0x33,
  0x0C, 0xC3, 0x70, 0xD8, 0x36, 0x0D, 0x87, 0x61, 0x98, 0x6C, 0x18, 0x08,
  0x71, 0x80, 0x00, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x61,
  0x80, 0x02, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x1E, 0x38, 0x00, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x39, 0x8E, 0x33, 0x86, 0xE0,
  0xD8, 0x1E, 0x07, 0xE0, 0xEC, 0x19, 0x83, 0x18, 0x63, 0x0C, 0x73, 0x86,
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x31, 0xC6,
  0x18, 0x61, 0x86, 0x00, 0x3F, 0x8F, 0x1F, 0xEF, 0x8E, 0x3C, 0xE6, 0x1C,
  0x33, 0x0C, 0x19, 0x86, 0x0D, 0xC3, 0x0E, 0xC1, 0x86, 0x60, 0xC3, 0x30,
  0xE1, 0x98, 0x60, 0xCC, 0x30, 0x6E, 0x18, 0x70, 0x3F, 0x8F, 0xF3, 0x8C,
  0xC3, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x60, 0xD8, 0x76, 0x19, 0x86, 0xE1,
  0x80, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x6E, 0x39, 0xFC, 0x3C, 0x00, 0x1B, 0xC1, 0xFE, 0x1C, 0x71, 0x83,
  0x18, 0x31, 0x83, 0x38, 0x33, 0x07, 0x30, 0x63, 0x06, 0x38, 0xE3, 0xFC,
  0x77, 0x86, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x1E, 0xCF, 0xF7,
  0x1D, 0x83, 0xE1, 0xF0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6E, 0x39, 0xFC,
  0x7B, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x3F, 0x3F, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x1E, 0x1F, 0x9C,
  0x6C, 0x36, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x61, 0xB0, 0xDF, 0xC3, 0xC0,
  0x18, 0x63, 0x3F, 0xFC, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x87, 0x1C,
  0x70, 0xD8, 0x36, 0x0D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x06, 0xC1, 0xB0,
  0xEC, 0x71, 0xFC, 0x7B, 0x00, 0x61, 0xD8, 0x66, 0x39, 0x8C, 0x63, 0x19,
  0x86, 0x60, 0xB0, 0x2C, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0xC3, 0x0F,
  0x1C, 0x7C, 0x71, 0xB3, 0xC6, 0xCF, 0x33, 0x2C, 0xCD, 0xB3, 0x36, 0x58,
  0xF1, 0x63, 0xC7, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x80, 0x18, 0x71, 0x8E,
  0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0x70, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0xB0,
  0x39, 0x87, 0x18, 0x61, 0xC0, 0x18, 0x61, 0x86, 0x18, 0xE1, 0x8C, 0x19,
  0xC1, 0x98, 0x19, 0x81, 0xB0, 0x1B, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xCF, 0xF0, 0x1C,
  0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0xFE, 0xFF,
  0x80, 0x02, 0x06, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30,
  0xE0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30,
  0x10, 0x08, 0x61, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x86, 0x10, 0xC0, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x70, 0xE0, 0x80, 0x3C, 0x37, 0xE3, 0x66, 0x2C, 0x3E, 0xC1,
  0xC0,
};

const GFXglyph RobotoCondensed_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 6, 1, -18 },
  { 13, 6, 6, 8, 2, -19 },
  { 18, 13, 18, 13, 1, -18 },
  { 48, 10, 23, 12, 1, -21 },
  { 77, 12, 18, 15, 2, -18 },
  { 104, 11, 18, 13, 1, -18 },
  { 129, 3, 6, 4, 2, -19 },
  { 132, 8, 26, 8, 1, -20 },
  { 158, 7, 26, 8, -1, -20 },
  { 181, 10, 10, 10, 1, -18 },
  { 194, 10, 13, 12, 1, -14 },
  { 211, 4, 6, 5, -1, -3 },
  { 214, 6, 2, 6, 0, -9 },
  { 216, 2, 3, 6, 1, -3 },
  { 217, 11, 20, 9, -1, -18 },
  { 245, 10, 18, 12, 1, -18 },
  { 268, 6, 18, 12, 3, -18 },
  { 282, 11, 18, 12, 0, -18 },
  { 307, 10, 18, 12, 1, -18 },
  { 330, 11, 18, 12, 0, -18 },
  { 355, 11, 18, 12, 1, -18 },
  { 380, 10, 18, 12, 1, -18 },
  { 403, 11, 18, 12, 2, -18 },
  { 428, 10, 18, 12, 1, -18 },
  { 451, 9, 18, 12, 2, -18 },
  { 472, 4, 14, 6, 1, -14 },
  { 479, 6, 17, 5, -1, -14 },
  { 492, 9, 11, 11, 1, -13 },
  { 505, 10, 7, 12, 1, -12 },
  { 514, 9, 11, 11, 1, -13 },
  { 527, 8, 18, 10, 2, -18 },
  { 545, 17, 23, 19, 1, -17 },
  { 594, 13, 18, 14, -1, -18 },
  { 624, 12, 18, 13, 1, -18 },
  { 651, 13, 18, 14, 1, -18 },
  { 681, 12, 18, 14, 1, -18 },
  { 708, 12, 18, 12, 1, -18 },
  { 735, 12, 18, 12, 1, -18 },
  { 762, 13, 18, 14, 1, -18 },
  { 792, 14, 18, 15, 1, -18 },
  { 824, 5, 18, 6, 1, -18 },
  { 836, 12, 18, 12, 0, -18 },
  { 863, 14, 18, 13, 1, -18 },
  { 895, 9, 18, 12, 1, -18 },
  { 916, 17, 18, 18, 1, -18 },
  { 955, 14, 18, 15, 1, -18 },
  { 987, 13, 18, 15, 1, -18 },
  { 1017, 13, 18, 13, 1, -18 },
  { 1047, 13, 21, 15, 1, -18 },
  { 1082, 12, 18, 13, 1, -18 },
  { 1109, 12, 18, 13, 1, -18 },
  { 1136, 12, 18, 13, 2, -18 },
  { 1163, 13, 18, 14, 1, -18 },
  { 1193, 13, 18, 14, 2, -18 },
  { 1223, 18, 18, 18, 2, -18 },
  { 1264, 14, 18, 13, 0, -18 },
  { 1296, 12, 18, 13, 2, -18 },
  { 1323, 13, 18, 13, 0, -18 },
  { 1353, 8, 24, 6, 0, -20 },
  { 1377, 5, 20, 9, 2, -18 },
  { 1390, 7, 24, 6, -1, -20 },
  { 1411, 7, 9, 9, 1, -18 },
  { 1419, 9, 2, 10, -1, 0 },
  { 1422, 4, 4, 8, 3, -19 },
  { 1424, 9, 13, 12, 1, -13 },
  { 1439, 11, 19, 12, 0, -19 },
  { 1466, 10, 13, 11, 1, -13 },
  { 1483, 11, 19, 12, 1, -19 },
  { 1510, 10, 13, 11, 1, -13 },
  { 1527, 8, 19, 8, 1, -19 },
  { 1546, 11, 18, 12, 0, -13 },
  { 1571, 10, 19, 12, 0, -19 },
  { 1595, 6, 18, 6, 0, -18 },
  { 1609, 7, 23, 5, -2, -18 },
  { 1630, 11, 19, 11, 0, -19 },
  { 1657, 6, 19, 6, 0, -19 },
  { 1672, 17, 13, 18, 0, -13 },
  { 1700, 10, 13, 12, 0, -13 },
  { 1717, 10, 13, 12, 1, -13 },
  { 1734, 12, 18, 12, -1, -13 },
  { 1761, 10, 18, 12, 1, -13 },
  { 1784, 8, 13, 7, 0, -13 },
  { 1797, 9, 13, 11, 1, -13 },
  { 1812, 6, 16, 7, 1, -16 },
  { 1824, 10, 13, 12, 1, -13 },
  { 1841, 10, 13, 10, 1, -13 },
  { 1858, 14, 13, 16, 2, -13 },
  { 1881, 12, 13, 11, -1, -13 },
  { 1901, 12, 18, 10, -1, -13 },
  { 1928, 10, 13, 11, 0, -13 },
  { 1945, 8, 24, 7, 1, -20 },
  { 1969, 6, 21, 6, 0, -18 },
  { 1985, 8, 24, 7, -1, -19 },
  { 2009, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Italic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_ITALIC25PT7B_H_
