#ifndef _ROBOTOCONDENSED_ITALIC27PT7B_H_
#define _ROBOTOCONDENSED_ITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x33, 0x98, 0xC6, 0x00, 0x00, 0xC6,
  0x30, 0x4F, 0x3C, 0xF2, 0xDA, 0x69, 0x80, 0x01, 0x88, 0x06, 0x60, 0x31,
  0x80, 0xCC, 0x03, 0x30, 0xFF, 0xF3, 0xFF, 0x81, 0x98, 0x0C, 0x60, 0x33,
  0x00, 0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x18, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x60, 0x00, 0x01, 0x80, 0x30, 0x06, 0x03, 0xC0, 0xFC,
  0x39, 0xCE, 0x19, 0x83, 0x30, 0x66, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x06, 0xC0, 0xD8, 0x1B, 0x87, 0x31, 0xC7, 0xF0, 0x7C, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0xF0, 0x19, 0x80, 0x8C, 0x64, 0x66, 0x23, 0x31,
  0x1B, 0x0F, 0xB0, 0x3B, 0x00, 0x18, 0x01, 0xB8, 0x1B, 0xE0, 0xD1, 0x8D,
  0x8C, 0xCC, 0x6C, 0x63, 0x63, 0x10, 0x0F, 0x80, 0x78, 0x07, 0x80, 0xFC,
  0x1C, 0xC1, 0x8E, 0x18, 0xE1, 0x8C, 0x19, 0xC1, 0xF0, 0x0E, 0x01, 0xE0,
  0x3E, 0x36, 0x73, 0xE3, 0x7C, 0x3E, 0xC1, 0xEC, 0x1C, 0xE1, 0xC7, 0xFE,
  0x3E, 0x60, 0x6D, 0xBD, 0x80, 0x01, 0x03, 0x07, 0x0E, 0x0C, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x18, 0x10, 0x08, 0x0C, 0x0C,
  0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xC0,
  0x80, 0x03, 0x00, 0xC0, 0x18, 0x33, 0x37, 0xFE, 0x7F, 0x83, 0x80, 0xF0,
  0x33, 0x0E, 0x70, 0x84, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xFF, 0xFF, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x00, 0x33, 0x76, 0x6C, 0x80, 0x7D, 0xF0, 0xDF, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x83, 0xF8, 0x63, 0x98, 0x33, 0x06,
  0xE0, 0xDC, 0x1B, 0x03, 0x60, 0x6C, 0x1D, 0x83, 0xF0, 0x6E, 0x0D, 0xC1,
  0xB8, 0x73, 0x0C, 0x63, 0x8F, 0xE0, 0xF8, 0x00, 0x02, 0x3D, 0xFF, 0x78,
  0xC1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60,
  0xC0, 0x03, 0xC0, 0xFE, 0x1C, 0x71, 0x83, 0x38, 0x33, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x37,
  0x06, 0x00, 0xC0, 0x38, 0x0E, 0x0F, 0x81, 0xE0, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xB0, 0x76, 0x0C, 0xE3, 0x8F, 0xE0, 0xF8, 0x00, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x36, 0x06, 0x60, 0xEE, 0x0C, 0xE1, 0x8C,
  0x38, 0xC3, 0x0C, 0x60, 0xCF, 0xFF, 0xFF, 0xF0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0F, 0xF0, 0xFF, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x37,
  0x83, 0xFC, 0x39, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0xE0,
  0xC6, 0x1C, 0x63, 0x87, 0xF0, 0x1E, 0x00, 0x01, 0xC1, 0xF0, 0xE0, 0x70,
  0x18, 0x0C, 0x03, 0x71, 0xFE, 0x79, 0xDC, 0x36, 0x0D, 0x83, 0xE0, 0xF8,
  0x36, 0x0D, 0x87, 0x73, 0x8F, 0xC1, 0xE0, 0x7F, 0xE7, 0xFE, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x00,
  0x07, 0x83, 0xF8, 0x73, 0x9C, 0x33, 0x06, 0x60, 0xCC, 0x39, 0xC6, 0x1F,
  0x87, 0xE1, 0xC6, 0x30, 0xEE, 0x0D, 0x81, 0xB0, 0x76, 0x0C, 0xE3, 0x8F,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0x60, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF8, 0x76, 0x39, 0xFE, 0x3D, 0x80, 0xC0, 0x30, 0x18, 0x1E,
  0x1F, 0x0F, 0x00, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x73,
  0x00, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC7,
  0x1C, 0x63, 0x0C, 0x00, 0x00, 0x40, 0x70, 0x78, 0x7C, 0x7C, 0x3C, 0x0E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x04, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x20, 0x0E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x70, 0x7C, 0x78, 0xF8, 0x38, 0x08, 0x00, 0x1E, 0x1F, 0x9C, 0xEC,
  0x3E, 0x18, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x18, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70,
  0x30, 0x30, 0x06, 0x1C, 0x00, 0x86, 0x00, 0x33, 0x0F, 0x0C, 0xC7, 0xF3,
  0x61, 0x98, 0xD8, 0xC6, 0x34, 0x21, 0x8F, 0x18, 0x63, 0xC6, 0x30, 0xF1,
  0x8C, 0x2C, 0x63, 0x0B, 0x18, 0xC6, 0xC6, 0x73, 0x31, 0xFF, 0x8C, 0x39,
  0xC3, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0,
  0x06, 0xC0, 0x3B, 0x00, 0xCE, 0x07, 0x18, 0x18, 0x60, 0xE1, 0x83, 0x06,
  0x1F, 0xF8, 0x7F, 0xE3, 0x81, 0xCC, 0x07, 0x70, 0x0D, 0x80, 0x3E, 0x00,
  0xC0, 0x1F, 0xC0, 0xFF, 0x86, 0x1C, 0x70, 0x63, 0x83, 0x98, 0x18, 0xC0,
  0xC6, 0x1C, 0x7F, 0xC3, 0xFE, 0x1C, 0x38, 0xC0, 0xC6, 0x06, 0x30, 0x33,
  0x81, 0x9C, 0x1C, 0xC1, 0xC7, 0xFE, 0x3F, 0xC0, 0x03, 0xE0, 0x3F, 0xC1,
  0xE3, 0x86, 0x06, 0x38, 0x1C, 0xC0, 0x77, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0xC6, 0x07, 0x18, 0x18,
  0x70, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x06, 0x1C, 0x70,
  0x63, 0x83, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x70, 0x3B, 0x81, 0xD8, 0x0C,
  0xC0, 0x66, 0x03, 0x30, 0x3B, 0x81, 0x9C, 0x1C, 0xC1, 0xC7, 0xFC, 0x3F,
  0x80, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x7F, 0xC3, 0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0x86,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xFE,
  0x1F, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x38, 0x1C,
  0xC0, 0x77, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x1F, 0x98, 0x7E,
  0xE0, 0x39, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x70, 0xF0, 0xFF, 0x81, 0xF8,
  0x00, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xC6, 0x01,
  0x8C, 0x03, 0x18, 0x0E, 0x7F, 0xFC, 0xFF, 0xF9, 0x80, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC0, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x33, 0x9C, 0xC6, 0x31, 0x9C, 0xE6,
  0x30, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x70, 0x63,
  0x83, 0x1C, 0x38, 0x73, 0x83, 0xFC, 0x0F, 0x80, 0x18, 0x1C, 0x30, 0x70,
  0x60, 0xE1, 0xC3, 0x83, 0x8E, 0x06, 0x38, 0x0C, 0xE0, 0x1B, 0x80, 0x7E,
  0x00, 0xFE, 0x01, 0xEC, 0x03, 0x98, 0x06, 0x38, 0x0C, 0x30, 0x38, 0x70,
  0x70, 0x60, 0xC0, 0xE1, 0x81, 0xC3, 0x01, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x3F, 0xFF, 0xF8, 0x1C, 0x01, 0xE3, 0x80,
  0x38, 0x70, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0x7C, 0x6C, 0x0D, 0x8D, 0x83,
  0xF1, 0xB0, 0x6C, 0x76, 0x1D, 0x8E, 0xC3, 0x31, 0x98, 0x66, 0x31, 0x99,
  0xC6, 0x33, 0x38, 0xC6, 0xC6, 0x38, 0xD8, 0xC7, 0x1E, 0x18, 0xC3, 0xC7,
  0x18, 0x70, 0xE3, 0x06, 0x1C, 0x00, 0x18, 0x06, 0x38, 0x0C, 0x70, 0x39,
  0xE0, 0x73, 0xE0, 0xC6, 0xC1, 0x8D, 0x83, 0x19, 0x8E, 0x73, 0x1C, 0xE6,
  0x39, 0xC6, 0x63, 0x0C, 0xC6, 0x19, 0x8C, 0x1F, 0x38, 0x3E, 0x70, 0x78,
  0xC0, 0x71, 0x80, 0xE3, 0x01, 0xC0, 0x03, 0xE0, 0x3F, 0xC1, 0xE3, 0x86,
  0x06, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x1D, 0x80, 0x66,
  0x01, 0x98, 0x06, 0x60, 0x39, 0x80, 0xE6, 0x03, 0x18, 0x1C, 0x70, 0xE0,
  0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0x83, 0x8E, 0x06, 0x38,
  0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x70, 0x39, 0xC1, 0xC7, 0xFE, 0x1F,
  0xF0, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xE3, 0x86, 0x06, 0x30, 0x1C, 0xC0,
  0x77, 0x01, 0xD8, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB8, 0x06, 0xE0,
  0x3B, 0x80, 0xC6, 0x03, 0x18, 0x1C, 0x70, 0xE0, 0xFF, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x70, 0x01, 0x00, 0x1F, 0xC0, 0xFF, 0x86, 0x1C, 0x70, 0x73,
  0x83, 0x98, 0x1C, 0xC0, 0xE6, 0x06, 0x70, 0xF3, 0xFF, 0x1F, 0xE0, 0xC3,
  0x06, 0x18, 0x30, 0xE3, 0x83, 0x1C, 0x18, 0xC0, 0xE6, 0x07, 0x30, 0x18,
  0x07, 0xC0, 0xFF, 0x07, 0x1C, 0x70, 0x63, 0x03, 0x18, 0x1C, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x60, 0x33, 0x03,
  0x9C, 0x1C, 0xE1, 0xC3, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x38, 0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC0,
  0x67, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0xE0,
  0x33, 0x81, 0xCE, 0x06, 0x38, 0x18, 0x71, 0xE1, 0xFF, 0x01, 0xF0, 0x00,
  0xE0, 0x1D, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x71, 0xC1, 0x87, 0x0E,
  0x1C, 0x38, 0x30, 0xC0, 0xC7, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0x00, 0xDC,
  0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0xC1,
  0xF0, 0x70, 0x7C, 0x1C, 0x1B, 0x07, 0x0E, 0xC3, 0xC3, 0x30, 0xF0, 0xCC,
  0x6C, 0x73, 0x1B, 0x18, 0xC6, 0x46, 0x33, 0x13, 0x8C, 0xC4, 0xC3, 0x61,
  0xB0, 0xD8, 0x7C, 0x36, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x38, 0x38, 0x30, 0x70, 0x71,
  0xC0, 0xE3, 0x00, 0xCE, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0xEC, 0x03, 0x98, 0x06, 0x38, 0x1C, 0x30, 0x70,
  0x60, 0xC0, 0xE3, 0x81, 0xC0, 0x60, 0x3B, 0x01, 0x9C, 0x1C, 0xE0, 0xC3,
  0x0E, 0x18, 0xE0, 0xC6, 0x07, 0x70, 0x1B, 0x00, 0xF0, 0x07, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0x0F,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xF0, 0xF0,
  0xC6, 0x31, 0x8C, 0x61, 0x8C, 0x63, 0x18, 0xC6, 0x18, 0xC6, 0x31, 0x8C,
  0x61, 0x80, 0x1F, 0x1F, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38,
  0x30, 0x30, 0xF0, 0xF0, 0x06, 0x0E, 0x0E, 0x1E, 0x1E, 0x32, 0x33, 0x63,
  0x63, 0xE3, 0xFF, 0xFF, 0xF0, 0xE6, 0x73, 0x0F, 0x0F, 0xE3, 0x1D, 0xC3,
  0x00, 0xC0, 0x31, 0xFD, 0xFF, 0x61, 0xB0, 0x6C, 0x1B, 0x0E, 0xE7, 0xBF,
  0xE7, 0xB8, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x1B,
  0xC1, 0xFE, 0x3C, 0x63, 0x87, 0x30, 0x73, 0x07, 0x30, 0x73, 0x07, 0x70,
  0x67, 0x06, 0x60, 0x67, 0x0E, 0x71, 0xC7, 0xFC, 0xEF, 0x00, 0x0F, 0x07,
  0xF8, 0xC3, 0x30, 0x66, 0x0D, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x06, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x1E, 0x63, 0xF6, 0x71, 0xE6, 0x0E, 0x60, 0xEE,
  0x0C, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0xCC, 0x18, 0xE3, 0x87,
  0xF8, 0x3D, 0x80, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE1, 0x9F, 0xE3, 0xE0, 0x07, 0x87,
  0xC3, 0x03, 0x81, 0x80, 0xC1, 0xF8, 0xFC, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x0F, 0x31,
  0xFB, 0x38, 0xF3, 0x07, 0x30, 0x77, 0x06, 0x70, 0x66, 0x06, 0x60, 0x66,
  0x0E, 0x60, 0xE6, 0x0C, 0x71, 0xC3, 0xFC, 0x1E, 0xC0, 0x1C, 0x01, 0x8C,
  0x38, 0xFF, 0x03, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0xF0, 0xFF, 0x3C, 0xE7, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xDC,
  0x3B, 0x87, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x6E, 0x1C, 0x0C, 0x30, 0xC0,
  0x00, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18,
  0x01, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0xF0, 0xF0, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x71, 0x8E, 0x39, 0xC3, 0xB8, 0x33, 0x03, 0x60, 0x3E,
  0x03, 0xE0, 0x7F, 0x07, 0x30, 0x63, 0x06, 0x38, 0x61, 0x86, 0x1C, 0xE1,
  0xC0, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3,
  0x1C, 0x71, 0x86, 0x18, 0x60, 0x1B, 0xC7, 0x87, 0xFF, 0xF3, 0x8F, 0x9C,
  0xE1, 0xC3, 0x30, 0x60, 0xCC, 0x18, 0x33, 0x06, 0x0C, 0xC1, 0x83, 0x70,
  0xE1, 0xDC, 0x38, 0x76, 0x0C, 0x19, 0x83, 0x06, 0x60, 0xC1, 0x98, 0x30,
  0x6E, 0x1C, 0x38, 0x1B, 0xC3, 0xFC, 0xF3, 0x9C, 0x33, 0x06, 0x60, 0xCC,
  0x19, 0x83, 0x70, 0xEE, 0x1D, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0xB8, 0x70,
  0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x76, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1B, 0x03, 0x70, 0xE6, 0x38, 0xFE, 0x0F, 0x80, 0x0D, 0xE0, 0x7F,
  0x87, 0x8C, 0x38, 0x71, 0x83, 0x8C, 0x1C, 0x60, 0xE3, 0x07, 0x38, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0xE3, 0x8E, 0x3F, 0xE1, 0xDE, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x1F, 0x67, 0xED, 0xC3, 0xB0, 0x76,
  0x0F, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x3B, 0x07, 0x60, 0xCE, 0x38,
  0xFF, 0x0F, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x1B, 0x1F,
  0x3C, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0x0F, 0x0F, 0xE3, 0x1D, 0xC3, 0x60, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xEC, 0x1B, 0x06, 0xE3, 0x9F, 0xC3, 0xC0, 0x18, 0x30, 0x67, 0xFF,
  0xE6, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x78, 0x70,
  0x30, 0x66, 0x0D, 0xC3, 0xB0, 0x76, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0xE1,
  0xDC, 0x3B, 0x06, 0x60, 0xCE, 0x38, 0xFF, 0x0F, 0xE0, 0xC1, 0xB0, 0x6C,
  0x3B, 0x0C, 0xC7, 0x31, 0x8C, 0x61, 0xB0, 0x6C, 0x1B, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x06, 0x00, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x8E, 0xC7, 0x8C,
  0xC7, 0x8C, 0xCD, 0x98, 0xCD, 0x98, 0xCD, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0,
  0xF1, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x60, 0xC0, 0x60, 0xC0, 0x18, 0x30,
  0xE3, 0x83, 0x18, 0x19, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x7C, 0x07, 0x60, 0x33, 0x03, 0x9C, 0x38, 0x61, 0x83, 0x00, 0x18,
  0x30, 0xC3, 0x86, 0x18, 0x30, 0xC1, 0x8E, 0x0C, 0x60, 0x67, 0x03, 0xB0,
  0x0D, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x03,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0x07, 0x06, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0x60, 0x30, 0x38, 0x10, 0x0C, 0x30, 0xC6, 0x18, 0x61,
  0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x84,
  0x00, 0x08, 0x1C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E,
  0x06, 0x07, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30,
  0x70, 0xE0, 0x80, 0x1C, 0x19, 0xF0, 0xD9, 0xCC, 0xC7, 0xEC, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 8, 3, -20 },
  { 19, 14, 19, 14, 1, -19 },
  { 53, 11, 24, 13, 1, -22 },
  { 86, 13, 19, 17, 2, -19 },
  { 117, 12, 19, 14, 1, -19 },
  { 146, 3, 6, 5, 2, -20 },
  { 149, 8, 28, 8, 1, -22 },
  { 177, 8, 28, 8, -1, -22 },
  { 205, 11, 11, 11, 1, -19 },
  { 221, 11, 14, 13, 1, -16 },
  { 241, 4, 7, 5, -1, -3 },
  { 245, 6, 2, 7, 0, -9 },
  { 247, 3, 3, 7, 1, -3 },
  { 249, 12, 21, 10, -1, -19 },
  { 281, 11, 19, 13, 1, -19 },
  { 308, 7, 19, 13, 3, -19 },
  { 325, 12, 19, 13, 0, -19 },
  { 354, 11, 19, 13, 1, -19 },
  { 381, 12, 19, 13, 0, -19 },
  { 410, 12, 19, 13, 1, -19 },
  { 439, 10, 19, 13, 1, -19 },
  { 463, 12, 19, 13, 2, -19 },
  { 492, 11, 19, 13, 1, -19 },
  { 519, 10, 19, 13, 2, -19 },
  { 543, 5, 15, 6, 1, -15 },
  { 553, 6, 19, 5, -1, -15 },
  { 568, 10, 12, 12, 1, -15 },
  { 583, 11, 8, 13, 1, -13 },
  { 594, 10, 11, 12, 1, -14 },
  { 608, 9, 19, 11, 2, -19 },
  { 630, 18, 25, 20, 1, -19 },
  { 687, 14, 19, 15, -1, -19 },
  { 721, 13, 19, 14, 1, -19 },
  { 752, 14, 19, 15, 1, -19 },
  { 786, 13, 19, 15, 1, -19 },
  { 817, 13, 19, 13, 1, -19 },
  { 848, 13, 19, 13, 1, -19 },
  { 879, 14, 19, 15, 1, -19 },
  { 913, 15, 19, 16, 1, -19 },
  { 949, 5, 19, 7, 1, -19 },
  { 961, 13, 19, 13, 0, -19 },
  { 992, 15, 19, 14, 1, -19 },
  { 1028, 10, 19, 12, 1, -19 },
  { 1052, 19, 19, 20, 1, -19 },
  { 1098, 15, 19, 16, 1, -19 },
  { 1134, 14, 19, 16, 1, -19 },
  { 1168, 14, 19, 15, 1, -19 },
  { 1202, 14, 22, 16, 1, -19 },
  { 1241, 13, 19, 14, 1, -19 },
  { 1272, 13, 19, 14, 1, -19 },
  { 1303, 13, 19, 14, 2, -19 },
  { 1334, 14, 19, 15, 1, -19 },
  { 1368, 14, 19, 15, 2, -19 },
  { 1402, 18, 19, 20, 3, -19 },
  { 1445, 15, 19, 14, 0, -19 },
  { 1481, 13, 19, 14, 2, -19 },
  { 1512, 14, 19, 14, 0, -19 },
  { 1546, 8, 26, 7, 0, -22 },
  { 1572, 5, 21, 10, 3, -19 },
  { 1586, 8, 26, 7, -1, -22 },
  { 1612, 8, 10, 10, 1, -19 },
  { 1622, 10, 2, 11, -1, 0 },
  { 1625, 4, 4, 8, 3, -20 },
  { 1627, 10, 15, 13, 1, -15 },
  { 1646, 12, 21, 13, 0, -21 },
  { 1678, 11, 15, 12, 1, -15 },
  { 1699, 12, 21, 13, 1, -21 },
  { 1731, 10, 15, 12, 1, -15 },
  { 1750, 9, 21, 8, 1, -21 },
  { 1774, 12, 20, 13, 0, -15 },
  { 1804, 11, 21, 13, 0, -21 },
  { 1833, 6, 20, 6, 0, -20 },
  { 1848, 9, 25, 6, -3, -20 },
  { 1877, 12, 21, 12, 0, -21 },
  { 1909, 6, 21, 6, 0, -21 },
  { 1925, 18, 15, 20, 0, -15 },
  { 1959, 11, 15, 13, 0, -15 },
  { 1980, 11, 15, 13, 1, -15 },
  { 2001, 13, 20, 13, -1, -15 },
  { 2034, 11, 20, 13, 1, -15 },
  { 2062, 8, 15, 8, 0, -15 },
  { 2077, 10, 15, 12, 1, -15 },
  { 2096, 7, 18, 8, 1, -18 },
  { 2112, 11, 15, 13, 1, -15 },
  { 2133, 10, 15, 11, 2, -15 },
  { 2152, 16, 15, 17, 2, -15 },
  { 2182, 13, 15, 12, -1, -15 },
  { 2207, 13, 20, 11, -1, -15 },
  { 2240, 11, 15, 12, 0, -15 },
  { 2261, 8, 26, 8, 1, -21 },
  { 2287, 6, 23, 6, 0, -19 },
  { 2305, 8, 26, 8, -1, -21 },
  { 2331, 13, 5, 15, 1, -10 },
};

const GFXfont RobotoCondensed_Italic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_ITALIC27PT7B_H_
