#ifndef _ROBOTOCONDENSED_ITALIC36PT7B_H_
#define _ROBOTOCONDENSED_ITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xE0, 0x60, 0x67, 0x67, 0x67, 0xE6, 0xE6, 0xC6, 0xC6, 0xCC, 0xCC,
  0x00, 0x61, 0x80, 0x18, 0xE0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00,
  0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x31,
  0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xC0,
  0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0x86, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0C,
  0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0x7F, 0x81, 0xFF,
  0x07, 0x8F, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xF0, 0x3C, 0xE0, 0x71,
  0xE1, 0xE1, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1C, 0xE0, 0x0C, 0x30, 0x46, 0x18, 0x77,
  0x0C, 0x33, 0x86, 0x31, 0xC3, 0x38, 0x63, 0xB8, 0x31, 0x98, 0x1F, 0xDC,
  0x07, 0x9C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x78, 0x06, 0x7E, 0x06,
  0x73, 0x07, 0x71, 0xC3, 0x30, 0x63, 0x18, 0x73, 0x8C, 0x3B, 0x86, 0x1D,
  0x83, 0x0C, 0x41, 0xCE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xE3, 0x80, 0xE0, 0xC0, 0x70, 0x60, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xFE, 0x00, 0xF7, 0x0C, 0xF3, 0xC6, 0x70, 0xE7, 0x78, 0x7B, 0xB8,
  0x1F, 0x9C, 0x0F, 0xCE, 0x03, 0xC7, 0x81, 0xE1, 0xC1, 0xF0, 0xFF, 0xFC,
  0x3F, 0xEE, 0x07, 0xC7, 0x80, 0x77, 0x66, 0x6E, 0xEC, 0x00, 0x40, 0x18,
  0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x80,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x04, 0x00, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x43, 0x87,
  0xCC, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0x80, 0x3E, 0x01, 0xD8, 0x0E, 0x70,
  0x70, 0xC1, 0xC3, 0x82, 0x08, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x71, 0xCF, 0x39, 0xE7, 0x38, 0x40, 0xFF,
  0xFF, 0xF8, 0x6F, 0xFE, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0,
  0x73, 0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x81,
  0xE1, 0xF9, 0xFE, 0x7B, 0xB8, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0x01,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x81, 0xCE, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x3F, 0xC0, 0x7E, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x0F, 0x1C, 0x1C, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x77, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0x87, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x1C, 0x3C, 0x3F,
  0xF0, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0xC1, 0xFE, 0x1F, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x9E, 0x1F, 0xFC, 0xFF,
  0xE7, 0x87, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0x78, 0x39, 0xC3, 0xCF, 0xFC, 0x3F, 0xC0, 0xF8, 0x00,
  0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x78, 0xF1,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x38,
  0x70, 0x7F, 0xC0, 0x7F, 0x03, 0xFE, 0x0F, 0x1E, 0x3C, 0x1C, 0x70, 0x38,
  0xE0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x3F,
  0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7,
  0x07, 0x38, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0x78, 0x79, 0xFF, 0xCF, 0xFE, 0x1E, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x3E, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x00,
  0x1C, 0x73, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x63, 0xCF, 0x38, 0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x04, 0x00, 0xE0,
  0x0F, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x3F,
  0xFD, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x10, 0x00, 0x60, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x83, 0xFC,
  0x7F, 0xE7, 0x0E, 0xF0, 0x7E, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x1C, 0x0F, 0x03, 0x18, 0x1F, 0xC3, 0x38, 0x39, 0xC3, 0x30, 0x70, 0xC3,
  0x30, 0xE1, 0xC3, 0x70, 0xC1, 0xC3, 0x61, 0xC1, 0x83, 0x61, 0xC1, 0x83,
  0x61, 0xC3, 0x83, 0xE1, 0x83, 0x87, 0xE3, 0x83, 0x06, 0xE3, 0x87, 0x06,
  0xE3, 0x87, 0x0E, 0xC3, 0x8F, 0x0C, 0xC1, 0xFB, 0x18, 0xE1, 0xFB, 0xF0,
  0xE0, 0xE1, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7,
  0x00, 0x1C, 0x60, 0x07, 0x0C, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E,
  0x70, 0x01, 0xDC, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xC0, 0xF1, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x8E, 0x03, 0x8F, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xE0, 0xE0,
  0x78, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0xF3, 0xC0, 0xF1, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03,
  0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E,
  0x1C, 0x07, 0x87, 0x83, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x3C, 0x1E, 0x03, 0x87,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x78, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x1C,
  0x07, 0x8F, 0x07, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7C, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x3C, 0xE0, 0x0F,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x1F, 0xEE, 0x07, 0xF3, 0x81, 0xFC, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x3C, 0xF0, 0x0E, 0x1C, 0x03, 0x87, 0x83, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x1E, 0x07, 0x8F, 0x03,
  0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F,
  0x01, 0xE1, 0xE0, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x1C, 0x78, 0x01, 0xCF,
  0x00, 0x3D, 0xE0, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3E,
  0xE0, 0x03, 0xCF, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x70, 0x78, 0x07,
  0x03, 0x80, 0x70, 0x3C, 0x07, 0x01, 0xC0, 0xF0, 0x1E, 0x0E, 0x01, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1D, 0x80, 0x77, 0x0E, 0xE0, 0x3B, 0x8E, 0x70, 0x39, 0xC7, 0x38,
  0x1D, 0xC3, 0x9C, 0x1C, 0xE1, 0xCE, 0x0E, 0x70, 0xE7, 0x0E, 0x38, 0x71,
  0x87, 0x1C, 0x78, 0xC7, 0x1E, 0x38, 0x73, 0x8E, 0x1C, 0x3B, 0x87, 0x0E,
  0x1D, 0xC3, 0x87, 0x0F, 0xC1, 0xC3, 0x83, 0xE1, 0xE3, 0xC1, 0xE0, 0xE1,
  0xC0, 0xF0, 0x70, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x00, 0x0F, 0x00,
  0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE1, 0xF8, 0x07, 0x0F,
  0xC0, 0x78, 0x76, 0x03, 0x83, 0xB8, 0x1C, 0x1D, 0xC0, 0xE0, 0xE6, 0x07,
  0x0F, 0x38, 0x38, 0x71, 0xC3, 0xC3, 0x86, 0x1C, 0x1C, 0x38, 0xE0, 0xE1,
  0xC7, 0x07, 0x06, 0x38, 0x78, 0x39, 0xC3, 0x81, 0xDE, 0x1C, 0x06, 0xE0,
  0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x38, 0x07, 0xC3, 0xC0, 0x3E, 0x1C, 0x01,
  0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x3C, 0xE0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x03,
  0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x1C, 0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x83, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0x3C, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0F, 0x70,
  0x03, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x0E, 0x1C, 0x07, 0x87, 0x83, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x1E, 0x0E, 0x03,
  0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3,
  0xC0, 0x70, 0xF0, 0x3C, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xE1,
  0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x70, 0x1C,
  0x1C, 0x07, 0x0F, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x03, 0x80,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xE1, 0xE0, 0x78, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x80, 0xE1, 0xE0,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0,
  0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x03,
  0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF,
  0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x1C, 0x38, 0x07, 0x0F, 0x07, 0x81, 0xFF, 0xE0, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x39, 0xC0, 0x1E,
  0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1E,
  0x07, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x06, 0x70, 0x01, 0xDC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0E, 0xE0,
  0x78, 0x0E, 0xE0, 0x78, 0x1E, 0xE0, 0xF8, 0x1C, 0xE0, 0xFC, 0x1C, 0xE0,
  0xDC, 0x3C, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x38, 0xE1, 0x9C, 0x70, 0xE3,
  0x9C, 0x70, 0xE3, 0x9C, 0x70, 0xE7, 0x0C, 0xE0, 0xE7, 0x0C, 0xE0, 0xE6,
  0x0C, 0xE0, 0xEE, 0x0D, 0xC0, 0xEE, 0x0D, 0xC0, 0xEC, 0x0D, 0xC0, 0xFC,
  0x0D, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x3C,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xE1, 0xE0,
  0x07, 0x0E, 0x00, 0x3C, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x01, 0xE3, 0x80, 0x0E, 0x1C,
  0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xF0, 0x78,
  0x07, 0x83, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0xB8, 0x03, 0xDC, 0x03, 0xCE,
  0x01, 0xC7, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x70,
  0x0E, 0x78, 0x07, 0x38, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x71,
  0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0x61, 0x87, 0x1C, 0x71, 0xC7, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0x80,
  0x70, 0x0E, 0x03, 0xE0, 0x7C, 0x1D, 0x83, 0x30, 0xE6, 0x1C, 0xC7, 0x1C,
  0xE3, 0xB8, 0x77, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xC7,
  0x8E, 0x1C, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x1C, 0xE0,
  0x70, 0x01, 0xC0, 0x0E, 0x07, 0xF8, 0x7F, 0xE7, 0xE3, 0x9C, 0x0E, 0xF0,
  0x3B, 0x81, 0xCE, 0x07, 0x3C, 0x3C, 0xFF, 0xF1, 0xFD, 0xC3, 0xE7, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x0E,
  0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x78, 0x3C,
  0x7F, 0xF8, 0x77, 0xF0, 0x63, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xEF, 0x03, 0x9C, 0x1C, 0x7F, 0xF0,
  0xFF, 0x80, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x07, 0xCE, 0x07,
  0xF7, 0x07, 0xFF, 0x87, 0x87, 0xC3, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0xC0, 0xE0, 0xE0, 0xF0, 0x7F, 0xF8, 0x1F, 0xD8, 0x07,
  0xDC, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xC0,
  0x77, 0x01, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x1C, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x7E, 0x07, 0xE0, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x7F, 0x8F, 0xF8, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0xE3, 0x07, 0xF7, 0x0F, 0xFF, 0x1E,
  0x0F, 0x1C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x78, 0x1C, 0x38,
  0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xB8, 0x00, 0x38, 0x00, 0x38, 0x40,
  0x70, 0x60, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE0,
  0x04, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87,
  0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x00,
  0xC0, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x1C, 0xF0, 0x1C,
  0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x39,
  0xC0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x38, 0x70, 0x38, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70,
  0xE1, 0xC3, 0x80, 0x0E, 0xF8, 0x7C, 0x1D, 0xFC, 0xFE, 0x1F, 0xFD, 0xFF,
  0x1E, 0x1F, 0x87, 0x1C, 0x0F, 0x07, 0x1C, 0x0E, 0x07, 0x1C, 0x0E, 0x07,
  0x38, 0x0E, 0x07, 0x38, 0x0E, 0x07, 0x38, 0x1C, 0x07, 0x38, 0x1C, 0x07,
  0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x70, 0x1C, 0x0E, 0x70, 0x1C, 0x0E,
  0x70, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C,
  0x0E, 0xF8, 0x3B, 0xF8, 0x7F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE0,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3, 0x81, 0xEF, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01,
  0xDC, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00,
  0x06, 0x7C, 0x07, 0x7F, 0x03, 0xFF, 0xC1, 0xE0, 0xE0, 0xE0, 0x78, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x78, 0x3C, 0x3F, 0xFC,
  0x1D, 0xFC, 0x1E, 0x7C, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x07, 0xCE, 0x1F, 0xDC,
  0x7F, 0xF9, 0xE0, 0xF3, 0x81, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x0E,
  0x38, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7D, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0xE3, 0xBC,
  0x7F, 0x8F, 0x81, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x73, 0x81,
  0xCE, 0x07, 0x3C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x1F, 0xE7, 0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x1F, 0x83, 0xC0, 0x70, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3,
  0x81, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC0,
  0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x78, 0x7F, 0xF0,
  0x7F, 0xE0, 0x79, 0xC0, 0xE0, 0x3F, 0x01, 0xD8, 0x1C, 0xC0, 0xE7, 0x0E,
  0x38, 0x71, 0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x9C, 0x0C, 0xE0, 0x66, 0x03,
  0x70, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xD8, 0x3C, 0x1C, 0xC1, 0xE0, 0xE6, 0x0F, 0x06,
  0x38, 0xF8, 0x71, 0xC6, 0xE3, 0x8E, 0x77, 0x38, 0x73, 0xB9, 0xC3, 0xB9,
  0xCC, 0x1D, 0xCE, 0xE0, 0xEC, 0x77, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x0C, 0x07,
  0x00, 0x0E, 0x07, 0x07, 0x07, 0x83, 0x87, 0x80, 0xE3, 0x80, 0x73, 0xC0,
  0x19, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x38,
  0x38, 0x3C, 0x1C, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x87, 0x03, 0xC3, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x3C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xF9, 0xFF, 0xE3,
  0xFF, 0xC0, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x07, 0xC0,
  0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0x80, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x00, 0x02, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x04, 0x00, 0x1E, 0x03, 0x9F, 0x81,
  0xDF, 0xE0, 0xDC, 0x78, 0xEE, 0x1F, 0xE6, 0x07, 0xF0, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 26, 9, 1, -26 },
  { 27, 8, 9, 11, 4, -27 },
  { 36, 18, 26, 19, 2, -26 },
  { 95, 15, 33, 17, 1, -30 },
  { 157, 17, 26, 22, 3, -26 },
  { 213, 17, 26, 19, 1, -26 },
  { 269, 4, 8, 6, 3, -27 },
  { 273, 11, 37, 11, 2, -29 },
  { 324, 11, 37, 11, -2, -29 },
  { 375, 14, 15, 15, 2, -26 },
  { 402, 15, 18, 17, 1, -21 },
  { 436, 6, 9, 7, -2, -4 },
  { 443, 7, 3, 9, 1, -13 },
  { 446, 4, 4, 9, 1, -4 },
  { 448, 16, 28, 13, -2, -26 },
  { 504, 14, 26, 17, 2, -26 },
  { 550, 10, 26, 17, 4, -26 },
  { 583, 16, 26, 17, 0, -26 },
  { 635, 15, 26, 17, 1, -26 },
  { 684, 16, 26, 17, 0, -26 },
  { 736, 15, 26, 17, 2, -26 },
  { 785, 13, 26, 17, 2, -26 },
  { 828, 16, 26, 17, 2, -26 },
  { 880, 15, 26, 17, 1, -26 },
  { 929, 13, 26, 17, 3, -26 },
  { 972, 6, 20, 8, 1, -20 },
  { 987, 9, 25, 7, -2, -20 },
  { 1016, 14, 15, 16, 1, -19 },
  { 1043, 14, 10, 17, 2, -17 },
  { 1061, 14, 16, 16, 1, -19 },
  { 1089, 12, 26, 15, 3, -26 },
  { 1128, 24, 33, 27, 1, -25 },
  { 1227, 19, 26, 20, -1, -26 },
  { 1289, 17, 26, 19, 1, -26 },
  { 1345, 18, 26, 20, 2, -26 },
  { 1404, 18, 26, 20, 1, -26 },
  { 1463, 18, 26, 17, 1, -26 },
  { 1522, 17, 26, 17, 1, -26 },
  { 1578, 18, 26, 21, 2, -26 },
  { 1637, 21, 26, 22, 1, -26 },
  { 1706, 8, 26, 9, 1, -26 },
  { 1732, 17, 26, 17, 0, -26 },
  { 1788, 20, 26, 19, 1, -26 },
  { 1853, 13, 26, 17, 1, -26 },
  { 1896, 25, 26, 26, 1, -26 },
  { 1978, 21, 26, 22, 1, -26 },
  { 2047, 18, 26, 21, 2, -26 },
  { 2106, 18, 26, 19, 1, -26 },
  { 2165, 18, 30, 21, 2, -26 },
  { 2233, 18, 26, 19, 1, -26 },
  { 2292, 17, 26, 18, 1, -26 },
  { 2348, 17, 26, 18, 3, -26 },
  { 2404, 18, 26, 20, 2, -26 },
  { 2463, 18, 26, 20, 3, -26 },
  { 2522, 24, 26, 27, 4, -26 },
  { 2600, 21, 26, 19, -1, -26 },
  { 2669, 17, 26, 18, 3, -26 },
  { 2725, 19, 26, 18, 0, -26 },
  { 2787, 11, 34, 9, 0, -29 },
  { 2834, 6, 28, 13, 4, -26 },
  { 2855, 11, 34, 9, -2, -29 },
  { 2902, 11, 13, 13, 1, -26 },
  { 2920, 14, 3, 14, -2, 0 },
  { 2926, 6, 5, 11, 4, -27 },
  { 2930, 14, 19, 17, 1, -19 },
  { 2964, 16, 27, 17, 0, -27 },
  { 3018, 14, 19, 16, 1, -19 },
  { 3052, 17, 27, 17, 1, -27 },
  { 3110, 14, 19, 16, 1, -19 },
  { 3144, 12, 27, 11, 2, -27 },
  { 3185, 16, 26, 17, 0, -19 },
  { 3237, 15, 27, 17, 0, -27 },
  { 3288, 7, 26, 8, 1, -26 },
  { 3311, 11, 33, 8, -3, -26 },
  { 3357, 16, 27, 16, 0, -27 },
  { 3411, 7, 27, 8, 1, -27 },
  { 3435, 24, 19, 26, 0, -19 },
  { 3492, 15, 19, 17, 0, -19 },
  { 3528, 15, 19, 18, 1, -19 },
  { 3564, 17, 26, 17, -1, -19 },
  { 3620, 15, 26, 17, 1, -19 },
  { 3669, 11, 19, 11, 0, -19 },
  { 3696, 14, 19, 16, 1, -19 },
  { 3730, 10, 24, 10, 1, -24 },
  { 3760, 15, 19, 17, 1, -19 },
  { 3796, 13, 19, 15, 2, -19 },
  { 3827, 21, 19, 23, 2, -19 },
  { 3877, 17, 19, 15, -1, -19 },
  { 3918, 17, 26, 15, -2, -19 },
  { 3974, 15, 19, 15, 0, -19 },
  { 4010, 11, 34, 11, 1, -28 },
  { 4057, 7, 31, 9, 1, -26 },
  { 4085, 12, 34, 11, -2, -28 },
  { 4136, 17, 7, 21, 2, -14 },
};

const GFXfont RobotoCondensed_Italic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_ITALIC36PT7B_H_
