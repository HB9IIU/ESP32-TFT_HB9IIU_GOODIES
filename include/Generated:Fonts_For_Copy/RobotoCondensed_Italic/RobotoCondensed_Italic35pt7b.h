#ifndef _ROBOTOCONDENSED_ITALIC35PT7B_H_
#define _ROBOTOCONDENSED_ITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3,
  0x87, 0x0C, 0x18, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x70, 0x60, 0x33,
  0x99, 0x9C, 0xCC, 0x66, 0x73, 0x31, 0x98, 0x8C, 0x00, 0x63, 0x80, 0x71,
  0x80, 0x30, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x38, 0x07,
  0x18, 0x3F, 0xFF, 0x9F, 0xFF, 0xC1, 0xC6, 0x00, 0xC3, 0x00, 0x63, 0x80,
  0x71, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x06, 0x38,
  0x07, 0x18, 0x03, 0x0C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x1F, 0x00,
  0xFF, 0x03, 0xFF, 0x07, 0x0E, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0,
  0x71, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0x70,
  0x38, 0xE0, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x73, 0x00, 0x61, 0x86, 0x61, 0x86,
  0xE1, 0x8C, 0xE1, 0x9C, 0xC3, 0x98, 0xE3, 0x30, 0x67, 0x70, 0x7E, 0xE0,
  0x3C, 0xC0, 0x01, 0x80, 0x03, 0xBC, 0x03, 0x7E, 0x06, 0x67, 0x0E, 0xC3,
  0x0C, 0xC3, 0x18, 0xC3, 0x38, 0xC3, 0x70, 0xC3, 0x60, 0xC7, 0x00, 0xC6,
  0x00, 0x7E, 0x00, 0x38, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0xF0,
  0x07, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xC7, 0x39, 0xC7, 0x71, 0xE7,
  0x70, 0xE6, 0xE0, 0xFE, 0xE0, 0x7C, 0xE0, 0x7C, 0xE0, 0x38, 0x70, 0x7C,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x8E, 0x77, 0x66, 0xEE, 0xCC, 0x00, 0x40,
  0x30, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x20, 0x02, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x20, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x43, 0x0B, 0xCC, 0xEF, 0xFF, 0x8F, 0xFC, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x0E, 0x70, 0x71, 0xC1, 0x83, 0x82, 0x08, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x71,
  0xCE, 0x38, 0xE7, 0x38, 0x40, 0xFF, 0xFF, 0xF8, 0x6F, 0xFE, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0x0E, 0x38,
  0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xF8,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x00,
  0x01, 0x83, 0xC7, 0xEF, 0xFF, 0xB6, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0x0E, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF0, 0xE1, 0xC1, 0xC7, 0x01, 0xCE, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x0E, 0x0E,
  0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x6E, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0x9C,
  0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x77, 0x80, 0xFF, 0x81, 0xFF, 0x83, 0x87, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1E,
  0x1E, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0x70, 0x1F, 0x81, 0xFC,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xBE, 0x1F,
  0xF8, 0xFF, 0xEF, 0x87, 0x78, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0D, 0xC0, 0xEE, 0x07, 0x38, 0x71, 0xFF, 0x87, 0xF8, 0x1F, 0x00,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x70, 0xE1, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x78, 0x3F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0x8E, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x07, 0x8E, 0x0E, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F,
  0x80, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x87, 0x70, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0x7F, 0xF7,
  0xFE, 0x3E, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0xF0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x00, 0x18, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x83, 0xC0, 0xC0, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0x80, 0x04, 0x3F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0xFF, 0xF7, 0xFF, 0x80, 0x10, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x78, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x0C, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x0F,
  0x06, 0x18, 0x3F, 0x83, 0x38, 0x71, 0xC3, 0x30, 0xE1, 0xC3, 0x70, 0xE1,
  0x83, 0x61, 0xC1, 0x86, 0x61, 0xC3, 0x86, 0x61, 0x83, 0x06, 0xE1, 0x83,
  0x06, 0xE3, 0x87, 0x06, 0xE3, 0x87, 0x0C, 0xC3, 0x86, 0x0C, 0xC3, 0x8E,
  0x18, 0xC3, 0xDF, 0x38, 0xC1, 0xF3, 0xF0, 0xE0, 0xE3, 0xE0, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1D, 0x80,
  0x07, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E,
  0x1C, 0x03, 0x83, 0x01, 0xC0, 0xC0, 0x70, 0x38, 0x3F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x01, 0x8E, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0E,
  0x1C, 0x07, 0x1E, 0x07, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC0,
  0xE0, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E,
  0x03, 0xC7, 0x01, 0xC7, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xE1, 0xC0, 0x79,
  0xC0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCF, 0x01, 0xC3, 0x81, 0xE1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xC1, 0xE1, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x3C, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E,
  0x03, 0xC7, 0x01, 0xC7, 0x03, 0xC3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC1, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xE1, 0xC0, 0x79,
  0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x07, 0xF7, 0x07, 0xFB, 0x83, 0xFD, 0xC0, 0x1E, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xE3, 0xC1, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x0E, 0x1C,
  0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE0, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x38, 0x0E,
  0x1C, 0x07, 0x0F, 0x07, 0x83, 0x83, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0x80, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x38, 0x1E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0xF0, 0x07,
  0xBC, 0x00, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0x38, 0x03, 0xC7, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xF0, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xD8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xEE, 0x1C,
  0xC0, 0x77, 0x0E, 0x60, 0x33, 0x87, 0x38, 0x39, 0xC3, 0x9C, 0x19, 0xC1,
  0xCE, 0x1C, 0xE0, 0xE7, 0x0C, 0x70, 0xF3, 0x8E, 0x38, 0x70, 0xC7, 0x1C,
  0x38, 0x67, 0x1E, 0x1C, 0x3B, 0x8E, 0x0E, 0x1F, 0x87, 0x07, 0x0F, 0xC3,
  0x87, 0x07, 0xC1, 0xC3, 0x81, 0xE0, 0xE1, 0xC0, 0xE0, 0xF0, 0xE0, 0x70,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0E,
  0x1F, 0x80, 0xE1, 0xF8, 0x0E, 0x1D, 0x80, 0xE1, 0xDC, 0x0E, 0x1D, 0xC1,
  0xC3, 0xCC, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x61, 0xC3, 0x87,
  0x1C, 0x38, 0x73, 0x87, 0x87, 0x38, 0x70, 0x3B, 0x87, 0x03, 0xB8, 0x70,
  0x3B, 0x87, 0x01, 0xF8, 0x70, 0x1F, 0x0F, 0x01, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC0, 0xE1, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7,
  0x01, 0xC3, 0xC1, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x0E, 0x1C, 0x03, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x78,
  0xE0, 0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x81, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x03,
  0x9C, 0x01, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC0, 0xE1, 0xC0, 0x78, 0xE0, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x8E, 0x01, 0xC7, 0x03, 0xC3,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x1E, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xC1,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1E, 0x78, 0x0F, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x70, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x8F, 0x01,
  0xC3, 0x81, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07,
  0x01, 0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0F, 0x1C,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x83,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x39, 0xC0, 0x06, 0x70, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x07,
  0x70, 0x1C, 0x07, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x0E,
  0x70, 0x7C, 0x1C, 0x70, 0x6C, 0x1C, 0x70, 0xEC, 0x1C, 0x70, 0xEC, 0x38,
  0x70, 0xCC, 0x38, 0x71, 0xCC, 0x38, 0x71, 0x8C, 0x70, 0x73, 0x8C, 0x70,
  0x73, 0x8C, 0x70, 0x73, 0x0E, 0xE0, 0x77, 0x0E, 0xE0, 0x76, 0x0E, 0xE0,
  0x76, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x3C,
  0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x39, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x01,
  0xC7, 0x80, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x1C,
  0x0F, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x03,
  0x8E, 0x03, 0xC7, 0x01, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x38,
  0xF0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0x60, 0xC1, 0x83, 0x87, 0x0E,
  0x1C, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x18, 0x38, 0x70,
  0xE1, 0xC3, 0x83, 0x06, 0x0E, 0x1C, 0x38, 0x07, 0xE0, 0xFC, 0x1F, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xFC,
  0x1B, 0x87, 0x70, 0xE6, 0x38, 0xC7, 0x19, 0xC3, 0xB8, 0x70, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0x80, 0xE3, 0x9C, 0x71, 0x80, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0E, 0x38, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xFE, 0x1F, 0xF9,
  0xF0, 0xE7, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x3F, 0xFC,
  0x7F, 0x70, 0xF9, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF8, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x77, 0x01, 0xCE, 0x03, 0x9E, 0x0F, 0x3F,
  0xFC, 0x77, 0xF1, 0xC7, 0xC0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E,
  0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x3B, 0x81, 0xC7, 0x07, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0xCE, 0x1F, 0xEE, 0x1F, 0xFC, 0x3C,
  0x3C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x70, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0x70, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8E, 0x0E,
  0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x7E,
  0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x87, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0xFF, 0x9F, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0xE7, 0x0F, 0xF7, 0x0F, 0xFF, 0x1E, 0x1E, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x38, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xB8, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x60, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x1F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0xF8, 0x3B, 0xF8, 0x7F, 0xF0,
  0xF0, 0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x39, 0xC0, 0x70, 0x04, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x0E, 0x1C,
  0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38,
  0x70, 0xE0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0xF0,
  0x1D, 0xE0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3D, 0xC0,
  0x39, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0x70, 0x70,
  0x60, 0x38, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1,
  0xC0, 0x0C, 0xF8, 0x7C, 0x1F, 0xFD, 0xFE, 0x1F, 0xFF, 0xFE, 0x1E, 0x1F,
  0x0F, 0x1C, 0x1E, 0x07, 0x1C, 0x0E, 0x07, 0x38, 0x0E, 0x07, 0x38, 0x1C,
  0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C,
  0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38,
  0x1C, 0x70, 0x38, 0x1C, 0x60, 0x38, 0x1C, 0x0C, 0xF8, 0x3B, 0xF8, 0x7F,
  0xF0, 0xF0, 0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x39, 0xC0, 0x70, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE1, 0xE0,
  0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x03, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B,
  0x80, 0x77, 0x00, 0xEE, 0x03, 0xCE, 0x07, 0x1C, 0x1C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x1F, 0x00, 0x06, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0E,
  0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x3C, 0x1C, 0x3F, 0xFC, 0x3F,
  0xF8, 0x71, 0xF0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xCE, 0x3F, 0xDC, 0x7F, 0xF9, 0xE1,
  0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x39, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3E, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x0C, 0xE3, 0xFC, 0x7F, 0x8F, 0x81, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xEE, 0x07, 0x70, 0x3B, 0x83, 0xCF, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC3, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xC1, 0xE0,
  0xF0, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE,
  0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x3F, 0xF8, 0x7F, 0xF0, 0x3C, 0xE0, 0xE0,
  0x3F, 0x03, 0xB8, 0x1C, 0xC1, 0xC6, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38,
  0x73, 0x83, 0x9C, 0x0C, 0xC0, 0x6E, 0x03, 0x60, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xC0, 0x00, 0xE0, 0x70, 0x77, 0x03, 0x83, 0xB8, 0x3C,
  0x1C, 0xC1, 0xE1, 0xC6, 0x1F, 0x0E, 0x30, 0xD8, 0x61, 0x8E, 0xC7, 0x0C,
  0x66, 0x38, 0x77, 0x33, 0x83, 0xB9, 0x9C, 0x1D, 0x8C, 0xC0, 0xFC, 0x7E,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78,
  0x1C, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x07,
  0x3C, 0x07, 0x38, 0x03, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C, 0x70, 0x38,
  0x70, 0x78, 0x38, 0x70, 0x38, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x07, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x04, 0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E,
  0x07, 0x80, 0x40, 0x00, 0x1E, 0x03, 0x3F, 0x03, 0x7F, 0x87, 0xE3, 0xC6,
  0xE1, 0xFE, 0xC0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 25, 8, 1, -25 },
  { 23, 9, 8, 11, 3, -26 },
  { 32, 17, 25, 19, 2, -25 },
  { 86, 15, 32, 17, 1, -29 },
  { 146, 16, 25, 21, 3, -25 },
  { 196, 16, 25, 18, 1, -25 },
  { 246, 4, 8, 6, 3, -26 },
  { 250, 10, 36, 11, 2, -28 },
  { 295, 11, 36, 11, -2, -28 },
  { 345, 14, 15, 15, 2, -25 },
  { 372, 15, 18, 17, 1, -20 },
  { 406, 6, 9, 7, -2, -4 },
  { 413, 7, 3, 8, 1, -12 },
  { 416, 4, 4, 9, 1, -4 },
  { 418, 16, 27, 13, -2, -25 },
  { 472, 14, 25, 17, 2, -25 },
  { 516, 9, 25, 17, 4, -25 },
  { 545, 16, 25, 17, 0, -25 },
  { 595, 15, 25, 17, 1, -25 },
  { 642, 16, 25, 17, 0, -25 },
  { 692, 15, 25, 17, 2, -25 },
  { 739, 13, 25, 17, 2, -25 },
  { 780, 16, 25, 17, 2, -25 },
  { 830, 15, 25, 17, 1, -25 },
  { 877, 12, 25, 17, 3, -25 },
  { 915, 6, 19, 8, 1, -19 },
  { 930, 9, 24, 7, -2, -19 },
  { 957, 13, 16, 15, 1, -19 },
  { 983, 13, 10, 16, 2, -17 },
  { 1000, 14, 16, 16, 1, -19 },
  { 1028, 12, 25, 14, 3, -25 },
  { 1066, 24, 32, 26, 1, -24 },
  { 1162, 18, 25, 20, -1, -25 },
  { 1219, 17, 25, 19, 1, -25 },
  { 1273, 17, 25, 19, 2, -25 },
  { 1327, 17, 25, 19, 1, -25 },
  { 1381, 17, 25, 17, 1, -25 },
  { 1435, 17, 25, 16, 1, -25 },
  { 1489, 17, 25, 20, 2, -25 },
  { 1543, 20, 25, 21, 1, -25 },
  { 1606, 7, 25, 9, 1, -25 },
  { 1628, 17, 25, 16, 0, -25 },
  { 1682, 19, 25, 19, 1, -25 },
  { 1742, 13, 25, 16, 1, -25 },
  { 1783, 25, 25, 26, 1, -25 },
  { 1862, 20, 25, 21, 1, -25 },
  { 1925, 17, 25, 20, 2, -25 },
  { 1979, 18, 25, 19, 1, -25 },
  { 2036, 17, 29, 20, 2, -25 },
  { 2098, 17, 25, 18, 1, -25 },
  { 2152, 17, 25, 18, 1, -25 },
  { 2206, 16, 25, 18, 3, -25 },
  { 2256, 19, 25, 19, 1, -25 },
  { 2316, 18, 25, 19, 3, -25 },
  { 2373, 24, 25, 26, 3, -25 },
  { 2448, 21, 25, 19, -1, -25 },
  { 2514, 17, 25, 18, 3, -25 },
  { 2568, 18, 25, 18, 0, -25 },
  { 2625, 11, 33, 9, 0, -28 },
  { 2671, 7, 27, 13, 3, -25 },
  { 2695, 11, 33, 9, -2, -28 },
  { 2741, 11, 12, 13, 1, -25 },
  { 2758, 14, 3, 14, -2, 0 },
  { 2764, 5, 5, 11, 4, -26 },
  { 2768, 14, 18, 16, 1, -18 },
  { 2800, 15, 26, 17, 0, -26 },
  { 2849, 14, 18, 16, 1, -18 },
  { 2881, 16, 26, 17, 1, -26 },
  { 2933, 14, 18, 16, 1, -18 },
  { 2965, 11, 26, 11, 2, -26 },
  { 3001, 16, 25, 17, 0, -18 },
  { 3051, 15, 26, 16, 0, -26 },
  { 3100, 7, 25, 8, 1, -25 },
  { 3122, 11, 32, 8, -3, -25 },
  { 3166, 16, 26, 15, 0, -26 },
  { 3218, 7, 26, 8, 1, -26 },
  { 3241, 24, 18, 26, 0, -18 },
  { 3295, 15, 18, 16, 0, -18 },
  { 3329, 15, 18, 17, 1, -18 },
  { 3363, 16, 25, 17, -1, -18 },
  { 3413, 15, 25, 17, 1, -18 },
  { 3460, 11, 18, 10, 0, -18 },
  { 3485, 13, 18, 15, 1, -18 },
  { 3515, 9, 23, 10, 1, -23 },
  { 3541, 15, 18, 16, 1, -18 },
  { 3575, 13, 18, 15, 2, -18 },
  { 3605, 21, 18, 22, 2, -18 },
  { 3653, 16, 18, 15, -1, -18 },
  { 3689, 16, 25, 14, -1, -18 },
  { 3739, 15, 18, 15, 0, -18 },
  { 3773, 11, 33, 10, 1, -27 },
  { 3819, 7, 30, 8, 1, -25 },
  { 3846, 11, 33, 10, -2, -27 },
  { 3892, 16, 7, 20, 2, -14 },
};

const GFXfont RobotoCondensed_Italic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_ITALIC35PT7B_H_
