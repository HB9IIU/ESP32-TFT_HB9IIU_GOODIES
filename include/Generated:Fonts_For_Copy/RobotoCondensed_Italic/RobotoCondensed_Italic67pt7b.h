#ifndef _ROBOTOCONDENSED_ITALIC67PT7B_H_
#define _ROBOTOCONDENSED_ITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x30, 0x00, 0x3E, 0x1E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xF3, 0xE1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x70, 0x78, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x08, 0x3C, 0x07, 0xC0, 0x3C, 0x78,
  0x07, 0x80, 0xF8, 0xF0, 0x0F, 0x01, 0xE3, 0xE0, 0x1E, 0x07, 0xC7, 0xC0,
  0x7C, 0x1F, 0x0F, 0x80, 0xF8, 0x3C, 0x1E, 0x01, 0xE0, 0xF8, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0x80, 0x78, 0x1F, 0x1F, 0x00, 0xF8, 0x7C,
  0x7C, 0x01, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0x8F,
  0x80, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xC7, 0xFE,
  0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0xF8, 0xF8, 0x3C,
  0x01, 0xE1, 0xE0, 0x78, 0x07, 0x87, 0xC0, 0xF8, 0x1F, 0x0F, 0x00, 0xF0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x3C, 0x03, 0xC3, 0xE0, 0xF8, 0x0F, 0x8F,
  0x81, 0xF0, 0x1F, 0x1E, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x79, 0xF0,
  0x0F, 0x80, 0xF1, 0xC0, 0x0F, 0x03, 0xE1, 0x80, 0x1E, 0x07, 0x80, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xF0, 0xFE, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0xFE, 0x7E, 0x07, 0xC3, 0xF8,
  0xFE, 0x0F, 0x8F, 0xE0, 0xFC, 0x1F, 0x1F, 0x81, 0xFC, 0x3E, 0x7E, 0x01,
  0xF8, 0xF8, 0xFC, 0x03, 0xF9, 0xF3, 0xF0, 0x03, 0xF3, 0xE7, 0xE0, 0x07,
  0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x1F, 0x80, 0x0F, 0xFC, 0x3F, 0x00, 0x0F,
  0xF8, 0x7E, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xF1, 0xFC,
  0x03, 0xFF, 0x81, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7,
  0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x30,
  0x0F, 0x80, 0xC7, 0xC1, 0xF0, 0xF9, 0xFE, 0x3C, 0x7F, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x30, 0x03, 0x80, 0x02, 0x00, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xBF, 0x7E,
  0x1F, 0xBC, 0x0F, 0x98, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7D, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xDF, 0xFC,
  0x07, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0x83,
  0xF8, 0xFF, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFE,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0x01, 0xF8, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xCF,
  0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0xFE, 0x7C, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x1F, 0xC0,
  0x7F, 0x87, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFD, 0xF0, 0x0F, 0xFC, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xBF, 0xC7, 0xF0, 0x3F,
  0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xC0,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x78, 0x3E,
  0x00, 0xFF, 0xFE, 0x03, 0xC1, 0xE0, 0x0F, 0xE3, 0xF0, 0x1E, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0x87, 0x80, 0x7C,
  0x03, 0xC0, 0x3C, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x79, 0xF0, 0x1F, 0x00, 0x78,
  0x03, 0xCF, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x78, 0x07, 0x80, 0x3E, 0x00,
  0xF3, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xBE, 0x03, 0xE0, 0x0F, 0x00, 0x3D,
  0xF0, 0x1F, 0x00, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x78,
  0x0F, 0x80, 0x3E, 0x00, 0xF3, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xBE, 0x03,
  0xE0, 0x0F, 0x00, 0x39, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xCF, 0x80, 0xF8,
  0x07, 0xC0, 0x1E, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0xE3, 0xE0, 0x3E, 0x03,
  0xF0, 0x0F, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0xF0, 0x0F, 0x81, 0xF8,
  0x07, 0x87, 0x80, 0x7C, 0x0F, 0xE0, 0x7C, 0x3C, 0x03, 0xF0, 0xFF, 0x03,
  0xC1, 0xF0, 0x1F, 0xFE, 0x7C, 0x7C, 0x0F, 0x80, 0x7F, 0xF3, 0xFF, 0xC0,
  0x3C, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xC7, 0xE0,
  0x07, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xFE, 0x1F,
  0x80, 0x1F, 0xFF, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x07,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFC,
  0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x00, 0x01,
  0xFF, 0xC0, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x7D, 0xF0, 0x00, 0x0F,
  0xFF, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x00, 0x7E,
  0xF8, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x0F, 0x9F, 0x80, 0x03, 0xF7,
  0xE0, 0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x00, 0x1F, 0x9F,
  0x80, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x03, 0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xF0,
  0x0F, 0x87, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xC7, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x9F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x3D, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x00, 0x7E, 0x03,
  0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0x00,
  0x3F, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x1F,
  0x9F, 0x00, 0x0F, 0xC0, 0x7E, 0x7C, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x00,
  0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x03, 0xF1, 0xF8,
  0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0xFC, 0x00,
  0x7E, 0xFC, 0x03, 0xF0, 0x00, 0xFB, 0xF0, 0x0F, 0xC0, 0x03, 0xEF, 0xC0,
  0x3E, 0x00, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x00,
  0x7F, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFE, 0x01,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xDF, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xE7, 0xC0, 0x3F, 0x07, 0xE0, 0x3E, 0x3E, 0x01, 0xF0, 0x3F, 0x01,
  0xF1, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x87, 0x80, 0xFC, 0x0F, 0xC0, 0xF8,
  0x3C, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x0F,
  0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xC1,
  0xF8, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0xF0, 0x7C,
  0x00, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x80, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x03, 0xEF,
  0x80, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0xFB, 0xE0,
  0x03, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x3C, 0x0F, 0x83, 0xC1, 0xF0, 0x3E,
  0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xEF, 0x80, 0x3E, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF0, 0xFC, 0x3F, 0xC0, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF,
  0x01, 0xFF, 0xE7, 0xC0, 0x3F, 0xE1, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0xF0, 0x03, 0xEF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xF8, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x7F,
  0x07, 0xFF, 0x1F, 0xF0, 0xFD, 0xFF, 0xFE, 0x0F, 0xCF, 0xFF, 0xC0, 0xF8,
  0xFF, 0xF8, 0x0F, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x7E, 0x00, 0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xF7,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xDF, 0x00, 0x0F, 0xFF, 0x7E,
  0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x1F, 0x80, 0x07, 0x03, 0xF0,
  0x07, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x20, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0xFC, 0x01, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xF3, 0xE0, 0x1F,
  0xFF, 0xF7, 0xC0, 0x3F, 0xE3, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xF8,
  0x01, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7E, 0x00, 0x0F,
  0xFC, 0xFC, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xC0, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x1F, 0xF8, 0x03, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x03, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xE0, 0x7F,
  0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0xFB,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xF0, 0x00,
  0x7F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xEF, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF,
  0xF1, 0xFF, 0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x80,
  0x3F, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x7F, 0xC0, 0x0F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFF, 0xC0, 0x01, 0xF7, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x1F, 0xBF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x00, 0x7E,
  0x7F, 0xFC, 0x00, 0xFC, 0x7F, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xFC, 0x7C,
  0x07, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x3F,
  0x80, 0x7F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0x80, 0x0F, 0xFC, 0xFC, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x7F, 0x03, 0xEF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x1F, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xDF, 0x00, 0x7F, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0xFD,
  0xF0, 0x03, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE0, 0x07, 0xE7, 0xC0, 0x0F,
  0xC0, 0x0F, 0xCF, 0x80, 0x3F, 0x80, 0x1F, 0x1F, 0x00, 0x7F, 0x80, 0x7E,
  0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x7C, 0x03, 0xFE, 0x03, 0xF0, 0xF8, 0x0F,
  0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0xF8, 0x0F, 0x83, 0xE0, 0x7D, 0xF0, 0x3F,
  0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x1F, 0x07,
  0xCF, 0x83, 0xE0, 0x3E, 0x0F, 0x8F, 0x07, 0xC0, 0x7E, 0x3E, 0x1E, 0x1F,
  0x80, 0x7C, 0x7C, 0x3C, 0x3E, 0x00, 0xF9, 0xF0, 0x7C, 0x7C, 0x01, 0xF3,
  0xE0, 0xF9, 0xF0, 0x03, 0xEF, 0xC1, 0xF3, 0xE0, 0x07, 0xDF, 0x03, 0xEF,
  0xC0, 0x0F, 0xBE, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x0F, 0xBE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE1,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0x0F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x1F,
  0x1F, 0xFF, 0xC0, 0x1E, 0x3F, 0x9F, 0xE0, 0x3E, 0x3E, 0x07, 0xF0, 0x7E,
  0x7E, 0x03, 0xF8, 0xFC, 0x7C, 0x03, 0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xF8,
  0xF8, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoCondensed_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 14, 49, 16, 2, -48 },
  { 87, 15, 16, 21, 7, -50 },
  { 117, 33, 48, 36, 3, -48 },
  { 315, 29, 63, 32, 2, -56 },
  { 544, 31, 50, 41, 6, -49 },
  { 738, 31, 50, 35, 2, -49 },
  { 932, 7, 16, 11, 6, -50 },
  { 946, 20, 69, 20, 3, -54 },
  { 1119, 20, 69, 21, -3, -54 },
  { 1292, 27, 28, 28, 3, -48 },
  { 1387, 27, 35, 32, 3, -40 },
  { 1506, 12, 17, 13, -4, -7 },
  { 1532, 14, 5, 16, 1, -23 },
  { 1541, 7, 8, 17, 2, -7 },
  { 1548, 30, 52, 24, -3, -48 },
  { 1743, 27, 50, 32, 3, -49 },
  { 1912, 17, 48, 32, 8, -48 },
  { 2014, 30, 49, 32, 1, -49 },
  { 2198, 28, 50, 32, 2, -49 },
  { 2373, 30, 48, 32, 0, -48 },
  { 2553, 30, 49, 32, 3, -48 },
  { 2737, 25, 49, 32, 4, -48 },
  { 2891, 30, 48, 32, 4, -48 },
  { 3071, 29, 50, 32, 2, -49 },
  { 3253, 25, 49, 32, 5, -49 },
  { 3407, 13, 37, 16, 1, -36 },
  { 3468, 16, 46, 14, -3, -36 },
  { 3560, 25, 29, 29, 2, -36 },
  { 3651, 25, 19, 31, 4, -32 },
  { 3711, 26, 30, 30, 2, -36 },
  { 3809, 22, 50, 27, 6, -49 },
  { 3947, 45, 62, 50, 2, -47 },
  { 4296, 35, 48, 37, -2, -48 },
  { 4506, 32, 48, 35, 2, -48 },
  { 4698, 32, 50, 37, 4, -49 },
  { 4898, 33, 48, 37, 2, -48 },
  { 5096, 32, 48, 32, 2, -48 },
  { 5288, 32, 48, 31, 2, -48 },
  { 5480, 34, 50, 38, 3, -49 },
  { 5693, 38, 48, 40, 2, -48 },
  { 5921, 14, 48, 16, 2, -48 },
  { 6005, 32, 49, 31, 0, -48 },
  { 6201, 37, 48, 35, 2, -48 },
  { 6423, 24, 48, 31, 2, -48 },
  { 6567, 47, 48, 49, 2, -48 },
  { 6849, 38, 48, 40, 2, -48 },
  { 7077, 33, 50, 39, 4, -49 },
  { 7284, 34, 48, 36, 2, -48 },
  { 7488, 34, 57, 39, 3, -49 },
  { 7731, 32, 48, 34, 2, -48 },
  { 7923, 33, 50, 34, 1, -49 },
  { 8130, 31, 48, 34, 6, -48 },
  { 8316, 34, 49, 37, 3, -48 },
  { 8525, 34, 48, 36, 6, -48 },
  { 8729, 45, 48, 50, 7, -48 },
  { 8999, 39, 48, 36, -1, -48 },
  { 9233, 32, 48, 34, 6, -48 },
  { 9425, 36, 48, 34, -1, -48 },
  { 9641, 20, 64, 16, 0, -54 },
  { 9801, 12, 52, 24, 7, -48 },
  { 9879, 21, 64, 16, -4, -54 },
  { 10047, 20, 24, 24, 3, -48 },
  { 10107, 26, 5, 26, -4, 0 },
  { 10124, 11, 10, 20, 7, -51 },
  { 10138, 26, 37, 31, 2, -36 },
  { 10259, 28, 51, 32, 1, -50 },
  { 10438, 27, 37, 30, 2, -36 },
  { 10563, 31, 51, 32, 2, -50 },
  { 10761, 26, 37, 30, 2, -36 },
  { 10882, 22, 51, 21, 3, -51 },
  { 11023, 31, 50, 32, 0, -36 },
  { 11217, 27, 50, 31, 1, -50 },
  { 11386, 14, 48, 15, 1, -48 },
  { 11470, 21, 62, 15, -6, -48 },
  { 11633, 29, 50, 29, 1, -50 },
  { 11815, 15, 50, 15, 1, -50 },
  { 11909, 44, 36, 49, 1, -36 },
  { 12107, 27, 36, 31, 1, -36 },
  { 12229, 28, 37, 33, 2, -36 },
  { 12359, 31, 50, 32, -2, -36 },
  { 12553, 29, 50, 33, 2, -36 },
  { 12735, 20, 36, 20, 1, -36 },
  { 12825, 26, 37, 30, 1, -36 },
  { 12946, 17, 45, 19, 3, -44 },
  { 13042, 27, 36, 31, 3, -35 },
  { 13164, 25, 35, 28, 4, -35 },
  { 13274, 39, 35, 42, 4, -35 },
  { 13445, 31, 35, 29, -2, -35 },
  { 13581, 32, 49, 27, -3, -35 },
  { 13777, 28, 35, 29, 0, -35 },
  { 13900, 21, 64, 20, 2, -52 },
  { 14068, 14, 57, 16, 1, -48 },
  { 14168, 21, 64, 20, -3, -52 },
  { 14336, 32, 13, 38, 3, -26 },
};

const GFXfont RobotoCondensed_Italic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_ITALIC67PT7B_H_
