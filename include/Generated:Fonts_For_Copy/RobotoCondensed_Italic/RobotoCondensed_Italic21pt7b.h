#ifndef _ROBOTOCONDENSED_ITALIC21PT7B_H_
#define _ROBOTOCONDENSED_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x66, 0x44, 0xC0, 0x0C, 0xC0, 0x5A, 0xF5, 0xA9,
  0x00, 0x06, 0x41, 0x30, 0x48, 0x32, 0x09, 0x8F, 0xF1, 0x90, 0x4C, 0x12,
  0x3F, 0xE2, 0x60, 0x90, 0x64, 0x13, 0x04, 0x80, 0x06, 0x02, 0x07, 0x87,
  0xE3, 0x33, 0x0D, 0x86, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x6C, 0x36, 0x1B,
  0x18, 0xFC, 0x78, 0x18, 0x0C, 0x00, 0x70, 0x16, 0x0C, 0x8A, 0x24, 0x8B,
  0x37, 0x87, 0x40, 0x20, 0x1B, 0x85, 0x22, 0x4D, 0xB2, 0x4C, 0x81, 0x60,
  0x70, 0x1E, 0x1F, 0x8C, 0xC6, 0x63, 0x31, 0xB0, 0x70, 0x70, 0x6C, 0xE6,
  0xF1, 0xF0, 0xEC, 0x37, 0xF9, 0xE6, 0xFE, 0x80, 0x04, 0x31, 0x86, 0x30,
  0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x20,
  0x80, 0x10, 0x60, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x30, 0xC3, 0x0C, 0x30,
  0x86, 0x18, 0xC3, 0x18, 0xC2, 0x00, 0x0C, 0x08, 0x08, 0xEF, 0x3E, 0x38,
  0x2C, 0x64, 0x44, 0x0C, 0x06, 0x03, 0x01, 0x0F, 0xF7, 0xF8, 0x60, 0x30,
  0x18, 0x08, 0x0C, 0x00, 0x2D, 0xE8, 0x7F, 0xC0, 0xF0, 0x00, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x1E, 0x1F, 0x88, 0x4C, 0x26, 0x12, 0x09, 0x05, 0x86,
  0xC3, 0x61, 0xB0, 0xD8, 0x4C, 0x63, 0xE1, 0xE0, 0x0C, 0xF7, 0x82, 0x18,
  0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC2, 0x00, 0x0F, 0x07, 0xE3, 0x18,
  0xC3, 0x30, 0x80, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3F, 0xEF, 0xF0, 0x1E, 0x3F, 0x63, 0x61, 0x03, 0x03, 0x1E, 0x1C, 0x06,
  0x02, 0x02, 0x86, 0xC6, 0xFC, 0x78, 0x01, 0x81, 0xC0, 0xE0, 0xF0, 0xD8,
  0x68, 0x6C, 0x26, 0x33, 0x31, 0x9F, 0xFF, 0xF0, 0x60, 0x30, 0x18, 0x1F,
  0x9F, 0xCC, 0x06, 0x02, 0x01, 0xF1, 0xF8, 0x46, 0x03, 0x01, 0x80, 0xD8,
  0x6C, 0x63, 0xF0, 0xF0, 0x07, 0x1E, 0x38, 0x30, 0x60, 0x7E, 0x7E, 0x63,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x38, 0x7F, 0x9F, 0xE0, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x00, 0x1E, 0x1F, 0x8C, 0x4C, 0x26, 0x13, 0x18, 0xF8, 0x78, 0x66,
  0x61, 0x30, 0xD8, 0x4C, 0x67, 0xE1, 0xE0, 0x3C, 0xFF, 0x1E, 0x38, 0x30,
  0xE1, 0xE3, 0xFE, 0xEC, 0x30, 0x61, 0x9E, 0x38, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x18, 0xC4, 0x60,
  0x02, 0x06, 0x1C, 0x70, 0xC0, 0xE0, 0x38, 0x1C, 0x04, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x40, 0x70, 0x3C, 0x0E, 0x03, 0x1E, 0x78, 0xE0, 0x80,
  0x38, 0xFB, 0x1E, 0x30, 0x61, 0x86, 0x1C, 0x30, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0xE0, 0x38, 0xC1, 0x81, 0x84, 0x02, 0x20, 0x0D, 0x8F,
  0x14, 0x64, 0x51, 0x11, 0xCC, 0xCE, 0x23, 0x39, 0x88, 0xA6, 0x22, 0x99,
  0x9A, 0x6A, 0x48, 0xEE, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x30, 0x07,
  0x80, 0x01, 0x80, 0x30, 0x0F, 0x01, 0xE0, 0x6C, 0x0D, 0x83, 0x30, 0x62,
  0x18, 0x43, 0xF8, 0x7F, 0x98, 0x32, 0x06, 0xC0, 0xD0, 0x18, 0x1F, 0x83,
  0xF8, 0x41, 0x18, 0x33, 0x04, 0x61, 0x8F, 0xE1, 0xFC, 0x21, 0x8C, 0x19,
  0x83, 0x30, 0x46, 0x18, 0xFE, 0x1F, 0x80, 0x0F, 0x87, 0xF3, 0x0D, 0x83,
  0x60, 0x58, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x06, 0x43, 0x9F,
  0xC3, 0xE0, 0x1F, 0x83, 0xF8, 0x43, 0x18, 0x33, 0x06, 0x60, 0xCC, 0x19,
  0x83, 0x20, 0x4C, 0x19, 0x83, 0x30, 0x66, 0x18, 0xFE, 0x1F, 0x80, 0x1F,
  0xE3, 0xFC, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xE1, 0xFC, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0F, 0xE1, 0xF8, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x00, 0x0F, 0x07, 0xF3, 0x0D, 0x83, 0x60, 0x58,
  0x04, 0x03, 0x1F, 0xC7, 0xF0, 0x3C, 0x1B, 0x06, 0x61, 0x9F, 0xC3, 0xE0,
  0x18, 0x10, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xFF, 0x87,
  0xFC, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x30, 0x61, 0x03,
  0x00, 0x33, 0x32, 0x66, 0x66, 0x64, 0xCC, 0xCC, 0x80, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x33, 0x0C,
  0xC3, 0x1F, 0x83, 0xC0, 0x18, 0x31, 0x86, 0x10, 0xC3, 0x18, 0x33, 0x03,
  0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x30, 0x63, 0x06, 0x30, 0x61, 0x86,
  0x18, 0x40, 0xC0, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x60, 0x7F, 0x7F, 0x18, 0x06, 0x38, 0x1C, 0x70, 0x39,
  0xE0, 0xF3, 0xC1, 0xE6, 0x86, 0x8D, 0x0F, 0x1A, 0x36, 0x26, 0x6C, 0xCD,
  0x99, 0x9B, 0x33, 0x3C, 0x46, 0x39, 0x8C, 0x63, 0x10, 0xC6, 0x00, 0x18,
  0x10, 0xC1, 0x87, 0x0C, 0x78, 0x63, 0x43, 0x1B, 0x18, 0xD8, 0x86, 0x4C,
  0x23, 0x63, 0x1B, 0x18, 0x58, 0xC3, 0xC6, 0x1C, 0x30, 0x61, 0x03, 0x00,
  0x0F, 0x83, 0xF8, 0xC3, 0x30, 0x26, 0x04, 0xC0, 0x90, 0x16, 0x06, 0xC0,
  0xD8, 0x1B, 0x03, 0x60, 0xC6, 0x18, 0xFE, 0x0F, 0x80, 0x1F, 0x83, 0xFC,
  0x41, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0xFE, 0x3F, 0x8C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x0F, 0x07, 0xF3, 0x0D, 0x83, 0x60,
  0x58, 0x14, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0x41, 0x9F, 0xC3,
  0xE0, 0x0C, 0x03, 0x80, 0x40, 0x1F, 0x83, 0xF8, 0x61, 0x98, 0x33, 0x06,
  0x60, 0xCC, 0x31, 0xFC, 0x3F, 0x0C, 0x61, 0x8C, 0x30, 0xC6, 0x18, 0xC3,
  0x10, 0x60, 0x0F, 0x83, 0xF8, 0x63, 0x18, 0x23, 0x06, 0x60, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x31, 0x02, 0x20, 0xC6, 0x18, 0xFE, 0x07, 0x80, 0xFF,
  0xBF, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x00, 0x30, 0x64, 0x09, 0x83, 0x30, 0x66,
  0x0C, 0xC1, 0x98, 0x32, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x30,
  0xFE, 0x0F, 0x00, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x10, 0xC6, 0x21,
  0x98, 0x66, 0x1B, 0x06, 0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC3, 0x0F,
  0x0C, 0x3C, 0x30, 0xF1, 0xC6, 0xC5, 0x1B, 0x34, 0x4C, 0xD3, 0x32, 0x4C,
  0xD9, 0xA3, 0x47, 0x8D, 0x1E, 0x1C, 0x70, 0x61, 0xC1, 0x87, 0x04, 0x18,
  0x00, 0x30, 0x71, 0x86, 0x18, 0xC1, 0x9C, 0x0D, 0x80, 0xF0, 0x0F, 0x00,
  0x60, 0x0E, 0x01, 0xB0, 0x1B, 0x03, 0x30, 0x71, 0x86, 0x18, 0xC1, 0x80,
  0xC1, 0xF0, 0x64, 0x31, 0x8C, 0x66, 0x19, 0x82, 0xC0, 0xA0, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xFF, 0x3F, 0xE0, 0x1C, 0x71, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x86, 0x10, 0xC3, 0x0E, 0x38, 0xCC, 0xC4, 0x44, 0x66, 0x66,
  0x22, 0x23, 0x33, 0x1C, 0x70, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x86,
  0x10, 0xC3, 0x0C, 0x30, 0xCE, 0x38, 0x18, 0x63, 0x8A, 0x6D, 0x3C, 0xC0,
  0xFF, 0xFF, 0xC6, 0x20, 0x1E, 0x7E, 0x63, 0x03, 0x3E, 0x66, 0xC6, 0x86,
  0x86, 0xFE, 0x76, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0xF8, 0xFE, 0x63,
  0x21, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x19, 0xFD, 0xBC, 0x3C, 0x7E, 0x63,
  0xC3, 0xC0, 0xC0, 0xC0, 0x86, 0xC6, 0xFC, 0x78, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x19, 0xE9, 0xFC, 0xC6, 0xC3, 0x61, 0xB0, 0xD0, 0x48, 0x66, 0x33,
  0xF8, 0xEC, 0x1C, 0x7E, 0x63, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE,
  0x78, 0x0E, 0x3C, 0xC1, 0x83, 0x1F, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x04,
  0x18, 0x30, 0x60, 0x1E, 0xCF, 0xE3, 0x19, 0x86, 0x61, 0x98, 0x66, 0x11,
  0x84, 0x63, 0x1F, 0xC3, 0xF0, 0x0C, 0x06, 0x3F, 0x87, 0x80, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0xF8, 0xFE, 0x63, 0x21, 0xB0, 0xD8, 0x4C, 0x66,
  0x32, 0x19, 0x0D, 0x86, 0x18, 0xC0, 0x03, 0x18, 0xC4, 0x23, 0x18, 0xC6,
  0x23, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x02, 0x0C, 0x18, 0x31, 0xC3, 0x80, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x63, 0x30, 0x98, 0x2C, 0x1E, 0x07, 0xC1, 0xB0, 0x64, 0x11,
  0x84, 0x63, 0x0C, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31,
  0x18, 0x3F, 0x38, 0xFD, 0xF3, 0x18, 0xC8, 0x63, 0x61, 0x8D, 0x84, 0x36,
  0x30, 0xD8, 0xC3, 0x43, 0x09, 0x0C, 0x6C, 0x31, 0x80, 0x3F, 0x1F, 0xCC,
  0x64, 0x36, 0x1B, 0x09, 0x8C, 0xC6, 0x43, 0x21, 0xB0, 0xC0, 0x1E, 0x7F,
  0x63, 0xC3, 0xC1, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0x78, 0x1F, 0x87, 0xF1,
  0x8C, 0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x31, 0x9F, 0xE6, 0xF1, 0x80,
  0x60, 0x18, 0x04, 0x00, 0x3D, 0x3F, 0x98, 0xD8, 0x6C, 0x36, 0x1B, 0x09,
  0x0C, 0xC6, 0x7F, 0x1F, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x3E, 0x78, 0xC1,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x00, 0x1E, 0x1F, 0x8C, 0x44, 0x03,
  0x80, 0xE0, 0x19, 0x86, 0x43, 0x3F, 0x0F, 0x00, 0x31, 0x8D, 0xF6, 0x31,
  0x8C, 0x62, 0x31, 0x8E, 0x30, 0x61, 0x63, 0x43, 0x43, 0xC3, 0xC2, 0xC6,
  0xC6, 0xC6, 0xFE, 0x76, 0xC3, 0xC2, 0x46, 0x44, 0x4C, 0x6C, 0x68, 0x78,
  0x70, 0x30, 0x20, 0xC2, 0x16, 0x31, 0x91, 0x8C, 0x9C, 0xC4, 0xB6, 0x2D,
  0xA1, 0x4F, 0x0E, 0x70, 0x73, 0x83, 0x0C, 0x18, 0x40, 0x18, 0xC6, 0x61,
  0xB0, 0x2C, 0x0E, 0x03, 0x00, 0xE0, 0x78, 0x32, 0x0C, 0xC6, 0x30, 0x30,
  0xCC, 0x61, 0x18, 0x44, 0x13, 0x06, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x30, 0x3C, 0x0E, 0x00, 0x3F, 0x9F, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x7F, 0x3F, 0x80, 0x04, 0x31, 0x84, 0x30, 0xC3,
  0x0C, 0x23, 0x8C, 0x10, 0x61, 0x86, 0x10, 0x41, 0x06, 0x08, 0x18, 0x84,
  0x23, 0x18, 0xC4, 0x21, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x00, 0x10, 0x30,
  0x20, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x1C, 0x38, 0xC1, 0x86, 0x0C, 0x18,
  0x30, 0x41, 0x84, 0x00, 0x38, 0xDF, 0x3C, 0xFB, 0x1C,
};

const GFXglyph RobotoCondensed_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 5, 1, -15 },
  { 9, 5, 5, 7, 2, -16 },
  { 13, 10, 15, 11, 1, -15 },
  { 32, 9, 19, 10, 1, -17 },
  { 54, 10, 15, 13, 2, -15 },
  { 73, 9, 15, 11, 1, -15 },
  { 90, 2, 5, 4, 2, -16 },
  { 92, 6, 22, 6, 1, -17 },
  { 109, 6, 22, 6, -1, -17 },
  { 126, 8, 9, 9, 1, -15 },
  { 135, 9, 11, 10, 1, -12 },
  { 148, 3, 5, 4, -1, -2 },
  { 150, 5, 2, 5, 0, -8 },
  { 152, 2, 2, 5, 1, -2 },
  { 153, 9, 16, 8, -1, -15 },
  { 171, 9, 15, 10, 1, -15 },
  { 188, 6, 15, 10, 2, -15 },
  { 200, 10, 15, 10, 0, -15 },
  { 219, 8, 15, 10, 1, -15 },
  { 234, 9, 15, 10, 0, -15 },
  { 251, 9, 15, 10, 1, -15 },
  { 268, 8, 15, 10, 1, -15 },
  { 283, 10, 15, 10, 1, -15 },
  { 302, 9, 15, 10, 1, -15 },
  { 319, 7, 15, 10, 2, -15 },
  { 333, 4, 11, 5, 0, -11 },
  { 339, 5, 14, 4, -1, -11 },
  { 348, 8, 9, 9, 1, -11 },
  { 357, 8, 6, 10, 1, -10 },
  { 363, 8, 9, 9, 1, -11 },
  { 372, 7, 15, 9, 2, -15 },
  { 386, 14, 20, 16, 1, -15 },
  { 421, 11, 15, 12, -1, -15 },
  { 442, 11, 15, 11, 0, -15 },
  { 463, 10, 15, 12, 1, -15 },
  { 482, 11, 15, 12, 0, -15 },
  { 503, 11, 15, 10, 0, -15 },
  { 524, 11, 15, 10, 0, -15 },
  { 545, 10, 15, 12, 1, -15 },
  { 564, 13, 15, 13, 0, -15 },
  { 589, 4, 15, 5, 1, -15 },
  { 597, 10, 15, 10, 0, -15 },
  { 616, 12, 15, 11, 0, -15 },
  { 639, 8, 15, 10, 0, -15 },
  { 654, 15, 15, 15, 0, -15 },
  { 683, 13, 15, 13, 0, -15 },
  { 708, 11, 15, 12, 1, -15 },
  { 729, 11, 15, 11, 0, -15 },
  { 750, 10, 18, 12, 1, -15 },
  { 773, 11, 15, 11, 0, -15 },
  { 794, 11, 15, 11, 0, -15 },
  { 815, 10, 15, 11, 2, -15 },
  { 834, 11, 15, 11, 1, -15 },
  { 855, 10, 15, 11, 2, -15 },
  { 874, 14, 15, 16, 2, -15 },
  { 901, 12, 15, 11, 0, -15 },
  { 924, 10, 15, 11, 2, -15 },
  { 943, 11, 15, 11, 0, -15 },
  { 964, 6, 20, 5, 0, -17 },
  { 979, 4, 16, 8, 2, -15 },
  { 987, 6, 20, 5, -1, -17 },
  { 1002, 6, 7, 8, 1, -15 },
  { 1008, 8, 2, 8, -1, 0 },
  { 1010, 4, 3, 6, 2, -16 },
  { 1012, 8, 11, 10, 1, -11 },
  { 1023, 9, 16, 10, 0, -16 },
  { 1041, 8, 11, 9, 1, -11 },
  { 1052, 9, 16, 10, 1, -16 },
  { 1070, 8, 11, 10, 1, -11 },
  { 1081, 7, 16, 6, 1, -16 },
  { 1095, 10, 15, 10, 0, -11 },
  { 1114, 9, 16, 10, 0, -16 },
  { 1132, 5, 15, 5, 0, -15 },
  { 1142, 7, 19, 5, -2, -15 },
  { 1159, 10, 16, 9, 0, -16 },
  { 1179, 5, 16, 5, 0, -16 },
  { 1189, 14, 11, 15, 0, -11 },
  { 1209, 9, 11, 10, 0, -11 },
  { 1222, 8, 11, 10, 1, -11 },
  { 1233, 10, 15, 10, -1, -11 },
  { 1252, 9, 15, 10, 1, -11 },
  { 1269, 7, 11, 6, 0, -11 },
  { 1279, 9, 11, 9, 0, -11 },
  { 1292, 5, 14, 6, 1, -14 },
  { 1301, 8, 11, 10, 1, -11 },
  { 1312, 8, 11, 9, 1, -11 },
  { 1323, 13, 11, 13, 1, -11 },
  { 1341, 10, 11, 9, -1, -11 },
  { 1355, 10, 15, 8, -1, -11 },
  { 1374, 9, 11, 9, 0, -11 },
  { 1387, 6, 20, 6, 1, -16 },
  { 1402, 5, 18, 5, 0, -15 },
  { 1414, 7, 20, 6, -1, -16 },
  { 1432, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_Italic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_ITALIC21PT7B_H_
