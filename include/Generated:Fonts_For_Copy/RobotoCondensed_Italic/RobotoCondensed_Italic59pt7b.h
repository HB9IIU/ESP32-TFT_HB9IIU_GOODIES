#ifndef _ROBOTOCONDENSED_ITALIC59PT7B_H_
#define _ROBOTOCONDENSED_ITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x20, 0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF,
  0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x87, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0F, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x10, 0x78, 0x1E, 0x01, 0x87, 0x81, 0xE0, 0x3C,
  0x78, 0x1E, 0x07, 0x87, 0x01, 0xE0, 0x78, 0x70, 0x1E, 0x0F, 0x07, 0x01,
  0xE1, 0xE0, 0x70, 0x1E, 0x1E, 0x07, 0x01, 0xE3, 0xC0, 0x70, 0x3C, 0x78,
  0x07, 0x83, 0xCF, 0x80, 0x78, 0x78, 0xF0, 0x03, 0xFF, 0x9E, 0x00, 0x3F,
  0xF3, 0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x02, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x7F, 0x00,
  0x03, 0xCF, 0xF8, 0x00, 0x79, 0xFF, 0xC0, 0x0F, 0x1E, 0x1E, 0x00, 0xF3,
  0xC1, 0xE0, 0x1E, 0x3C, 0x0E, 0x03, 0xC7, 0x80, 0xE0, 0x7C, 0x78, 0x0E,
  0x07, 0x87, 0x80, 0xE0, 0xF0, 0x78, 0x0E, 0x1E, 0x07, 0x81, 0xE1, 0xE0,
  0x78, 0x1E, 0x3C, 0x07, 0x81, 0xE7, 0x80, 0x78, 0x1E, 0x18, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x1E,
  0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x9F, 0xC0,
  0x01, 0xF7, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xDF, 0x03, 0xE3, 0xF3, 0xF0, 0x78, 0xFC, 0x3E,
  0x0F, 0x3F, 0x07, 0xE1, 0xE7, 0xC0, 0x7C, 0x7D, 0xF8, 0x0F, 0xCF, 0x3E,
  0x00, 0xFB, 0xE7, 0xC0, 0x1F, 0xFC, 0xF8, 0x01, 0xFF, 0x1F, 0x00, 0x3F,
  0xE3, 0xE0, 0x03, 0xF8, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF,
  0x01, 0xFF, 0xF3, 0xF0, 0x1F, 0xF8, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x3C,
  0xF3, 0xCF, 0x7D, 0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x18, 0x1E, 0x07, 0x7E, 0x3C, 0x7E,
  0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x1F,
  0x1E, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x3C, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x06, 0x00, 0xE0, 0x04, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x1C, 0x02, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFD, 0xFB, 0xF7, 0xEF, 0x84,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xBE, 0xF8, 0x7D, 0xC0, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x07, 0xBF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x8F, 0xE0, 0x7E,
  0x7F, 0x00, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7E, 0x03, 0xE0, 0xFC,
  0x3F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xC3, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00,
  0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x9F, 0x81, 0xFE, 0x3F, 0x9F, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x7C, 0x03, 0xF1, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x00, 0x80, 0x00, 0x38,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0xF8, 0x01, 0xF8, 0x01, 0xC1, 0xE0,
  0x0F, 0xFC, 0x03, 0x87, 0x80, 0x3F, 0xFC, 0x07, 0x0F, 0x00, 0xFF, 0xFC,
  0x0E, 0x3C, 0x03, 0xE0, 0x78, 0x1C, 0x78, 0x0F, 0x81, 0xE0, 0x38, 0xF0,
  0x1E, 0x03, 0xC0, 0x73, 0xC0, 0x7C, 0x07, 0x80, 0xE7, 0x80, 0xF0, 0x0F,
  0x01, 0xCF, 0x03, 0xE0, 0x3C, 0x03, 0xBC, 0x07, 0x80, 0x78, 0x07, 0x78,
  0x0F, 0x00, 0xF0, 0x0E, 0xF0, 0x3E, 0x01, 0xE0, 0x1D, 0xE0, 0x78, 0x07,
  0x80, 0x7B, 0x80, 0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xDE,
  0x07, 0xC0, 0x3C, 0x03, 0xBC, 0x0F, 0x80, 0xF0, 0x0F, 0x78, 0x1F, 0x01,
  0xE0, 0x1E, 0xF0, 0x3C, 0x03, 0xC0, 0x39, 0xE0, 0x78, 0x0F, 0x80, 0xF3,
  0xC0, 0xF0, 0x1F, 0x01, 0xC7, 0x81, 0xF0, 0x7E, 0x07, 0x8F, 0x03, 0xE1,
  0xFC, 0x1E, 0x1E, 0x03, 0xFF, 0xF8, 0x7C, 0x3C, 0x07, 0xFE, 0xFF, 0xF0,
  0x78, 0x0F, 0xF8, 0xFF, 0xC0, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x02,
  0x00, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00,
  0x00, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7E,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F,
  0xB3, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0x8F, 0x80, 0x3F, 0xFC, 0x7C, 0x01, 0xFF,
  0xE3, 0xE0, 0x1F, 0xFF, 0x3F, 0x00, 0xFF, 0xF9, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x0F, 0x8F, 0xE0,
  0x00, 0x07, 0xCF, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x1F, 0xE3,
  0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x3E, 0xF0, 0x0F, 0x7C, 0x00, 0x0F, 0xFC,
  0x07, 0xDF, 0x00, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x7C,
  0xF0, 0x00, 0xF9, 0xF0, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x07, 0xCF, 0x00,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x03,
  0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0, 0x3E, 0x1E,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x1E, 0x0F, 0xC0, 0x7C, 0x0F, 0x0F, 0x83, 0xE0,
  0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x07, 0xC0, 0xF1, 0xF0, 0x3E, 0x03, 0xF0,
  0x3C, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x3E, 0x03, 0xEF,
  0x01, 0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x1F,
  0x00, 0x7F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F,
  0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x3E, 0xF0, 0x01,
  0xF0, 0x0F, 0xBC, 0x00, 0x7C, 0x07, 0xEF, 0x80, 0x1F, 0x01, 0xF9, 0xE0,
  0x07, 0xC0, 0x7C, 0x78, 0x01, 0xF0, 0x1F, 0x1F, 0x00, 0xFC, 0x07, 0xC3,
  0xC0, 0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x80,
  0xF8, 0x0F, 0x07, 0xC0, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x7C,
  0x07, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x01, 0xF3,
  0xF0, 0x1F, 0x00, 0x3C, 0xF8, 0x07, 0xC0, 0x0F, 0x3E, 0x03, 0xF0, 0x03,
  0xEF, 0x80, 0xF8, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x1E, 0xF8, 0x0F, 0x80,
  0x07, 0xFE, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x33, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x80, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00,
  0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0xF8,
  0x03, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xDE, 0x01, 0xF0, 0xF8, 0x07, 0xDE,
  0x01, 0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xF0, 0xF8, 0x07, 0x9E, 0x03, 0xE0,
  0xF8, 0x0F, 0x9E, 0x03, 0xE0, 0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0xF8, 0x0F,
  0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x1E, 0x07, 0xC0, 0x78, 0x1E, 0x1E, 0x07,
  0xC0, 0x78, 0x3E, 0x1E, 0x0F, 0x80, 0x78, 0x3C, 0x1E, 0x0F, 0x80, 0x78,
  0x3C, 0x1E, 0x0F, 0x80, 0x78, 0x7C, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x0E,
  0x1F, 0x00, 0x78, 0x78, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x0F, 0x3E, 0x00,
  0x78, 0xF0, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x0F, 0x3C, 0x00, 0x7D, 0xE0,
  0x0F, 0x7C, 0x00, 0x7D, 0xE0, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE1, 0xE0, 0xF0, 0x78,
  0x7C, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xF0, 0x1F, 0x78,
  0x07, 0xC0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE,
  0x03, 0xE7, 0xF0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF,
  0x80, 0x7F, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xBF, 0x07, 0xF8, 0xFC, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x7F, 0xC0, 0x1F, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xFC, 0x03, 0xF1, 0xFF, 0x07, 0xF0,
  0xFB, 0xFF, 0xF8, 0x7D, 0xFF, 0xF8, 0x3E, 0x7F, 0xF8, 0x1E, 0x1F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F,
  0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01,
  0xFE, 0x1F, 0x00, 0xFF, 0xF3, 0xE0, 0x3F, 0xFE, 0x78, 0x0F, 0xFF, 0xFF,
  0x01, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xF7, 0xC0, 0x07, 0xFC, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0x3C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x81, 0xF0, 0x03, 0x83, 0xF8, 0x1F, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x7C, 0x03, 0xFF, 0xCF, 0x80, 0xFF, 0xF9, 0xF0, 0x3F,
  0xFF, 0xBC, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0x00, 0x1F, 0xF3, 0xE0, 0x00, 0x20, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x02, 0x00,
  0x1F, 0x00, 0x60, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xCF, 0xF0, 0x07, 0xDF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7F,
  0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x9F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0xF0, 0x1F, 0x87,
  0xC0, 0x1F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x01, 0xF1, 0xF0, 0x03,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xF0, 0x07, 0xDF, 0xFC, 0x07, 0xBF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xC0, 0x07,
  0x9F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x1F,
  0xF0, 0x7F, 0x03, 0xEF, 0xFF, 0xC0, 0x7D, 0xFF, 0xF8, 0x0F, 0x9F, 0xFC,
  0x01, 0xF1, 0xFF, 0x00, 0x3E, 0x02, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC7, 0xC0, 0xFF, 0xF3, 0xE0, 0xFF, 0xFD, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x07, 0xF8, 0x7E, 0x01, 0xFC, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xC0, 0x1F, 0xF3,
  0xE0, 0x00, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF8, 0x3F, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x01, 0x80, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF3, 0xE0, 0x01, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x1F,
  0x3E, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0xFE, 0x01, 0xF3, 0xE0, 0x3F, 0xC0,
  0xF8, 0xF8, 0x1F, 0xF0, 0x3E, 0x3E, 0x07, 0xFC, 0x0F, 0x07, 0x83, 0xEF,
  0x07, 0xC1, 0xE0, 0xF3, 0xC1, 0xF0, 0x78, 0x7C, 0xF0, 0xF8, 0x1E, 0x1E,
  0x3C, 0x3E, 0x07, 0x87, 0x8F, 0x0F, 0x01, 0xE3, 0xE3, 0xC7, 0xC0, 0x78,
  0xF0, 0xF1, 0xE0, 0x1E, 0x7C, 0x3C, 0xF8, 0x07, 0x9E, 0x0F, 0x3E, 0x01,
  0xEF, 0x83, 0xEF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x3E,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x00, 0xF3, 0xFF,
  0xE0, 0x1E, 0x3F, 0xFF, 0x01, 0xE7, 0xC3, 0xF0, 0x3E, 0x78, 0x1F, 0x83,
  0xC7, 0x80, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xF8, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 43, 14, 2, -42 },
  { 66, 14, 14, 18, 6, -44 },
  { 91, 29, 42, 31, 3, -42 },
  { 244, 25, 55, 28, 2, -49 },
  { 416, 28, 44, 36, 5, -43 },
  { 570, 27, 44, 31, 2, -43 },
  { 719, 6, 14, 10, 5, -44 },
  { 730, 18, 61, 18, 3, -47 },
  { 868, 18, 61, 18, -3, -47 },
  { 1006, 23, 24, 25, 3, -42 },
  { 1075, 25, 30, 28, 2, -34 },
  { 1169, 10, 15, 11, -3, -6 },
  { 1188, 12, 4, 14, 1, -20 },
  { 1194, 7, 7, 15, 1, -6 },
  { 1201, 27, 46, 21, -3, -42 },
  { 1357, 24, 44, 28, 3, -43 },
  { 1489, 15, 42, 28, 7, -42 },
  { 1568, 26, 43, 28, 1, -43 },
  { 1708, 24, 44, 28, 2, -43 },
  { 1840, 26, 42, 28, 0, -42 },
  { 1977, 26, 43, 28, 3, -42 },
  { 2117, 22, 43, 28, 3, -42 },
  { 2236, 26, 42, 28, 4, -42 },
  { 2373, 25, 44, 28, 2, -43 },
  { 2511, 22, 43, 28, 4, -43 },
  { 2630, 11, 32, 14, 1, -31 },
  { 2674, 15, 40, 12, -3, -31 },
  { 2749, 22, 26, 26, 2, -32 },
  { 2821, 23, 17, 27, 3, -28 },
  { 2870, 23, 26, 26, 2, -32 },
  { 2945, 19, 44, 24, 5, -43 },
  { 3050, 39, 54, 44, 2, -41 },
  { 3314, 31, 42, 33, -2, -42 },
  { 3477, 29, 42, 31, 1, -42 },
  { 3630, 29, 44, 32, 3, -43 },
  { 3790, 30, 42, 33, 1, -42 },
  { 3948, 29, 42, 28, 1, -42 },
  { 4101, 29, 42, 28, 1, -42 },
  { 4254, 29, 44, 34, 3, -43 },
  { 4414, 34, 42, 36, 1, -42 },
  { 4593, 12, 42, 14, 2, -42 },
  { 4656, 28, 43, 28, 0, -42 },
  { 4807, 33, 42, 31, 1, -42 },
  { 4981, 22, 42, 27, 1, -42 },
  { 5097, 42, 42, 43, 1, -42 },
  { 5318, 34, 42, 35, 1, -42 },
  { 5497, 29, 44, 34, 3, -43 },
  { 5657, 31, 42, 32, 1, -42 },
  { 5820, 29, 50, 34, 3, -43 },
  { 6002, 29, 42, 30, 1, -42 },
  { 6155, 29, 44, 30, 1, -43 },
  { 6315, 27, 42, 30, 5, -42 },
  { 6457, 31, 43, 32, 2, -42 },
  { 6624, 30, 42, 32, 5, -42 },
  { 6782, 40, 42, 44, 6, -42 },
  { 6992, 35, 42, 32, -1, -42 },
  { 7176, 29, 42, 30, 5, -42 },
  { 7329, 31, 42, 30, 0, -42 },
  { 7492, 18, 57, 14, 0, -48 },
  { 7621, 11, 46, 21, 6, -42 },
  { 7685, 18, 57, 14, -3, -48 },
  { 7814, 18, 21, 21, 2, -42 },
  { 7862, 23, 4, 23, -3, 0 },
  { 7874, 10, 8, 18, 6, -44 },
  { 7884, 22, 33, 27, 2, -32 },
  { 7975, 25, 45, 28, 1, -44 },
  { 8116, 23, 33, 26, 2, -32 },
  { 8211, 27, 45, 28, 2, -44 },
  { 8363, 23, 33, 27, 2, -32 },
  { 8458, 19, 45, 18, 3, -45 },
  { 8565, 27, 44, 28, 0, -32 },
  { 8714, 24, 44, 28, 1, -44 },
  { 8846, 12, 42, 13, 1, -42 },
  { 8909, 19, 54, 13, -6, -42 },
  { 9038, 26, 44, 26, 1, -44 },
  { 9181, 13, 44, 13, 1, -44 },
  { 9253, 39, 32, 43, 1, -32 },
  { 9409, 24, 32, 28, 1, -32 },
  { 9505, 24, 33, 29, 2, -32 },
  { 9604, 27, 44, 28, -1, -32 },
  { 9753, 25, 44, 29, 2, -32 },
  { 9891, 18, 32, 17, 1, -32 },
  { 9963, 23, 33, 26, 1, -32 },
  { 10058, 15, 40, 17, 2, -39 },
  { 10133, 24, 32, 28, 2, -31 },
  { 10229, 21, 31, 24, 4, -31 },
  { 10311, 34, 31, 37, 4, -31 },
  { 10443, 27, 31, 25, -1, -31 },
  { 10548, 28, 43, 24, -3, -31 },
  { 10699, 25, 31, 25, 0, -31 },
  { 10796, 18, 57, 18, 2, -46 },
  { 10925, 12, 50, 14, 1, -42 },
  { 11000, 19, 57, 18, -3, -46 },
  { 11136, 28, 12, 34, 3, -24 },
};

const GFXfont RobotoCondensed_Italic59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Italic59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Italic59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_ITALIC59PT7B_H_
