#ifndef _NOTOSANS_CONDENSED_BLACKITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x66, 0x66, 0x0C, 0xC0, 0x7F, 0x6D, 0x80, 0x1E, 0x16, 0x7F,
  0x7E, 0x2C, 0xFE, 0xFE, 0x58, 0xD8, 0x08, 0x7D, 0xF3, 0x87, 0x07, 0x87,
  0x6E, 0xF8, 0x40, 0x80, 0x73, 0x3C, 0x8B, 0x62, 0xF6, 0xEB, 0x87, 0xB3,
  0x68, 0xDE, 0x63, 0x00, 0x3E, 0x36, 0x3E, 0x3C, 0x7B, 0xFF, 0xCE, 0xFE,
  0x7F, 0x7B, 0x00, 0x19, 0x8C, 0xC6, 0x33, 0x18, 0xC6, 0x30, 0xC0, 0x30,
  0xC6, 0x31, 0x8C, 0x66, 0x31, 0x19, 0x80, 0x32, 0xCF, 0xDF, 0xF1, 0x60,
  0x21, 0x09, 0xF2, 0x10, 0x80, 0x76, 0x6C, 0xFE, 0xF0, 0x07, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x3C, 0x79, 0xBB, 0x66, 0xDD, 0xBF,
  0x3C, 0x70, 0x1B, 0xFE, 0xF3, 0x18, 0xC6, 0x70, 0x3D, 0xF2, 0xC3, 0x18,
  0xC6, 0x3F, 0xF8, 0x7C, 0x5C, 0x31, 0xE3, 0x83, 0x87, 0x7C, 0xF0, 0x0E,
  0x38, 0xF1, 0x67, 0xDF, 0xBF, 0x0C, 0x38, 0x3E, 0x78, 0xC3, 0xC7, 0xC1,
  0x87, 0x7C, 0xF8, 0x1E, 0x75, 0x83, 0xE7, 0xDD, 0xBB, 0x3E, 0x78, 0x3E,
  0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0xE0, 0x3C, 0xFD, 0xB1, 0xE3, 0x8D,
  0xB3, 0x7E, 0x78, 0x3C, 0xF9, 0xBB, 0x67, 0xCF, 0x86, 0x7C, 0xF0, 0x76,
  0x00, 0x0E, 0xC0, 0x39, 0x80, 0x00, 0x39, 0x8C, 0xC0, 0x09, 0xFD, 0x87,
  0x8C, 0x20, 0xFF, 0xC1, 0xFF, 0x80, 0x87, 0x1E, 0x3F, 0x62, 0x00, 0xFF,
  0xC6, 0xE6, 0x60, 0x18, 0xC0, 0x1F, 0x8C, 0x26, 0xFD, 0x6B, 0x52, 0xF5,
  0xAD, 0xFB, 0x28, 0x62, 0x0F, 0x80, 0x0E, 0x0E, 0x1E, 0x1E, 0x37, 0x3F,
  0x7F, 0x67, 0xE7, 0x3E, 0x7D, 0xDB, 0xF7, 0xCD, 0xDB, 0x7E, 0xF8, 0x1E,
  0x7D, 0xC3, 0x06, 0x1C, 0x18, 0x3E, 0x7C, 0x3E, 0x3E, 0x77, 0x66, 0x66,
  0x66, 0x6E, 0xFC, 0xF8, 0x3E, 0x79, 0xC3, 0xE7, 0x8C, 0x18, 0x7C, 0xF8,
  0x3E, 0x79, 0xC3, 0x27, 0x8C, 0x18, 0x70, 0xC0, 0x3E, 0xFB, 0x86, 0x0D,
  0xD9, 0xB3, 0x7E, 0x78, 0x33, 0x33, 0x77, 0x7E, 0x7E, 0x66, 0x66, 0xEE,
  0xCC, 0x7C, 0xC3, 0x0C, 0x31, 0xC6, 0x3C, 0xF0, 0x0C, 0x31, 0xC7, 0x18,
  0x61, 0x8E, 0x30, 0xCF, 0x38, 0x37, 0x36, 0x7E, 0x7C, 0x78, 0x7C, 0x6C,
  0xEC, 0xCE, 0x31, 0x9C, 0xC6, 0x31, 0x9F, 0xF8, 0x39, 0xE7, 0x39, 0xEF,
  0x3D, 0xE7, 0xEC, 0xFF, 0x1F, 0x66, 0xEC, 0xD9, 0x80, 0x39, 0x9C, 0xDE,
  0xCF, 0x66, 0xF3, 0x79, 0xBD, 0x9C, 0xCE, 0x00, 0x3C, 0xFF, 0x9E, 0x3C,
  0xF9, 0xF3, 0x7E, 0xF8, 0x3E, 0x7D, 0xDB, 0x77, 0xCF, 0x18, 0x70, 0xC0,
  0x3C, 0xFF, 0x9E, 0x3C, 0xF9, 0xF3, 0x7E, 0xF8, 0x70, 0x60, 0x3E, 0x7D,
  0xDB, 0x77, 0xCF, 0x1F, 0x76, 0xCE, 0x3E, 0xF9, 0x83, 0x83, 0x83, 0xA6,
  0x7C, 0xF0, 0xFF, 0xF7, 0x1C, 0x61, 0x86, 0x38, 0xC0, 0x66, 0xDF, 0xBE,
  0x6C, 0xD9, 0xB7, 0x7C, 0xF0, 0xC7, 0x9B, 0x36, 0xED, 0x9B, 0x3C, 0x78,
  0xE0, 0xCC, 0xF9, 0x9B, 0x76, 0x6E, 0xCF, 0xD9, 0xFE, 0x3B, 0xC7, 0x78,
  0xEE, 0x00, 0x3B, 0x8D, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xF8, 0xEC, 0xE6,
  0x00, 0xEF, 0xD9, 0xE3, 0xC7, 0x0C, 0x18, 0x30, 0xE0, 0x3F, 0x3E, 0x0E,
  0x0C, 0x18, 0x38, 0x70, 0x7E, 0xFC, 0x1C, 0x71, 0x0C, 0x30, 0xC3, 0x18,
  0x61, 0x86, 0x3C, 0xC4, 0x66, 0x66, 0x66, 0x30, 0x1C, 0xE1, 0x86, 0x18,
  0x63, 0x0C, 0x30, 0xC2, 0x38, 0x18, 0x63, 0xDB, 0x6F, 0x30, 0xF8, 0xCC,
  0x3E, 0xFD, 0xB7, 0x6E, 0xDF, 0x9A, 0x00, 0x30, 0x60, 0xC3, 0xE7, 0xED,
  0xDB, 0x76, 0xFD, 0xF0, 0x3D, 0xE6, 0x38, 0xE3, 0xE7, 0x80, 0x06, 0x0C,
  0x19, 0xF7, 0xED, 0xBB, 0x76, 0xFC, 0xD0, 0x3D, 0xB6, 0xFE, 0xC3, 0xE7,
  0x80, 0x0E, 0x38, 0x61, 0xE3, 0xC6, 0x0C, 0x18, 0x30, 0xC1, 0x87, 0x0C,
  0x00, 0x3E, 0xFD, 0xB7, 0x6E, 0xDF, 0x9E, 0x0C, 0xF9, 0xE0, 0x30, 0x60,
  0xC3, 0xE7, 0xED, 0x9B, 0x76, 0xCD, 0xB8, 0x33, 0x07, 0x66, 0x6E, 0xCC,
  0x0C, 0x30, 0x07, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x3C, 0xE0, 0x30, 0x30,
  0x31, 0x66, 0x6C, 0x78, 0x78, 0xF8, 0xDC, 0xCC, 0x33, 0x37, 0x66, 0x6E,
  0xCC, 0x7D, 0xDF, 0xF6, 0xCD, 0xB7, 0xED, 0xB3, 0x6D, 0xD8, 0x7C, 0xFD,
  0xB3, 0x6E, 0xD9, 0xB7, 0x00, 0x3D, 0xF6, 0xFB, 0xEF, 0xF7, 0x80, 0x3E,
  0x3F, 0x37, 0x36, 0x76, 0x7E, 0x7C, 0x60, 0x60, 0xE0, 0x3E, 0xFD, 0xB7,
  0x6E, 0xDF, 0x9E, 0x0C, 0x18, 0x70, 0x7D, 0xE6, 0x18, 0xE3, 0x0C, 0x00,
  0x7D, 0xA7, 0x1E, 0x3B, 0xEF, 0x00, 0x26, 0xFF, 0xCC, 0xCE, 0xE0, 0x76,
  0xDD, 0xB3, 0x6E, 0xDF, 0x9B, 0x00, 0xDF, 0x6D, 0xBC, 0xF3, 0x8E, 0x00,
  0xDD, 0xEF, 0xBE, 0xDD, 0x6E, 0xE7, 0x73, 0x30, 0x37, 0x3E, 0x1C, 0x1C,
  0x3C, 0x7C, 0xEE, 0x37, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0xF0,
  0xE0, 0x7D, 0xE3, 0x9C, 0x63, 0xEF, 0x00, 0x1C, 0xE3, 0x0C, 0xF3, 0x06,
  0x18, 0x61, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xE1, 0x8E, 0x1C,
  0x63, 0x0C, 0x63, 0x8E, 0x00, 0xEF, 0xE6,
};

const GFXglyph NotoSans_Condensed_BlackItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 6, 3, 6, 1, -9 },
  { 9, 8, 9, 7, 0, -9 },
  { 18, 7, 11, 7, 0, -10 },
  { 28, 10, 9, 11, 1, -9 },
  { 40, 8, 9, 8, 0, -9 },
  { 49, 3, 3, 3, 1, -9 },
  { 51, 5, 12, 4, 0, -10 },
  { 59, 5, 12, 4, -1, -10 },
  { 67, 6, 6, 6, 1, -10 },
  { 72, 5, 7, 7, 1, -8 },
  { 77, 4, 4, 4, -1, -2 },
  { 79, 4, 2, 4, 0, -4 },
  { 80, 2, 2, 4, 0, -2 },
  { 81, 8, 9, 5, -1, -9 },
  { 90, 7, 9, 7, 0, -9 },
  { 98, 5, 9, 7, 1, -9 },
  { 104, 6, 9, 7, 0, -9 },
  { 111, 7, 9, 7, 0, -9 },
  { 119, 7, 9, 7, 0, -9 },
  { 127, 7, 9, 7, 0, -9 },
  { 135, 7, 9, 7, 0, -9 },
  { 143, 7, 9, 7, 0, -9 },
  { 151, 7, 9, 7, 0, -9 },
  { 159, 7, 9, 7, 0, -9 },
  { 167, 4, 7, 4, 0, -7 },
  { 171, 5, 9, 4, -1, -7 },
  { 177, 5, 7, 7, 1, -8 },
  { 182, 5, 5, 7, 1, -7 },
  { 186, 5, 7, 7, 1, -8 },
  { 191, 5, 9, 5, 1, -9 },
  { 197, 10, 10, 10, 0, -9 },
  { 210, 8, 9, 7, -1, -9 },
  { 219, 7, 9, 7, 0, -9 },
  { 227, 7, 9, 7, 0, -9 },
  { 235, 8, 9, 8, 0, -9 },
  { 244, 7, 9, 6, 0, -9 },
  { 252, 7, 9, 6, 0, -9 },
  { 260, 7, 9, 8, 1, -9 },
  { 268, 8, 9, 8, 0, -9 },
  { 277, 6, 9, 5, 0, -9 },
  { 284, 6, 12, 4, -2, -9 },
  { 293, 8, 9, 7, 0, -9 },
  { 302, 5, 9, 6, 0, -9 },
  { 308, 11, 9, 10, 0, -9 },
  { 321, 9, 9, 9, 0, -9 },
  { 332, 7, 9, 8, 1, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 7, 11, 8, 1, -9 },
  { 358, 7, 9, 7, 0, -9 },
  { 366, 7, 9, 6, 0, -9 },
  { 374, 6, 9, 6, 1, -9 },
  { 381, 7, 9, 8, 1, -9 },
  { 389, 7, 9, 7, 1, -9 },
  { 397, 11, 9, 10, 1, -9 },
  { 410, 9, 9, 7, -1, -9 },
  { 421, 7, 9, 7, 1, -9 },
  { 429, 8, 9, 6, -1, -9 },
  { 438, 6, 12, 4, -1, -10 },
  { 447, 4, 9, 5, 1, -9 },
  { 452, 6, 12, 4, -1, -10 },
  { 461, 6, 6, 6, 0, -9 },
  { 466, 5, 1, 5, -1, 1 },
  { 467, 3, 2, 4, 2, -10 },
  { 468, 7, 7, 7, 0, -7 },
  { 475, 7, 10, 7, 0, -10 },
  { 484, 6, 7, 6, 0, -7 },
  { 490, 7, 10, 7, 0, -10 },
  { 499, 6, 7, 6, 0, -7 },
  { 505, 7, 13, 4, -1, -10 },
  { 517, 7, 10, 7, 0, -7 },
  { 526, 7, 10, 7, 0, -10 },
  { 535, 4, 10, 4, 0, -10 },
  { 540, 6, 13, 4, -2, -10 },
  { 550, 8, 10, 7, 0, -10 },
  { 560, 4, 10, 4, 0, -10 },
  { 565, 10, 7, 10, 0, -7 },
  { 574, 7, 7, 7, 0, -7 },
  { 581, 6, 7, 7, 0, -7 },
  { 587, 8, 10, 7, -1, -7 },
  { 597, 7, 10, 7, 0, -7 },
  { 606, 6, 7, 5, 0, -7 },
  { 612, 6, 7, 5, 0, -7 },
  { 618, 4, 9, 5, 1, -9 },
  { 623, 7, 7, 7, 0, -7 },
  { 630, 6, 7, 6, 1, -7 },
  { 636, 9, 7, 9, 1, -7 },
  { 644, 8, 7, 6, -1, -7 },
  { 651, 8, 10, 6, -1, -7 },
  { 661, 6, 7, 5, 0, -7 },
  { 667, 6, 11, 5, 0, -9 },
  { 676, 2, 13, 6, 2, -10 },
  { 680, 6, 11, 5, -1, -9 },
  { 689, 5, 3, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_BlackItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC13PT7B_H_
