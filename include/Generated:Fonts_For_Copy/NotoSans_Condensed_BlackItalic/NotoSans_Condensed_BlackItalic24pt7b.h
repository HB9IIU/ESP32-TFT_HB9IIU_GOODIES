#ifndef _NOTOSANS_CONDENSED_BLACKITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78,
  0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0xF7,
  0xBD, 0xE0, 0x03, 0xBC, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xC3, 0xB8, 0x1C, 0xE0, 0x73, 0x8F, 0xFF, 0xBF, 0xFE, 0x39,
  0xC0, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0x77, 0x00, 0x00, 0x80, 0x18, 0x0F,
  0xF1, 0xFF, 0x1F, 0xE3, 0xD2, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x47, 0xE6, 0x5E, 0x7F, 0xCF, 0xF8, 0x7F, 0x00, 0xC0, 0x08,
  0x00, 0x1F, 0x07, 0x0F, 0xC3, 0x87, 0xF1, 0xE1, 0xDC, 0x70, 0x77, 0x38,
  0x39, 0xCE, 0x0E, 0x77, 0x13, 0xFB, 0xDF, 0x7E, 0xEF, 0xDF, 0x77, 0xF0,
  0x1D, 0xDC, 0x0E, 0x77, 0x07, 0x3D, 0xC1, 0xCE, 0x70, 0xE1, 0xF8, 0x78,
  0x7E, 0x1C, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF3, 0xC1,
  0xEF, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xEF, 0x3F, 0x9E, 0xFF, 0xFD, 0xEF,
  0xF7, 0x9F, 0xCF, 0x1F, 0x9F, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x7C,
  0x7B, 0xDC, 0xEF, 0x78, 0x03, 0x83, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1C, 0x0E, 0x07, 0x83, 0xC0, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x1E,
  0x0E, 0x0F, 0x07, 0x07, 0x87, 0x80, 0x0F, 0x03, 0x8E, 0xE3, 0xFF, 0xFF,
  0xCF, 0xF3, 0xE1, 0xFC, 0xF7, 0x09, 0xE2, 0x20, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x3D, 0xE7, 0x9C, 0xF3, 0x80, 0x7E, 0xFF, 0xF8, 0x77, 0xFD, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0xFF, 0x9E, 0xF7, 0x9E, 0xF3, 0xDE,
  0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xCF, 0x79, 0xEF, 0x7D, 0xEF, 0x3F, 0xC7,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE1, 0xF8, 0xFE, 0x7F, 0xBD, 0xE6, 0xF1,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x1D, 0xF0, 0xC7, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0xF1,
  0xFF, 0x8F, 0xFC, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0x8F, 0x00,
  0xF0, 0x1E, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xE0, 0x3E, 0x03,
  0xEC, 0x7C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0xFE, 0x1F, 0xE1, 0xDE, 0x3B, 0xC7, 0x3C, 0x7F, 0xFF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x07, 0x80, 0x78, 0x07, 0x80, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF1, 0xE0, 0x1E, 0x01, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0x3E,
  0x01, 0xE0, 0x1E, 0x03, 0xEE, 0x7C, 0xFF, 0xCF, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x1F, 0xE3, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xCF, 0xFC, 0xFF,
  0xCF, 0xBC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x7C, 0xFF, 0x87, 0xF0, 0x3E,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF7, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xEF, 0x1C, 0xF1, 0xEF,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7B, 0xE7, 0x9E, 0xF1, 0xEF, 0x3E,
  0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF8, 0xFF, 0xBE, 0xF7, 0x9E,
  0xF3, 0xFE, 0x7F, 0xDF, 0xFF, 0xEF, 0xF9, 0xFF, 0x01, 0xC0, 0x79, 0x1E,
  0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0x1E, 0x7C, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE3, 0xE7, 0x8F, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x20, 0x1C,
  0x0F, 0x87, 0xF3, 0xF9, 0xFC, 0x3E, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x07,
  0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xF8, 0x7F, 0x7F, 0x9F, 0xC3, 0xC0, 0x60, 0x00, 0x3F, 0x9F, 0xE7, 0xFD,
  0x8F, 0x03, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0E, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xC3,
  0xC7, 0x80, 0x73, 0x8F, 0xBB, 0x9F, 0xDD, 0xDE, 0xEF, 0xCE, 0x77, 0xEE,
  0x73, 0xF7, 0x39, 0xF3, 0x9C, 0xD9, 0xDE, 0xEC, 0xFF, 0xE7, 0x3D, 0xE3,
  0x80, 0x01, 0xE0, 0x20, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF,
  0x1E, 0x78, 0xF3, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0xBF, 0xFD, 0xE1, 0xFF,
  0x0F, 0xF0, 0x78, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3C, 0xF1, 0xE7, 0x9F,
  0x3C, 0xF7, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x9F, 0x3C, 0xF1, 0xE7, 0x9F,
  0x3D, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xC7, 0xFC,
  0x7C, 0x47, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xBF, 0x1E, 0x7C, 0xF9, 0xF3, 0xC7, 0xCF,
  0x1F, 0x3C, 0x7C, 0xF1, 0xE7, 0xC7, 0x9E, 0x3E, 0x79, 0xF1, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E,
  0x03, 0xE0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x8F, 0xC4, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0xFE, 0xFB,
  0xF3, 0xCF, 0xCF, 0x0F, 0x3C, 0x3C, 0xF9, 0xF3, 0xF7, 0x87, 0xFE, 0x1F,
  0xF8, 0x3F, 0xC0, 0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xE3,
  0xC7, 0xC7, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xF1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xF0, 0x0F,
  0xF1, 0xFF, 0x0F, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x1F, 0x1F,
  0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x1E, 0xF0, 0x3F, 0xF0, 0x3D, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7B, 0xE0, 0x79, 0xE0,
  0x79, 0xE0, 0x79, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0x1F, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xFD,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC,
  0x3F, 0xBF, 0xC3, 0xBB, 0xBC, 0x7B, 0xFF, 0x87, 0xBF, 0x78, 0x7B, 0xF7,
  0x87, 0xBE, 0x78, 0x73, 0xE7, 0x8F, 0x3C, 0xF0, 0xF3, 0xCF, 0x00, 0x1F,
  0x87, 0x8F, 0xC7, 0x87, 0xE3, 0xC3, 0xF1, 0xE1, 0xF8, 0xF1, 0xFE, 0xF0,
  0xFF, 0x78, 0x7F, 0xBC, 0x3F, 0xDE, 0x1C, 0xEF, 0x1E, 0x7F, 0x0F, 0x3F,
  0x87, 0x9F, 0xC3, 0xCF, 0xE1, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x7C, 0x7D, 0xF1, 0xF7, 0x87,
  0xFE, 0x1F, 0xF8, 0x7B, 0xC1, 0xEF, 0x0F, 0xBC, 0x3E, 0xF1, 0xF3, 0xEF,
  0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3D,
  0xF1, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0xBE, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x7C, 0x7D, 0xF1, 0xF7, 0x87, 0xFE, 0x1F,
  0xF8, 0x7B, 0xC1, 0xEF, 0x0F, 0xBC, 0x3E, 0xF1, 0xF3, 0xEF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x3F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x1F,
  0xE0, 0xFF, 0x87, 0xFE, 0x3D, 0xF1, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0xFE,
  0x3F, 0xF1, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBE, 0x3C, 0xF1, 0xE7, 0x9F,
  0x3E, 0xF1, 0xF0, 0x0F, 0xF1, 0xFF, 0x1F, 0xE3, 0xE6, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x83, 0xCF, 0xFC,
  0xFF, 0x8F, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x79, 0xF1, 0xE7, 0x8F, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x8F,
  0x3C, 0x78, 0xF1, 0xE3, 0xEF, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0xF0,
  0xFF, 0x87, 0xBC, 0x3D, 0xE3, 0xEF, 0x1E, 0x79, 0xF3, 0xCF, 0x1E, 0x78,
  0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x8F, 0x79, 0xF1,
  0xEF, 0x3E, 0x7D, 0xE7, 0xCF, 0x3D, 0xF9, 0xE7, 0xBF, 0x78, 0xFF, 0xEF,
  0x1F, 0xDD, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF8, 0xF8, 0xFF, 0xCF, 0x9E, 0x78, 0xF7,
  0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xFF, 0x87, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0xF1, 0xC7, 0x1C, 0x79,
  0xE7, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3, 0xC7, 0x1C, 0x07, 0xE0, 0xF8,
  0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x3E,
  0x07, 0xC1, 0xF8, 0x00, 0x03, 0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xC1,
  0xFC, 0x1D, 0xE3, 0xCE, 0x78, 0xE7, 0x0E, 0xF0, 0xF0, 0xFF, 0xFF, 0xF0,
  0xF9, 0xE3, 0xC0, 0x08, 0x01, 0xEF, 0x3F, 0xE7, 0xFE, 0x79, 0xEF, 0x1E,
  0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xCF, 0xF8, 0xFB, 0x87, 0xB8,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x41, 0xDE, 0x3F, 0xF3, 0xFF,
  0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0x7B, 0xEF, 0xFC,
  0xFF, 0xCE, 0x78, 0x02, 0x07, 0xF3, 0xF9, 0xFE, 0x78, 0xBC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x33, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x8F, 0x1F, 0x78, 0xFF, 0x8F, 0xFC, 0x79, 0xE7,
  0xCF, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x1F, 0xF0, 0xFF,
  0x83, 0xDC, 0x00, 0x1F, 0xC7, 0xF9, 0xFF, 0xBC, 0xFF, 0x3D, 0xFF, 0xBF,
  0xE7, 0xE0, 0xF0, 0x1E, 0x13, 0xFE, 0x7F, 0xC7, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3C, 0x00, 0x02, 0x00, 0x7B, 0xC7, 0xFC, 0x7F, 0xE3, 0xCF, 0x3C,
  0x79, 0xE7, 0xCF, 0x3C, 0x79, 0xE7, 0xCF, 0x1E, 0xF8, 0xFF, 0x87, 0xFC,
  0x1F, 0xE0, 0x0F, 0x10, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xF8, 0x00,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x41, 0xDE, 0x3F, 0xF3, 0xFF,
  0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x1E,
  0xF3, 0xCF, 0x3C, 0x04, 0x0F, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0x00, 0x80,
  0x3C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x04, 0xF9, 0xE3, 0xCF, 0x0F, 0x7C, 0x3F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x3C,
  0xF8, 0xF3, 0xE3, 0xC7, 0x80, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0x00,
  0x41, 0x07, 0x79, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF7, 0xCF, 0x3D, 0xE7, 0x8F, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B,
  0xC7, 0x9E, 0xF3, 0xC7, 0xBC, 0xF3, 0xC0, 0x00, 0x41, 0xDE, 0x3F, 0xF3,
  0xFF, 0x3C, 0xF3, 0xCF, 0x7C, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xEF,
  0x1E, 0xF3, 0xCF, 0x3C, 0x02, 0x03, 0xF0, 0xFF, 0x3F, 0xF7, 0x9F, 0xE3,
  0xFC, 0x7F, 0x9F, 0xF3, 0xDE, 0x7B, 0xDF, 0x7F, 0xCF, 0xF0, 0xFC, 0x00,
  0x00, 0x40, 0x77, 0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0xF9, 0xE7, 0x8F, 0x7C, 0xFF, 0xC7, 0xFE, 0x3D, 0xE1, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x7B,
  0xC7, 0xFC, 0x7F, 0xE3, 0xCF, 0x3E, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE7,
  0xCF, 0x1E, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x47, 0x73, 0xFC, 0xFE, 0x3F,
  0x8F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x00,
  0x02, 0x07, 0xF3, 0xFC, 0xFE, 0x7C, 0x9F, 0x03, 0xF0, 0xFC, 0x0F, 0x83,
  0xE8, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0x0E, 0x0E, 0x07, 0x0F, 0xFF, 0xF7,
  0xF9, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x27, 0xE3, 0xF0, 0xF8,
  0x7C, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x7C, 0xFF, 0xCF, 0xF8, 0x7B, 0x80, 0xF1, 0xFF, 0x1E, 0x73,
  0xE7, 0x3C, 0x73, 0xC7, 0x78, 0x77, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x00, 0xF3, 0xE7, 0xFC, 0xF9, 0xEF, 0x3E, 0x73, 0xDF,
  0xBC, 0xF7, 0xEF, 0x3D, 0xFF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x00, 0x1E, 0x7C,
  0x7B, 0xE1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0xFF, 0x07, 0xDE, 0x1E, 0x78, 0xF9, 0xE0, 0x3C, 0x7C, 0xF1,
  0xE1, 0xCF, 0x87, 0xBC, 0x1E, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE2,
  0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7F, 0xCF,
  0xF8, 0xFF, 0x80, 0x03, 0xC1, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x78, 0x7E, 0x3F, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1F, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x0F, 0x07, 0xC1, 0xE3, 0xF3, 0xE1, 0xE0, 0xF0, 0x78, 0x38, 0x7C, 0x3E,
  0x1E, 0x0C, 0x00, 0x38, 0x3F, 0xCF, 0xFF, 0xEF, 0xF8, 0x3C,
};

const GFXglyph NotoSans_Condensed_BlackItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 17, 7, 0, -17 },
  { 18, 10, 6, 11, 2, -17 },
  { 26, 14, 17, 14, 0, -17 },
  { 56, 12, 19, 12, 0, -18 },
  { 85, 18, 17, 20, 1, -17 },
  { 124, 15, 17, 15, 0, -17 },
  { 156, 5, 6, 6, 2, -17 },
  { 160, 9, 22, 7, 0, -18 },
  { 185, 9, 22, 7, -2, -18 },
  { 210, 10, 11, 11, 2, -18 },
  { 224, 11, 11, 13, 1, -14 },
  { 240, 6, 6, 7, -1, -3 },
  { 245, 7, 3, 8, 0, -8 },
  { 248, 5, 4, 7, 0, -4 },
  { 251, 13, 17, 10, -1, -17 },
  { 279, 11, 17, 12, 1, -17 },
  { 303, 10, 17, 12, 2, -17 },
  { 325, 13, 17, 12, -1, -17 },
  { 353, 12, 17, 12, 0, -17 },
  { 379, 12, 17, 12, 0, -17 },
  { 405, 12, 17, 12, 0, -17 },
  { 431, 12, 17, 12, 1, -17 },
  { 457, 12, 17, 12, 1, -17 },
  { 483, 12, 17, 12, 0, -17 },
  { 509, 11, 17, 12, 1, -17 },
  { 533, 7, 13, 7, 0, -13 },
  { 545, 8, 16, 7, -1, -13 },
  { 561, 11, 12, 13, 1, -15 },
  { 578, 11, 9, 13, 1, -13 },
  { 591, 11, 12, 13, 1, -15 },
  { 608, 10, 17, 10, 1, -17 },
  { 630, 17, 19, 18, 1, -17 },
  { 671, 13, 17, 14, -1, -17 },
  { 699, 13, 17, 13, 0, -17 },
  { 727, 13, 17, 12, 1, -17 },
  { 755, 14, 17, 14, 0, -17 },
  { 785, 12, 17, 11, 0, -17 },
  { 811, 12, 17, 11, 0, -17 },
  { 837, 14, 17, 14, 1, -17 },
  { 867, 15, 17, 15, 0, -17 },
  { 899, 12, 17, 9, -1, -17 },
  { 925, 12, 22, 7, -4, -17 },
  { 958, 16, 17, 13, 0, -17 },
  { 992, 9, 17, 11, 0, -17 },
  { 1012, 20, 17, 19, 0, -17 },
  { 1055, 17, 17, 16, 0, -17 },
  { 1092, 14, 17, 15, 1, -17 },
  { 1122, 13, 17, 13, 0, -17 },
  { 1150, 14, 21, 15, 1, -17 },
  { 1187, 13, 17, 13, 0, -17 },
  { 1215, 12, 17, 11, 0, -17 },
  { 1241, 11, 17, 11, 2, -17 },
  { 1265, 14, 17, 14, 1, -17 },
  { 1295, 13, 17, 13, 2, -17 },
  { 1323, 19, 17, 19, 2, -17 },
  { 1364, 16, 17, 13, -1, -17 },
  { 1398, 13, 17, 13, 2, -17 },
  { 1426, 14, 17, 11, -1, -17 },
  { 1456, 10, 22, 7, -1, -18 },
  { 1484, 6, 17, 10, 2, -17 },
  { 1497, 11, 22, 7, -2, -18 },
  { 1528, 12, 11, 12, 0, -17 },
  { 1545, 10, 2, 10, -2, 2 },
  { 1548, 6, 3, 8, 3, -18 },
  { 1551, 12, 14, 13, 1, -14 },
  { 1572, 12, 18, 13, 0, -18 },
  { 1599, 10, 14, 10, 1, -14 },
  { 1617, 13, 18, 13, 1, -18 },
  { 1647, 11, 13, 12, 1, -13 },
  { 1665, 14, 24, 8, -3, -18 },
  { 1707, 13, 20, 13, 0, -14 },
  { 1740, 12, 18, 13, 0, -18 },
  { 1767, 8, 19, 7, 0, -19 },
  { 1786, 11, 25, 7, -3, -19 },
  { 1821, 14, 18, 13, 0, -18 },
  { 1853, 8, 18, 7, 0, -18 },
  { 1871, 18, 14, 19, 0, -14 },
  { 1903, 12, 14, 13, 0, -14 },
  { 1924, 11, 14, 12, 1, -14 },
  { 1944, 13, 20, 13, -1, -14 },
  { 1977, 13, 20, 13, 0, -14 },
  { 2010, 10, 14, 9, 0, -14 },
  { 2028, 10, 14, 10, 0, -14 },
  { 2046, 9, 16, 9, 1, -16 },
  { 2064, 12, 13, 13, 1, -13 },
  { 2084, 12, 13, 12, 1, -13 },
  { 2104, 18, 13, 17, 1, -13 },
  { 2134, 14, 13, 12, -1, -13 },
  { 2157, 14, 19, 12, -1, -13 },
  { 2191, 12, 13, 10, -1, -13 },
  { 2211, 10, 21, 8, 0, -17 },
  { 2238, 3, 23, 11, 4, -18 },
  { 2247, 9, 21, 8, -1, -17 },
  { 2271, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_BlackItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC24PT7B_H_
