#ifndef _NOTOSANS_CONDENSED_BLACKITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x9F,
  0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE,
  0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0xE7, 0xE0,
  0x1F, 0xF7, 0x87, 0x00, 0x7F, 0x9E, 0x04, 0x01, 0xFE, 0x78, 0x00, 0x07,
  0xF9, 0xC0, 0x00, 0x1F, 0xF7, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xE7, 0xFC, 0x10, 0x03, 0x9F, 0xF0, 0x70,
  0x1E, 0x7F, 0x81, 0xF0, 0x7B, 0xFE, 0x07, 0xF9, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x07, 0xFD, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0,
  0x00, 0xFF, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x87, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x3F, 0xC1, 0xF8, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0xF1, 0xFE, 0x7F,
  0x9F, 0xE3, 0xFF, 0xCF, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xCF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xC7, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFC, 0x7F, 0x9F, 0xE7, 0xF8, 0xFF, 0xC7, 0xF8, 0xFF,
  0x1F, 0xC0, 0xF0, 0x3F, 0xCF, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x8F,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x03, 0xF8,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xDF, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x20, 0x1F, 0xC0, 0x06, 0x07, 0xF0, 0x03, 0xE3,
  0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0x83, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0xC0, 0x3F, 0x1F, 0xF8, 0x07, 0x83, 0xF8,
  0x00, 0xC0, 0xF8, 0x00, 0x10, 0x38, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE,
  0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF,
  0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F,
  0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x0F,
  0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF,
  0xFC, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0,
  0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF8, 0x3F, 0x9F, 0xF8, 0x1E,
  0x3F, 0xF0, 0x1C, 0x3F, 0xF0, 0x08, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xFC, 0x01, 0xF8, 0x3F, 0xF8,
  0x01, 0xE0, 0x3F, 0xF0, 0x03, 0x80, 0x7F, 0xE0, 0x02, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0xFF, 0xF0, 0x06, 0x01, 0xFF, 0x80, 0x10, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x80, 0x01, 0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0x0F,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xDF,
  0xF8, 0x00, 0xFF, 0x7F, 0xE0, 0x03, 0xFB, 0xFF, 0x00, 0x1F, 0xCF, 0xFC,
  0x00, 0xFF, 0x3F, 0xF0, 0x07, 0xF8, 0xFF, 0xC0, 0x1F, 0xC3, 0xFF, 0x00,
  0xFF, 0x1F, 0xF8, 0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF,
  0x07, 0xFE, 0x27, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x60, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x7F, 0xF0, 0xE0,
  0x07, 0xFF, 0x87, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x3F,
  0x80, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFB, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0x07,
  0xFE, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0x83,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF1, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3,
  0xFF, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF,
  0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x20, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x07, 0xFF,
  0x1C, 0x03, 0xFF, 0x10, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xFF, 0xF1, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x1F, 0x87, 0xF8, 0x3F,
  0xFF, 0xE3, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xFF,
  0x0F, 0xE7, 0xF0, 0xFF, 0x8F, 0xE1, 0xFC, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0xFE,
  0x3F, 0xC1, 0xFC, 0x3F, 0x9F, 0x87, 0xF0, 0x3F, 0x87, 0xF7, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x9F, 0xC7, 0xF8, 0x3F,
  0x87, 0xF3, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x7E, 0x1F, 0xC1, 0xFC, 0x1F,
  0x8F, 0xC3, 0xF8, 0x3F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F,
  0x0F, 0xF3, 0xFE, 0x7F, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0xDF, 0xFE, 0x03, 0xF8, 0x3F, 0xF3,
  0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x04, 0x00, 0x40,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x30, 0x0F, 0xFF, 0x00, 0x10,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0x00,
  0x7F, 0xF0, 0x07, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0x80, 0x7F, 0xFC, 0x00, 0xC0, 0x1F, 0xFE,
  0x00, 0x10, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFE,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0x7F, 0x8F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xC7, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xE7, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF3, 0xFD, 0xFF, 0x80,
  0x3F, 0xF7, 0xFB, 0xFE, 0xFF, 0xC0, 0x1F, 0xF3, 0xFD, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF9, 0xFE, 0xFF, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xFF, 0x3F, 0xF0,
  0x07, 0xFE, 0x7F, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xFF, 0x8F, 0xFC,
  0x01, 0xFF, 0x1F, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0xF1, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF,
  0xF8, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x1F,
  0xF0, 0x07, 0xFD, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xBF, 0xF3, 0xFF, 0x00, 0x7F, 0xCF,
  0xF9, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x07,
  0xFC, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFD,
  0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0,
  0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x07,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0x87, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x7F, 0xF0,
  0x1E, 0x01, 0xFF, 0xC0, 0x10, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0xFF, 0xE0, 0x70, 0x03, 0xFF, 0x81,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC7,
  0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0xBF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0x80, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0xF8,
  0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0xFE,
  0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x7F,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xDF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xEF,
  0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xFC,
  0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3,
  0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xFE, 0x7F, 0xC0, 0xFF, 0xFD, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x87, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x1F, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF,
  0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0x1E, 0x07, 0xFF, 0x01, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x83,
  0xFF, 0x80, 0x40, 0x7F, 0xF0, 0x70, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF,
  0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F,
  0xF3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x20, 0x7F, 0xE0,
  0x0E, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x84, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x08, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x23,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xF9,
  0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F,
  0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x61, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x03, 0xFF, 0x00, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x0F, 0xFD,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x02, 0x7F, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xF3, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0x3F, 0xFC, 0x7F, 0xFC, 0x07, 0xFB, 0xFF, 0xF7, 0xFF,
  0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xBF, 0xFF, 0x7F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0x00, 0xFF, 0x7F, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03,
  0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7,
  0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0xE0,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF7, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F,
  0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xC0, 0x7F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x04, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x81, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFD, 0xFC, 0x0F, 0xFC, 0x1C, 0x0F, 0xFE,
  0x02, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0x00, 0x3F, 0xF8, 0xF0, 0x1F, 0xFC,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC8, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x10, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xFC, 0x07,
  0xFF, 0xDF, 0xE0, 0x0F, 0xFE, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0,
  0x1F, 0xFC, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xEF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xFF, 0x07, 0xFE,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0xCF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0xE3, 0xFF, 0x0F, 0xF9, 0xFF, 0xF8, 0xFF,
  0xC3, 0xFE, 0x7F, 0xFE, 0x3F, 0xE0, 0xFF, 0xBF, 0xFF, 0x9F, 0xF8, 0x3F,
  0xEF, 0xEF, 0xE7, 0xFC, 0x0F, 0xFB, 0xFB, 0xF9, 0xFF, 0x03, 0xFD, 0xFE,
  0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x3F, 0xBF, 0xE0, 0x3F, 0xDF, 0xCF, 0xEF,
  0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x9F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xE0,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x1F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x37, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x27, 0xFF,
  0xC0, 0x0D, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xF2, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 43, 16, 0, -42 },
  { 104, 25, 15, 27, 5, -42 },
  { 151, 35, 42, 33, 0, -42 },
  { 335, 30, 48, 30, 1, -45 },
  { 515, 45, 44, 49, 3, -43 },
  { 763, 38, 44, 38, 0, -43 },
  { 972, 12, 15, 14, 5, -42 },
  { 995, 22, 52, 18, 1, -43 },
  { 1138, 21, 52, 18, -4, -43 },
  { 1275, 26, 28, 28, 4, -45 },
  { 1366, 26, 28, 31, 3, -35 },
  { 1457, 15, 16, 16, -3, -8 },
  { 1487, 17, 9, 19, 1, -20 },
  { 1507, 11, 11, 16, 0, -10 },
  { 1523, 33, 44, 25, -3, -43 },
  { 1705, 28, 44, 30, 2, -43 },
  { 1859, 24, 42, 30, 5, -42 },
  { 1985, 31, 43, 30, -2, -43 },
  { 2152, 30, 44, 30, 0, -43 },
  { 2317, 30, 42, 30, 0, -42 },
  { 2475, 29, 43, 30, 1, -42 },
  { 2631, 29, 44, 30, 2, -43 },
  { 2791, 32, 42, 30, 1, -42 },
  { 2959, 29, 44, 30, 1, -43 },
  { 3119, 29, 44, 30, 1, -43 },
  { 3279, 16, 34, 16, 0, -33 },
  { 3347, 19, 41, 16, -3, -33 },
  { 3445, 27, 30, 31, 2, -36 },
  { 3547, 26, 21, 31, 3, -31 },
  { 3616, 26, 30, 31, 3, -36 },
  { 3714, 24, 44, 24, 3, -43 },
  { 3846, 43, 48, 45, 2, -43 },
  { 4104, 33, 42, 34, -3, -42 },
  { 4278, 33, 42, 33, 0, -42 },
  { 4452, 32, 44, 31, 2, -43 },
  { 4628, 34, 42, 35, 0, -42 },
  { 4807, 30, 42, 27, 0, -42 },
  { 4965, 30, 42, 27, 0, -42 },
  { 5123, 34, 44, 35, 2, -43 },
  { 5310, 38, 42, 36, 0, -42 },
  { 5510, 29, 42, 23, -2, -42 },
  { 5663, 29, 55, 18, -9, -42 },
  { 5863, 39, 42, 33, 0, -42 },
  { 6068, 23, 42, 26, 0, -42 },
  { 6189, 49, 42, 47, 0, -42 },
  { 6447, 41, 42, 39, 0, -42 },
  { 6663, 34, 44, 37, 2, -43 },
  { 6850, 32, 42, 31, 0, -42 },
  { 7018, 34, 53, 37, 2, -43 },
  { 7244, 32, 42, 32, 0, -42 },
  { 7412, 30, 44, 28, 0, -43 },
  { 7577, 27, 42, 28, 5, -42 },
  { 7719, 34, 43, 35, 3, -42 },
  { 7902, 32, 42, 32, 5, -42 },
  { 8070, 49, 42, 47, 4, -42 },
  { 8328, 41, 42, 32, -4, -42 },
  { 8544, 31, 42, 31, 5, -42 },
  { 8707, 34, 42, 28, -2, -42 },
  { 8886, 26, 53, 18, -3, -43 },
  { 9059, 15, 44, 25, 6, -43 },
  { 9142, 25, 53, 18, -4, -43 },
  { 9308, 30, 28, 29, -1, -42 },
  { 9413, 26, 7, 24, -6, 4 },
  { 9436, 14, 9, 20, 8, -45 },
  { 9452, 30, 34, 31, 1, -33 },
  { 9580, 30, 46, 31, 0, -45 },
  { 9753, 26, 34, 25, 1, -33 },
  { 9864, 33, 46, 31, 1, -45 },
  { 10054, 28, 34, 29, 1, -33 },
  { 10173, 33, 59, 20, -6, -45 },
  { 10417, 32, 47, 31, -1, -33 },
  { 10605, 30, 45, 31, 0, -45 },
  { 10774, 19, 46, 16, 0, -46 },
  { 10884, 26, 60, 16, -7, -46 },
  { 11079, 34, 45, 31, 0, -45 },
  { 11271, 19, 45, 16, 0, -45 },
  { 11378, 45, 33, 46, 0, -33 },
  { 11564, 30, 33, 31, 0, -33 },
  { 11688, 28, 34, 31, 1, -33 },
  { 11807, 33, 47, 31, -3, -33 },
  { 12001, 30, 47, 31, 1, -33 },
  { 12178, 25, 33, 22, 0, -33 },
  { 12282, 25, 34, 25, 0, -33 },
  { 12389, 22, 40, 22, 2, -39 },
  { 12499, 30, 34, 31, 2, -33 },
  { 12627, 29, 33, 29, 3, -33 },
  { 12747, 42, 33, 43, 4, -33 },
  { 12921, 35, 33, 29, -3, -33 },
  { 13066, 36, 47, 29, -4, -33 },
  { 13278, 28, 33, 25, -2, -33 },
  { 13394, 25, 51, 21, 0, -42 },
  { 13554, 8, 58, 26, 9, -45 },
  { 13612, 23, 51, 21, -3, -42 },
  { 13759, 27, 11, 31, 2, -26 },
};

const GFXfont NotoSans_Condensed_BlackItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC59PT7B_H_
