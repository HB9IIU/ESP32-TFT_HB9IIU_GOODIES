#ifndef _NOTOSANS_CONDENSED_BLACKITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x29, 0x80, 0xFA, 0x2B, 0xD5, 0xF7, 0x70, 0x13, 0xD8, 0xC3,
  0x79, 0x88, 0x20, 0xE9, 0xA7, 0xF5, 0xE5, 0x5B, 0x80, 0x11, 0xE7, 0x9F,
  0xFB, 0x6F, 0x80, 0xE0, 0x36, 0x44, 0xCC, 0xCC, 0x23, 0x33, 0x22, 0x6C,
  0x6D, 0x7A, 0x2F, 0x22, 0x78, 0xE0, 0xB0, 0x18, 0x88, 0xC4, 0x62, 0x00,
  0x23, 0x97, 0xAD, 0x79, 0x80, 0x7D, 0xB4, 0x80, 0x27, 0x53, 0x6C, 0xF0,
  0x23, 0xC4, 0xC3, 0x5B, 0x80, 0x39, 0x9D, 0xEF, 0x10, 0x7A, 0x1C, 0x6B,
  0x70, 0x13, 0xD0, 0xED, 0x79, 0x80, 0x78, 0x8C, 0x46, 0x60, 0x23, 0xD4,
  0xEF, 0x6B, 0x80, 0x23, 0x96, 0xA7, 0x1B, 0x80, 0x68, 0x4C, 0x32, 0x00,
  0x6C, 0x13, 0xE7, 0x10, 0xF0, 0xF0, 0x8E, 0x37, 0xC0, 0x27, 0x36, 0x44,
  0xC0, 0x08, 0x69, 0x6F, 0x5A, 0xB7, 0x92, 0x18, 0x18, 0x63, 0xCF, 0x7F,
  0x30, 0x7B, 0xDC, 0xBD, 0x78, 0x13, 0xD8, 0x8C, 0x69, 0xC0, 0x7B, 0x52,
  0xBD, 0x78, 0x7B, 0x1C, 0x8C, 0x70, 0x7B, 0x1C, 0xEC, 0x60, 0x14, 0xE6,
  0x16, 0xDB, 0x67, 0x00, 0x6D, 0xA7, 0x96, 0xDB, 0x40, 0x76, 0x66, 0x4E,
  0x33, 0x22, 0x66, 0x4C, 0x7D, 0xE7, 0x1C, 0xD3, 0x60, 0x66, 0x44, 0xDE,
  0x66, 0xDD, 0xBB, 0x7F, 0x5E, 0x80, 0x65, 0xF7, 0xD6, 0xDB, 0x60, 0x11,
  0xE6, 0xD2, 0xCB, 0x67, 0x00, 0x7B, 0xD6, 0xEC, 0x60, 0x11, 0xE6, 0xD2,
  0xCB, 0x67, 0x0C, 0x10, 0x7B, 0xDE, 0xEF, 0x6C, 0x23, 0xD0, 0xC3, 0x5B,
  0x80, 0xF4, 0x4C, 0xC8, 0x6D, 0xA5, 0x96, 0xD9, 0xC0, 0x9D, 0xA9, 0xCC,
  0x60, 0xB7, 0x6A, 0xF6, 0xCD, 0x9B, 0x00, 0x3E, 0x70, 0x61, 0xC7, 0x99,
  0x00, 0xFF, 0x38, 0x8C, 0x60, 0x79, 0x88, 0xCC, 0x78, 0x6D, 0x2D, 0xA6,
  0xC0, 0xAB, 0xD4, 0x33, 0x33, 0x22, 0x26, 0xC0, 0x37, 0x59, 0xF0, 0xD0,
  0x7A, 0xB5, 0xEF, 0x00, 0x63, 0x1C, 0xBD, 0x6B, 0xC0, 0x74, 0xCD, 0x60,
  0x08, 0xDE, 0xAD, 0x7B, 0xC0, 0x75, 0xFC, 0x70, 0x19, 0x9C, 0x42, 0x31,
  0x8C, 0xC0, 0x7A, 0xB5, 0xEF, 0x1B, 0x80, 0x63, 0x1C, 0xBD, 0x6B, 0xC0,
  0x69, 0xAD, 0xB0, 0x32, 0x32, 0x26, 0x64, 0xC0, 0x63, 0x16, 0xEE, 0x7B,
  0xC0, 0x6D, 0x2D, 0xB0, 0x76, 0xBF, 0x5E, 0xAF, 0x40, 0x72, 0xF5, 0xAF,
  0x00, 0x75, 0xDF, 0x60, 0x38, 0xB6, 0x9A, 0x79, 0x0C, 0x00, 0x7A, 0xB5,
  0xEF, 0x18, 0x80, 0x76, 0xCC, 0xC0, 0x74, 0x6A, 0xE0, 0x2F, 0x44, 0xCE,
  0x7A, 0xF5, 0xED, 0x00, 0xDA, 0x9C, 0xC6, 0x00, 0xBF, 0xAE, 0xBE, 0xB0,
  0x5B, 0x98, 0xCF, 0x00, 0x6C, 0xA3, 0x8C, 0x30, 0x8E, 0x00, 0x72, 0x6C,
  0xE0, 0x36, 0x68, 0x44, 0xC0, 0xFF, 0xFF, 0xC0, 0x33, 0x21, 0x26, 0xC0,
  0xF9,
};

const GFXglyph NotoSans_Condensed_BlackItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 4, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 7, 7, 8, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 2, 2, 2, 1, -6 },
  { 28, 4, 8, 3, 0, -7 },
  { 32, 4, 8, 3, -1, -7 },
  { 36, 4, 4, 4, 1, -7 },
  { 38, 4, 4, 5, 0, -5 },
  { 40, 3, 2, 2, -1, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 2, 2, 2, 0, -2 },
  { 43, 5, 7, 4, 0, -7 },
  { 48, 5, 7, 5, 0, -7 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 5, 6, 5, 0, -6 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 4, 6, 3, -1, -5 },
  { 97, 4, 5, 5, 0, -6 },
  { 100, 4, 3, 5, 0, -5 },
  { 102, 4, 5, 5, 0, -6 },
  { 105, 4, 7, 4, 0, -7 },
  { 109, 7, 8, 7, 0, -7 },
  { 116, 6, 6, 5, -1, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 4, 0, -6 },
  { 138, 5, 6, 4, 0, -6 },
  { 142, 6, 7, 5, 0, -7 },
  { 148, 6, 6, 5, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 8, 3, -1, -6 },
  { 160, 6, 6, 5, 0, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 7, 6, 7, 0, -6 },
  { 174, 6, 6, 6, 0, -6 },
  { 179, 6, 7, 6, 0, -7 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 6, 9, 6, 0, -7 },
  { 196, 5, 6, 5, 0, -6 },
  { 200, 5, 7, 4, 0, -7 },
  { 205, 4, 6, 4, 1, -6 },
  { 208, 6, 6, 5, 0, -6 },
  { 213, 5, 6, 5, 1, -6 },
  { 217, 7, 6, 7, 1, -6 },
  { 223, 7, 6, 5, -1, -6 },
  { 229, 5, 6, 5, 1, -6 },
  { 233, 5, 6, 4, 0, -6 },
  { 237, 3, 9, 3, 0, -7 },
  { 241, 2, 7, 4, 1, -7 },
  { 243, 4, 9, 3, -1, -7 },
  { 248, 4, 4, 4, 0, -6 },
  { 250, 4, 1, 4, -1, 1 },
  { 251, 2, 2, 3, 1, -7 },
  { 252, 5, 5, 5, 0, -5 },
  { 256, 5, 7, 5, 0, -7 },
  { 261, 4, 5, 4, 0, -5 },
  { 264, 5, 7, 5, 0, -7 },
  { 269, 4, 5, 4, 0, -5 },
  { 272, 5, 9, 3, -1, -7 },
  { 278, 5, 7, 5, 0, -5 },
  { 283, 5, 7, 5, 0, -7 },
  { 288, 3, 7, 2, 0, -7 },
  { 291, 4, 9, 2, -1, -7 },
  { 296, 5, 7, 5, 0, -7 },
  { 301, 3, 7, 2, 0, -7 },
  { 304, 7, 5, 7, 0, -5 },
  { 309, 5, 5, 5, 0, -5 },
  { 313, 4, 5, 5, 0, -5 },
  { 316, 6, 7, 5, -1, -5 },
  { 322, 5, 7, 5, 0, -5 },
  { 327, 4, 5, 3, 0, -5 },
  { 330, 4, 5, 4, 0, -5 },
  { 333, 4, 6, 3, 0, -6 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 5, 5, 4, 0, -5 },
  { 344, 6, 5, 6, 1, -5 },
  { 348, 5, 5, 4, 0, -5 },
  { 352, 6, 7, 4, -1, -5 },
  { 358, 4, 5, 4, 0, -5 },
  { 361, 4, 7, 3, 0, -6 },
  { 365, 2, 9, 4, 1, -7 },
  { 368, 4, 7, 3, -1, -6 },
  { 372, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_BlackItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC9PT7B_H_
