#ifndef _NOTOSANS_CONDENSED_BLACKITALIC66PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xEF, 0xE0, 0x0F, 0xFD, 0xE0, 0xF0, 0x0F,
  0xFC, 0xF0, 0x10, 0x07, 0xFE, 0x78, 0x00, 0x03, 0xFF, 0x3C, 0x00, 0x01,
  0xFF, 0x9E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xCF, 0xFC, 0x10, 0x01, 0xE7, 0xFE, 0x0E, 0x00, 0xF3,
  0xFF, 0x07, 0xC0, 0x79, 0xFF, 0x03, 0xF8, 0x3D, 0xFF, 0x81, 0xFF, 0xBF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x8F,
  0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC7, 0xFC, 0x0F, 0xC0, 0xFF, 0x1F, 0xF1,
  0xFE, 0x1F, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xC7, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF,
  0xF1, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0x1F,
  0xFC, 0x3F, 0xC7, 0xFC, 0x7F, 0xC0, 0xF8, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x30, 0x1F, 0xF0, 0x03, 0xC1, 0xFF, 0x00, 0x3F,
  0x1F, 0xE0, 0x07, 0xFD, 0xFE, 0x01, 0x7F, 0xFF, 0xE3, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFE,
  0x3F, 0xF0, 0x0F, 0xE3, 0xFF, 0x00, 0x7C, 0x1F, 0xF8, 0x03, 0x81, 0xFC,
  0x00, 0x18, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF0, 0x01, 0x01, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE,
  0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0x03,
  0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xF8, 0x7F,
  0xCF, 0xFE, 0x0F, 0xE7, 0xFF, 0x81, 0xF1, 0xFF, 0xC0, 0x78, 0x7F, 0xF0,
  0x08, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFE, 0x3F, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xC0,
  0x07, 0x80, 0x7F, 0xF0, 0x00, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0x83,
  0xFF, 0xE0, 0x06, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x08, 0x00, 0x07, 0xFF,
  0x87, 0x00, 0x07, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0xC0,
  0x01, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xCF, 0xFE,
  0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xE0, 0x07, 0xF8, 0x7F,
  0xF0, 0x03, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x10,
  0x00, 0x3F, 0xFE, 0x0E, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x03,
  0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x2D, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFF, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0x7F,
  0xF8, 0x3F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF,
  0x83, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF7,
  0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0x00, 0x7F, 0xF0,
  0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3C, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F,
  0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x3F,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F,
  0x87, 0xF8, 0x1F, 0xE0, 0xFE, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFE, 0x7F,
  0x0F, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF0, 0xFE,
  0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x07, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x78, 0x01, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0xFF, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0x00, 0xFF, 0xFC, 0x00, 0x40, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x04, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0x87, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x04, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF,
  0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD,
  0xFE, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xF7, 0xF8, 0x7F, 0xDF, 0xF8, 0x01,
  0xFF, 0xDF, 0xE3, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0x8F, 0xFB, 0xFF,
  0x80, 0x1F, 0xF9, 0xFE, 0x7F, 0xCF, 0xFE, 0x00, 0xFF, 0xE7, 0xFD, 0xFF,
  0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x80,
  0x1F, 0xFC, 0x7F, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x3F,
  0xF8, 0x01, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xCF, 0xFE,
  0x00, 0x7F, 0xF7, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0xFF, 0xE0,
  0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xEF, 0xFC, 0x00,
  0xFF, 0xE3, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03,
  0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF,
  0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xFE, 0x03, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xBF, 0xC0, 0x0F, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x18, 0x00, 0xFF,
  0xE0, 0x02, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x04, 0x00, 0x0F, 0xFF, 0x01, 0x80, 0x03, 0xFF, 0xC0,
  0x78, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFE, 0x7F, 0xDF, 0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xFF, 0x9F, 0xFC,
  0x00, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xEF, 0xF9,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xBF, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFE,
  0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xF3, 0xFE, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x40, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xF8,
  0x03, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF, 0xF8, 0x01,
  0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x3F, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xBF, 0xFC, 0x01,
  0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0x00, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0xF8, 0x1F,
  0xFE, 0x01, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x40, 0xFF, 0xE0, 0x0C, 0x0F, 0xFF,
  0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0,
  0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x08, 0x3F, 0xF8, 0x00, 0xE0, 0xFF, 0xF8, 0x1F, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x1F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xF0,
  0x00, 0x02, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x07,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0x80,
  0x3F, 0xEF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xE7, 0xFF,
  0x03, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0,
  0x1F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFE, 0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xBF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F,
  0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF,
  0xE3, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xF7, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE7, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0xC0, 0x00, 0x78, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xB8, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x1F, 0x80, 0xFF, 0xE0,
  0x38, 0x0F, 0xFE, 0x01, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xC0, 0x07, 0xFF,
  0x0F, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xBF, 0xE0, 0x1F, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x3F, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFE, 0xFF, 0x3F, 0xF8, 0x3F, 0xF3, 0xFD,
  0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0xFD, 0xFF, 0xC0, 0xFF, 0xDF, 0xEF,
  0xFB, 0xFF, 0x01, 0xFF, 0xBF, 0xDF, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xBF,
  0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x7F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0xDF,
  0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x7F, 0xE0, 0x00, 0x17, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xA0, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_BlackItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 21, 48, 18, 0, -47 },
  { 127, 28, 17, 30, 6, -47 },
  { 187, 39, 47, 37, 0, -47 },
  { 417, 33, 54, 33, 1, -50 },
  { 640, 50, 49, 55, 4, -48 },
  { 947, 42, 49, 42, 0, -48 },
  { 1205, 14, 17, 16, 6, -47 },
  { 1235, 25, 58, 20, 1, -48 },
  { 1417, 24, 58, 20, -5, -48 },
  { 1591, 28, 32, 31, 5, -51 },
  { 1703, 30, 32, 35, 3, -39 },
  { 1823, 17, 18, 18, -4, -9 },
  { 1862, 19, 10, 21, 1, -23 },
  { 1886, 12, 13, 18, 0, -12 },
  { 1906, 37, 49, 28, -4, -48 },
  { 2133, 31, 49, 33, 2, -48 },
  { 2323, 26, 47, 33, 6, -47 },
  { 2476, 34, 48, 33, -2, -48 },
  { 2680, 33, 49, 33, 0, -48 },
  { 2883, 34, 47, 33, 0, -47 },
  { 3083, 33, 48, 33, 1, -47 },
  { 3281, 33, 49, 33, 2, -48 },
  { 3484, 35, 47, 33, 2, -47 },
  { 3690, 33, 49, 33, 1, -48 },
  { 3893, 31, 49, 33, 2, -48 },
  { 4083, 18, 38, 18, 0, -37 },
  { 4169, 22, 46, 18, -4, -37 },
  { 4296, 30, 34, 35, 3, -41 },
  { 4424, 30, 23, 35, 3, -35 },
  { 4511, 30, 34, 35, 3, -41 },
  { 4639, 27, 49, 27, 3, -48 },
  { 4805, 48, 53, 50, 2, -48 },
  { 5123, 38, 47, 38, -4, -47 },
  { 5347, 37, 47, 36, 0, -47 },
  { 5565, 35, 49, 34, 3, -48 },
  { 5780, 38, 47, 39, 0, -47 },
  { 6004, 33, 47, 30, 0, -47 },
  { 6198, 33, 47, 30, 0, -47 },
  { 6392, 37, 49, 39, 3, -48 },
  { 6619, 42, 47, 40, 0, -47 },
  { 6866, 32, 47, 26, -2, -47 },
  { 7054, 33, 62, 20, -11, -47 },
  { 7310, 43, 47, 37, 0, -47 },
  { 7563, 26, 47, 29, 0, -47 },
  { 7716, 54, 47, 52, 0, -47 },
  { 8034, 46, 47, 44, 0, -47 },
  { 8305, 38, 49, 41, 3, -48 },
  { 8538, 36, 47, 35, 0, -47 },
  { 8750, 38, 59, 41, 3, -48 },
  { 9031, 36, 47, 36, 0, -47 },
  { 9243, 34, 49, 31, 0, -48 },
  { 9452, 31, 47, 31, 5, -47 },
  { 9635, 38, 48, 39, 3, -47 },
  { 9863, 36, 47, 36, 6, -47 },
  { 10075, 54, 47, 53, 5, -47 },
  { 10393, 45, 47, 36, -4, -47 },
  { 10658, 34, 47, 35, 6, -47 },
  { 10858, 38, 47, 31, -3, -47 },
  { 11082, 28, 59, 20, -3, -48 },
  { 11289, 16, 49, 28, 7, -48 },
  { 11387, 28, 59, 20, -5, -48 },
  { 11594, 33, 31, 32, -1, -47 },
  { 11722, 28, 8, 27, -6, 4 },
  { 11750, 15, 11, 22, 9, -51 },
  { 11771, 34, 38, 35, 1, -37 },
  { 11933, 33, 51, 35, 0, -50 },
  { 12144, 28, 38, 28, 2, -37 },
  { 12277, 37, 51, 34, 1, -50 },
  { 12513, 30, 38, 33, 2, -37 },
  { 12656, 37, 66, 22, -7, -50 },
  { 12962, 36, 53, 35, -1, -37 },
  { 13201, 33, 50, 35, 0, -50 },
  { 13408, 21, 51, 18, 0, -51 },
  { 13542, 29, 67, 18, -8, -51 },
  { 13785, 38, 50, 35, 0, -50 },
  { 14023, 21, 50, 18, 0, -50 },
  { 14155, 50, 37, 52, 0, -37 },
  { 14387, 33, 37, 35, 0, -37 },
  { 14540, 31, 38, 34, 2, -37 },
  { 14688, 37, 53, 35, -4, -37 },
  { 14934, 34, 53, 35, 1, -37 },
  { 15160, 28, 37, 25, 0, -37 },
  { 15290, 28, 38, 28, 0, -37 },
  { 15423, 24, 45, 25, 3, -44 },
  { 15558, 33, 38, 35, 2, -37 },
  { 15715, 32, 37, 32, 4, -37 },
  { 15863, 47, 37, 48, 4, -37 },
  { 16081, 40, 37, 32, -4, -37 },
  { 16266, 40, 53, 32, -4, -37 },
  { 16531, 32, 37, 28, -2, -37 },
  { 16679, 28, 57, 23, 0, -47 },
  { 16879, 9, 66, 29, 10, -51 },
  { 16954, 27, 57, 23, -4, -47 },
  { 17147, 30, 13, 35, 3, -30 },
};

const GFXfont NotoSans_Condensed_BlackItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC66PT7B_H_
