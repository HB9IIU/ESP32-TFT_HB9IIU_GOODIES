#ifndef _NOTOSANS_CONDENSED_BLACKITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x00, 0x07,
  0x1E, 0x3C, 0x78, 0x7F, 0xBB, 0xFD, 0xFE, 0xEE, 0x77, 0x38, 0x07, 0x30,
  0x3B, 0x81, 0xDC, 0x0C, 0xC3, 0xFF, 0x9F, 0xFD, 0xFF, 0xE3, 0xB8, 0x1D,
  0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xC3, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0,
  0x01, 0x80, 0x20, 0x3F, 0x8F, 0xF3, 0xFE, 0x74, 0x8E, 0x81, 0xF0, 0x1F,
  0x81, 0xF0, 0x1F, 0x02, 0xE4, 0x5C, 0xFF, 0x3F, 0xE3, 0xF8, 0x08, 0x03,
  0x00, 0x1C, 0x0E, 0x1F, 0x0E, 0x1F, 0xC6, 0x0E, 0xE7, 0x0E, 0x77, 0x07,
  0x33, 0x83, 0xBB, 0x99, 0xFF, 0xBE, 0x7D, 0xDF, 0xBD, 0xDD, 0xC0, 0xCE,
  0xE0, 0xE6, 0x70, 0xE7, 0x30, 0x71, 0xB8, 0x70, 0xF8, 0x70, 0x78, 0x03,
  0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xB8, 0x1E, 0xE0, 0x7F, 0x81, 0xFC, 0x07,
  0xEF, 0x3F, 0xBD, 0xFF, 0xEF, 0x7F, 0xBC, 0xFC, 0xF3, 0xE3, 0xFF, 0x87,
  0xFF, 0x0F, 0xBE, 0x7B, 0xBD, 0xEE, 0x70, 0x07, 0x87, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0xF0,
  0x1E, 0x0E, 0x37, 0x1F, 0xBF, 0xF9, 0xFC, 0xF1, 0xFC, 0x6F, 0x13, 0x01,
  0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x3B, 0xDC, 0xEF, 0x70, 0x7E, 0xFB, 0xF7, 0xE0, 0x7F,
  0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xEF, 0x7B, 0xDC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xEE, 0x7B, 0x9E, 0xE7, 0x3F, 0xCF, 0xE1, 0xF0, 0x07, 0x87, 0xC7,
  0xC7, 0xEF, 0xF7, 0xF9, 0xB8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x03, 0xC0, 0xFE, 0x1F, 0xF0, 0xEF, 0x08, 0xF0, 0x0F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFC,
  0x7F, 0xCF, 0xFC, 0x0F, 0x87, 0xF8, 0x7F, 0x8C, 0xF0, 0x1E, 0x03, 0x87,
  0xF0, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x01, 0xE8, 0x7D, 0xFF, 0x3F, 0xC7,
  0xF0, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0x7C, 0x1B, 0x87, 0xF1, 0xDE,
  0x33, 0x8E, 0x73, 0xFF, 0xFF, 0xEF, 0xFC, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xC0, 0x78, 0x0F, 0xE1, 0xFE, 0x3F, 0xC0,
  0x78, 0x0F, 0x01, 0xE8, 0x7D, 0xFF, 0x3F, 0xC7, 0xF0, 0x03, 0xE1, 0xF8,
  0x7F, 0x1F, 0x07, 0x80, 0xF0, 0x1F, 0xE7, 0xFC, 0xFF, 0x9E, 0x73, 0xCE,
  0x73, 0xCF, 0x79, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0xE7, 0xFD, 0xFF, 0xBF,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xFC, 0x7F, 0x9E, 0x73, 0xCE,
  0x7B, 0xC7, 0xF0, 0xFC, 0x1F, 0x8F, 0xF9, 0xEF, 0x79, 0xEF, 0x3D, 0xFF,
  0x1F, 0xE1, 0xF8, 0x0F, 0x0F, 0xE3, 0xFD, 0xEF, 0x7B, 0xFC, 0xFF, 0x3F,
  0xDF, 0xFF, 0xDF, 0xE3, 0x78, 0x1C, 0x0F, 0x3F, 0x8F, 0xC3, 0xE0, 0x3C,
  0xF3, 0xCE, 0x00, 0x00, 0x00, 0x73, 0xCF, 0x3C, 0x1E, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0x40,
  0x30, 0x3C, 0x7F, 0x7F, 0x3F, 0x0F, 0x81, 0xF8, 0x1F, 0xC1, 0xF0, 0x1C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x0F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0xFE, 0xFE, 0x3E, 0x0E,
  0x02, 0x00, 0x1E, 0x3F, 0x9F, 0xEC, 0xF0, 0x78, 0x38, 0x7C, 0x7C, 0x3C,
  0x3C, 0x00, 0x00, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x01, 0xF0, 0x07, 0xFC,
  0x1F, 0x1E, 0x3C, 0x0E, 0x31, 0xE6, 0x73, 0xF7, 0x67, 0x77, 0xEE, 0x67,
  0xCE, 0x66, 0xCC, 0xE6, 0xCC, 0xEE, 0xCF, 0xFC, 0xCF, 0x78, 0xE6, 0x20,
  0xE0, 0x20, 0x79, 0xE0, 0x3F, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x1E, 0x71, 0xCF, 0x3F,
  0xF3, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7, 0x9E, 0x79,
  0xE7, 0x9E, 0x7B, 0xE7, 0xFC, 0xFF, 0xCF, 0xF0, 0x07, 0xC0, 0xFF, 0x1F,
  0xE3, 0xEC, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF1, 0x8F, 0xF8, 0x7F, 0x83, 0xF0, 0x1F, 0x80, 0xFF, 0x07,
  0xFC, 0x3F, 0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0xF3, 0xC7,
  0x9E, 0x3C, 0xF3, 0xC7, 0xBE, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE3, 0xC0, 0x78, 0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0x01,
  0xE0, 0x3C, 0x07, 0x88, 0xFE, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xFC, 0x3F, 0x8F, 0xF1, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xE6,
  0x7C, 0x07, 0x80, 0x78, 0x1F, 0x3E, 0xF3, 0xEF, 0x7E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x1F, 0xE3,
  0xFC, 0x7F, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0xC7, 0xF8, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x0B, 0xE1, 0xF8, 0x3E, 0x0F,
  0x80, 0x1E, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0xBC, 0x3D, 0xE0, 0xF7, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1,
  0xCF, 0x8F, 0x1E, 0x3C, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFD, 0xFE, 0x1F,
  0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF8, 0xEC, 0xFE, 0x3B, 0x77, 0x1E, 0xFF, 0xC7, 0xBE, 0xF1,
  0xEF, 0xBC, 0x73, 0xCE, 0x1C, 0xF3, 0x8F, 0x3D, 0xE3, 0xCE, 0x78, 0x1F,
  0x0E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF3, 0xF9, 0xC7, 0xF3, 0x8E, 0xEF,
  0x1D, 0xDE, 0x3B, 0xB8, 0xF7, 0xF1, 0xEF, 0xE3, 0xCF, 0xC7, 0x1F, 0x8E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7D, 0xE7,
  0xCF, 0x3C, 0x3F, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE3,
  0xCF, 0x3E, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF1,
  0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC,
  0x7D, 0xE7, 0xCF, 0x3C, 0x3F, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x3D, 0xE3, 0xCF, 0x3E, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x81, 0xFE, 0x1F, 0xF1, 0xDF, 0x3C, 0xF3,
  0xCF, 0x3D, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7B, 0x87, 0xBC, 0x7B, 0xC7,
  0x3C, 0xF3, 0xEF, 0x1E, 0x07, 0xC3, 0xFC, 0x7F, 0x9F, 0x63, 0xC4, 0x78,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1E, 0x43, 0xCC, 0x79, 0xFF, 0x3F,
  0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x3C, 0x79,
  0xE3, 0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x71,
  0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0x3C, 0x7F, 0xE1, 0xFE, 0x07, 0xE0,
  0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x78,
  0xF7, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF1, 0xC3, 0xFC, 0x71, 0xEF, 0x3C, 0x7B, 0x8F, 0x1C, 0xE7, 0xCF, 0x39,
  0xF3, 0xCE, 0x7D, 0xE3, 0xBF, 0x78, 0xEF, 0xDC, 0x3F, 0xFF, 0x0F, 0xDF,
  0xC3, 0xF7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0xC0,
  0x1E, 0x3E, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xDE,
  0x0F, 0x3C, 0x1E, 0x78, 0x78, 0x78, 0xF1, 0xFE, 0x3F, 0xCF, 0x39, 0xE7,
  0x78, 0xFE, 0x1F, 0xC3, 0xF0, 0x7C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x80, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x3E, 0x3F, 0x1F, 0x00, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x78,
  0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x0F, 0xC3, 0xE0, 0xF8, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x1F, 0x07, 0xC3, 0xF0, 0x03, 0x00, 0x70, 0x1E, 0x07, 0xC0,
  0xF8, 0x3F, 0x0F, 0x71, 0xCE, 0x71, 0xDE, 0x3B, 0x83, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF3, 0xCE, 0x70, 0x1E, 0xF3, 0xFE, 0x3F, 0xE7, 0x9E, 0x79,
  0xE7, 0x9C, 0x71, 0xC7, 0x3C, 0xF3, 0xC7, 0xFC, 0x7F, 0x83, 0xB8, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x7F, 0x8F, 0xF9, 0xFF, 0x3D, 0xEF,
  0x3D, 0xE7, 0xBC, 0xF7, 0x9C, 0xF7, 0xBF, 0xF7, 0xFC, 0xEF, 0x00, 0x1F,
  0x9F, 0xDF, 0xDE, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE2, 0x7F, 0x3F, 0x8F,
  0x80, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x78, 0xFF,
  0x87, 0xFC, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0xE3, 0x87, 0x3C, 0x79, 0xE1,
  0xFF, 0x0F, 0xF0, 0x3B, 0x80, 0x1F, 0x8F, 0xE7, 0xBF, 0xCF, 0xF7, 0xBF,
  0xEF, 0xE3, 0x80, 0xE1, 0x3F, 0xCF, 0xF1, 0xF8, 0x01, 0xE0, 0x3F, 0x03,
  0xE0, 0x78, 0x07, 0xA0, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x1F, 0xF3, 0xFE, 0x3F, 0xE7, 0x9E, 0x79,
  0xE7, 0x9C, 0x71, 0xC7, 0x3C, 0xF3, 0xC7, 0xFC, 0x7F, 0x87, 0xB8, 0x07,
  0x88, 0x78, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x7F, 0x8F, 0xF9, 0xFF, 0x3D, 0xEF, 0x3D, 0xE7, 0xBC, 0xE7,
  0x9C, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0x80, 0x0E, 0x3C, 0x78, 0x60, 0x07,
  0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF0, 0x01, 0xC0,
  0xF0, 0x3C, 0x06, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC3, 0xF0, 0xFC,
  0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x9E, 0x78,
  0xF7, 0x87, 0xBC, 0x3B, 0xC3, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3B,
  0xC3, 0xCF, 0x1E, 0x78, 0xF3, 0xC0, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F,
  0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF0, 0x3B, 0xEF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xBC, 0xF7, 0x9E, 0x7B, 0xCF, 0x39, 0xE7, 0x3C,
  0xF7, 0x9E, 0x73, 0xCF, 0x79, 0xE7, 0x3C, 0xF3, 0x9E, 0x73, 0xC0, 0x3B,
  0xC7, 0xFC, 0xFF, 0x9E, 0xF7, 0x9E, 0xF3, 0xDE, 0x73, 0xCE, 0x73, 0xDE,
  0x7B, 0xCF, 0x79, 0xC0, 0x1F, 0x0F, 0xE7, 0xFF, 0xCF, 0xF3, 0xFC, 0xFE,
  0x3F, 0x9E, 0xE7, 0xBF, 0xCF, 0xF1, 0xF0, 0x1D, 0xE1, 0xFF, 0x1F, 0xF1,
  0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x3D, 0xE7, 0xFE, 0x7F, 0xC7,
  0xF8, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xF3, 0xFE,
  0x3F, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x3C, 0xF3, 0xC7, 0xFC,
  0x7F, 0x87, 0xB8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x3B,
  0x9F, 0xCF, 0xE7, 0xE7, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E,
  0x00, 0x1F, 0x9F, 0xDE, 0xCF, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x8F, 0x7F,
  0xBF, 0x9F, 0x80, 0x1C, 0x1C, 0x3C, 0x7F, 0xFF, 0xFE, 0x78, 0x78, 0x70,
  0xF0, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x79, 0xEF, 0x39, 0xE7, 0x39, 0xEF,
  0x3D, 0xE7, 0xBC, 0xE7, 0xBC, 0xF7, 0x9F, 0xF3, 0xFE, 0x7B, 0x80, 0xF1,
  0xFE, 0x7B, 0xCF, 0x7B, 0xC7, 0x78, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3C, 0x00, 0xF3, 0xCF, 0xF7, 0xCE, 0xF7, 0xDE, 0xF7, 0xDE,
  0xFF, 0xDC, 0xFF, 0xFC, 0xFD, 0xF8, 0xFD, 0xF8, 0xFD, 0xF0, 0xF9, 0xF0,
  0xF9, 0xF0, 0xF9, 0xE0, 0x3E, 0xF8, 0xF7, 0x87, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0xC1, 0xDE, 0x1E, 0xF1, 0xE7, 0xC0,
  0x3C, 0x79, 0xE7, 0x8F, 0x3C, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0,
  0x1F, 0x00, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0xFF, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0xF1, 0xFE, 0x7F, 0xC0, 0x01, 0x83, 0xC3,
  0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x38, 0x7C, 0x7C, 0x3C, 0x0F, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x70, 0x38,
  0x3C, 0x0F, 0x83, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xE0, 0x70, 0xF8, 0x7C,
  0x3C, 0x00, 0x70, 0x7F, 0xFF, 0xFE, 0x3F,
};

const GFXglyph NotoSans_Condensed_BlackItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 13, 16, 12, 0, -16 },
  { 48, 11, 18, 11, 0, -17 },
  { 73, 17, 16, 18, 1, -16 },
  { 107, 14, 16, 14, 0, -16 },
  { 135, 5, 6, 5, 2, -16 },
  { 139, 9, 19, 7, 0, -16 },
  { 161, 8, 19, 7, -2, -16 },
  { 180, 9, 11, 10, 2, -17 },
  { 193, 10, 11, 12, 1, -13 },
  { 207, 5, 6, 6, -1, -3 },
  { 211, 7, 4, 7, 0, -8 },
  { 215, 4, 4, 6, 0, -4 },
  { 217, 12, 16, 9, -1, -16 },
  { 241, 10, 16, 11, 1, -16 },
  { 261, 9, 16, 11, 2, -16 },
  { 279, 12, 16, 11, -1, -16 },
  { 303, 11, 16, 11, 0, -16 },
  { 325, 11, 16, 11, 0, -16 },
  { 347, 11, 16, 11, 0, -16 },
  { 369, 11, 16, 11, 1, -16 },
  { 391, 11, 16, 11, 1, -16 },
  { 413, 11, 16, 11, 0, -16 },
  { 435, 10, 16, 11, 1, -16 },
  { 455, 6, 12, 6, 0, -12 },
  { 464, 7, 15, 6, -1, -12 },
  { 478, 10, 12, 12, 1, -14 },
  { 493, 10, 8, 12, 1, -12 },
  { 503, 10, 12, 12, 1, -14 },
  { 518, 9, 16, 9, 1, -16 },
  { 536, 16, 18, 17, 1, -16 },
  { 572, 12, 16, 13, -1, -16 },
  { 596, 12, 16, 12, 0, -16 },
  { 620, 12, 16, 11, 1, -16 },
  { 644, 13, 16, 13, 0, -16 },
  { 670, 11, 16, 10, 0, -16 },
  { 692, 11, 16, 10, 0, -16 },
  { 714, 12, 16, 13, 1, -16 },
  { 738, 14, 16, 13, 0, -16 },
  { 766, 11, 16, 9, -1, -16 },
  { 788, 11, 21, 7, -4, -16 },
  { 817, 14, 16, 12, 0, -16 },
  { 845, 9, 16, 10, 0, -16 },
  { 863, 18, 16, 17, 0, -16 },
  { 899, 15, 16, 15, 0, -16 },
  { 929, 13, 16, 14, 1, -16 },
  { 955, 12, 16, 12, 0, -16 },
  { 979, 13, 20, 14, 1, -16 },
  { 1012, 12, 16, 12, 0, -16 },
  { 1036, 11, 16, 10, 0, -16 },
  { 1058, 10, 16, 10, 2, -16 },
  { 1078, 13, 16, 13, 1, -16 },
  { 1104, 12, 16, 12, 2, -16 },
  { 1128, 18, 16, 18, 2, -16 },
  { 1164, 15, 16, 12, -1, -16 },
  { 1194, 11, 16, 12, 2, -16 },
  { 1216, 13, 16, 10, -1, -16 },
  { 1242, 9, 20, 7, -1, -16 },
  { 1265, 6, 16, 9, 2, -16 },
  { 1277, 10, 20, 7, -2, -16 },
  { 1302, 11, 11, 11, 0, -16 },
  { 1318, 9, 3, 9, -2, 1 },
  { 1322, 5, 4, 7, 3, -17 },
  { 1325, 12, 12, 12, 0, -12 },
  { 1343, 11, 17, 12, 0, -17 },
  { 1367, 9, 12, 9, 1, -12 },
  { 1381, 13, 17, 11, 0, -17 },
  { 1409, 10, 12, 11, 1, -12 },
  { 1424, 12, 22, 7, -2, -17 },
  { 1457, 12, 17, 12, 0, -12 },
  { 1483, 11, 17, 12, 0, -17 },
  { 1507, 7, 17, 6, 0, -17 },
  { 1522, 10, 22, 6, -3, -17 },
  { 1550, 13, 17, 12, 0, -17 },
  { 1578, 7, 17, 6, 0, -17 },
  { 1593, 17, 12, 17, 0, -12 },
  { 1619, 11, 12, 12, 0, -12 },
  { 1636, 10, 12, 11, 1, -12 },
  { 1651, 12, 17, 12, -1, -12 },
  { 1677, 12, 17, 12, 0, -12 },
  { 1703, 9, 12, 8, 0, -12 },
  { 1717, 9, 12, 9, 0, -12 },
  { 1731, 8, 15, 8, 1, -15 },
  { 1746, 11, 12, 12, 1, -12 },
  { 1763, 11, 12, 11, 1, -12 },
  { 1780, 16, 12, 16, 1, -12 },
  { 1804, 13, 12, 11, -1, -12 },
  { 1824, 13, 17, 11, -1, -12 },
  { 1852, 11, 12, 9, -1, -12 },
  { 1869, 9, 19, 8, 0, -16 },
  { 1891, 3, 22, 10, 3, -17 },
  { 1900, 9, 19, 8, -1, -16 },
  { 1922, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_BlackItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC22PT7B_H_
