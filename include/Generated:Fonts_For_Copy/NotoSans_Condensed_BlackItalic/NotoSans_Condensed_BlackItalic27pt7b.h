#ifndef _NOTOSANS_CONDENSED_BLACKITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x7D,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xC7, 0x3C, 0xF3, 0xC0, 0x03, 0xCE,
  0x03, 0xDE, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0xBC, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3D, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x7B, 0xC0, 0x73, 0x80,
  0x00, 0x40, 0x01, 0x00, 0x1E, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xE9,
  0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xC4, 0x2F, 0x18, 0xBC, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x1E, 0x0F, 0xE0,
  0xE0, 0x7F, 0x0F, 0x07, 0xBC, 0x70, 0x39, 0xE7, 0x01, 0xCE, 0x78, 0x0E,
  0x73, 0x80, 0xF7, 0xBC, 0xE3, 0xFB, 0xDF, 0x9F, 0xDD, 0xFE, 0xFD, 0xEF,
  0xF0, 0x8E, 0xF3, 0x80, 0xF7, 0xBC, 0x0F, 0x39, 0xE0, 0x71, 0xCE, 0x07,
  0x8E, 0x70, 0x38, 0x7F, 0x83, 0x83, 0xF8, 0x3C, 0x0F, 0x80, 0x00, 0x40,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF7, 0xC7, 0xF3, 0xE7, 0xFD, 0xE7,
  0xFF, 0xF7, 0xCF, 0xF3, 0xE7, 0xF9, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xF7, 0xE0, 0x7D, 0xE7, 0x9E, 0x79, 0xCF, 0x00, 0x03,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x83, 0xC0, 0x06, 0x00, 0x78, 0x47, 0x06, 0x70, 0xFF, 0x6F, 0xFF, 0x7F,
  0xF1, 0xFF, 0x3F, 0x0F, 0xF8, 0x7B, 0xC3, 0x3C, 0x13, 0x00, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xCF, 0x1E,
  0x78, 0x7F, 0x7F, 0x7F, 0xFE, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01,
  0x00, 0x3F, 0x03, 0xFC, 0x3F, 0xE3, 0xFF, 0x1E, 0x7D, 0xF3, 0xEF, 0x9F,
  0x78, 0xF7, 0xC7, 0xBE, 0x3D, 0xF3, 0xEF, 0x9F, 0x78, 0xF3, 0xCF, 0x9E,
  0x7C, 0xFF, 0xC7, 0xFC, 0x1F, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x3F,
  0x8F, 0xE7, 0xFD, 0xFF, 0x9F, 0xF1, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x40, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x18, 0xF0, 0x47, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0x00, 0x80,
  0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x0E, 0xFC, 0x21, 0xE0, 0x07, 0x80, 0x3E,
  0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x20, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xBC, 0x1D,
  0xF0, 0xF7, 0xC7, 0x9E, 0x1C, 0x78, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC8, 0x1F, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x1F, 0xC3, 0xFE, 0x3F, 0xF1,
  0xF8, 0x9F, 0x00, 0xF0, 0x0F, 0xB8, 0x7B, 0xE3, 0xFF, 0xBF, 0xFD, 0xF3,
  0xEF, 0x9F, 0x7C, 0xFB, 0xE7, 0xDF, 0x7C, 0xFF, 0xE3, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0x79, 0xF1, 0xE7,
  0x87, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xFC, 0x7D, 0xF1, 0xE3,
  0xCF, 0x8F, 0x3E, 0x3C, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x01,
  0x00, 0x7F, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x3E, 0x79, 0xF3, 0xEF, 0x1E,
  0x79, 0xF3, 0xEF, 0x9F, 0xFC, 0xFF, 0xE3, 0xFE, 0x0C, 0xF0, 0x0F, 0x00,
  0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0x81, 0xF8, 0x00, 0x1E, 0x3C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0xCF, 0x9F, 0x3C, 0x00, 0x07, 0x83,
  0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x00, 0x00, 0x10, 0x03, 0x00,
  0xF0, 0x3F, 0x0F, 0xF3, 0xF8, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0x0F, 0xF3, 0xFC, 0xFF, 0x0F,
  0xC0, 0xF0, 0x0C, 0x00, 0x02, 0x03, 0xF9, 0xFF, 0xBF, 0xF3, 0xBE, 0x43,
  0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x1E, 0x78, 0x61, 0xCE, 0x3F,
  0xBB, 0xCF, 0xF7, 0x73, 0xDC, 0xFE, 0xF3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E,
  0x7E, 0x73, 0x9F, 0xCE, 0x73, 0xB9, 0xFF, 0xE7, 0x3E, 0xFC, 0xE3, 0x9E,
  0x1E, 0x00, 0x01, 0xE0, 0x10, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xDE, 0x03, 0xDE, 0x07, 0xDF, 0x07, 0x9F, 0x0F, 0x9F, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C,
  0x1F, 0xFC, 0x1F, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC7, 0x9F, 0x1F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x1F, 0x3E, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFF, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8,
  0xF8, 0x23, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x08, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E,
  0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7D, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x84, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x30, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0x04,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xFC, 0xF9, 0xFC, 0xF9, 0xFC,
  0xF9, 0xFC, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE3, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0,
  0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7F,
  0xC7, 0xFE, 0x3F, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xF8, 0x00, 0x0F, 0x8F, 0xC3,
  0xC7, 0xC0, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xEF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0xC0, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0x7F, 0xDF, 0xFB, 0xFF, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x07,
  0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x3D, 0xCF, 0xF0, 0xF7, 0x7B, 0xC3, 0xDD,
  0xFF, 0x0F, 0x77, 0x7C, 0x7D, 0xFD, 0xE1, 0xF7, 0xE7, 0x87, 0x9F, 0x9E,
  0x1E, 0x7E, 0xF8, 0x79, 0xF3, 0xE3, 0xE7, 0xCF, 0x0F, 0x9E, 0x3C, 0x00,
  0x0F, 0xC3, 0xE1, 0xF8, 0x78, 0x3F, 0x0F, 0x0F, 0xE3, 0xE1, 0xFC, 0x7C,
  0x3F, 0xCF, 0x07, 0xF9, 0xE1, 0xFF, 0x3C, 0x3D, 0xEF, 0x87, 0xBF, 0xF0,
  0xF7, 0xFC, 0x1E, 0x7F, 0x87, 0xCF, 0xF0, 0xF9, 0xFE, 0x1E, 0x3F, 0xC3,
  0xC3, 0xF0, 0x78, 0x7E, 0x1F, 0x0F, 0xC3, 0xC1, 0xF8, 0x00, 0x00, 0x40,
  0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x7E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE3,
  0xE7, 0xC7, 0x8F, 0x1F, 0x3E, 0x3E, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x40, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3E, 0x3E, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1,
  0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x3E, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x07, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0x7C, 0x78, 0xF9,
  0xF1, 0xF3, 0xE3, 0xF0, 0x00, 0x80, 0x1F, 0xE0, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0xF8, 0x43, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xE0, 0x0F, 0x88, 0x3E, 0x30, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xC0, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x1F,
  0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80,
  0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xC7, 0x8F, 0x8F, 0x1F, 0x1E,
  0x7C, 0x3C, 0xF8, 0x79, 0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0xF9,
  0xF8, 0xF3, 0xE7, 0xE7, 0xCF, 0xBF, 0x9E, 0x3E, 0xFE, 0xF8, 0xFB, 0xFB,
  0xE3, 0xDF, 0xEF, 0x0F, 0x7F, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83,
  0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E,
  0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xC3,
  0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0xF1, 0xF1, 0xF3, 0xE3, 0xEF, 0x87, 0xDF,
  0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xFC, 0x3F, 0x87, 0xE0,
  0xFC, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0x1E, 0x79, 0xE7, 0x9E, 0x78,
  0xE3, 0xCF, 0x3C, 0xF3, 0xCF, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x7B, 0xC3, 0xDE, 0x3C, 0xF3, 0xC3, 0x9E,
  0x1F, 0xE0, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xFB, 0xE7, 0x8F, 0x1C,
  0x1F, 0x79, 0xFB, 0xCF, 0xFE, 0xFF, 0xF7, 0xCF, 0x7C, 0x7B, 0xE7, 0xDF,
  0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE1, 0xEF,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xEF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xE7, 0xCF, 0x1F, 0x3C, 0x79,
  0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8,
  0xF7, 0xC0, 0x0F, 0xC3, 0xFC, 0xFF, 0xBF, 0xE7, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC2, 0x7F, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE1, 0xF7, 0x8F,
  0xDE, 0x3F, 0xF9, 0xFF, 0xE7, 0xCF, 0x3E, 0x3C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7B, 0xC0,
  0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xCF, 0x78, 0xFF, 0x9F, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x8C, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00,
  0x18, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x5F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xBC, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3E, 0x79, 0xF1,
  0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xC7, 0x9F, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0x83, 0xDE, 0x00, 0x78, 0x03, 0xE3, 0x1F, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xEF, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3, 0xE7, 0xCF, 0x9E,
  0x3C, 0x79, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x40, 0x00, 0x7C,
  0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x3E, 0x1F, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x80,
  0x00, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x3F, 0x1E,
  0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xF0, 0xF9, 0xF0, 0xF9,
  0xF0, 0xF8, 0xF8, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x1F, 0x0F, 0x80, 0x1E, 0xF9, 0xE0, 0xFF, 0xDF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xE7, 0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x00, 0x1E, 0xF0, 0x7F, 0xE3, 0xFF,
  0xCF, 0xFF, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0x8F, 0x1E, 0x3C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x0F, 0xC1,
  0xFE, 0x3F, 0xF7, 0xFF, 0x7C, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF,
  0x1F, 0xF3, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0xBC, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x9F, 0x0F, 0x1F, 0x0F, 0x1E, 0x1F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3D, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x0F, 0x79, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xCF, 0x7C,
  0x7B, 0xE7, 0xDF, 0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xE1, 0xEF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x00, 0x1E, 0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0xC1, 0xFF, 0x3F, 0xE3, 0xCC, 0x3C, 0x03, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xC0, 0x7C, 0x87, 0xCF, 0xFC, 0xFF, 0x8F, 0xF8, 0xFE, 0x00,
  0x0F, 0x03, 0x81, 0xE0, 0xFF, 0x7F, 0xFF, 0xEF, 0xF9, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x80, 0x3C,
  0x7C, 0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xBE, 0x3F, 0xF8, 0xFF, 0xE3, 0xF7, 0x87,
  0xDC, 0x00, 0xF0, 0xFF, 0x8F, 0xBC, 0x79, 0xE7, 0xCF, 0x3C, 0x7B, 0xE3,
  0xDE, 0x1E, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x00, 0xF1, 0xF3, 0xFE, 0x7E, 0x7B, 0xCF, 0xDF, 0x7B, 0xFB,
  0xEF, 0x7E, 0x79, 0xEF, 0xDF, 0x3F, 0xFB, 0xC7, 0xF7, 0x78, 0xFE, 0xFE,
  0x1F, 0xDF, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0,
  0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x1F, 0x3E, 0x0F, 0x7C, 0x0F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x7D, 0xF0, 0x7D, 0xF0, 0xF8, 0xF8, 0x1F, 0x0F, 0x87,
  0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xFF, 0xC7, 0xFE, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x0F, 0xC1, 0xF8, 0x78, 0x0F,
  0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x7E, 0x1F,
  0x83, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_BlackItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 19, 7, 0, -19 },
  { 23, 12, 7, 12, 2, -19 },
  { 34, 16, 19, 15, 0, -19 },
  { 72, 14, 23, 14, 0, -21 },
  { 113, 21, 20, 22, 1, -20 },
  { 166, 17, 20, 17, 0, -20 },
  { 209, 6, 7, 6, 2, -19 },
  { 215, 11, 24, 8, 0, -20 },
  { 248, 10, 24, 8, -2, -20 },
  { 278, 12, 13, 13, 2, -21 },
  { 298, 12, 13, 14, 1, -16 },
  { 318, 7, 8, 7, -2, -4 },
  { 325, 8, 4, 8, 0, -9 },
  { 329, 5, 5, 7, 0, -5 },
  { 333, 15, 20, 11, -1, -20 },
  { 371, 13, 20, 14, 1, -20 },
  { 404, 11, 19, 14, 2, -19 },
  { 431, 14, 20, 14, -1, -20 },
  { 466, 14, 20, 14, 0, -20 },
  { 501, 14, 19, 14, 0, -19 },
  { 535, 14, 19, 14, 0, -19 },
  { 569, 13, 20, 14, 1, -20 },
  { 602, 14, 19, 14, 1, -19 },
  { 636, 14, 20, 14, 0, -20 },
  { 671, 13, 20, 14, 1, -20 },
  { 704, 7, 15, 8, 0, -15 },
  { 718, 9, 19, 8, -2, -15 },
  { 740, 12, 14, 14, 1, -17 },
  { 761, 12, 9, 14, 1, -14 },
  { 775, 12, 14, 14, 1, -17 },
  { 796, 11, 20, 11, 1, -20 },
  { 824, 19, 22, 21, 1, -20 },
  { 877, 16, 19, 16, -2, -19 },
  { 915, 15, 19, 15, 0, -19 },
  { 951, 14, 20, 14, 1, -20 },
  { 986, 16, 19, 16, 0, -19 },
  { 1024, 14, 19, 12, 0, -19 },
  { 1058, 14, 19, 12, 0, -19 },
  { 1092, 16, 20, 16, 1, -20 },
  { 1132, 17, 19, 16, 0, -19 },
  { 1173, 13, 19, 11, -1, -19 },
  { 1204, 13, 25, 8, -4, -19 },
  { 1245, 18, 19, 15, 0, -19 },
  { 1288, 11, 19, 12, 0, -19 },
  { 1315, 22, 19, 21, 0, -19 },
  { 1368, 19, 19, 18, 0, -19 },
  { 1414, 16, 20, 17, 1, -20 },
  { 1454, 15, 19, 14, 0, -19 },
  { 1490, 16, 25, 17, 1, -20 },
  { 1540, 15, 19, 15, 0, -19 },
  { 1576, 14, 20, 13, 0, -20 },
  { 1611, 13, 19, 13, 2, -19 },
  { 1642, 16, 19, 16, 1, -19 },
  { 1680, 15, 19, 15, 2, -19 },
  { 1716, 22, 19, 22, 2, -19 },
  { 1769, 19, 19, 15, -2, -19 },
  { 1815, 15, 19, 14, 2, -19 },
  { 1851, 15, 19, 13, -1, -19 },
  { 1887, 11, 25, 8, -1, -20 },
  { 1922, 6, 20, 11, 3, -20 },
  { 1937, 12, 25, 8, -2, -20 },
  { 1975, 13, 12, 13, 0, -19 },
  { 1995, 12, 3, 11, -3, 2 },
  { 2000, 6, 5, 9, 4, -21 },
  { 2004, 13, 15, 14, 1, -15 },
  { 2029, 14, 21, 14, 0, -21 },
  { 2066, 11, 15, 12, 1, -15 },
  { 2087, 14, 21, 14, 1, -21 },
  { 2124, 12, 15, 13, 1, -15 },
  { 2147, 15, 27, 9, -3, -21 },
  { 2198, 14, 21, 14, 0, -15 },
  { 2235, 14, 21, 14, 0, -21 },
  { 2272, 9, 21, 7, 0, -21 },
  { 2296, 12, 27, 7, -3, -21 },
  { 2337, 16, 21, 14, 0, -21 },
  { 2379, 9, 21, 7, 0, -21 },
  { 2403, 21, 15, 21, 0, -15 },
  { 2443, 14, 15, 14, 0, -15 },
  { 2470, 12, 15, 14, 1, -15 },
  { 2493, 16, 21, 14, -2, -15 },
  { 2535, 13, 21, 14, 1, -15 },
  { 2570, 12, 15, 10, 0, -15 },
  { 2593, 12, 15, 11, 0, -15 },
  { 2616, 10, 18, 10, 1, -18 },
  { 2639, 14, 15, 14, 1, -15 },
  { 2666, 13, 15, 13, 2, -15 },
  { 2691, 19, 15, 19, 2, -15 },
  { 2727, 16, 15, 13, -1, -15 },
  { 2757, 17, 21, 13, -2, -15 },
  { 2802, 13, 15, 11, -1, -15 },
  { 2827, 11, 23, 9, 0, -19 },
  { 2859, 4, 27, 12, 4, -21 },
  { 2873, 11, 23, 9, -2, -19 },
  { 2905, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_BlackItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC27PT7B_H_
