#ifndef _NOTOSANS_CONDENSED_BLACKITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC,
  0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03, 0xE3, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x7F, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xF7, 0x83, 0xF6, 0x10, 0x7C, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x1D, 0xF9, 0x83, 0xBE, 0x3C, 0x6F, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xF8,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0xC0, 0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x07, 0xC0, 0x3E,
  0xF8, 0x3E, 0x01, 0xF3, 0xE0, 0xF8, 0x07, 0xCF, 0x87, 0xC0, 0x1F, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0xF8, 0x03, 0xE3, 0xE7, 0xC0, 0x0F, 0x8F, 0x9F,
  0x00, 0x3E, 0x7C, 0xF8, 0xF8, 0xFB, 0xF7, 0xCF, 0xF3, 0xFF, 0x9F, 0x7F,
  0xE7, 0xFE, 0xF9, 0xFF, 0x9F, 0xF7, 0xEF, 0xBF, 0x3F, 0x1F, 0x3E, 0x7C,
  0x00, 0xF9, 0xF1, 0xF0, 0x03, 0xE7, 0xC7, 0xC0, 0x1F, 0x1F, 0x3E, 0x00,
  0xF8, 0x7C, 0xF8, 0x03, 0xE1, 0xF3, 0xE0, 0x1F, 0x07, 0x8F, 0x80, 0x7C,
  0x1F, 0x7C, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80,
  0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xF8, 0x3F, 0xF1,
  0xFC, 0x7F, 0xF9, 0xFC, 0x7F, 0xFE, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xBF,
  0xFF, 0x1F, 0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xE1, 0xFF, 0x87, 0xF0,
  0xFF, 0x83, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x7E, 0x7E,
  0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x3E, 0x07, 0x1E, 0x03, 0xEF, 0x07,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE3, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0x79, 0xFC, 0x1C, 0x7C, 0x04,
  0x38, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xC7, 0xE3,
  0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x7F, 0xF7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xF3, 0xF8,
  0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0xBF, 0x87, 0xE7,
  0xF0, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF,
  0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F,
  0xBF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x7E, 0xFC, 0x3D, 0xFC,
  0x39, 0xFC, 0x11, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xC7, 0xF0, 0x38, 0x7F, 0x01, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x02,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0x88, 0x03, 0xF8, 0xF8, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1E, 0xFC, 0x03, 0xFF, 0xC0, 0x7D, 0xF8,
  0x0F, 0x9F, 0x80, 0xF9, 0xF8, 0x1F, 0x3F, 0x83, 0xE3, 0xF8, 0x3E, 0x3F,
  0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xE7, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF1, 0x01, 0xFE, 0x3C, 0x7F, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xC6, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x80,
  0x3F, 0x7F, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFB, 0xFC, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFE, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xF9, 0xF8, 0x7F, 0x1F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xEF, 0xE1, 0xF9, 0xFC, 0x7F, 0x3F,
  0x8F, 0xE7, 0xF3, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFB, 0xF0, 0x3C, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x21, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xF8, 0x00, 0x00,
  0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFF, 0x3E, 0xFF, 0x30, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0,
  0xF8, 0x7F, 0x1F, 0x1F, 0x0F, 0xFC, 0xF3, 0xE3, 0xFF, 0xCF, 0x3E, 0x3F,
  0xFC, 0xF3, 0xC7, 0xC7, 0x8F, 0x7C, 0xF8, 0xF8, 0xF7, 0x8F, 0x8F, 0x8F,
  0x78, 0xF0, 0xF8, 0xFF, 0x9F, 0x0F, 0x1F, 0xF9, 0xF1, 0xF1, 0xEF, 0x9F,
  0x1F, 0x1E, 0xF9, 0xF1, 0xF3, 0xEF, 0x9F, 0x3F, 0x7C, 0xF9, 0xFF, 0xFF,
  0x8F, 0x8F, 0xFF, 0xF0, 0xF8, 0xFE, 0xFE, 0x0F, 0x83, 0x83, 0x80, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x3F, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7E, 0x3F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x1F, 0xE0, 0xC3, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x20, 0xFF, 0xBE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0,
  0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x0F, 0xE3, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x02, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x3F,
  0xF3, 0xF8, 0xFF, 0xCF, 0xE3, 0xFF, 0x3F, 0x8F, 0xF8, 0xFE, 0x7F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x21, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF,
  0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xBE, 0x7F, 0xF8, 0x1F, 0xBE,
  0x7D, 0xF8, 0x1F, 0xBE, 0xFD, 0xF8, 0x1F, 0xBE, 0xFB, 0xF8, 0x3F, 0xBE,
  0xFB, 0xF8, 0x3F, 0xBF, 0xFB, 0xF0, 0x3F, 0x3F, 0xF3, 0xF0, 0x3F, 0x3F,
  0xF7, 0xF0, 0x3F, 0x3F, 0xE7, 0xF0, 0x7F, 0x3F, 0xE7, 0xE0, 0x7E, 0x3F,
  0xC7, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0x03, 0xFC,
  0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xE0,
  0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x87, 0xF0, 0x7F, 0xF0,
  0xFC, 0x0F, 0xFE, 0x1F, 0x81, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0xFE, 0x07,
  0xFF, 0x9F, 0xC1, 0xFB, 0xF3, 0xF0, 0x3F, 0x7E, 0x7E, 0x07, 0xE7, 0xEF,
  0xC0, 0xFC, 0xFD, 0xF8, 0x3F, 0x9F, 0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFC,
  0x7F, 0xF8, 0x1F, 0x87, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0xFE, 0x1F, 0xF8,
  0x1F, 0x83, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0,
  0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0x7E, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xCF,
  0xF0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x8F,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xF3, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xE1,
  0xC1, 0xFC, 0x04, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x40, 0x7F, 0x0F,
  0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x3F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0x81, 0xFC,
  0x7E, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F,
  0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07,
  0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0xFC, 0xFE, 0x1F,
  0xE1, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE1, 0xF8, 0xFE, 0x3F,
  0xE3, 0xF8, 0xFE, 0x3F, 0xE3, 0xF0, 0xFE, 0x7F, 0xE7, 0xF0, 0xFE, 0x7F,
  0xE7, 0xF0, 0xFC, 0x7F, 0xE7, 0xE0, 0xFC, 0xFF, 0xEF, 0xE0, 0xFC, 0xFF,
  0xEF, 0xC0, 0xFD, 0xFF, 0xEF, 0xC0, 0xFD, 0xF7, 0xFF, 0xC0, 0xFD, 0xF7,
  0xDF, 0x80, 0xFF, 0xF7, 0xDF, 0x80, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE7,
  0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0xFE, 0x07,
  0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E,
  0x1F, 0x83, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x01,
  0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0xFE,
  0x7E, 0x7F, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x7F, 0x3E, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xBE, 0x03, 0xF3, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xEF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFD, 0xFE, 0x0F,
  0x8F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFE, 0x08, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x10,
  0xFE, 0x38, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xE7,
  0xF0, 0x3F, 0xBF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFD,
  0xFC, 0x3F, 0x7F, 0x3F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x06, 0x3F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x02, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0xFC, 0x07, 0xF3, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFE, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x80, 0x3F, 0x03, 0x81, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE7, 0x80, 0xFD,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x4F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE1,
  0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x81, 0xFC, 0xFE,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7E, 0x3F, 0x80, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xC7, 0x81, 0xE0, 0x3F, 0x7F, 0x9F, 0xE0, 0xFF,
  0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x80, 0x0F, 0xCF, 0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87,
  0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xF7, 0xF3, 0xF9,
  0xFD, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x7F, 0x3F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC,
  0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x7F, 0x80, 0xFC, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xE3, 0xF0, 0x7F, 0x3E, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC7, 0x87, 0xEF, 0x83,
  0xEF, 0xC1, 0xF7, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFC, 0x70, 0xFE, 0x08, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF1, 0x01, 0xF8, 0xE1, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x43, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0x7F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x03, 0xF3, 0xE0, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE3, 0xF8, 0xFC, 0x7F,
  0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1, 0xFB, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC3, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F,
  0xC7, 0xEF, 0xE7, 0xFC, 0x7E, 0xFE, 0x7F, 0xCF, 0xEF, 0xE7, 0xFC, 0xFC,
  0xFC, 0xFF, 0x9F, 0xCF, 0xCF, 0xF9, 0xF8, 0xFC, 0xF7, 0x9F, 0x8F, 0xDF,
  0xFB, 0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDE, 0xFB, 0xF0, 0xFF, 0xEF, 0xFE,
  0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x0F,
  0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01,
  0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_BlackItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 28, 11, 0, -28 },
  { 47, 16, 10, 18, 4, -28 },
  { 67, 23, 28, 22, 0, -28 },
  { 148, 19, 32, 20, 1, -30 },
  { 224, 30, 28, 32, 2, -28 },
  { 329, 25, 28, 25, 0, -28 },
  { 417, 8, 10, 9, 4, -28 },
  { 427, 14, 35, 12, 1, -29 },
  { 489, 14, 35, 12, -3, -29 },
  { 551, 17, 19, 18, 3, -30 },
  { 592, 17, 19, 21, 2, -23 },
  { 633, 10, 10, 11, -2, -5 },
  { 646, 12, 6, 12, 0, -13 },
  { 655, 7, 7, 11, 0, -7 },
  { 662, 22, 28, 16, -2, -28 },
  { 739, 19, 28, 20, 1, -28 },
  { 806, 16, 28, 20, 3, -28 },
  { 862, 20, 28, 20, -1, -28 },
  { 932, 20, 28, 20, 0, -28 },
  { 1002, 20, 28, 20, 0, -28 },
  { 1072, 19, 28, 20, 1, -28 },
  { 1139, 20, 28, 20, 1, -28 },
  { 1209, 21, 28, 20, 1, -28 },
  { 1283, 20, 28, 20, 0, -28 },
  { 1353, 19, 28, 20, 1, -28 },
  { 1420, 11, 22, 11, 0, -22 },
  { 1451, 13, 27, 11, -2, -22 },
  { 1495, 17, 20, 21, 2, -24 },
  { 1538, 17, 14, 21, 2, -21 },
  { 1568, 17, 20, 21, 2, -24 },
  { 1611, 16, 28, 16, 2, -28 },
  { 1667, 28, 31, 30, 1, -28 },
  { 1776, 22, 28, 22, -2, -28 },
  { 1853, 22, 28, 22, 0, -28 },
  { 1930, 20, 28, 20, 2, -28 },
  { 2000, 23, 28, 23, 0, -28 },
  { 2081, 20, 28, 18, 0, -28 },
  { 2151, 20, 28, 18, 0, -28 },
  { 2221, 22, 28, 23, 2, -28 },
  { 2298, 25, 28, 24, 0, -28 },
  { 2386, 19, 28, 15, -1, -28 },
  { 2453, 19, 37, 12, -6, -28 },
  { 2541, 25, 28, 22, 0, -28 },
  { 2629, 15, 28, 17, 0, -28 },
  { 2682, 32, 28, 31, 0, -28 },
  { 2794, 27, 28, 26, 0, -28 },
  { 2889, 22, 28, 24, 2, -28 },
  { 2966, 21, 28, 20, 0, -28 },
  { 3040, 22, 35, 24, 2, -28 },
  { 3137, 21, 28, 21, 0, -28 },
  { 3211, 20, 28, 18, 0, -28 },
  { 3281, 18, 28, 18, 3, -28 },
  { 3344, 22, 28, 23, 2, -28 },
  { 3421, 22, 28, 21, 3, -28 },
  { 3498, 32, 28, 31, 3, -28 },
  { 3610, 26, 28, 21, -2, -28 },
  { 3701, 21, 28, 20, 3, -28 },
  { 3775, 23, 28, 18, -2, -28 },
  { 3856, 17, 36, 12, -2, -29 },
  { 3933, 10, 28, 16, 4, -28 },
  { 3968, 17, 36, 12, -3, -29 },
  { 4045, 20, 19, 19, -1, -28 },
  { 4093, 17, 4, 16, -4, 3 },
  { 4102, 8, 6, 13, 6, -30 },
  { 4108, 20, 22, 20, 1, -22 },
  { 4163, 20, 30, 20, 0, -30 },
  { 4238, 17, 22, 17, 1, -22 },
  { 4285, 21, 30, 20, 1, -30 },
  { 4364, 18, 22, 19, 1, -22 },
  { 4414, 22, 39, 13, -4, -30 },
  { 4522, 22, 31, 20, -1, -22 },
  { 4608, 20, 30, 21, 0, -30 },
  { 4683, 12, 30, 11, 0, -30 },
  { 4728, 17, 39, 11, -5, -30 },
  { 4811, 23, 30, 20, 0, -30 },
  { 4898, 13, 30, 11, 0, -30 },
  { 4947, 30, 22, 31, 0, -22 },
  { 5030, 20, 22, 21, 0, -22 },
  { 5085, 18, 22, 20, 1, -22 },
  { 5135, 22, 31, 20, -2, -22 },
  { 5221, 20, 31, 20, 1, -22 },
  { 5299, 17, 22, 15, 0, -22 },
  { 5346, 17, 22, 16, 0, -22 },
  { 5393, 14, 26, 15, 2, -26 },
  { 5439, 20, 22, 21, 1, -22 },
  { 5494, 19, 22, 19, 2, -22 },
  { 5547, 28, 22, 28, 2, -22 },
  { 5624, 23, 22, 19, -2, -22 },
  { 5688, 23, 31, 19, -2, -22 },
  { 5778, 18, 22, 16, -1, -22 },
  { 5828, 17, 34, 14, 0, -28 },
  { 5901, 5, 39, 17, 6, -30 },
  { 5926, 16, 34, 14, -2, -28 },
  { 5994, 17, 7, 21, 2, -17 },
};

const GFXfont NotoSans_Condensed_BlackItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC39PT7B_H_
