#ifndef _NOTOSANS_CONDENSED_BLACKITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x04, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x7C, 0xFB, 0xE7, 0xDF, 0x7E, 0xFB,
  0xEF, 0x9F, 0x7C, 0xFB, 0xE7, 0x9E, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x07, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x1E, 0x78, 0x03, 0x8F, 0x00,
  0xF3, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x83,
  0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xC0, 0x1E,
  0x78, 0x00, 0x00, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xDC, 0x3E, 0xC4, 0x3E, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x83, 0x78,
  0xC3, 0x78, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x78, 0x3F, 0xC0, 0xF0,
  0x3F, 0xC1, 0xF0, 0x7F, 0xC1, 0xE0, 0x79, 0xE3, 0xC0, 0xF3, 0xC3, 0xC0,
  0xF3, 0xC7, 0x80, 0xF3, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xF7, 0xDE, 0x7C,
  0xF7, 0xBE, 0xFE, 0xFF, 0xBD, 0xFF, 0x7F, 0x79, 0xFF, 0x7E, 0x7B, 0xCF,
  0x00, 0xF3, 0xCF, 0x01, 0xE3, 0xCF, 0x01, 0xE7, 0x8F, 0x03, 0xC7, 0x9E,
  0x07, 0xC7, 0x9E, 0x07, 0x87, 0xFE, 0x0F, 0x03, 0xFC, 0x0F, 0x03, 0xF8,
  0x1E, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF9, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF7,
  0xFF, 0xFE, 0x7E, 0xFF, 0xEF, 0xCF, 0xFC, 0xFC, 0x7F, 0x8F, 0xC7, 0xF8,
  0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xCF,
  0xE0, 0x7D, 0xF7, 0xDF, 0xFB, 0xEF, 0xBC, 0x03, 0xE0, 0xF8, 0x1E, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C,
  0x00, 0x02, 0x00, 0x0F, 0x80, 0x3C, 0x08, 0xF0, 0x73, 0xC1, 0xFE, 0x77,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0x03, 0xFE, 0x1F, 0xF8, 0x3D, 0xF0,
  0x63, 0xC0, 0x8C, 0x00, 0x20, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x1F,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0xFF,
  0x80, 0x11, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F,
  0x1F, 0x7E, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xFF, 0xC7, 0xDF, 0x8F,
  0xBE, 0x3F, 0x7C, 0x7E, 0xF8, 0xF9, 0xF3, 0xF3, 0xFF, 0xC7, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0xE1, 0xFF, 0x1F, 0xFB, 0xFF, 0x9F, 0xFC, 0x7F, 0xE3, 0x3F, 0x09, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x38, 0xFC, 0x08, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x04, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x80, 0xFC, 0xF3, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0xFC, 0x7C, 0xF8, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF9, 0x03, 0xF3, 0xDF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xE6, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0xF8, 0x7D, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFE, 0xFC, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x9F,
  0x1F, 0x1F, 0x1F, 0xBF, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7E, 0xFC, 0x7C,
  0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x8F, 0xBF,
  0x3F, 0x7E, 0x7E, 0xF8, 0xFD, 0xFB, 0xFB, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE2, 0x3F, 0x87, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x83, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x3F, 0xF1,
  0xFF, 0x8F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xFF, 0x98, 0x7C, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07,
  0xE0, 0xF8, 0x03, 0xC3, 0xE0, 0x03, 0xC7, 0x8F, 0xE7, 0x9E, 0x3F, 0xEF,
  0x78, 0xFF, 0xCE, 0xF3, 0xCF, 0x1D, 0xC7, 0x9E, 0x7F, 0x9E, 0x3C, 0xFF,
  0x3C, 0x79, 0xFE, 0x79, 0xE3, 0xBC, 0xE3, 0xCF, 0x79, 0xE7, 0x9C, 0xF3,
  0xFF, 0xF9, 0xE7, 0xFF, 0xE3, 0xC7, 0xDF, 0x87, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x60, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC,
  0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xFF, 0xC0, 0x7C, 0x07, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0xDF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC,
  0x10, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x04, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE1, 0xF8, 0xF8,
  0x7E, 0x7E, 0x3F, 0x9F, 0x9F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x81, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF9, 0xFE, 0x3E, 0x3F, 0xCF, 0xC7, 0xF9, 0xF9, 0xFE, 0x3F, 0x07,
  0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFE,
  0xFF, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xC1, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x1F, 0xF1, 0xFF,
  0x87, 0xFC, 0x7F, 0xC1, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0x7C, 0x3E, 0xF7,
  0xFF, 0x0F, 0xBD, 0xEF, 0x83, 0xEF, 0xFB, 0xE0, 0xFB, 0xFC, 0xF8, 0x7E,
  0xFF, 0x3E, 0x1F, 0x3F, 0x9F, 0x87, 0xCF, 0xE7, 0xC1, 0xF3, 0xF9, 0xF0,
  0x7C, 0xFC, 0x7C, 0x3F, 0x3F, 0x3F, 0x0F, 0x8F, 0x8F, 0xC0, 0x07, 0xE0,
  0x7C, 0x1F, 0x81, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8,
  0x3F, 0xC3, 0xE0, 0xFF, 0x8F, 0x87, 0xFE, 0x7E, 0x1F, 0xF9, 0xF0, 0x7F,
  0xE7, 0xC1, 0xFF, 0x9F, 0x0F, 0xDF, 0x7C, 0x3E, 0x7F, 0xF0, 0xF9, 0xFF,
  0x83, 0xE7, 0xFE, 0x0F, 0x9F, 0xF8, 0x7E, 0x3F, 0xE1, 0xF0, 0xFF, 0x07,
  0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC3, 0xE0, 0x7F, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0x3F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0xFC, 0x3E, 0x3E,
  0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F,
  0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0x3F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x87, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0xFC, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x9F,
  0x8F, 0xCF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7D, 0xF8, 0x7E, 0xFC, 0x3F, 0x3E, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7,
  0xC7, 0xE7, 0xE1, 0xFB, 0xF0, 0xFC, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x84, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x80, 0xFC, 0xE1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC,
  0x3E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0xC3,
  0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0xBF, 0x07, 0xDF,
  0x03, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x1F, 0x07, 0xEF,
  0x83, 0xE1, 0xF9, 0xF0, 0xFC, 0x3F, 0x3E, 0x1F, 0x87, 0xC7, 0xC3, 0xF1,
  0xF8, 0xF8, 0xFE, 0x3E, 0x1F, 0x1F, 0xC7, 0xC3, 0xE7, 0xF9, 0xF8, 0x7C,
  0xFF, 0x3E, 0x0F, 0xBF, 0xEF, 0xC1, 0xF7, 0xFD, 0xF0, 0x3E, 0xFF, 0xBE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0x7C, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81,
  0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x1F,
  0x9F, 0x8F, 0xC7, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x03,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E,
  0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x03, 0xF8, 0x3F, 0xC1,
  0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xBC,
  0x1F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xF9, 0xF9, 0xF3, 0xE3, 0xE3,
  0xC0, 0x07, 0x9F, 0x0F, 0xDF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E,
  0x7E, 0x7C, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8,
  0xFC, 0xF8, 0xF8, 0xFD, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0xF8, 0x7C,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xBC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF3,
  0xE0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x23,
  0xF3, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x7C,
  0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xCF, 0xC7, 0xC7,
  0xE7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E,
  0x3E, 0x1F, 0xBF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xE0,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xEF, 0xC7, 0xDF,
  0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x86, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0xFD, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F,
  0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xDF, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0xC0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xBC, 0x1F, 0x7E, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E,
  0x3E, 0x7E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0xFC,
  0x7C, 0xFC, 0xFC, 0xF8, 0xFC, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0x80,
  0x80, 0x00, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x80,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x83, 0xE7, 0xE0, 0x7D,
  0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7E, 0x07, 0xCF,
  0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC3, 0xE0, 0x0F, 0x3C, 0x3E, 0x1F, 0x7E, 0x7F, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x3F, 0x9F, 0x3F, 0x3F, 0x1F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3F, 0x3E, 0x3E, 0x3F, 0x7E, 0x3E, 0x3E, 0x7E,
  0x7E, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0x7C, 0x7C, 0xFC, 0xFC, 0x7C, 0xF8, 0xFC, 0xFC, 0x0F, 0x3C, 0x1F, 0x7E,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7E,
  0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xF8, 0xFC, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xEF, 0xCF, 0xDF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFB, 0xE1, 0xF7, 0xC7, 0xEF, 0x8F, 0xDF, 0xBF, 0x3F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x03, 0xCF, 0x01, 0xF7, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F,
  0x0F, 0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x9F, 0x87,
  0xEF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3E, 0xFE, 0x0F, 0x9E, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x9F, 0x0F, 0xDF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC,
  0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFD, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x7D, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x3C, 0x7D,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x3F, 0x30, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0xFC, 0x83, 0xF3, 0x0F, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x00, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xFF, 0x3F, 0xF7, 0xFE, 0x7F, 0xEF,
  0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x8F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x3F, 0x1F, 0x3F,
  0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFD,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0xF8, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xF7, 0xC7, 0xEF, 0x8F, 0x9F, 0x3F, 0x3E, 0x7C, 0x7D, 0xF8,
  0xFB, 0xE1, 0xF7, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x7F, 0xF1, 0xF8,
  0xFB, 0xE7, 0xF1, 0xF7, 0xCF, 0xE7, 0xEF, 0x9F, 0xCF, 0x9F, 0x7F, 0xBF,
  0x3E, 0xFF, 0x7C, 0x7D, 0xFE, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0xC3,
  0xFE, 0xFF, 0x87, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x3F,
  0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xDF, 0x81, 0xF9,
  0xF0, 0x7E, 0x3E, 0x1F, 0xC7, 0xE0, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D,
  0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xFE,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0x03, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0E, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 23, 9, 0, -23 },
  { 30, 13, 8, 14, 3, -23 },
  { 43, 19, 23, 18, 0, -23 },
  { 98, 16, 26, 16, 1, -24 },
  { 150, 24, 23, 27, 2, -23 },
  { 219, 20, 23, 20, 0, -23 },
  { 277, 6, 8, 8, 3, -23 },
  { 283, 11, 28, 10, 1, -23 },
  { 322, 11, 28, 10, -2, -23 },
  { 361, 14, 16, 15, 2, -25 },
  { 389, 15, 15, 17, 1, -19 },
  { 418, 8, 8, 9, -2, -4 },
  { 426, 10, 5, 10, 0, -11 },
  { 433, 6, 6, 9, 0, -6 },
  { 438, 18, 23, 13, -2, -23 },
  { 490, 15, 23, 16, 1, -23 },
  { 534, 13, 23, 16, 3, -23 },
  { 572, 17, 23, 16, -1, -23 },
  { 621, 16, 23, 16, 0, -23 },
  { 667, 16, 23, 16, 0, -23 },
  { 713, 15, 23, 16, 1, -23 },
  { 757, 16, 23, 16, 1, -23 },
  { 803, 17, 23, 16, 1, -23 },
  { 852, 16, 23, 16, 0, -23 },
  { 898, 15, 23, 16, 1, -23 },
  { 942, 9, 18, 9, 0, -18 },
  { 963, 11, 22, 9, -2, -18 },
  { 994, 15, 17, 17, 1, -20 },
  { 1026, 15, 11, 17, 1, -17 },
  { 1047, 15, 17, 17, 1, -20 },
  { 1079, 13, 23, 13, 1, -23 },
  { 1117, 23, 26, 24, 1, -23 },
  { 1192, 18, 23, 18, -2, -23 },
  { 1244, 18, 23, 18, 0, -23 },
  { 1296, 17, 23, 17, 1, -23 },
  { 1345, 18, 23, 19, 0, -23 },
  { 1397, 16, 23, 15, 0, -23 },
  { 1443, 16, 23, 15, 0, -23 },
  { 1489, 19, 23, 19, 1, -23 },
  { 1544, 20, 23, 19, 0, -23 },
  { 1602, 16, 23, 12, -1, -23 },
  { 1648, 16, 30, 10, -5, -23 },
  { 1708, 21, 23, 18, 0, -23 },
  { 1769, 13, 23, 14, 0, -23 },
  { 1807, 26, 23, 25, 0, -23 },
  { 1882, 22, 23, 21, 0, -23 },
  { 1946, 19, 23, 20, 1, -23 },
  { 2001, 17, 23, 17, 0, -23 },
  { 2050, 19, 28, 20, 1, -23 },
  { 2117, 17, 23, 18, 0, -23 },
  { 2166, 16, 23, 15, 0, -23 },
  { 2212, 15, 23, 15, 2, -23 },
  { 2256, 19, 23, 19, 1, -23 },
  { 2311, 17, 23, 18, 3, -23 },
  { 2360, 27, 23, 26, 2, -23 },
  { 2438, 22, 23, 18, -2, -23 },
  { 2502, 17, 23, 17, 3, -23 },
  { 2551, 18, 23, 15, -1, -23 },
  { 2603, 13, 28, 10, -1, -23 },
  { 2649, 8, 23, 13, 3, -23 },
  { 2672, 13, 28, 10, -2, -23 },
  { 2718, 16, 15, 16, 0, -23 },
  { 2748, 14, 4, 13, -3, 2 },
  { 2755, 7, 6, 11, 5, -25 },
  { 2761, 16, 18, 17, 1, -18 },
  { 2797, 16, 24, 17, 0, -24 },
  { 2845, 14, 18, 14, 1, -18 },
  { 2877, 17, 24, 17, 1, -24 },
  { 2928, 15, 18, 16, 1, -18 },
  { 2962, 17, 32, 11, -3, -24 },
  { 3030, 18, 26, 17, -1, -18 },
  { 3089, 16, 24, 17, 0, -24 },
  { 3137, 10, 25, 9, 0, -25 },
  { 3169, 14, 33, 9, -4, -25 },
  { 3227, 19, 24, 17, 0, -24 },
  { 3284, 10, 24, 9, 0, -24 },
  { 3314, 24, 18, 25, 0, -18 },
  { 3368, 16, 18, 17, 0, -18 },
  { 3404, 15, 18, 17, 1, -18 },
  { 3438, 18, 26, 17, -2, -18 },
  { 3497, 16, 26, 17, 1, -18 },
  { 3549, 14, 18, 12, 0, -18 },
  { 3581, 14, 18, 13, 0, -18 },
  { 3613, 12, 21, 12, 1, -21 },
  { 3645, 16, 18, 17, 1, -18 },
  { 3681, 15, 18, 15, 2, -18 },
  { 3715, 23, 18, 23, 2, -18 },
  { 3767, 19, 18, 16, -2, -18 },
  { 3810, 19, 26, 15, -2, -18 },
  { 3872, 15, 18, 13, -1, -18 },
  { 3906, 14, 28, 11, 0, -23 },
  { 3955, 4, 32, 14, 5, -25 },
  { 3971, 13, 28, 11, -2, -23 },
  { 4017, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_Condensed_BlackItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC32PT7B_H_
