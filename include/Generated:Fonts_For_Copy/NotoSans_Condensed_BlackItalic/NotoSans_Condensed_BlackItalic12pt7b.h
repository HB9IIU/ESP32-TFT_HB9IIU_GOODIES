#ifndef _NOTOSANS_CONDENSED_BLACKITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x66, 0x66, 0x0C, 0xC0, 0x7E, 0xF7, 0xA0, 0x16, 0x28, 0xD3,
  0xF2, 0xDF, 0xBF, 0x2C, 0xD0, 0x08, 0xF7, 0x5C, 0x38, 0x6A, 0xBE, 0x60,
  0x80, 0x63, 0x7B, 0x2D, 0x17, 0x8E, 0xBE, 0xBC, 0xD6, 0x4A, 0x67, 0x00,
  0x18, 0x3C, 0x3C, 0x3C, 0x3B, 0xFE, 0xDE, 0xFC, 0x7E, 0x7B, 0x60, 0x19,
  0x98, 0xC6, 0x63, 0x18, 0xC6, 0x10, 0x30, 0x86, 0x31, 0x18, 0xC6, 0x23,
  0x30, 0x37, 0x7E, 0xED, 0x10, 0x63, 0x3F, 0xF6, 0x30, 0x6D, 0xE0, 0xFE,
  0xF0, 0x06, 0x08, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0xE0, 0x18, 0xF6, 0xDB,
  0x6F, 0x3D, 0xBE, 0x70, 0x19, 0xDD, 0xE3, 0x18, 0xCC, 0x60, 0x19, 0xF2,
  0xC3, 0x18, 0xC6, 0x3E, 0xF8, 0x39, 0xF4, 0xC7, 0x30, 0x61, 0xBE, 0xF0,
  0x0C, 0x71, 0xCA, 0x7B, 0x6F, 0xC6, 0x30, 0x3C, 0xF2, 0x1C, 0x78, 0x61,
  0xBE, 0xF0, 0x0C, 0xF7, 0x1E, 0x7F, 0xBD, 0xDE, 0x70, 0x3E, 0xF8, 0x30,
  0xC1, 0x86, 0x0C, 0x30, 0xE0, 0x18, 0xF6, 0xDB, 0x39, 0xED, 0xBE, 0x70,
  0x19, 0xF6, 0xDB, 0x7D, 0xF1, 0xBE, 0xF0, 0x2C, 0x81, 0xB0, 0x13, 0x10,
  0x06, 0x66, 0xC0, 0x0C, 0xFE, 0x1E, 0x1C, 0x10, 0xF8, 0x3F, 0xF0, 0x87,
  0x0E, 0xEC, 0x40, 0x6F, 0xB3, 0x6C, 0x0C, 0xC0, 0x0E, 0x1F, 0x88, 0x6B,
  0xD5, 0x6F, 0xAF, 0xFD, 0xB4, 0x64, 0x1E, 0x00, 0x0E, 0x1C, 0x78, 0xF3,
  0x66, 0xDF, 0xB3, 0xE6, 0x38, 0x7D, 0xBB, 0x67, 0x8D, 0x9B, 0x7E, 0xF8,
  0x1C, 0x7D, 0xD3, 0x06, 0x1C, 0x38, 0x3C, 0x78, 0x38, 0x79, 0xBB, 0x36,
  0x6D, 0xDB, 0x7E, 0xF0, 0x3C, 0xF6, 0x18, 0x79, 0x86, 0x3E, 0xF0, 0x3C,
  0xF6, 0x18, 0x79, 0xE6, 0x30, 0xC0, 0x0C, 0x7D, 0xCB, 0x06, 0xEF, 0xFB,
  0x3E, 0x7C, 0x33, 0x36, 0x66, 0x66, 0x7E, 0x6E, 0x6C, 0xCC, 0xCC, 0x7D,
  0xE3, 0x0C, 0x31, 0x86, 0x18, 0xF0, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8E,
  0x30, 0xCF, 0x30, 0x37, 0x36, 0x6C, 0x7C, 0x78, 0x78, 0x78, 0xDC, 0xCC,
  0x31, 0x98, 0xC6, 0x31, 0x9F, 0xF0, 0x39, 0xCE, 0x77, 0xB9, 0xEE, 0x7F,
  0x9F, 0x65, 0xDB, 0x7C, 0xDB, 0x00, 0x33, 0x33, 0x7B, 0x7B, 0x7A, 0x7E,
  0x4E, 0xCE, 0xCE, 0x0C, 0x7D, 0xDB, 0x36, 0x6C, 0xFB, 0xBE, 0x78, 0x38,
  0x79, 0xBB, 0x67, 0xCF, 0x18, 0x60, 0xC0, 0x0C, 0x7D, 0xDB, 0x36, 0x6C,
  0xFB, 0xBE, 0x78, 0x30, 0x70, 0x38, 0x79, 0xBB, 0x67, 0xCF, 0x1E, 0x6E,
  0xCC, 0x19, 0xF6, 0x58, 0x78, 0xE1, 0xBE, 0xF0, 0xFF, 0xD8, 0xC6, 0x31,
  0x98, 0xC0, 0x6D, 0xBC, 0xF3, 0xCF, 0x6D, 0xBE, 0xF0, 0xCF, 0x9B, 0x36,
  0xCD, 0x9E, 0x3C, 0x70, 0xE0, 0xCC, 0xF3, 0x6D, 0xDB, 0x7C, 0xFF, 0x3F,
  0xCE, 0xE3, 0xB8, 0xCC, 0x00, 0x33, 0x3B, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x7E, 0xE6, 0xCF, 0x3D, 0x9C, 0x71, 0x86, 0x18, 0xE0, 0x7D, 0xF1, 0xC6,
  0x31, 0xC6, 0x3E, 0xF8, 0x1C, 0x63, 0x0C, 0x30, 0x86, 0x18, 0x61, 0xCE,
  0x00, 0xD9, 0x26, 0xDB, 0x60, 0x39, 0xC6, 0x31, 0x18, 0xC6, 0x23, 0x38,
  0x18, 0x63, 0x9A, 0x6B, 0x30, 0xF8, 0xD0, 0x35, 0xF6, 0xFB, 0xDB, 0xE7,
  0x80, 0x30, 0xC6, 0x9F, 0x6D, 0xBC, 0xFE, 0xF8, 0x3B, 0xD9, 0xCC, 0x79,
  0xC0, 0x06, 0x1C, 0xF3, 0xE6, 0xDD, 0xB6, 0x7C, 0x78, 0x39, 0xF6, 0xFE,
  0xC3, 0xA7, 0x80, 0x1C, 0x73, 0xDE, 0x30, 0xC3, 0x1C, 0x61, 0x8E, 0x30,
  0x35, 0xF6, 0xFB, 0xDB, 0xE7, 0x86, 0xF3, 0x80, 0x30, 0xC6, 0x9F, 0x6D,
  0xBC, 0xF6, 0xD8, 0x32, 0x66, 0x66, 0xCC, 0xC0, 0x0C, 0x21, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xCF, 0x38, 0x30, 0x61, 0x9B, 0x67, 0x8F, 0x3E, 0x6C,
  0xDC, 0x33, 0x66, 0x66, 0xCC, 0xC0, 0x69, 0xBF, 0xDB, 0x6D, 0xBC, 0xDE,
  0xDB, 0x6C, 0x69, 0xF6, 0xDB, 0xCF, 0x6D, 0x80, 0x39, 0xF6, 0xFB, 0xCF,
  0xE7, 0x00, 0x34, 0x7C, 0xD9, 0xB6, 0x6F, 0x9F, 0x30, 0x61, 0x80, 0x35,
  0xF6, 0xFB, 0xDB, 0xE7, 0x86, 0x18, 0xC0, 0x6B, 0xD8, 0xCC, 0x63, 0x00,
  0x33, 0xD8, 0xE3, 0x7B, 0xC0, 0x31, 0xFE, 0xC6, 0x31, 0xCE, 0x6D, 0xB6,
  0xDB, 0xDF, 0xE7, 0x80, 0xDE, 0xFD, 0xEE, 0x73, 0x00, 0xDB, 0xFB, 0xFE,
  0xFE, 0xFE, 0xDC, 0xDC, 0x37, 0x36, 0x3C, 0x18, 0x38, 0x6C, 0xEC, 0x36,
  0x6C, 0xF1, 0xE3, 0x87, 0x0C, 0x18, 0xE1, 0xC0, 0x7B, 0xCC, 0x66, 0x7B,
  0xC0, 0x09, 0xCC, 0x66, 0x63, 0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x21, 0xC6,
  0x63, 0x0C, 0xE4, 0x67, 0x30, 0xFE, 0x70,
};

const GFXglyph NotoSans_Condensed_BlackItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 7, 9, 7, 0, -9 },
  { 17, 6, 10, 6, 0, -9 },
  { 25, 9, 9, 10, 1, -9 },
  { 36, 8, 9, 8, 0, -9 },
  { 45, 3, 4, 3, 1, -9 },
  { 47, 5, 11, 4, 0, -9 },
  { 54, 5, 11, 4, -1, -9 },
  { 61, 5, 6, 6, 1, -9 },
  { 65, 5, 6, 6, 1, -7 },
  { 69, 3, 4, 3, -1, -2 },
  { 71, 4, 2, 4, 0, -4 },
  { 72, 2, 2, 3, 0, -2 },
  { 73, 7, 9, 5, -1, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 5, 9, 6, 1, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 6, 9, 6, 0, -9 },
  { 115, 6, 9, 6, 0, -9 },
  { 122, 6, 9, 6, 0, -9 },
  { 129, 7, 9, 6, 0, -9 },
  { 137, 6, 9, 6, 0, -9 },
  { 144, 6, 9, 6, 0, -9 },
  { 151, 3, 7, 3, 0, -7 },
  { 154, 4, 9, 3, -1, -7 },
  { 159, 6, 6, 6, 0, -7 },
  { 164, 5, 4, 6, 1, -6 },
  { 167, 5, 6, 6, 1, -7 },
  { 171, 4, 9, 5, 1, -9 },
  { 176, 9, 10, 9, 0, -9 },
  { 188, 7, 9, 7, -1, -9 },
  { 196, 7, 9, 7, 0, -9 },
  { 204, 7, 9, 6, 0, -9 },
  { 212, 7, 9, 7, 0, -9 },
  { 220, 6, 9, 6, 0, -9 },
  { 227, 6, 9, 5, 0, -9 },
  { 234, 7, 9, 7, 0, -9 },
  { 242, 8, 9, 7, 0, -9 },
  { 251, 6, 9, 5, 0, -9 },
  { 258, 6, 12, 4, -2, -9 },
  { 267, 8, 9, 7, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 10, 9, 10, 0, -9 },
  { 294, 8, 9, 8, 0, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 7, 9, 6, 0, -9 },
  { 319, 7, 11, 7, 0, -9 },
  { 329, 7, 9, 7, 0, -9 },
  { 337, 6, 9, 6, 0, -9 },
  { 344, 5, 9, 6, 1, -9 },
  { 350, 6, 9, 7, 1, -9 },
  { 357, 7, 9, 7, 1, -9 },
  { 365, 10, 9, 10, 1, -9 },
  { 377, 8, 9, 7, -1, -9 },
  { 386, 6, 9, 6, 1, -9 },
  { 393, 6, 9, 6, 0, -9 },
  { 400, 6, 11, 4, -1, -9 },
  { 409, 3, 9, 5, 1, -9 },
  { 413, 5, 11, 4, -1, -9 },
  { 420, 6, 6, 6, 0, -9 },
  { 425, 5, 1, 5, -1, 1 },
  { 426, 2, 2, 4, 2, -9 },
  { 427, 6, 7, 6, 0, -7 },
  { 433, 6, 9, 6, 0, -9 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 7, 9, 6, 0, -9 },
  { 453, 6, 7, 6, 0, -7 },
  { 459, 6, 12, 4, -1, -9 },
  { 468, 6, 10, 6, 0, -7 },
  { 476, 6, 9, 6, 0, -9 },
  { 483, 4, 9, 3, 0, -9 },
  { 488, 6, 12, 3, -2, -9 },
  { 497, 7, 9, 6, 0, -9 },
  { 505, 4, 9, 3, 0, -9 },
  { 510, 9, 7, 9, 0, -7 },
  { 518, 6, 7, 6, 0, -7 },
  { 524, 6, 7, 6, 0, -7 },
  { 530, 7, 10, 6, -1, -7 },
  { 539, 6, 10, 6, 0, -7 },
  { 547, 5, 7, 5, 0, -7 },
  { 552, 5, 7, 5, 0, -7 },
  { 557, 5, 8, 5, 0, -8 },
  { 562, 6, 7, 6, 0, -7 },
  { 568, 5, 7, 6, 1, -7 },
  { 573, 8, 7, 9, 1, -7 },
  { 580, 8, 7, 6, -1, -7 },
  { 587, 7, 10, 6, -1, -7 },
  { 596, 5, 7, 5, 0, -7 },
  { 601, 5, 11, 4, 0, -9 },
  { 608, 1, 12, 5, 2, -9 },
  { 610, 5, 11, 4, -1, -9 },
  { 617, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_BlackItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC12PT7B_H_
