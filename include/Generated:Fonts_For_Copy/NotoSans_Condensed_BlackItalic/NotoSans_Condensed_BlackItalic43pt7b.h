#ifndef _NOTOSANS_CONDENSED_BLACKITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x04, 0x00, 0x7F, 0x9F, 0xDF,
  0xCF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF3, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x0F, 0xC7, 0xC0, 0x07, 0xC7, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1F, 0x1F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE,
  0xEF, 0x07, 0xF7, 0x08, 0x3F, 0x30, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xBF, 0x08,
  0x1D, 0xF8, 0xF0, 0xEF, 0xC7, 0xF7, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x01, 0xFB, 0xF0, 0x7E, 0x01, 0xF9,
  0xF8, 0x7E, 0x00, 0xFC, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x3F, 0x00, 0x3E,
  0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0x9F, 0x80, 0x0F,
  0xCF, 0xCF, 0x87, 0x87, 0xE7, 0xCF, 0xCF, 0xF3, 0xFF, 0xE7, 0xCF, 0xFC,
  0xFF, 0xE7, 0xCF, 0xFE, 0x7F, 0xF7, 0xE7, 0xFF, 0x9F, 0xF3, 0xE7, 0xEF,
  0xC7, 0xE3, 0xF3, 0xE3, 0xE0, 0x03, 0xF3, 0xF3, 0xF0, 0x01, 0xF1, 0xF9,
  0xF8, 0x01, 0xF8, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xFC, 0x3E,
  0x3E, 0x00, 0xFC, 0x1F, 0x3F, 0x00, 0x7C, 0x0F, 0x9F, 0x80, 0x7E, 0x07,
  0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0xC0, 0x3F, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xDF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0x03, 0xFF, 0x8F, 0xE0, 0x7F,
  0xF1, 0xFE, 0x1F, 0xFF, 0x9F, 0xC3, 0xFF, 0xF9, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFB, 0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0x0F, 0xF1, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFE, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x10, 0x7C, 0x03, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0xBC,
  0x73, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0x7F,
  0x03, 0xC7, 0xE0, 0x30, 0xF0, 0x02, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xFB, 0xFF, 0xC0, 0x08, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xDF, 0xC3, 0xFC, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF,
  0xF1, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xF9, 0xFE,
  0x1F, 0xCF, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8,
  0xFF, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xBF, 0x8F, 0xBF, 0xC3, 0x9F, 0xE1, 0x8F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0x7F, 0xC0, 0x70, 0x7F, 0x01,
  0x81, 0xFC, 0x04, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3C, 0x7F, 0xC0, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x47, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x20, 0x07, 0xF8, 0xE0, 0x3F, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7C, 0xFE, 0x03, 0xE7,
  0xF8, 0x1F, 0x9F, 0xE0, 0xFC, 0x7F, 0x03, 0xE1, 0xFC, 0x1F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x41, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x10, 0x07, 0xF8, 0xE0, 0x7F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0,
  0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE7, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F,
  0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xFB, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC,
  0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC7, 0xF8,
  0xFF, 0x7F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xDF, 0xC0, 0x79, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xF8, 0xFE, 0x20, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x0F, 0xC3, 0xFE,
  0x3E, 0x3F, 0x0F, 0xFE, 0x7C, 0x7C, 0x3F, 0xFC, 0x79, 0xF8, 0xFF, 0xF8,
  0xF3, 0xE3, 0xF1, 0xF1, 0xE7, 0xC7, 0xC7, 0xC3, 0xDF, 0x1F, 0x0F, 0x8F,
  0xBE, 0x3E, 0x1F, 0x1F, 0x7C, 0xFC, 0x3E, 0x3E, 0xF1, 0xF0, 0xF8, 0x7F,
  0xE3, 0xE1, 0xF1, 0xF7, 0xC7, 0xC3, 0xE3, 0xEF, 0x8F, 0x8F, 0xC7, 0x9F,
  0x1F, 0x3F, 0x9F, 0x3E, 0x3F, 0xFF, 0xFC, 0x7C, 0x7F, 0xFF, 0xF0, 0xF8,
  0x7F, 0xBF, 0xC1, 0xF8, 0x7E, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x07, 0xF0, 0x07, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF9, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF8,
  0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x87, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0x3C, 0x0F, 0xF8, 0x18, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x40, 0xFF, 0x83, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x7C, 0x1F, 0xF0, 0x0C, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x8F, 0xFE, 0xFF, 0x1F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF,
  0x1F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0x3F, 0xF8, 0xFF, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF,
  0x87, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0x87, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F,
  0xBF, 0x3F, 0x7F, 0x03, 0xF7, 0xE7, 0xFF, 0xC0, 0xFE, 0xFD, 0xFB, 0xF8,
  0x1F, 0xDF, 0xBF, 0x7F, 0x03, 0xFB, 0xF7, 0xCF, 0xE0, 0x7F, 0x7F, 0xFB,
  0xF8, 0x1F, 0xCF, 0xFF, 0x7F, 0x03, 0xF9, 0xFF, 0xCF, 0xE0, 0x7F, 0x3F,
  0xF9, 0xFC, 0x0F, 0xE7, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0xCF, 0xE0, 0x7F,
  0x1F, 0xF1, 0xFC, 0x0F, 0xE3, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x87, 0xF0,
  0x3F, 0x8F, 0xF1, 0xFE, 0x07, 0xF1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x87,
  0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF8,
  0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x03,
  0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0x01, 0xFF, 0xE1, 0xFC,
  0x07, 0xFF, 0x87, 0xF0, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xF8, 0x7F, 0x03,
  0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0xCF, 0xE0, 0x3F, 0x7F, 0x3F, 0x80, 0xFD,
  0xFC, 0xFE, 0x07, 0xF7, 0xF3, 0xF8, 0x1F, 0xCF, 0xFF, 0xC0, 0x7F, 0x3F,
  0xFF, 0x01, 0xFC, 0xFF, 0xFC, 0x0F, 0xE3, 0xFF, 0xF0, 0x3F, 0x87, 0xFF,
  0x80, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x7F, 0xF8, 0x0F, 0xE1, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x1F,
  0xC0, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF,
  0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F,
  0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC,
  0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE,
  0x3F, 0xE1, 0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFC,
  0x07, 0xFB, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x9F,
  0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFC, 0x18, 0x0F, 0xE0, 0x20, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x04, 0x03, 0xFC, 0x18, 0x0F, 0xF0,
  0xFC, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF7,
  0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFE, 0x7F,
  0x07, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0,
  0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xE0, 0x7F, 0xBF, 0x81,
  0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F,
  0xC3, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F,
  0x0F, 0xE3, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0xE3, 0xF8, 0x3F, 0x9F, 0xFC,
  0x7F, 0x07, 0xE3, 0xFF, 0x9F, 0xE0, 0xFC, 0xFF, 0xF3, 0xF8, 0x3F, 0x9F,
  0xFE, 0xFF, 0x07, 0xF3, 0xFF, 0xDF, 0xC0, 0xFE, 0xFD, 0xFB, 0xF8, 0x1F,
  0xDF, 0xBF, 0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF8,
  0x0F, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F,
  0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFE, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0,
  0x1F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x01, 0xF1, 0xFC, 0x1F, 0xE7, 0xE0, 0xFF, 0xDF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFC, 0xFF, 0x0F,
  0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8,
  0xFF, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0x7E, 0x07, 0xFD, 0xF8, 0x07, 0xC7, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0x3F, 0xC0, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x41, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x02, 0x1F, 0xE1, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF3, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xCF, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0xFF, 0x3F, 0xC7, 0xF3, 0xF8,
  0x7F, 0x7F, 0x8F, 0xF7, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x10, 0xFF, 0x8F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xE4, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x7E, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x0F,
  0xE1, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xCF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xC0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x7E, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF8,
  0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xDF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x7C, 0x03, 0xF7, 0xFC, 0xFF, 0x83, 0xF7,
  0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xCF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x7F, 0x87, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x01,
  0xF9, 0xF8, 0x01, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F, 0x9F, 0x80, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x0F, 0xF7, 0xE0, 0x7F,
  0xDF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0xFF,
  0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0xFD, 0xFC, 0x3F, 0x7E,
  0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xE4, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFB, 0xE1, 0xFC,
  0x10, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x30,
  0x3F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF1,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x84, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFD,
  0xF8, 0x0F, 0xE7, 0xE0, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xC1, 0xFC,
  0xFE, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE7,
  0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8,
  0xFF, 0x87, 0xFF, 0xE3, 0xFE, 0x3F, 0xBF, 0x0F, 0xF8, 0xFE, 0xFC, 0x7F,
  0xE7, 0xFB, 0xF1, 0xFF, 0x9F, 0xCF, 0xCF, 0xFE, 0x7F, 0x3F, 0x3F, 0xF3,
  0xF8, 0xFC, 0xFF, 0xCF, 0xE3, 0xF7, 0xFF, 0x3F, 0x0F, 0xDF, 0x7D, 0xFC,
  0x3F, 0x7D, 0xF7, 0xF0, 0xFF, 0xF7, 0xDF, 0x83, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F,
  0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8,
  0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_BlackItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 18, 11, 19, 4, -31 },
  { 82, 25, 31, 24, 0, -31 },
  { 179, 21, 36, 22, 1, -33 },
  { 274, 33, 31, 36, 2, -31 },
  { 402, 28, 31, 27, 0, -31 },
  { 511, 9, 11, 10, 4, -31 },
  { 524, 16, 39, 13, 1, -32 },
  { 602, 16, 39, 13, -3, -32 },
  { 680, 19, 20, 20, 3, -33 },
  { 728, 19, 21, 23, 2, -26 },
  { 778, 11, 12, 12, -2, -6 },
  { 795, 13, 7, 14, 0, -15 },
  { 807, 8, 9, 12, 0, -8 },
  { 816, 24, 31, 18, -2, -31 },
  { 909, 21, 31, 22, 1, -31 },
  { 991, 17, 31, 22, 4, -31 },
  { 1057, 22, 31, 22, -1, -31 },
  { 1143, 22, 31, 22, 0, -31 },
  { 1229, 22, 31, 22, 0, -31 },
  { 1315, 21, 31, 22, 1, -31 },
  { 1397, 22, 31, 22, 1, -31 },
  { 1483, 23, 31, 22, 1, -31 },
  { 1573, 21, 31, 22, 1, -31 },
  { 1655, 21, 31, 22, 1, -31 },
  { 1737, 12, 25, 12, 0, -24 },
  { 1775, 15, 30, 12, -3, -24 },
  { 1832, 19, 22, 23, 2, -27 },
  { 1885, 19, 15, 23, 2, -23 },
  { 1921, 19, 22, 23, 2, -27 },
  { 1974, 17, 32, 18, 2, -31 },
  { 2042, 31, 34, 33, 1, -31 },
  { 2174, 25, 31, 25, -3, -31 },
  { 2271, 24, 31, 24, 0, -31 },
  { 2364, 23, 31, 22, 2, -31 },
  { 2454, 25, 31, 25, 0, -31 },
  { 2551, 22, 31, 20, 0, -31 },
  { 2637, 22, 31, 20, 0, -31 },
  { 2723, 24, 31, 26, 2, -31 },
  { 2816, 27, 31, 26, 0, -31 },
  { 2921, 22, 31, 17, -2, -31 },
  { 3007, 21, 41, 13, -7, -31 },
  { 3115, 28, 31, 24, 0, -31 },
  { 3224, 17, 31, 19, 0, -31 },
  { 3290, 35, 31, 34, 0, -31 },
  { 3426, 30, 31, 28, 0, -31 },
  { 3543, 24, 31, 27, 2, -31 },
  { 3636, 23, 31, 23, 0, -31 },
  { 3726, 24, 38, 27, 2, -31 },
  { 3840, 23, 31, 24, 0, -31 },
  { 3930, 22, 31, 20, 0, -31 },
  { 4016, 20, 31, 20, 3, -31 },
  { 4094, 25, 31, 25, 2, -31 },
  { 4191, 23, 31, 24, 4, -31 },
  { 4281, 35, 31, 34, 3, -31 },
  { 4417, 30, 31, 24, -3, -31 },
  { 4534, 22, 31, 22, 4, -31 },
  { 4620, 25, 31, 20, -2, -31 },
  { 4717, 19, 39, 13, -2, -32 },
  { 4810, 11, 31, 18, 4, -31 },
  { 4853, 18, 39, 13, -3, -32 },
  { 4941, 22, 21, 21, -1, -31 },
  { 4999, 19, 5, 17, -4, 3 },
  { 5011, 10, 7, 14, 6, -33 },
  { 5020, 22, 24, 22, 1, -24 },
  { 5086, 22, 33, 22, 0, -33 },
  { 5177, 19, 24, 18, 1, -24 },
  { 5234, 24, 33, 22, 1, -33 },
  { 5333, 20, 24, 21, 1, -24 },
  { 5393, 24, 43, 15, -5, -33 },
  { 5522, 24, 34, 22, -1, -24 },
  { 5624, 22, 33, 23, 0, -33 },
  { 5715, 14, 33, 12, 0, -33 },
  { 5773, 19, 43, 12, -5, -33 },
  { 5876, 25, 33, 23, 0, -33 },
  { 5980, 14, 33, 12, 0, -33 },
  { 6038, 33, 24, 34, 0, -24 },
  { 6137, 22, 24, 23, 0, -24 },
  { 6203, 20, 24, 22, 1, -24 },
  { 6263, 24, 34, 22, -2, -24 },
  { 6365, 22, 34, 22, 1, -24 },
  { 6459, 18, 24, 16, 0, -24 },
  { 6513, 18, 24, 18, 0, -24 },
  { 6567, 15, 29, 16, 2, -29 },
  { 6622, 22, 24, 23, 1, -24 },
  { 6688, 21, 24, 21, 2, -24 },
  { 6751, 30, 24, 31, 3, -24 },
  { 6841, 25, 24, 21, -2, -24 },
  { 6916, 26, 34, 21, -3, -24 },
  { 7027, 21, 24, 18, -2, -24 },
  { 7090, 18, 38, 15, 0, -31 },
  { 7176, 5, 43, 19, 7, -33 },
  { 7203, 18, 38, 15, -3, -31 },
  { 7289, 19, 8, 23, 2, -19 },
};

const GFXfont NotoSans_Condensed_BlackItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC43PT7B_H_
