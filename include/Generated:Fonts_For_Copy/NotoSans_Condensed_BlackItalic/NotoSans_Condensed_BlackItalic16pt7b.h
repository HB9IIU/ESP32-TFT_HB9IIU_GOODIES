#ifndef _NOTOSANS_CONDENSED_BLACKITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0xE7, 0x39, 0x80, 0x67, 0x38, 0x7E, 0xDD, 0xB7, 0x60,
  0x0D, 0x8D, 0x86, 0xCF, 0xF1, 0x21, 0xB3, 0xFF, 0xFE, 0x6C, 0x36, 0x1B,
  0x00, 0x04, 0x1F, 0x3F, 0x39, 0x78, 0x3C, 0x1E, 0x0E, 0x96, 0xFE, 0xFC,
  0x10, 0x30, 0x30, 0x07, 0x8C, 0xF9, 0x8D, 0x98, 0xDB, 0x0D, 0xEE, 0xF7,
  0xF6, 0xDB, 0x0D, 0xB1, 0x9B, 0x31, 0xE7, 0x1C, 0x04, 0x07, 0xC3, 0xB0,
  0xEC, 0x3F, 0x07, 0x87, 0xDD, 0xBE, 0xEF, 0xB9, 0xCF, 0xF1, 0xFE, 0x76,
  0x6E, 0x0C, 0x63, 0x8C, 0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xE1, 0x86,
  0x00, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x0C, 0x73, 0x8C,
  0x00, 0x18, 0xB3, 0xFB, 0xF7, 0x9D, 0x8B, 0x00, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x18, 0x77, 0x6E, 0x7F, 0xFC, 0x7F, 0x80, 0x01, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x00, 0x08,
  0x7D, 0xFB, 0x7E, 0xFD, 0xF3, 0xE7, 0xDD, 0xBB, 0xE7, 0x80, 0x1E, 0x79,
  0xF7, 0xE5, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE0, 0x0C, 0x3E, 0x7F, 0x27,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xFE, 0xFC, 0x0C, 0x3F, 0x3F, 0x07,
  0x07, 0x3E, 0x3C, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x07, 0x0F, 0x1F, 0x1E,
  0x3E, 0x6E, 0xEE, 0xFF, 0xFE, 0x1C, 0x1C, 0x1F, 0x3F, 0x38, 0x30, 0x7E,
  0x7E, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x07, 0x3E, 0x7E, 0x70, 0xE8, 0xFC,
  0xFE, 0xEE, 0xCC, 0xDC, 0xFC, 0x78, 0x3F, 0x9F, 0x81, 0xC0, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x00, 0x0C, 0x1F, 0x3F, 0x33, 0x3F,
  0x3E, 0x3E, 0x7E, 0xE6, 0xEE, 0xFE, 0x7C, 0x0C, 0x3E, 0x3F, 0x77, 0x77,
  0x77, 0x7F, 0x7E, 0x0E, 0x1C, 0xFC, 0xF0, 0x37, 0x30, 0x00, 0x6E, 0xE0,
  0x19, 0xC6, 0x00, 0x00, 0x0E, 0x73, 0x38, 0x02, 0x1C, 0xFF, 0x8E, 0x0F,
  0x87, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC3, 0xE1, 0xF1, 0xEF,
  0xBC, 0x40, 0x13, 0xF7, 0xE3, 0x1C, 0xE7, 0x18, 0x03, 0x0E, 0x30, 0x01,
  0x00, 0xFE, 0x18, 0x73, 0x33, 0x67, 0xB6, 0xDB, 0x69, 0xB5, 0x9B, 0xDB,
  0x6C, 0xFC, 0x60, 0x07, 0x18, 0x3F, 0x80, 0x07, 0x87, 0xC3, 0x63, 0xF1,
  0xF8, 0xDC, 0xFE, 0x7F, 0x7F, 0xB9, 0xF8, 0xE0, 0x3F, 0x1F, 0xCE, 0xE6,
  0x77, 0xF3, 0xF1, 0xDC, 0xEE, 0x67, 0x7F, 0x3F, 0x00, 0x0C, 0x3F, 0x7E,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x3F, 0x1F, 0xCE,
  0xE6, 0x77, 0x3B, 0x9D, 0xCE, 0xEE, 0x6F, 0x7F, 0x3F, 0x00, 0x3F, 0x3F,
  0x38, 0x30, 0x7E, 0x7E, 0x70, 0x70, 0x60, 0xFC, 0xFC, 0x3F, 0x3F, 0x38,
  0x30, 0x7E, 0x7E, 0x7C, 0x70, 0x60, 0xE0, 0xE0, 0x06, 0x1F, 0xDF, 0xCE,
  0x0E, 0x07, 0x7B, 0xBD, 0xDE, 0xE6, 0x77, 0x3F, 0x8F, 0xC0, 0x39, 0xCE,
  0x73, 0x9C, 0xC6, 0x7F, 0x9F, 0xE7, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x70,
  0x1F, 0x1E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x7C, 0xFC, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x78,
  0x78, 0xE0, 0x39, 0xCE, 0xE3, 0xF0, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x66, 0x39, 0xCE, 0x70, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x63, 0xFF,
  0xC0, 0x3C, 0x79, 0xE7, 0xCF, 0x3E, 0x79, 0xE7, 0xDB, 0x3E, 0xF9, 0xFD,
  0xCD, 0xEC, 0x6F, 0x67, 0x77, 0x3B, 0xB8, 0x3C, 0xE7, 0x9C, 0xF3, 0x1E,
  0x67, 0xFC, 0xFF, 0x9D, 0xF3, 0x3C, 0x67, 0x9C, 0xF3, 0x9E, 0x00, 0x0C,
  0x1F, 0x9F, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCE, 0xE7, 0x77, 0xBF, 0x8F,
  0x80, 0x3F, 0x1F, 0xCE, 0xE6, 0x77, 0x73, 0xF9, 0xF8, 0xE0, 0x60, 0x70,
  0x38, 0x00, 0x0C, 0x1F, 0x9F, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCE, 0xE7,
  0x77, 0xBF, 0x8F, 0x81, 0xC0, 0xE0, 0x38, 0x3F, 0x1F, 0xCE, 0xE6, 0x77,
  0x73, 0xF9, 0xF8, 0xFC, 0x6E, 0x73, 0xB9, 0xC0, 0x0C, 0x3F, 0x3F, 0x72,
  0x70, 0x3C, 0x3C, 0x1E, 0x0E, 0xDE, 0xFC, 0xF8, 0x7F, 0xFE, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x73, 0xB9, 0xDC, 0xCC, 0xEE,
  0x77, 0x3B, 0x9D, 0xDC, 0xEE, 0x7E, 0x1E, 0x00, 0xE3, 0xF3, 0xB9, 0xCC,
  0xC6, 0xE3, 0x61, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x00, 0xE7, 0x3F, 0x39,
  0xFB, 0xDD, 0xDE, 0xEE, 0xF6, 0x7D, 0xF3, 0xEF, 0x9F, 0x78, 0xF3, 0xC7,
  0x9C, 0x3C, 0xE0, 0x1D, 0xE3, 0xB8, 0x7E, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0xC1, 0xF8, 0x3F, 0x0E, 0x63, 0x8E, 0x00, 0xE7, 0xBB, 0x9F, 0x8F, 0x87,
  0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0xCF, 0xE0, 0x70,
  0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1F, 0xCF, 0xE0, 0x1E, 0x3C,
  0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x8E, 0x3C, 0x00,
  0xCC, 0xCC, 0xCE, 0xE6, 0x66, 0x67, 0x1E, 0x38, 0xB0, 0x61, 0xC3, 0x86,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x1E, 0x3C, 0x00, 0x0C, 0x1C, 0x1E, 0x36,
  0x76, 0x66, 0xC7, 0x7F, 0xFC, 0xE7, 0x1B, 0x3F, 0x77, 0x77, 0x67, 0xE6,
  0xEE, 0xFE, 0x7E, 0x38, 0x38, 0x38, 0x36, 0x3F, 0x77, 0x77, 0x67, 0x67,
  0xEE, 0xFE, 0xDC, 0x1E, 0x7D, 0xCB, 0x86, 0x1C, 0x39, 0x3E, 0x7C, 0x03,
  0x81, 0xC0, 0xE3, 0x63, 0xF3, 0xB9, 0xDC, 0xCE, 0xE6, 0x77, 0x3F, 0x8F,
  0xC0, 0x1E, 0x3F, 0x77, 0x67, 0x7E, 0xE0, 0xE2, 0x7C, 0x7C, 0x07, 0x83,
  0xC3, 0x81, 0xE1, 0xF0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03,
  0x87, 0xC3, 0xC1, 0xC0, 0x1B, 0x3F, 0x77, 0x77, 0x67, 0xE6, 0xEE, 0xFE,
  0x7E, 0x0C, 0x9C, 0xFC, 0xF0, 0x38, 0x38, 0x38, 0x36, 0x3F, 0x77, 0x77,
  0x77, 0x67, 0xE6, 0xEE, 0xEE, 0x39, 0xC0, 0x73, 0x39, 0xCE, 0x67, 0x39,
  0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x9E, 0x3C, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x77, 0x73, 0xF1, 0xF0, 0xF8,
  0x7C, 0x77, 0x3B, 0x9D, 0xE0, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x67, 0x39,
  0xC0, 0x37, 0x73, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x76, 0x67, 0xE6, 0x6E,
  0xEE, 0xEE, 0xE0, 0x36, 0x3F, 0x77, 0x77, 0x77, 0x67, 0xE6, 0xEE, 0xEE,
  0x1E, 0x3F, 0x77, 0x77, 0x67, 0xE7, 0xEE, 0x7E, 0x7C, 0x1B, 0x0F, 0xCE,
  0xE7, 0x73, 0x39, 0x9D, 0xDC, 0xFE, 0x7E, 0x30, 0x18, 0x1C, 0x0E, 0x00,
  0x1B, 0x3F, 0x77, 0x77, 0x67, 0xE6, 0xEE, 0xFE, 0x7E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x36, 0x79, 0xF3, 0x87, 0x0C, 0x38, 0x70, 0xE0, 0x3C, 0xFD, 0xD3,
  0x87, 0xC3, 0xA7, 0x7E, 0xF8, 0x31, 0x9F, 0xF6, 0x73, 0x9C, 0xC7, 0xBC,
  0x33, 0xB9, 0x9D, 0xCE, 0xE7, 0x73, 0x33, 0xB9, 0xFC, 0x76, 0x00, 0xE7,
  0xEE, 0xEC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0xEE, 0x7D, 0xDF, 0x7B,
  0x6F, 0xED, 0xFD, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x00, 0x3B, 0xCE, 0xE1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE1, 0xD8, 0xE7, 0x00, 0x39, 0xCE, 0xE3,
  0xB0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x70, 0x1C, 0x0E, 0x0F, 0x83, 0xC0,
  0xE0, 0x00, 0x3F, 0x3F, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0x7E, 0xFE, 0x1E,
  0x38, 0x61, 0xC3, 0x9E, 0x38, 0x78, 0x70, 0xE1, 0x83, 0x87, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x78, 0x70, 0xE1, 0x83, 0xC3,
  0x1E, 0x38, 0x61, 0xC7, 0x8E, 0x10, 0x00, 0xF3, 0xFE, 0x70,
};

const GFXglyph NotoSans_Condensed_BlackItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 9, 11, 9, 0, -11 },
  { 25, 8, 13, 8, 0, -12 },
  { 38, 12, 12, 13, 1, -12 },
  { 56, 10, 12, 10, 0, -12 },
  { 71, 4, 4, 4, 1, -11 },
  { 73, 6, 15, 5, 0, -12 },
  { 85, 6, 15, 5, -1, -12 },
  { 97, 7, 7, 8, 1, -12 },
  { 104, 7, 8, 8, 1, -10 },
  { 111, 4, 4, 4, -1, -2 },
  { 113, 5, 3, 5, 0, -6 },
  { 115, 3, 3, 4, 0, -3 },
  { 117, 9, 12, 7, -1, -12 },
  { 131, 7, 12, 8, 1, -12 },
  { 142, 7, 11, 8, 1, -11 },
  { 152, 8, 12, 8, 0, -12 },
  { 164, 8, 12, 8, 0, -12 },
  { 176, 8, 11, 8, 0, -11 },
  { 187, 8, 11, 8, 0, -11 },
  { 198, 8, 12, 8, 1, -12 },
  { 210, 9, 11, 8, 0, -11 },
  { 223, 8, 12, 8, 0, -12 },
  { 235, 8, 12, 8, 0, -12 },
  { 247, 4, 9, 4, 0, -9 },
  { 252, 5, 11, 4, -1, -9 },
  { 259, 7, 8, 8, 1, -10 },
  { 266, 7, 5, 8, 1, -8 },
  { 271, 7, 8, 8, 1, -10 },
  { 278, 6, 12, 7, 1, -12 },
  { 287, 12, 13, 12, 0, -12 },
  { 307, 9, 11, 9, -1, -11 },
  { 320, 9, 11, 9, 0, -11 },
  { 333, 8, 12, 8, 1, -12 },
  { 345, 9, 11, 9, 0, -11 },
  { 358, 8, 11, 7, 0, -11 },
  { 369, 8, 11, 7, 0, -11 },
  { 380, 9, 12, 9, 1, -12 },
  { 394, 10, 11, 10, 0, -11 },
  { 408, 8, 11, 6, -1, -11 },
  { 419, 8, 15, 5, -3, -11 },
  { 434, 10, 11, 9, 0, -11 },
  { 448, 6, 11, 7, 0, -11 },
  { 457, 13, 11, 13, 0, -11 },
  { 475, 11, 11, 11, 0, -11 },
  { 491, 9, 12, 10, 1, -12 },
  { 505, 9, 11, 8, 0, -11 },
  { 518, 9, 15, 10, 1, -12 },
  { 535, 9, 11, 9, 0, -11 },
  { 548, 8, 12, 8, 0, -12 },
  { 560, 8, 11, 7, 1, -11 },
  { 571, 9, 11, 9, 1, -11 },
  { 584, 9, 11, 9, 1, -11 },
  { 597, 13, 11, 13, 1, -11 },
  { 615, 11, 11, 9, -1, -11 },
  { 631, 9, 11, 8, 1, -11 },
  { 644, 10, 11, 7, -1, -11 },
  { 658, 7, 15, 5, -1, -12 },
  { 672, 4, 12, 7, 2, -12 },
  { 678, 7, 15, 5, -1, -12 },
  { 692, 8, 7, 8, 0, -11 },
  { 699, 7, 2, 6, -2, 1 },
  { 701, 4, 2, 5, 2, -12 },
  { 702, 8, 9, 8, 0, -9 },
  { 711, 8, 12, 8, 0, -12 },
  { 723, 7, 9, 7, 0, -9 },
  { 731, 9, 12, 8, 0, -12 },
  { 745, 8, 9, 8, 0, -9 },
  { 754, 9, 16, 5, -2, -12 },
  { 772, 8, 13, 8, 0, -9 },
  { 785, 8, 12, 8, 0, -12 },
  { 797, 5, 12, 4, 0, -12 },
  { 805, 7, 16, 4, -2, -12 },
  { 819, 9, 12, 8, 0, -12 },
  { 833, 5, 12, 4, 0, -12 },
  { 841, 12, 9, 13, 0, -9 },
  { 855, 8, 9, 8, 0, -9 },
  { 864, 8, 9, 8, 0, -9 },
  { 873, 9, 13, 8, -1, -9 },
  { 888, 8, 13, 8, 0, -9 },
  { 901, 7, 9, 6, 0, -9 },
  { 909, 7, 9, 7, 0, -9 },
  { 917, 5, 11, 6, 1, -11 },
  { 924, 9, 9, 8, 0, -9 },
  { 935, 8, 9, 8, 1, -9 },
  { 944, 11, 9, 12, 1, -9 },
  { 957, 10, 9, 8, -1, -9 },
  { 969, 10, 13, 8, -1, -9 },
  { 986, 8, 9, 7, -1, -9 },
  { 995, 7, 14, 6, 0, -11 },
  { 1008, 3, 16, 7, 2, -12 },
  { 1014, 7, 14, 6, -1, -11 },
  { 1027, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_BlackItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC16PT7B_H_
