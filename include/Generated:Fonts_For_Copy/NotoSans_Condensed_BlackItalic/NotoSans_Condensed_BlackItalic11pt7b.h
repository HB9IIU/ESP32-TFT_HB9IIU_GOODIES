#ifndef _NOTOSANS_CONDENSED_BLACKITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x40, 0xCC, 0xDE, 0xBC, 0x14, 0x79, 0xFB, 0xE6, 0x9F,
  0x94, 0x78, 0x19, 0xF7, 0x1C, 0x3A, 0xEF, 0x98, 0x20, 0x66, 0xA4, 0xA8,
  0xFE, 0xD5, 0x3F, 0x2F, 0x4E, 0x38, 0x59, 0xB1, 0xC7, 0x7B, 0xB7, 0x7E,
  0xFC, 0x32, 0x64, 0xCC, 0xCC, 0xC4, 0x31, 0x11, 0x33, 0x36, 0x6C, 0xA7,
  0xDF, 0xE6, 0x00, 0x31, 0xBF, 0xF3, 0x18, 0x6D, 0x60, 0xFC, 0xF0, 0x06,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0x39, 0xE6, 0xDA, 0xDB, 0x6F, 0x9C,
  0x37, 0xFB, 0x26, 0x66, 0x3B, 0xD6, 0x33, 0x33, 0xFE, 0x39, 0xF0, 0x8E,
  0x78, 0x6F, 0xBC, 0x0C, 0x63, 0x9E, 0x5B, 0xE3, 0x0C, 0x3C, 0xE6, 0x1E,
  0x58, 0x6F, 0xBC, 0x1C, 0xF6, 0x1E, 0xFB, 0x6F, 0x9C, 0x7D, 0xF1, 0x86,
  0x30, 0xC6, 0x38, 0x39, 0xF6, 0x9E, 0x7B, 0x6D, 0x9C, 0x39, 0xE6, 0xDE,
  0x78, 0x6B, 0x38, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x4C, 0x08, 0xDD,
  0xE1, 0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0x7B, 0xC6, 0x66,
  0x01, 0x98, 0x1E, 0x33, 0x6D, 0x55, 0xF5, 0xFF, 0xD6, 0x44, 0x3C, 0x0C,
  0x38, 0x71, 0xB3, 0x6F, 0xD9, 0xF3, 0x39, 0xF6, 0xDE, 0x79, 0x3F, 0xBC,
  0x1C, 0xF6, 0x18, 0xE3, 0x07, 0x9E, 0x39, 0xF6, 0xDB, 0x6D, 0x3F, 0xBC,
  0x3D, 0xE6, 0x1E, 0x71, 0x0F, 0x3C, 0x3D, 0xE6, 0x1E, 0x71, 0x0C, 0x30,
  0x1E, 0x79, 0x83, 0xED, 0xD9, 0x9F, 0x3C, 0x36, 0xCD, 0x9B, 0xE7, 0xC9,
  0xB3, 0x6C, 0x79, 0x8C, 0xC6, 0x31, 0x9E, 0x0C, 0x61, 0x86, 0x18, 0x63,
  0x0C, 0x33, 0x80, 0x36, 0xD9, 0xE3, 0xC7, 0x8B, 0x36, 0x6E, 0x36, 0x66,
  0x64, 0xFF, 0x33, 0xB9, 0xDD, 0xEE, 0xA7, 0x72, 0xFB, 0x6D, 0xB4, 0x33,
  0x72, 0x76, 0x7E, 0x7E, 0x5C, 0xDC, 0xCC, 0x1C, 0x7D, 0x9B, 0x3C, 0x79,
  0x9F, 0x3C, 0x39, 0xF6, 0xDB, 0x79, 0x0C, 0x30, 0x1C, 0x7D, 0x9B, 0x3C,
  0x79, 0x9F, 0x3C, 0x18, 0x30, 0x39, 0xF6, 0xDF, 0x79, 0x6D, 0xB7, 0x3D,
  0xE6, 0x1C, 0x30, 0x6F, 0x3C, 0xFF, 0xD8, 0xC6, 0x63, 0x18, 0x36, 0xCD,
  0xB3, 0x66, 0xC9, 0xBE, 0x3C, 0xCF, 0x6D, 0xB4, 0xF3, 0xCE, 0x38, 0xD9,
  0xED, 0xB6, 0xDF, 0x4E, 0xE7, 0x73, 0xB1, 0xB8, 0x33, 0x36, 0x1C, 0x1C,
  0x18, 0x3C, 0x6C, 0xEC, 0xDF, 0x6F, 0x1C, 0x61, 0x84, 0x30, 0x7D, 0xF1,
  0x8C, 0x61, 0x8F, 0xBC, 0x36, 0x64, 0x4C, 0xCC, 0xCC, 0xDB, 0x24, 0x9B,
  0x38, 0xC4, 0x23, 0x18, 0x84, 0xE7, 0x00, 0x11, 0x8E, 0xFC, 0x80, 0xF8,
  0xC0, 0x7D, 0xED, 0xB6, 0xD9, 0xE0, 0x31, 0x87, 0x9B, 0x4B, 0x6D, 0xBC,
  0x3B, 0x71, 0x8D, 0x38, 0x0C, 0x37, 0xDE, 0xDB, 0x6D, 0x9E, 0x3B, 0x7F,
  0xCC, 0xB8, 0x1C, 0x43, 0x9C, 0x30, 0xC6, 0x18, 0x63, 0x8C, 0x00, 0x7D,
  0xED, 0xB6, 0xD9, 0xE1, 0x3C, 0xE0, 0x31, 0x87, 0x9B, 0x6B, 0x6D, 0xB6,
  0x27, 0x06, 0x66, 0xCC, 0xC0, 0x11, 0xC0, 0x63, 0x19, 0x8C, 0x63, 0x31,
  0x00, 0x31, 0x86, 0xDE, 0x73, 0xCD, 0xB6, 0x36, 0x66, 0x6C, 0xCC, 0x7B,
  0x6F, 0x6B, 0xDB, 0xDB, 0xDB, 0x79, 0xB6, 0xB6, 0xDB, 0x60, 0x3B, 0xF3,
  0xBD, 0xB8, 0x3C, 0x6C, 0x93, 0x67, 0xCF, 0x18, 0x20, 0xC0, 0x7D, 0xED,
  0xB6, 0xD9, 0xE1, 0x0C, 0x30, 0x7B, 0x99, 0x8C, 0x60, 0x7B, 0x98, 0x6B,
  0x70, 0x37, 0xE6, 0x4E, 0x60, 0x6D, 0xB7, 0xB6, 0xF9, 0xE0, 0x9D, 0xAD,
  0xCE, 0x60, 0xBF, 0xB6, 0xB4, 0xFC, 0xDC, 0xD8, 0x36, 0x78, 0xE1, 0xC7,
  0x9D, 0x80, 0x26, 0x78, 0xF1, 0xC3, 0x86, 0x0C, 0x70, 0xC0, 0x79, 0x8C,
  0xCF, 0x78, 0x19, 0x88, 0xCE, 0x61, 0x88, 0x63, 0x00, 0xFF, 0xE0, 0x31,
  0x8C, 0x63, 0x9C, 0x8C, 0xE6, 0x00, 0x6F, 0xC0,
};

const GFXglyph NotoSans_Condensed_BlackItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 8, 3, 0, -8 },
  { 5, 5, 3, 5, 1, -8 },
  { 7, 7, 8, 6, 0, -8 },
  { 14, 6, 9, 6, 0, -8 },
  { 21, 8, 8, 9, 1, -8 },
  { 29, 7, 8, 7, 0, -8 },
  { 36, 2, 3, 3, 1, -8 },
  { 37, 4, 10, 3, 0, -8 },
  { 42, 4, 10, 3, -1, -8 },
  { 47, 5, 5, 5, 1, -8 },
  { 51, 5, 6, 6, 0, -7 },
  { 55, 3, 4, 3, -1, -2 },
  { 57, 3, 2, 3, 0, -4 },
  { 58, 2, 2, 3, 0, -2 },
  { 59, 7, 8, 5, -1, -8 },
  { 66, 6, 8, 6, 0, -8 },
  { 72, 4, 8, 6, 1, -8 },
  { 76, 5, 8, 6, 0, -8 },
  { 81, 6, 8, 6, 0, -8 },
  { 87, 6, 8, 6, 0, -8 },
  { 93, 6, 8, 6, 0, -8 },
  { 99, 6, 8, 6, 0, -8 },
  { 105, 6, 8, 6, 0, -8 },
  { 111, 6, 8, 6, 0, -8 },
  { 117, 6, 8, 6, 0, -8 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 4, 8, 3, -1, -6 },
  { 130, 5, 6, 6, 0, -7 },
  { 134, 5, 4, 6, 0, -6 },
  { 137, 5, 6, 6, 0, -7 },
  { 141, 5, 8, 5, 0, -8 },
  { 146, 8, 9, 8, 0, -8 },
  { 155, 7, 8, 6, -1, -8 },
  { 162, 6, 8, 6, 0, -8 },
  { 168, 6, 8, 6, 0, -8 },
  { 174, 6, 8, 6, 0, -8 },
  { 180, 6, 8, 5, 0, -8 },
  { 186, 6, 8, 5, 0, -8 },
  { 192, 7, 8, 7, 0, -8 },
  { 199, 7, 8, 7, 0, -8 },
  { 206, 5, 8, 4, 0, -8 },
  { 211, 6, 10, 3, -2, -8 },
  { 219, 7, 8, 6, 0, -8 },
  { 226, 4, 8, 5, 0, -8 },
  { 230, 9, 8, 9, 0, -8 },
  { 239, 8, 8, 7, 0, -8 },
  { 247, 7, 8, 7, 0, -8 },
  { 254, 6, 8, 6, 0, -8 },
  { 260, 7, 10, 7, 0, -8 },
  { 269, 6, 8, 6, 0, -8 },
  { 275, 6, 8, 5, 0, -8 },
  { 281, 5, 8, 5, 1, -8 },
  { 286, 7, 8, 7, 0, -8 },
  { 293, 6, 8, 6, 1, -8 },
  { 299, 9, 8, 9, 1, -8 },
  { 308, 8, 8, 6, -1, -8 },
  { 316, 6, 8, 6, 1, -8 },
  { 322, 6, 8, 5, 0, -8 },
  { 328, 4, 10, 3, 0, -8 },
  { 333, 3, 8, 5, 1, -8 },
  { 336, 5, 10, 3, -1, -8 },
  { 343, 5, 5, 5, 0, -8 },
  { 347, 5, 1, 4, -1, 1 },
  { 348, 2, 1, 4, 2, -8 },
  { 349, 6, 6, 6, 0, -6 },
  { 354, 6, 8, 6, 0, -8 },
  { 360, 5, 6, 5, 0, -6 },
  { 364, 6, 8, 6, 0, -8 },
  { 370, 5, 6, 5, 0, -6 },
  { 374, 6, 11, 4, -1, -8 },
  { 383, 6, 9, 6, 0, -6 },
  { 390, 6, 8, 6, 0, -8 },
  { 396, 4, 9, 3, 0, -9 },
  { 401, 5, 12, 3, -1, -9 },
  { 409, 6, 8, 6, 0, -8 },
  { 415, 4, 8, 3, 0, -8 },
  { 419, 8, 6, 9, 0, -6 },
  { 425, 6, 6, 6, 0, -6 },
  { 430, 5, 6, 6, 0, -6 },
  { 434, 7, 9, 6, -1, -6 },
  { 442, 6, 9, 6, 0, -6 },
  { 449, 5, 6, 4, 0, -6 },
  { 453, 5, 6, 5, 0, -6 },
  { 457, 4, 7, 4, 0, -7 },
  { 461, 6, 6, 6, 0, -6 },
  { 466, 5, 6, 5, 1, -6 },
  { 470, 8, 6, 8, 1, -6 },
  { 476, 7, 6, 5, -1, -6 },
  { 482, 7, 9, 5, -1, -6 },
  { 490, 5, 6, 5, 0, -6 },
  { 494, 5, 10, 4, 0, -8 },
  { 501, 1, 11, 5, 2, -8 },
  { 503, 5, 10, 4, -1, -8 },
  { 510, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_BlackItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC11PT7B_H_
