#ifndef _NOTOSANS_CONDENSED_BLACKITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA1, 0xB0, 0xFB, 0x3C, 0xA7, 0xDE, 0xF9, 0x4F, 0x00, 0x11,
  0xDA, 0xC3, 0x1F, 0xCC, 0x40, 0xED, 0x53, 0xE6, 0xF2, 0xAD, 0x73, 0x00,
  0x39, 0xA7, 0x9F, 0xFF, 0x6F, 0xC0, 0xE0, 0x36, 0x44, 0xCC, 0xCC, 0x40,
  0x33, 0x33, 0x32, 0x64, 0xC0, 0x6E, 0xFE, 0xB0, 0x21, 0x3E, 0x42, 0x00,
  0x78, 0xE0, 0xF0, 0x0C, 0x21, 0x8C, 0x21, 0x8C, 0x00, 0x3B, 0xD7, 0xBD,
  0xF9, 0x80, 0x3F, 0xA6, 0x66, 0x40, 0x7A, 0xC6, 0x66, 0x7B, 0xC0, 0x7A,
  0xC6, 0xE1, 0x5B, 0xC0, 0x19, 0xCE, 0xAF, 0xFC, 0xC0, 0x3B, 0x1C, 0xE1,
  0xDB, 0xC0, 0x3B, 0x15, 0xFD, 0xE9, 0xC0, 0x7C, 0x61, 0x8C, 0x21, 0x8C,
  0x00, 0x3B, 0xDE, 0xED, 0xE9, 0xC0, 0x7B, 0xD6, 0xF5, 0x1B, 0x80, 0x4C,
  0x0D, 0x80, 0x23, 0x00, 0x06, 0xC0, 0x0B, 0xB8, 0x70, 0x80, 0xF8, 0x3E,
  0xC3, 0x87, 0xE8, 0x00, 0x72, 0xCC, 0xC0, 0x23, 0x00, 0x3E, 0x62, 0x5F,
  0xEE, 0xAA, 0xBC, 0x44, 0x38, 0x1C, 0x73, 0xCF, 0x3D, 0xFC, 0xC0, 0x79,
  0xB7, 0x9E, 0x5B, 0x6F, 0x00, 0x3D, 0xA6, 0x30, 0xC3, 0xC7, 0x00, 0x79,
  0xB6, 0xD3, 0x5B, 0xEF, 0x00, 0x7B, 0x18, 0xE4, 0x63, 0xC0, 0x7B, 0x18,
  0xE4, 0x63, 0x00, 0x3D, 0x96, 0x17, 0xC9, 0xE7, 0x80, 0x65, 0xB6, 0xDF,
  0x4B, 0x6D, 0x80, 0x79, 0x18, 0xC6, 0x33, 0x80, 0x18, 0xC6, 0x31, 0x18,
  0xC6, 0xE0, 0x6E, 0xF1, 0xE3, 0x85, 0x1B, 0x36, 0x00, 0x66, 0x64, 0x4C,
  0xF0, 0x73, 0x77, 0x77, 0x5E, 0x5A, 0xDE, 0xD6, 0x76, 0xED, 0xD2, 0xA5,
  0xDB, 0xB7, 0x00, 0x3D, 0xB6, 0xF3, 0xCD, 0x67, 0x00, 0x7B, 0x5A, 0xF7,
  0x63, 0x00, 0x3D, 0xB6, 0xF3, 0xCF, 0xE7, 0x04, 0x18, 0x7B, 0x5E, 0xF5,
  0x6F, 0x60, 0x7B, 0x58, 0xE3, 0x5B, 0x80, 0xF6, 0x64, 0xCC, 0xC0, 0x6D,
  0xB6, 0xD2, 0x4B, 0x67, 0x00, 0xDE, 0xFD, 0xEE, 0x73, 0x00, 0xDB, 0xBA,
  0xBE, 0xBC, 0xFC, 0xDC, 0xD8, 0x36, 0x78, 0x70, 0xC3, 0x8D, 0xBB, 0x00,
  0xDF, 0xBC, 0xC4, 0x63, 0x00, 0x78, 0xCC, 0xC6, 0x63, 0xC0, 0x76, 0x44,
  0xCC, 0x8C, 0xC0, 0xFD, 0x54, 0x38, 0x8C, 0x63, 0x10, 0x8C, 0xE0, 0x31,
  0x9C, 0xB9, 0x80, 0xF0, 0xCC, 0x2B, 0xD7, 0xBD, 0x78, 0x23, 0x1C, 0xF5,
  0xEF, 0x7E, 0x3B, 0x91, 0x8D, 0x38, 0x0C, 0x32, 0x9E, 0x5B, 0x6D, 0x3C,
  0x33, 0xD7, 0xED, 0x38, 0x1C, 0x63, 0x9E, 0x30, 0x86, 0x18, 0x63, 0x00,
  0x2B, 0xD7, 0xBD, 0x78, 0xDE, 0x23, 0x1C, 0xF5, 0xEF, 0x7A, 0x2D, 0xB5,
  0xB6, 0x13, 0x33, 0x26, 0x66, 0x6C, 0x21, 0x86, 0xDE, 0x73, 0xCF, 0x36,
  0x2D, 0xB5, 0xB6, 0x52, 0x7F, 0x5B, 0xDA, 0xDE, 0xD6, 0x53, 0xD7, 0xBD,
  0xE8, 0x33, 0xD7, 0xBD, 0x38, 0x28, 0xF2, 0xDB, 0x6D, 0xE6, 0x30, 0x2B,
  0xD7, 0xBD, 0x78, 0xC6, 0x57, 0x6C, 0xCC, 0x27, 0x67, 0xBE, 0x27, 0xF6,
  0x4D, 0x60, 0x6B, 0xD7, 0xBD, 0xF8, 0x9B, 0xAE, 0xCC, 0xB7, 0x6B, 0xF6,
  0xCD, 0x9B, 0x00, 0x34, 0xF3, 0x8E, 0x3B, 0xE0, 0x24, 0xB2, 0x8E, 0x30,
  0xC2, 0x38, 0x77, 0x36, 0xCF, 0x32, 0x6E, 0xC4, 0x4E, 0x20, 0xFF, 0xC0,
  0x33, 0x33, 0x32, 0x6E, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_BlackItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 7, 7, 8, 1, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 2, 2, 1, -7 },
  { 31, 4, 9, 3, 0, -7 },
  { 36, 4, 9, 3, -1, -7 },
  { 41, 4, 5, 5, 1, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 6, 7, 4, -1, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 6, 7, 5, 0, -7 },
  { 97, 5, 7, 5, 0, -7 },
  { 102, 5, 7, 5, 0, -7 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 4, 7, 3, -1, -6 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 5, 3, 5, 0, -5 },
  { 120, 5, 5, 5, 0, -6 },
  { 124, 5, 7, 4, 0, -7 },
  { 129, 8, 8, 8, 0, -7 },
  { 137, 6, 7, 6, -1, -7 },
  { 143, 6, 7, 6, 0, -7 },
  { 149, 6, 7, 5, 0, -7 },
  { 155, 6, 7, 6, 0, -7 },
  { 161, 5, 7, 5, 0, -7 },
  { 166, 5, 7, 5, 0, -7 },
  { 171, 6, 7, 6, 0, -7 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 5, 7, 4, 0, -7 },
  { 188, 5, 9, 3, -2, -7 },
  { 194, 7, 7, 6, 0, -7 },
  { 201, 4, 7, 4, 0, -7 },
  { 205, 8, 7, 8, 0, -7 },
  { 212, 7, 7, 7, 0, -7 },
  { 219, 6, 7, 6, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 6, 9, 6, 0, -7 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 5, 7, 5, 0, -7 },
  { 247, 4, 7, 5, 1, -7 },
  { 251, 6, 7, 6, 0, -7 },
  { 257, 5, 7, 5, 1, -7 },
  { 262, 8, 7, 8, 1, -7 },
  { 269, 7, 7, 5, -1, -7 },
  { 276, 5, 7, 5, 1, -7 },
  { 281, 5, 7, 5, 0, -7 },
  { 286, 4, 9, 3, 0, -7 },
  { 291, 2, 7, 4, 1, -7 },
  { 293, 5, 9, 3, -1, -7 },
  { 299, 5, 5, 5, 0, -7 },
  { 303, 4, 1, 4, -1, 1 },
  { 304, 3, 2, 3, 1, -8 },
  { 305, 5, 6, 5, 0, -6 },
  { 309, 5, 8, 5, 0, -8 },
  { 314, 5, 6, 4, 0, -6 },
  { 318, 6, 8, 5, 0, -8 },
  { 324, 5, 6, 5, 0, -6 },
  { 328, 6, 10, 3, -1, -8 },
  { 336, 5, 8, 5, 0, -6 },
  { 341, 5, 8, 5, 0, -8 },
  { 346, 3, 8, 3, 0, -8 },
  { 349, 4, 10, 3, -1, -8 },
  { 354, 6, 8, 5, 0, -8 },
  { 360, 3, 8, 3, 0, -8 },
  { 363, 8, 6, 8, 0, -6 },
  { 369, 5, 6, 5, 0, -6 },
  { 373, 5, 6, 5, 0, -6 },
  { 377, 6, 8, 5, -1, -6 },
  { 383, 5, 8, 5, 0, -6 },
  { 388, 4, 6, 4, 0, -6 },
  { 391, 4, 6, 4, 0, -6 },
  { 394, 4, 7, 4, 0, -7 },
  { 398, 5, 6, 5, 0, -6 },
  { 402, 4, 6, 5, 1, -6 },
  { 405, 7, 6, 7, 1, -6 },
  { 411, 6, 6, 5, -1, -6 },
  { 416, 6, 8, 5, -1, -6 },
  { 422, 4, 6, 4, 0, -6 },
  { 425, 4, 9, 3, 0, -7 },
  { 430, 1, 10, 4, 2, -8 },
  { 432, 4, 9, 3, -1, -7 },
  { 437, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_BlackItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC10PT7B_H_
