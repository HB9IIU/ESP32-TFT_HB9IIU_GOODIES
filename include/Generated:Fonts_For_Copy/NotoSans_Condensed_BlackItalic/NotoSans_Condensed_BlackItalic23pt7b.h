#ifndef _NOTOSANS_CONDENSED_BLACKITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF0, 0x00, 0x07,
  0x1E, 0x3C, 0x78, 0x7B, 0xDC, 0xE7, 0x7B, 0xDE, 0xE7, 0x39, 0xC0, 0x07,
  0xB8, 0x1C, 0xC0, 0x77, 0x01, 0x9C, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0x87,
  0x38, 0x1D, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3B, 0x80, 0xCE, 0x07,
  0x30, 0x1D, 0xC0, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xFE, 0x3F, 0x63, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC8, 0x5C, 0x65, 0xC7, 0xFC,
  0xFF, 0x87, 0xF0, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x0F, 0x83, 0x83, 0xF1,
  0xC1, 0xDC, 0x70, 0x77, 0x38, 0x39, 0xDC, 0x0E, 0x77, 0x03, 0xBB, 0x9E,
  0xFE, 0xEF, 0x9F, 0x77, 0xF3, 0x3B, 0x9C, 0x0E, 0xE7, 0x07, 0x39, 0x81,
  0xCE, 0xE0, 0xE3, 0xB8, 0x70, 0xFC, 0x3C, 0x1E, 0x00, 0x01, 0x80, 0x0F,
  0xC0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x07, 0xE0,
  0x1F, 0xBE, 0x7F, 0x79, 0xFF, 0xF7, 0x9F, 0xCF, 0x3F, 0x1E, 0x3E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x7B, 0x9D, 0xEE, 0x70, 0x07, 0x83, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x81,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x00, 0x08, 0x03, 0x88,
  0xE3, 0xB1, 0xFF, 0xFF, 0xF3, 0xFD, 0xF8, 0xFF, 0x19, 0xC2, 0x60, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3D, 0xE7, 0x9C, 0xF3, 0x80, 0x7E, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0x9E, 0xF3,
  0xDE, 0x7F, 0x8E, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0x79, 0xEF, 0x3F,
  0xC7, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xCF, 0xEF, 0xEF, 0xF3, 0xF9, 0x3C,
  0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x01, 0xC0,
  0x7E, 0x0F, 0xF1, 0xFF, 0x0C, 0xF0, 0x8F, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xE7, 0xFC, 0xFF, 0xC0,
  0x03, 0x83, 0xFE, 0x1F, 0xE1, 0xFF, 0x11, 0xE0, 0x1E, 0x01, 0xE1, 0xFC,
  0x1F, 0x01, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xCC, 0x7C, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC3, 0xBC, 0x73, 0xC7, 0x3C, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xE0, 0x1C, 0x03, 0xF0, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0xC7, 0xCF, 0xF8, 0xFF,
  0x8F, 0xE0, 0x01, 0xE1, 0xFC, 0x7F, 0x9F, 0xF3, 0xC0, 0xF0, 0x1F, 0xE7,
  0xFC, 0xFF, 0xDF, 0x7B, 0xCF, 0x79, 0xEF, 0x3D, 0xEF, 0x3F, 0xE3, 0xF8,
  0x3E, 0x00, 0x3F, 0xF3, 0xFE, 0x7F, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xF1, 0xEF, 0x3C, 0xF3, 0xCE, 0x1F,
  0xE1, 0xFC, 0x0F, 0x83, 0xFC, 0x7B, 0xC7, 0x9C, 0xF1, 0xCF, 0x3C, 0xFF,
  0xC7, 0xF8, 0x3F, 0x00, 0x06, 0x03, 0xF0, 0xFF, 0x3F, 0xE7, 0x9C, 0xF3,
  0xFC, 0xF7, 0x9E, 0xFF, 0xCF, 0xF9, 0xFF, 0x09, 0xC0, 0x78, 0x1E, 0x3F,
  0x87, 0xE0, 0xF8, 0x00, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xCF,
  0x3C, 0xF0, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3,
  0xC7, 0x8E, 0x3C, 0x70, 0x00, 0x40, 0x70, 0x7C, 0x7F, 0x7E, 0x3E, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC0, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF0, 0xFC, 0xFE, 0xFE, 0x3E, 0x0C, 0x02, 0x00, 0x0E, 0x1F, 0xDF, 0xEF,
  0xF4, 0x38, 0x3C, 0x3E, 0x3E, 0x3E, 0x1C, 0x1E, 0x00, 0x00, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x1C, 0x0F,
  0x38, 0x07, 0x73, 0xFB, 0x77, 0xF3, 0xE7, 0x73, 0xEE, 0x73, 0xEE, 0x77,
  0xCE, 0x67, 0xCE, 0xE6, 0xCF, 0xFE, 0xCF, 0x7C, 0xE0, 0x00, 0xF0, 0x10,
  0x7D, 0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x77, 0x07, 0xB8, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF7, 0xFF, 0xBC, 0x3F, 0xE1, 0xFE, 0x0F, 0x1F, 0xF0, 0xFF, 0x87,
  0xFE, 0x3C, 0xF3, 0xC7, 0x9E, 0x78, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xCF,
  0x1E, 0x7C, 0xF3, 0xC7, 0xBE, 0x3F, 0xF3, 0xFF, 0x1F, 0xE0, 0x03, 0xC0,
  0xFF, 0x1F, 0xF3, 0xFE, 0x3C, 0x27, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x98, 0xFF, 0x87, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0x7B, 0xC7, 0xDE, 0x3C, 0xF3, 0xE7, 0xBE, 0x3F, 0xE3, 0xFE,
  0x1F, 0xC0, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xE0, 0x3C, 0x03, 0xC0, 0x3F,
  0xC3, 0xFC, 0x3F, 0x87, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0xFF,
  0x0F, 0xF0, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xE0, 0x3C, 0x03, 0xC0, 0x3F,
  0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x3F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x3E, 0x01,
  0xE0, 0x1F, 0x7E, 0xF3, 0xF7, 0x9F, 0xBC, 0xF9, 0xE3, 0xCF, 0x1E, 0x7C,
  0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x1F, 0x3E, 0x3C, 0x78, 0x78, 0xF0,
  0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0,
  0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0,
  0x1F, 0xF1, 0xFE, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xF8, 0xFF, 0x0F, 0xF0,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x09, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x3E, 0x3C, 0xF8,
  0x79, 0xE0, 0xF7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78,
  0x78, 0xF8, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xF0,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xEF,
  0xE1, 0xDD, 0xFC, 0x3B, 0xFF, 0x8F, 0x7E, 0xF1, 0xEF, 0xDE, 0x3D, 0xF3,
  0x87, 0x3E, 0xF0, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0x9E, 0x70, 0x1F, 0x0F,
  0x1F, 0x0E, 0x1F, 0x8E, 0x1F, 0x9E, 0x3F, 0x9E, 0x3F, 0x9E, 0x3F, 0xDC,
  0x3B, 0xDC, 0x3B, 0xFC, 0x79, 0xFC, 0x79, 0xFC, 0x79, 0xF8, 0x71, 0xF8,
  0x71, 0xF8, 0xF0, 0xF8, 0xF0, 0xF8, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7F,
  0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3D,
  0xE1, 0xEF, 0x1F, 0x7D, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x00, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0x3F, 0xE7,
  0xFC, 0x7E, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x7F, 0x87, 0xFC, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x1F, 0x7D, 0xF3, 0xFF, 0x0F, 0xF8,
  0x3F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xE0, 0xFF,
  0x87, 0xFC, 0x3D, 0xF3, 0xCF, 0x9E, 0x78, 0xF7, 0xC7, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3C, 0xF3, 0xC7, 0x9E, 0x3E, 0x03,
  0x80, 0xFF, 0x1F, 0xE3, 0xFE, 0x3C, 0x43, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x83, 0xCE, 0x78, 0xFF, 0x8F, 0xF0, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x3C, 0x79, 0xE3,
  0xCF, 0x1E, 0x78, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xE7,
  0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0xF0,
  0xFF, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F,
  0x00, 0xF1, 0xE3, 0xFE, 0x3C, 0x7B, 0xCF, 0x9E, 0x79, 0xF3, 0xCF, 0x3E,
  0x79, 0xEF, 0xDE, 0x3D, 0xFB, 0xC7, 0xFF, 0x70, 0xEE, 0xFE, 0x1D, 0xFF,
  0xC3, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x3E, 0x7E,
  0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xFF, 0x1E,
  0x7B, 0xC7, 0xBC, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0x0F,
  0xC3, 0xF0, 0xF8, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0xC3, 0xF0,
  0xFC, 0x00, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x78, 0xE3, 0x8E, 0x38,
  0xE3, 0xCF, 0x1C, 0x07, 0xC3, 0xF0, 0xFC, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xE1,
  0xFC, 0x3B, 0x8F, 0x71, 0xCF, 0x70, 0xFE, 0x1C, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFB, 0xCE, 0x70, 0x0E, 0x71, 0xFF, 0x3F, 0xF3, 0xDE, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x71, 0xCF, 0xBC, 0x7F, 0xC7, 0xFC, 0x3B, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1D, 0xC3, 0xFE, 0x3F, 0xE3, 0xDF, 0x3C,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBC, 0xFF, 0xCF, 0xF8, 0xEF,
  0x00, 0x0F, 0x1F, 0xDF, 0xEF, 0x2F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x79,
  0x3F, 0x9F, 0xC7, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0xEF,
  0x0F, 0xF8, 0xFF, 0xC7, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7,
  0x1C, 0x7D, 0xE1, 0xFF, 0x0F, 0xF8, 0x3B, 0xC0, 0x0F, 0x0F, 0xF7, 0xFD,
  0xE7, 0xF3, 0xFF, 0xFF, 0xFB, 0xF8, 0xE0, 0x3C, 0x4F, 0xF3, 0xFC, 0x7E,
  0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0x80, 0x7E, 0x1F, 0xE1,
  0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x04,
  0x00, 0x0E, 0x71, 0xFF, 0x3F, 0xF3, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xCF, 0xBC, 0x7F, 0xC7, 0xFC, 0x3B, 0xC0, 0x38, 0x87, 0x8F,
  0xF8, 0xFF, 0x0F, 0xE0, 0x10, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1D, 0xC3, 0xFE, 0x3F, 0xF3, 0xDF, 0x3C, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x0E, 0x3C, 0x78, 0xF0,
  0x03, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE0,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC7, 0x9E, 0x78, 0xF7, 0x87, 0xBC, 0x3B, 0xC3, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x39, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xE0, 0x1E, 0x3C,
  0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x78,
  0xF0, 0x1D, 0xC7, 0x1F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFE, 0xF3, 0xDF, 0x7B,
  0xCF, 0x3D, 0xE7, 0x9E, 0xF3, 0xCF, 0x79, 0xE7, 0xBC, 0xE7, 0xBC, 0xF3,
  0xDE, 0x79, 0xEF, 0x3C, 0xF0, 0x1D, 0xC3, 0xFE, 0x3F, 0xF3, 0xFF, 0x3C,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xC0, 0x0F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3,
  0xFD, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x0E, 0xE0, 0xFF, 0x87, 0xFC, 0x3D,
  0xF1, 0xE7, 0x9E, 0x38, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xEF, 0x1F, 0xF8,
  0xFF, 0x87, 0xB8, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0x0E, 0x71, 0xFF, 0x3F, 0xF3, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xCF, 0xBC, 0x7F, 0xC7, 0xFC, 0x3B, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x1D, 0xCF, 0xE3, 0xF8, 0xFE, 0x3C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x0F, 0xF3, 0xF9, 0xE2, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xA3, 0xCF,
  0xF3, 0xFC, 0xFE, 0x00, 0x1C, 0x1C, 0x3F, 0xFF, 0xFF, 0x78, 0x78, 0x78,
  0x70, 0xF0, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x79, 0xEF, 0x3D, 0xE7, 0xBC,
  0xF7, 0x1D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0xDE, 0xF3, 0xFE, 0x7F, 0xC7,
  0xB8, 0xF1, 0xFE, 0x3F, 0xCF, 0x39, 0xE7, 0x38, 0xEF, 0x1D, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF3, 0xE7, 0xF9, 0xF3, 0xBC,
  0xFB, 0xDE, 0xFD, 0xEF, 0x7D, 0xE7, 0xF6, 0xF3, 0xFF, 0x71, 0xFF, 0xF8,
  0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x00, 0x1E,
  0x7C, 0x7B, 0xE1, 0xEF, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF8, 0xF1, 0xE0, 0x3C, 0x79,
  0xE3, 0xCF, 0x3C, 0x39, 0xE1, 0xDE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0x10, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x91, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xFE, 0x7F, 0xCF, 0xF8, 0x07,
  0xC3, 0xE0, 0xF8, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F,
  0x81, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0F, 0x83, 0xC7,
  0xE3, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0xF8, 0x7C, 0x3C, 0x18, 0x00, 0xFC,
  0x7F, 0xFF, 0xFE, 0x1F,
};

const GFXglyph NotoSans_Condensed_BlackItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 10, 6, 10, 2, -16 },
  { 23, 14, 16, 13, 0, -16 },
  { 51, 12, 18, 12, 0, -17 },
  { 78, 18, 17, 19, 1, -17 },
  { 117, 15, 17, 15, 0, -17 },
  { 149, 5, 6, 6, 2, -16 },
  { 153, 9, 21, 7, 0, -17 },
  { 177, 9, 21, 7, -2, -17 },
  { 201, 10, 11, 11, 2, -18 },
  { 215, 10, 11, 12, 1, -14 },
  { 229, 6, 6, 6, -1, -3 },
  { 234, 7, 4, 7, 0, -8 },
  { 238, 4, 4, 6, 0, -4 },
  { 240, 13, 17, 10, -1, -17 },
  { 268, 11, 17, 12, 1, -17 },
  { 292, 9, 16, 12, 2, -16 },
  { 310, 12, 17, 12, -1, -17 },
  { 336, 12, 17, 12, 0, -17 },
  { 362, 12, 16, 12, 0, -16 },
  { 386, 12, 16, 12, 0, -16 },
  { 410, 11, 17, 12, 1, -17 },
  { 434, 12, 16, 12, 1, -16 },
  { 458, 12, 17, 12, 0, -17 },
  { 484, 11, 17, 12, 1, -17 },
  { 508, 6, 13, 6, 0, -13 },
  { 518, 7, 16, 6, -1, -13 },
  { 532, 10, 12, 12, 1, -14 },
  { 547, 10, 8, 12, 1, -12 },
  { 557, 10, 12, 12, 1, -14 },
  { 572, 9, 17, 9, 1, -17 },
  { 592, 16, 19, 18, 1, -17 },
  { 630, 13, 16, 13, -1, -16 },
  { 656, 13, 16, 13, 0, -16 },
  { 682, 12, 17, 12, 1, -17 },
  { 708, 13, 16, 13, 0, -16 },
  { 734, 12, 16, 11, 0, -16 },
  { 758, 12, 16, 10, 0, -16 },
  { 782, 13, 17, 14, 1, -17 },
  { 810, 15, 16, 14, 0, -16 },
  { 840, 12, 16, 9, -1, -16 },
  { 864, 12, 21, 7, -4, -16 },
  { 896, 15, 16, 13, 0, -16 },
  { 926, 9, 16, 10, 0, -16 },
  { 944, 19, 16, 18, 0, -16 },
  { 982, 16, 16, 15, 0, -16 },
  { 1014, 13, 17, 14, 1, -17 },
  { 1042, 12, 16, 12, 0, -16 },
  { 1066, 13, 21, 14, 1, -17 },
  { 1101, 13, 16, 13, 0, -16 },
  { 1127, 12, 17, 11, 0, -17 },
  { 1153, 10, 16, 11, 2, -16 },
  { 1173, 13, 16, 14, 1, -16 },
  { 1199, 13, 16, 13, 2, -16 },
  { 1225, 19, 16, 18, 2, -16 },
  { 1263, 15, 16, 13, -1, -16 },
  { 1293, 12, 16, 12, 2, -16 },
  { 1317, 13, 16, 11, -1, -16 },
  { 1343, 10, 21, 7, -1, -17 },
  { 1370, 6, 17, 10, 2, -17 },
  { 1383, 10, 21, 7, -2, -17 },
  { 1410, 11, 10, 11, 0, -16 },
  { 1424, 10, 3, 9, -2, 1 },
  { 1428, 5, 4, 8, 3, -18 },
  { 1431, 12, 13, 12, 0, -13 },
  { 1451, 12, 17, 12, 0, -17 },
  { 1477, 9, 13, 10, 1, -13 },
  { 1492, 13, 17, 12, 0, -17 },
  { 1520, 10, 13, 11, 1, -13 },
  { 1537, 12, 24, 8, -2, -18 },
  { 1573, 12, 19, 12, 0, -13 },
  { 1602, 12, 17, 12, 0, -17 },
  { 1628, 7, 18, 6, 0, -18 },
  { 1644, 10, 24, 6, -3, -18 },
  { 1674, 13, 17, 12, 0, -17 },
  { 1702, 7, 17, 6, 0, -17 },
  { 1717, 17, 13, 18, 0, -13 },
  { 1745, 12, 13, 12, 0, -13 },
  { 1765, 10, 13, 12, 1, -13 },
  { 1782, 13, 19, 12, -1, -13 },
  { 1813, 12, 19, 12, 0, -13 },
  { 1842, 10, 13, 9, 0, -13 },
  { 1859, 10, 13, 10, 0, -13 },
  { 1876, 8, 15, 9, 1, -15 },
  { 1891, 11, 13, 12, 1, -13 },
  { 1909, 11, 13, 11, 1, -13 },
  { 1927, 17, 13, 17, 1, -13 },
  { 1955, 14, 13, 11, -1, -13 },
  { 1978, 13, 19, 11, -1, -13 },
  { 2009, 11, 13, 10, -1, -13 },
  { 2027, 10, 20, 8, 0, -16 },
  { 2052, 4, 23, 10, 3, -18 },
  { 2064, 9, 20, 8, -1, -16 },
  { 2087, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_BlackItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC23PT7B_H_
