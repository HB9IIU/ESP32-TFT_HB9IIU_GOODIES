#ifndef _NOTOSANS_CONDENSED_BLACKITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x00, 0x7D, 0xF7, 0x9F, 0xF9, 0xEF, 0x9E, 0xF3, 0xEF,
  0x3E, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCE, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x83,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF0, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x80, 0x07, 0xC0, 0x7F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x8F, 0xEE, 0x1E, 0xC4, 0x3D, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0x7C, 0x86, 0xF1, 0xEF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x0E, 0x00, 0x10, 0x7E, 0x07, 0x83, 0xF8, 0x3C, 0x1F, 0xF0,
  0xF0, 0x73, 0xC7, 0x83, 0xCF, 0x1E, 0x0F, 0x3C, 0xF0, 0x3C, 0xE7, 0x80,
  0xE7, 0x9E, 0x03, 0x9E, 0xF3, 0xEF, 0xF7, 0x9F, 0xFF, 0xDE, 0xFF, 0x7E,
  0xF7, 0xFC, 0xE3, 0xDE, 0x70, 0x1E, 0x79, 0xC0, 0xF3, 0xCF, 0x03, 0xCF,
  0x3C, 0x1E, 0x3C, 0xF0, 0x70, 0xF7, 0x83, 0xC1, 0xFE, 0x1E, 0x07, 0xF0,
  0xF8, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xCF, 0x8F, 0xFB, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF,
  0x9F, 0x7F, 0xE7, 0xC7, 0xFC, 0xF8, 0xFF, 0x1F, 0x9F, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xBF, 0x00, 0x7D, 0xEF, 0xBE, 0xF3,
  0xCF, 0x00, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x11, 0xE0, 0xEF,
  0x07, 0xF9, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0x81, 0xFE, 0x1F, 0xF0,
  0x73, 0xC1, 0x9F, 0x08, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x1E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x78, 0xF8, 0x7F, 0xBF, 0xDF, 0xDF, 0xE0, 0x7B, 0xFF, 0xFE,
  0xF8, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xF9, 0xF3, 0xE7,
  0xDF, 0x9F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xFE, 0x3F, 0xF8, 0xFB, 0xE3,
  0xEF, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3, 0xEF, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFE, 0x7F, 0xEF, 0xFC,
  0xFF, 0xC7, 0x7C, 0x67, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0x3F, 0x06,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xE0, 0x1F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0x87, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x80, 0xF9, 0x83, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F,
  0x81, 0xFF, 0x03, 0xBE, 0x0F, 0xF8, 0x3D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7,
  0x8F, 0xBF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE0, 0xCF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x40, 0x7C, 0xE1,
  0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x03,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7D, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xCF, 0x9F, 0x9F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF9, 0xF9, 0xF3, 0xE3, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x07,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x87, 0xDF, 0x1F,
  0x3F, 0x3E, 0x3E, 0xF8, 0x7D, 0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x3F, 0xFD,
  0xF9, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF3, 0xF7, 0xFF, 0xDF, 0xFE,
  0x7F, 0xF8, 0xFF, 0xE1, 0xCF, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x8F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF8, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF8, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x07, 0xFC, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x03, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x1F, 0xF1, 0xFF, 0x3F, 0xF0, 0xFF,
  0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x03, 0x80, 0xFF, 0x1F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x98, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7F, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x78, 0x78, 0x01, 0xE3, 0xC7,
  0xF3, 0x8F, 0x3F, 0xEF, 0x79, 0xFF, 0x3D, 0xC7, 0x1C, 0xF7, 0x3C, 0xF3,
  0xFC, 0xE3, 0xCE, 0xF7, 0x8E, 0x3B, 0x9E, 0x39, 0xEE, 0x79, 0xE7, 0x39,
  0xEF, 0xBC, 0xE7, 0xFF, 0xE3, 0x8F, 0xBF, 0x0F, 0x18, 0x70, 0x3C, 0x00,
  0x00, 0x78, 0x02, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0x9F, 0x07, 0xDF, 0x83, 0xEF, 0x81, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x7C,
  0x3E, 0x7E, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xE7,
  0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x84, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF9,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF,
  0x87, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x10, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x10, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x3F, 0x9F, 0x3F, 0xDF, 0x9F, 0xEF, 0xCF, 0xE7, 0xE7,
  0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xFC, 0x7E, 0x7F, 0x3E, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8,
  0x7C, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xE1,
  0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0xF8, 0xFC, 0x0F, 0x8F,
  0xC0, 0xF9, 0xF8, 0x0F, 0xBF, 0x01, 0xFB, 0xE0, 0x1F, 0x7E, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07,
  0xC7, 0xC0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x00, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xFF, 0x7F, 0xEF, 0xFE, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1E, 0xF3, 0xFE, 0x1F, 0x7B,
  0xDF, 0x0F, 0xBD, 0xFF, 0x07, 0xDF, 0xEF, 0x83, 0xEF, 0xF7, 0xC1, 0xE7,
  0xFB, 0xE1, 0xF3, 0xF9, 0xE0, 0xF9, 0xFD, 0xF0, 0x7C, 0xFC, 0xF8, 0x3E,
  0x7E, 0x7C, 0x1E, 0x3E, 0x3E, 0x1F, 0x1F, 0x3E, 0x0F, 0x8F, 0x1F, 0x00,
  0x0F, 0xE0, 0xF8, 0x7F, 0x0F, 0x83, 0xF8, 0x7C, 0x1F, 0xC3, 0xE0, 0xFF,
  0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xCF, 0x83, 0xFE, 0x7C, 0x1E, 0xF3, 0xE1,
  0xF7, 0xDF, 0x0F, 0xBE, 0xF0, 0x7D, 0xFF, 0x83, 0xEF, 0xFC, 0x1E, 0x3F,
  0xE1, 0xF1, 0xFF, 0x0F, 0x8F, 0xF0, 0x7C, 0x7F, 0x83, 0xE1, 0xFC, 0x1E,
  0x0F, 0xE1, 0xF0, 0x7F, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x7C, 0xFC, 0x3E, 0x7C,
  0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7D, 0xF8, 0x7E, 0xFC, 0x7E, 0x7F, 0x7F, 0x1F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFC, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7D, 0xF8, 0x7E, 0xFC,
  0x7E, 0x7F, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x9F, 0x1F,
  0x1F, 0x1F, 0x3F, 0x1F, 0x3F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C,
  0x7C, 0xFC, 0x7E, 0xF8, 0x7E, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xC3, 0xE1, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0xC1,
  0xF9, 0xE7, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0,
  0xFC, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x3E, 0x1F, 0xBE, 0x1F, 0x0F,
  0x9F, 0x1F, 0x8F, 0xCF, 0x0F, 0xC7, 0xC7, 0x8F, 0xE3, 0xE7, 0xC7, 0xF3,
  0xE3, 0xE3, 0xF9, 0xF1, 0xF3, 0xFC, 0xF8, 0xF9, 0xFE, 0xF8, 0x7D, 0xFF,
  0x7C, 0x3E, 0xFF, 0xFC, 0x1F, 0x7F, 0xFE, 0x0F, 0xFB, 0xFF, 0x07, 0xFD,
  0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE3, 0xF8, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0xF9, 0xF8, 0x0F,
  0xC7, 0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x7F, 0xF0, 0xFB,
  0xE3, 0xF7, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x04,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0x7C, 0x78, 0xF1, 0xE3,
  0xC0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xBC,
  0x1E, 0x78, 0x7C, 0xF8, 0xF0, 0xF3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xC0,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0xF8, 0xF1, 0xF1, 0xE0,
  0x07, 0x1E, 0x3F, 0x7C, 0xFF, 0xF1, 0xFF, 0xE7, 0xEF, 0xCF, 0x9F, 0xBF,
  0x1F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0x9F,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7D, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xDE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F,
  0xBE, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x3C, 0xF8, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xF6,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x8C, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0x3E, 0x1F, 0xBE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0x7C, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7D, 0xE0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFE, 0x7E, 0x7D, 0xF1, 0xF7, 0xCF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x23, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xA0, 0x0F,
  0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x03, 0x8F, 0x0F, 0xDF, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3E, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x83, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xCE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF,
  0xF9, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0xBE, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x00,
  0x07, 0x83, 0xF0, 0xF8, 0x3E, 0x07, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x3E, 0x3E, 0x3E, 0x1F, 0x3F, 0x0F, 0xBF, 0x0F, 0x9F, 0x07, 0xDF, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0x7E, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xE3, 0xE3, 0xF0, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x3E, 0x0F, 0x80, 0x1E, 0x38, 0x78, 0x3D, 0xF9, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xE7, 0xCF, 0xCF, 0x8F, 0x9F,
  0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3,
  0xE3, 0xE7, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF9, 0xF0, 0x1E, 0x38, 0x3D, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF3, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7E, 0xF8, 0xF9,
  0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF8, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7E, 0xFD, 0xF1, 0xF7,
  0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF9, 0xF3,
  0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x07, 0x9E, 0x03, 0xDF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0x1E,
  0x3F, 0x7C, 0xFF, 0xF1, 0xFF, 0xE7, 0xEF, 0xCF, 0x8F, 0x9F, 0x1F, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0x9F, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x7D, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x38, 0xF7, 0x87, 0xBC,
  0x3F, 0xE3, 0xFF, 0x1F, 0xC8, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xE2, 0x1F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC8, 0x3E, 0x7F, 0xF3, 0xFF, 0x1F,
  0xF8, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0xF3, 0xFE, 0xFF, 0xFF,
  0xF1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xC4, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x80, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF9, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7E, 0x7C, 0xF9,
  0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0x9F, 0x9F, 0xFE, 0x3F, 0xFC, 0x7F,
  0x78, 0x7C, 0xF0, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3,
  0xE7, 0xCF, 0xBE, 0x3E, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0xF8, 0xFF,
  0xCF, 0xC7, 0xFE, 0x7E, 0x7D, 0xF7, 0xF3, 0xEF, 0xBF, 0x9F, 0x7D, 0xFD,
  0xF3, 0xDF, 0xEF, 0x9E, 0xFF, 0x78, 0xF7, 0x7F, 0xC7, 0xFB, 0xFC, 0x3F,
  0xDF, 0xE1, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0, 0x7D,
  0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x07,
  0xDF, 0x03, 0xF7, 0xC1, 0xF9, 0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xC3,
  0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xF0,
  0x3F, 0x00, 0xF0, 0x7F, 0x0F, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0x7F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_Condensed_BlackItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 21, 8, 0, -21 },
  { 28, 12, 7, 14, 3, -21 },
  { 39, 18, 21, 17, 0, -21 },
  { 87, 15, 25, 15, 1, -23 },
  { 134, 22, 22, 25, 2, -22 },
  { 195, 19, 22, 19, 0, -22 },
  { 248, 6, 7, 7, 3, -21 },
  { 254, 11, 27, 9, 1, -22 },
  { 292, 11, 27, 9, -2, -22 },
  { 330, 13, 14, 14, 2, -23 },
  { 353, 14, 15, 16, 1, -18 },
  { 380, 8, 8, 8, -2, -4 },
  { 388, 9, 4, 9, 0, -10 },
  { 393, 6, 5, 8, 0, -5 },
  { 397, 17, 22, 13, -2, -22 },
  { 444, 14, 22, 15, 1, -22 },
  { 483, 12, 21, 15, 3, -21 },
  { 515, 16, 22, 15, -1, -22 },
  { 559, 15, 22, 15, 0, -22 },
  { 601, 15, 21, 15, 0, -21 },
  { 641, 15, 21, 15, 0, -21 },
  { 681, 15, 22, 15, 1, -22 },
  { 723, 16, 21, 15, 1, -21 },
  { 765, 15, 22, 15, 0, -22 },
  { 807, 14, 22, 15, 1, -22 },
  { 846, 8, 17, 8, 0, -17 },
  { 863, 10, 21, 8, -2, -17 },
  { 890, 14, 16, 16, 1, -19 },
  { 918, 14, 11, 16, 1, -16 },
  { 938, 14, 16, 16, 1, -19 },
  { 966, 13, 22, 12, 1, -22 },
  { 1002, 22, 24, 23, 1, -22 },
  { 1068, 17, 21, 17, -2, -21 },
  { 1113, 17, 21, 17, 0, -21 },
  { 1158, 16, 22, 16, 1, -22 },
  { 1202, 17, 21, 18, 0, -21 },
  { 1247, 15, 21, 14, 0, -21 },
  { 1287, 15, 21, 14, 0, -21 },
  { 1327, 17, 22, 18, 1, -22 },
  { 1374, 19, 21, 18, 0, -21 },
  { 1424, 15, 21, 12, -1, -21 },
  { 1464, 15, 28, 9, -5, -21 },
  { 1517, 20, 21, 17, 0, -21 },
  { 1570, 12, 21, 13, 0, -21 },
  { 1602, 25, 21, 24, 0, -21 },
  { 1668, 21, 21, 20, 0, -21 },
  { 1724, 17, 22, 19, 1, -22 },
  { 1771, 16, 21, 16, 0, -21 },
  { 1813, 17, 27, 19, 1, -22 },
  { 1871, 16, 21, 16, 0, -21 },
  { 1913, 15, 22, 14, 0, -22 },
  { 1955, 14, 21, 14, 2, -21 },
  { 1992, 18, 21, 18, 1, -21 },
  { 2040, 16, 21, 16, 3, -21 },
  { 2082, 25, 21, 24, 2, -21 },
  { 2148, 21, 21, 16, -2, -21 },
  { 2204, 15, 21, 16, 3, -21 },
  { 2244, 17, 21, 14, -1, -21 },
  { 2289, 13, 27, 9, -1, -22 },
  { 2333, 7, 22, 13, 3, -22 },
  { 2353, 13, 27, 9, -2, -22 },
  { 2397, 15, 14, 15, 0, -21 },
  { 2424, 13, 4, 12, -3, 2 },
  { 2431, 7, 5, 10, 4, -23 },
  { 2436, 15, 17, 16, 1, -17 },
  { 2468, 15, 23, 16, 0, -23 },
  { 2512, 13, 17, 13, 1, -17 },
  { 2540, 16, 23, 16, 1, -23 },
  { 2586, 14, 17, 15, 1, -17 },
  { 2616, 17, 30, 10, -3, -23 },
  { 2680, 16, 24, 16, 0, -17 },
  { 2728, 15, 23, 16, 0, -23 },
  { 2772, 10, 23, 8, 0, -23 },
  { 2801, 14, 30, 8, -4, -23 },
  { 2854, 17, 23, 16, 0, -23 },
  { 2903, 10, 23, 8, 0, -23 },
  { 2932, 23, 17, 24, 0, -17 },
  { 2981, 15, 17, 16, 0, -17 },
  { 3013, 14, 17, 16, 1, -17 },
  { 3043, 17, 24, 16, -2, -17 },
  { 3094, 15, 24, 16, 1, -17 },
  { 3139, 13, 17, 11, 0, -17 },
  { 3167, 13, 17, 13, 0, -17 },
  { 3195, 11, 20, 11, 1, -20 },
  { 3223, 15, 17, 16, 1, -17 },
  { 3255, 14, 17, 14, 2, -17 },
  { 3285, 21, 17, 22, 2, -17 },
  { 3330, 18, 17, 15, -2, -17 },
  { 3369, 18, 24, 14, -2, -17 },
  { 3423, 14, 17, 13, -1, -17 },
  { 3453, 13, 26, 10, 0, -21 },
  { 3496, 4, 30, 13, 5, -23 },
  { 3511, 12, 26, 10, -2, -21 },
  { 3550, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_Condensed_BlackItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC30PT7B_H_
