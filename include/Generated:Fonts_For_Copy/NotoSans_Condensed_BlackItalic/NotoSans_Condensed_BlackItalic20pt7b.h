#ifndef _NOTOSANS_CONDENSED_BLACKITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9C, 0x70, 0x02, 0x3C, 0xF3, 0x80,
  0xF7, 0xE7, 0xEE, 0xEE, 0xEE, 0x06, 0x60, 0xEE, 0x0E, 0xC0, 0xCC, 0x3F,
  0xF7, 0xFF, 0x19, 0x81, 0xB8, 0xFF, 0xEF, 0xFC, 0x33, 0x07, 0x70, 0x76,
  0x06, 0xE0, 0x03, 0x01, 0xE1, 0xFC, 0xFF, 0x3A, 0x8F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xE4, 0xB9, 0xFE, 0xFF, 0x1F, 0x81, 0x80, 0x40, 0x3C, 0x38,
  0xFC, 0x61, 0xB9, 0xC7, 0x77, 0x0E, 0xEC, 0x1D, 0xBB, 0xBF, 0x6F, 0xBD,
  0xFF, 0x07, 0x76, 0x0C, 0xCC, 0x39, 0xB8, 0xE3, 0x71, 0x87, 0xC7, 0x0F,
  0x00, 0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xC0, 0x7D,
  0xEF, 0xEE, 0x77, 0xF7, 0xBF, 0x3C, 0xF1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0xFE, 0xEE, 0xE0, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x0E, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0xF0, 0x0E, 0x27, 0x1F, 0x3F, 0xF3, 0xF9, 0xF1, 0xD8, 0x6E,
  0x26, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0x3B, 0xDC, 0xEE, 0x70, 0x7D, 0xFF, 0xC0, 0x2F, 0xFE, 0x01,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0x1F, 0xDF, 0xEE, 0x77,
  0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0x73, 0xBB, 0xDF, 0xCF, 0xC3, 0xC0, 0x0F,
  0x1E, 0x3E, 0xFE, 0xFE, 0x5E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x0F, 0xC3, 0xFC, 0x7F, 0x84, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xC7, 0xF9, 0xFF, 0x00, 0x1F, 0x8F, 0xF1,
  0xBC, 0x0F, 0x03, 0x87, 0xE1, 0xE0, 0x7C, 0x07, 0x81, 0xE8, 0x7B, 0xFE,
  0xFF, 0x3F, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x3E, 0x1F, 0x86, 0xE3, 0xF9,
  0xDE, 0x7F, 0xFF, 0xEF, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0x1F, 0xC7, 0xF1,
  0xFC, 0xF0, 0x38, 0x0F, 0xC3, 0xF9, 0xFE, 0x07, 0x81, 0xE8, 0x7B, 0xFC,
  0xFF, 0x3F, 0x80, 0x0F, 0xC7, 0xE3, 0xC9, 0xE0, 0x74, 0x3F, 0xCF, 0xF3,
  0xDC, 0xE7, 0xB9, 0xCE, 0x73, 0xFC, 0xFE, 0x1F, 0x00, 0x3F, 0xE7, 0xFC,
  0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x87, 0xF3, 0xDC, 0xE7, 0x3F, 0xC7,
  0xE1, 0xF0, 0xFC, 0x7F, 0xBC, 0xEF, 0x3B, 0xDE, 0x7F, 0x0F, 0x80, 0x1F,
  0x8F, 0xF3, 0xFC, 0xE7, 0x79, 0xDE, 0xF7, 0xFD, 0xFE, 0x3F, 0x80, 0xE0,
  0x73, 0xFC, 0xFE, 0x3E, 0x00, 0x38, 0xF3, 0x84, 0x00, 0x00, 0x08, 0xF3,
  0xCE, 0x00, 0x1C, 0x3C, 0x70, 0x40, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xC3,
  0x8E, 0x1C, 0x00, 0x01, 0x83, 0xC7, 0xEF, 0xCF, 0x07, 0xC0, 0xFC, 0x1F,
  0x03, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x3F, 0x07, 0xE0, 0xF8, 0xFD, 0xF9, 0xF0, 0xE0, 0x40, 0x00,
  0x7E, 0x7F, 0x6F, 0x07, 0x0F, 0x1E, 0x3C, 0x78, 0x70, 0x00, 0x20, 0xF0,
  0xF0, 0xE0, 0x07, 0xF0, 0x7F, 0xE3, 0x81, 0xDC, 0xF3, 0x67, 0xEF, 0xBB,
  0x3C, 0xCC, 0xF7, 0x33, 0xDD, 0xDB, 0x77, 0x6D, 0xFF, 0x33, 0xB8, 0xE0,
  0x01, 0xE7, 0x03, 0xFC, 0x03, 0x80, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xEE, 0x1D, 0xC7, 0xB8, 0xE7, 0x3F, 0xE7, 0xFD, 0xFF, 0xBC, 0x77, 0x0F,
  0xE1, 0xC0, 0x1F, 0xC3, 0xFC, 0xFF, 0x9E, 0xF3, 0xDE, 0x7F, 0x8F, 0xE3,
  0xFE, 0x7B, 0xCE, 0x79, 0xCF, 0x3F, 0xEF, 0xF9, 0xFC, 0x00, 0x0F, 0xCF,
  0xF3, 0xF9, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0F, 0x13,
  0xFC, 0x7F, 0x0F, 0x80, 0x1F, 0xC1, 0xFE, 0x3F, 0xE3, 0xCE, 0x3C, 0xF3,
  0x8F, 0x38, 0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x73, 0xC7, 0xF8, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF3, 0xFC, 0xF0, 0x3C, 0x0F, 0xE3, 0xF1, 0xFC, 0x78,
  0x1C, 0x07, 0x01, 0xFC, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF3, 0xFC, 0xF0,
  0x3C, 0x0E, 0x23, 0xF1, 0xFC, 0x7F, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x00, 0x0F, 0xE3, 0xFC, 0xFF, 0x3C, 0x07, 0x81, 0xE0, 0x3D, 0xF7, 0xBE,
  0xE7, 0xDC, 0x7B, 0xCE, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x1E, 0x78, 0xE3,
  0x8F, 0x1C, 0x79, 0xE3, 0xCF, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x79, 0xE3,
  0x8F, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x79, 0xE0, 0x1F, 0xC7, 0xF0, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x7F,
  0x3F, 0x80, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE2, 0xF0, 0xFC, 0x3E,
  0x00, 0x1E, 0x78, 0xE7, 0x8F, 0x78, 0x7B, 0x83, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xBC, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0x79, 0xE0,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x7F,
  0xFF, 0xFE, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3F, 0x7E, 0x3F, 0x6E, 0x7F, 0xFE, 0x77, 0xFE, 0x77, 0xDC, 0x77, 0xDC,
  0x77, 0x9C, 0xF7, 0xBC, 0xE7, 0x38, 0x1E, 0x3C, 0x78, 0xE3, 0xF3, 0x8F,
  0xCE, 0x3F, 0x38, 0xFD, 0xE3, 0xF7, 0x1F, 0xFC, 0x73, 0xF1, 0xCF, 0xC7,
  0x3F, 0x1C, 0xF8, 0xF1, 0xE3, 0x87, 0x80, 0x02, 0x01, 0xF8, 0xFF, 0x9F,
  0xF7, 0x8E, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0x79, 0xEF,
  0xF8, 0xFE, 0x0F, 0x80, 0x1F, 0xC3, 0xF8, 0xFF, 0x9E, 0xF3, 0xDE, 0x73,
  0xCF, 0xF3, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x00,
  0x02, 0x01, 0xF8, 0xFF, 0x9F, 0xF7, 0x8E, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFC, 0x3F, 0x87, 0x79, 0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1F, 0xC3, 0xFC, 0xFF, 0x9E, 0xF3, 0xDE, 0x73, 0xCF, 0xF3, 0xFC,
  0x7F, 0x0E, 0xF1, 0xDE, 0x39, 0xCF, 0x3D, 0xE7, 0x80, 0x1F, 0xCF, 0xF3,
  0xF8, 0xE2, 0x38, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x01, 0xC8, 0x73, 0xFC,
  0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xBF, 0xC7, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x00, 0x38, 0xE7, 0x1D, 0xE7, 0xBC,
  0xF7, 0x1C, 0xE3, 0x9C, 0x77, 0x9E, 0xF3, 0xDC, 0x73, 0x9E, 0x7F, 0xCF,
  0xF0, 0xFC, 0x00, 0xE1, 0xFC, 0x7B, 0x8E, 0x73, 0xCE, 0x79, 0xCE, 0x3B,
  0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0xE3,
  0x8F, 0xE3, 0x8E, 0xE7, 0x9E, 0xE7, 0x9C, 0xEF, 0x9C, 0xEF, 0xBC, 0xEF,
  0xB8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFB, 0xF0, 0xFB, 0xF0, 0xF3, 0xE0, 0xF3,
  0xE0, 0xF3, 0xC0, 0x1E, 0x78, 0xF3, 0x83, 0xBC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0xF3, 0x87, 0x9C,
  0x78, 0xF0, 0xE3, 0xFC, 0xEF, 0x7B, 0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0x87, 0x83, 0xC3, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78,
  0x7C, 0x00, 0xE7, 0x38, 0xC7, 0x39, 0xCE, 0x73, 0x8C, 0x73, 0x9C, 0x1F,
  0x1F, 0x1F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0xF8, 0xF0, 0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x8E,
  0xE7, 0x39, 0xC6, 0xE1, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xF7, 0x30, 0x1E,
  0xE7, 0xF8, 0xFF, 0x3D, 0xE7, 0x3C, 0xE7, 0x1C, 0xE7, 0x9C, 0xFF, 0x8F,
  0xF1, 0xFC, 0x00, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3B, 0x8F, 0xF3, 0xFD,
  0xE7, 0x79, 0xDC, 0xF7, 0x3D, 0xCE, 0xFF, 0xBF, 0xCE, 0xE0, 0x1F, 0x9F,
  0xCF, 0xCF, 0x07, 0x03, 0x81, 0xC1, 0xE2, 0x7E, 0x3F, 0x0F, 0x80, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xF1, 0xFC, 0x7F, 0x8F, 0xF3, 0xDE, 0x73, 0xCE,
  0x71, 0xCE, 0x79, 0xCF, 0xF8, 0xFF, 0x1F, 0xC0, 0x0F, 0x8F, 0xE3, 0xBD,
  0xEF, 0x7F, 0x9F, 0xC7, 0xC3, 0xC0, 0x7B, 0x1F, 0xC3, 0xF0, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x1F, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0xE7, 0xF8, 0xFF, 0x3D, 0xE7, 0x3C, 0xE7, 0x1C, 0xE7,
  0xBC, 0xFF, 0x8F, 0xF1, 0xFC, 0x03, 0x88, 0xF1, 0xFC, 0x3F, 0x83, 0xC0,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3B, 0x8F, 0xF3, 0xFD, 0xE7, 0x7B, 0xDC,
  0xF7, 0x39, 0xCE, 0xF3, 0xBD, 0xEE, 0x78, 0x08, 0x71, 0xC7, 0x00, 0xF3,
  0x8E, 0x39, 0xE7, 0x1C, 0x73, 0xCF, 0x38, 0x01, 0x01, 0xC0, 0xE0, 0x70,
  0x00, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x1E, 0x3F, 0x1F, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC1, 0x39, 0xE3, 0x9C, 0x3B, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0xF7, 0x8F, 0x78, 0xE3, 0x80, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E,
  0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x00, 0x3B, 0xDE, 0x7F, 0xFC,
  0xFF, 0xFB, 0xCE, 0x77, 0xBC, 0xEE, 0x7B, 0xDC, 0xE7, 0xB9, 0xCE, 0xF3,
  0x9D, 0xEF, 0x3B, 0x9E, 0xF0, 0x3B, 0x8F, 0xF3, 0xFD, 0xE7, 0x7B, 0xDC,
  0xF7, 0x39, 0xCE, 0xF3, 0xBD, 0xEE, 0x78, 0x0F, 0x8F, 0xE3, 0xFD, 0xEF,
  0x73, 0xDC, 0xF7, 0x3B, 0xCE, 0x7F, 0x9F, 0xC3, 0xE0, 0x1D, 0xC3, 0xFC,
  0x7F, 0x9E, 0x73, 0xCE, 0x73, 0xCE, 0x79, 0xCE, 0x7F, 0xCF, 0xF1, 0xDC,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x1E, 0xE7, 0xF8, 0xFF, 0x3D,
  0xE7, 0x3C, 0xE7, 0x1C, 0xE7, 0xBC, 0xFF, 0x8F, 0xF1, 0xFC, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x3B, 0x9F, 0x8F, 0xCF, 0x87, 0x83, 0x81,
  0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x00, 0x3F, 0x9F, 0x9E, 0xCF, 0x07, 0xC1,
  0xF0, 0x78, 0x1C, 0xFE, 0x7F, 0x3F, 0x00, 0x18, 0x71, 0xFF, 0xFF, 0xEE,
  0x1C, 0x78, 0xF1, 0xC3, 0xE7, 0xCF, 0x80, 0x7B, 0xDC, 0xE7, 0x3B, 0xCE,
  0xF7, 0xB9, 0xEE, 0x73, 0x9C, 0xFF, 0x3F, 0xCF, 0x70, 0xF3, 0xFC, 0xEF,
  0x7B, 0xDC, 0xFF, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE7,
  0x9F, 0xCF, 0x3B, 0xBE, 0xE7, 0x7D, 0xCE, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC,
  0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0x83, 0xCF, 0x00, 0x3C, 0xF1, 0xDE, 0x1D,
  0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xF8, 0x3B, 0x87, 0xB8, 0xF3,
  0xC0, 0x3C, 0xF3, 0xCE, 0x3D, 0xE3, 0xDC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x0E,
  0x00, 0x1F, 0xCF, 0xF3, 0xF8, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x7F,
  0x1F, 0xCF, 0xF0, 0x07, 0x0F, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xE0,
  0xF0, 0x78, 0x78, 0x70, 0x70, 0x78, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x1E, 0x0E, 0x1E, 0x1C, 0x1E, 0x0F,
  0x07, 0x1E, 0x3C, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0x70, 0xFF, 0xFF,
  0xF0, 0xE0,
};

const GFXglyph NotoSans_Condensed_BlackItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 12, 14, 11, 0, -14 },
  { 38, 10, 16, 10, 0, -15 },
  { 58, 15, 14, 17, 1, -14 },
  { 85, 13, 14, 13, 0, -14 },
  { 108, 4, 5, 5, 2, -14 },
  { 111, 8, 18, 6, 0, -15 },
  { 129, 8, 18, 6, -2, -15 },
  { 147, 9, 9, 9, 1, -15 },
  { 158, 9, 10, 11, 1, -12 },
  { 170, 5, 6, 5, -1, -3 },
  { 174, 6, 3, 6, 0, -7 },
  { 177, 4, 4, 5, 0, -4 },
  { 179, 11, 14, 8, -1, -14 },
  { 199, 9, 14, 10, 1, -14 },
  { 215, 8, 14, 10, 2, -14 },
  { 229, 11, 14, 10, -1, -14 },
  { 249, 10, 14, 10, 0, -14 },
  { 267, 10, 14, 10, 0, -14 },
  { 285, 10, 14, 10, 0, -14 },
  { 303, 10, 14, 10, 1, -14 },
  { 321, 11, 14, 10, 0, -14 },
  { 341, 10, 14, 10, 0, -14 },
  { 359, 10, 14, 10, 0, -14 },
  { 377, 6, 11, 6, 0, -11 },
  { 386, 7, 14, 6, -1, -11 },
  { 399, 9, 10, 11, 1, -12 },
  { 411, 9, 8, 11, 1, -11 },
  { 420, 9, 10, 11, 1, -12 },
  { 432, 8, 14, 8, 1, -14 },
  { 446, 14, 16, 15, 1, -14 },
  { 474, 11, 14, 12, -1, -14 },
  { 494, 11, 14, 11, 0, -14 },
  { 514, 10, 14, 10, 1, -14 },
  { 532, 12, 14, 12, 0, -14 },
  { 553, 10, 14, 9, 0, -14 },
  { 571, 10, 14, 9, 0, -14 },
  { 589, 11, 14, 12, 1, -14 },
  { 609, 13, 14, 12, 0, -14 },
  { 632, 10, 14, 8, -1, -14 },
  { 650, 10, 18, 6, -3, -14 },
  { 673, 13, 14, 11, 0, -14 },
  { 696, 8, 14, 9, 0, -14 },
  { 710, 16, 14, 16, 0, -14 },
  { 738, 14, 14, 13, 0, -14 },
  { 763, 11, 15, 12, 1, -15 },
  { 784, 11, 14, 10, 0, -14 },
  { 804, 11, 18, 12, 1, -15 },
  { 829, 11, 14, 11, 0, -14 },
  { 849, 10, 14, 9, 0, -14 },
  { 867, 9, 14, 9, 2, -14 },
  { 883, 11, 14, 12, 1, -14 },
  { 903, 11, 14, 11, 2, -14 },
  { 923, 16, 14, 16, 2, -14 },
  { 951, 13, 14, 11, -1, -14 },
  { 974, 10, 14, 10, 2, -14 },
  { 992, 12, 14, 9, -1, -14 },
  { 1013, 9, 18, 6, -1, -15 },
  { 1034, 5, 14, 8, 2, -14 },
  { 1043, 8, 18, 6, -1, -15 },
  { 1061, 10, 9, 10, 0, -14 },
  { 1073, 9, 3, 8, -2, 1 },
  { 1077, 4, 3, 7, 3, -15 },
  { 1079, 11, 11, 10, 0, -11 },
  { 1095, 10, 15, 10, 0, -15 },
  { 1114, 9, 11, 9, 0, -11 },
  { 1127, 11, 15, 10, 0, -15 },
  { 1148, 10, 11, 10, 0, -11 },
  { 1162, 11, 20, 7, -2, -15 },
  { 1190, 11, 16, 10, 0, -11 },
  { 1212, 10, 15, 11, 0, -15 },
  { 1231, 6, 16, 5, 0, -16 },
  { 1243, 9, 21, 5, -3, -16 },
  { 1267, 12, 15, 10, 0, -15 },
  { 1290, 7, 15, 5, 0, -15 },
  { 1304, 15, 11, 16, 0, -11 },
  { 1325, 10, 11, 11, 0, -11 },
  { 1339, 10, 11, 10, 0, -11 },
  { 1353, 11, 16, 10, -1, -11 },
  { 1375, 11, 16, 10, 0, -11 },
  { 1397, 9, 11, 8, 0, -11 },
  { 1410, 9, 11, 8, 0, -11 },
  { 1423, 7, 13, 8, 1, -13 },
  { 1435, 10, 11, 11, 1, -11 },
  { 1449, 10, 11, 10, 1, -11 },
  { 1463, 15, 11, 14, 1, -11 },
  { 1484, 12, 11, 10, -1, -11 },
  { 1501, 12, 16, 10, -1, -11 },
  { 1525, 10, 11, 8, -1, -11 },
  { 1539, 8, 17, 7, 0, -14 },
  { 1556, 3, 20, 9, 3, -15 },
  { 1564, 8, 17, 7, -1, -14 },
  { 1581, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_BlackItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC20PT7B_H_
