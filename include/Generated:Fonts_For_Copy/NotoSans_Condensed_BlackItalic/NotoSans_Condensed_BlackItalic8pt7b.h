#ifndef _NOTOSANS_CONDENSED_BLACKITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x61, 0x80, 0xBC, 0x39, 0x9E, 0xAE, 0x50, 0x27, 0x63, 0xBE,
  0x64, 0xD2, 0xD2, 0xF2, 0xCD, 0x80, 0x32, 0x9D, 0xFB, 0x7C, 0xC0, 0x29,
  0x69, 0x30, 0x24, 0x92, 0xF0, 0xDF, 0x70, 0x22, 0xF2, 0xE0, 0xC0, 0xC0,
  0x12, 0x24, 0xC8, 0x35, 0x5F, 0xFE, 0x7F, 0x25, 0x80, 0x77, 0x36, 0xCE,
  0x75, 0x36, 0x3E, 0x13, 0x7A, 0xF2, 0x74, 0x67, 0xBE, 0x36, 0x7F, 0xF6,
  0x77, 0x32, 0x4C, 0x35, 0x76, 0xBE, 0x65, 0xD7, 0x2E, 0x43, 0x43, 0x80,
  0x16, 0xE1, 0xF0, 0xF0, 0x86, 0x3C, 0x67, 0x24, 0x0C, 0x39, 0x17, 0xED,
  0xBB, 0x23, 0x00, 0x33, 0x55, 0xF9, 0x75, 0x77, 0xFE, 0x3B, 0x91, 0x8C,
  0x30, 0x72, 0xD6, 0xAF, 0x70, 0x74, 0x76, 0xCE, 0x74, 0x46, 0xCC, 0x3B,
  0x53, 0xED, 0x38, 0x6A, 0xDE, 0xED, 0x78, 0x76, 0x64, 0x4E, 0x32, 0x22,
  0x66, 0xCC, 0x6A, 0x9C, 0xCF, 0x78, 0x69, 0x2D, 0xC0, 0x66, 0xD9, 0xB3,
  0xAF, 0xD5, 0x00, 0x6D, 0xA6, 0x9A, 0xFA, 0x40, 0x33, 0xD7, 0xBD, 0x38,
  0x75, 0x57, 0xCC, 0x33, 0xD7, 0xBD, 0x38, 0xC0, 0x75, 0x56, 0xFF, 0x75,
  0x46, 0xAE, 0xEB, 0x69, 0x00, 0x6A, 0xD6, 0xAD, 0x38, 0x9B, 0xAE, 0xCC,
  0xB6, 0xBE, 0xBA, 0xF2, 0xC0, 0x5B, 0x9C, 0xC7, 0x58, 0xBA, 0xEC, 0xC8,
  0x73, 0x24, 0xCE, 0x69, 0x69, 0x30, 0xAA, 0xD0, 0x33, 0x22, 0x22, 0xC0,
  0x22, 0x79, 0xF0, 0xC0, 0x47, 0xDF, 0xE0, 0x65, 0x7D, 0xFE, 0x36, 0xCC,
  0xE0, 0x1A, 0x9D, 0xAF, 0x70, 0x27, 0xFC, 0xE0, 0x39, 0x1C, 0x46, 0x31,
  0x18, 0x27, 0xDF, 0xEA, 0xE0, 0x65, 0x7D, 0xFA, 0x61, 0x6D, 0x00, 0x30,
  0x26, 0x64, 0x4C, 0x62, 0x5D, 0xCE, 0x58, 0x69, 0x6D, 0x00, 0x15, 0xFD,
  0x7F, 0xAC, 0x17, 0xDF, 0xA0, 0x27, 0xDF, 0xE0, 0x27, 0xDF, 0xE8, 0x80,
  0x27, 0xDF, 0xE2, 0x20, 0x2F, 0x68, 0x3D, 0x9E, 0x7D, 0x6E, 0x5D, 0xFE,
  0xF6, 0x64, 0xF7, 0xED, 0xB6, 0x76, 0x6A, 0xF6, 0x64, 0x48, 0xF6, 0xCE,
  0x2D, 0x65, 0xB0, 0xFF, 0x49, 0x35, 0xA0, 0x5F,
};

const GFXglyph NotoSans_Condensed_BlackItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 6, 4, 0, -6 },
  { 12, 7, 6, 7, 0, -6 },
  { 18, 5, 6, 5, 0, -6 },
  { 22, 1, 2, 2, 1, -6 },
  { 23, 3, 7, 2, 0, -6 },
  { 26, 3, 7, 2, -1, -6 },
  { 29, 3, 4, 4, 1, -6 },
  { 31, 4, 4, 4, 0, -5 },
  { 33, 2, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 2, 1, 2, 0, -1 },
  { 36, 4, 6, 3, 0, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 1, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 4, 6, 4, 0, -6 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 2, 5, 2, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 4, 3, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -5 },
  { 78, 4, 6, 3, 0, -6 },
  { 81, 6, 7, 6, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 5, 6, 4, 0, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 4, 6, 4, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 4, 6, 3, 0, -6 },
  { 118, 4, 8, 2, -1, -6 },
  { 122, 5, 6, 4, 0, -6 },
  { 126, 3, 6, 4, 0, -6 },
  { 129, 7, 6, 6, 0, -6 },
  { 135, 6, 6, 5, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 5, 7, 5, 0, -6 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 4, 6, 4, 0, -6 },
  { 158, 3, 6, 4, 1, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 4, 6, 4, 1, -6 },
  { 168, 6, 6, 6, 1, -6 },
  { 173, 5, 6, 4, 0, -6 },
  { 177, 4, 6, 4, 1, -6 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 3, 7, 2, 0, -6 },
  { 186, 2, 6, 3, 1, -6 },
  { 188, 4, 7, 2, -1, -6 },
  { 192, 4, 4, 4, 0, -6 },
  { 194, 4, 1, 3, -1, 0 },
  { 195, 2, 1, 3, 1, -6 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 4, 6, 4, 0, -6 },
  { 202, 4, 5, 3, 0, -5 },
  { 205, 5, 6, 4, 0, -6 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 5, 8, 3, -1, -6 },
  { 217, 4, 7, 4, 0, -5 },
  { 221, 4, 6, 4, 0, -6 },
  { 224, 3, 6, 2, 0, -6 },
  { 227, 4, 8, 2, -1, -6 },
  { 231, 5, 6, 4, 0, -6 },
  { 235, 3, 6, 2, 0, -6 },
  { 238, 6, 5, 6, 0, -5 },
  { 242, 4, 5, 4, 0, -5 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 4, 7, 4, 0, -5 },
  { 252, 4, 7, 4, 0, -5 },
  { 256, 3, 5, 3, 0, -5 },
  { 258, 3, 5, 3, 0, -5 },
  { 260, 3, 5, 3, 0, -5 },
  { 262, 4, 4, 4, 0, -4 },
  { 264, 4, 4, 4, 0, -4 },
  { 266, 6, 4, 6, 0, -4 },
  { 269, 4, 4, 4, 0, -4 },
  { 271, 4, 6, 4, 0, -4 },
  { 274, 4, 4, 3, 0, -4 },
  { 276, 3, 7, 3, 0, -6 },
  { 279, 1, 8, 4, 1, -6 },
  { 280, 3, 7, 3, 0, -6 },
  { 283, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_BlackItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC8PT7B_H_
