#ifndef _NOTOSANS_CONDENSED_BLACKITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xF9,
  0xC3, 0xC0, 0xFF, 0x9C, 0x08, 0x0F, 0xF9, 0xC0, 0x00, 0xFF, 0xBC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0xFF, 0x84, 0x01, 0xEF,
  0xF8, 0x60, 0x1E, 0xFF, 0x87, 0x81, 0xCF, 0xF0, 0x7E, 0x1D, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x7F, 0x80, 0x0F, 0xF1, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x1F, 0xCF, 0xF0, 0x7E, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xF3, 0xFD, 0xFE,
  0x7F, 0x9F, 0xFF, 0x7F, 0xFF, 0xCF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0x1F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x8F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF1, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC7, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF,
  0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0x81,
  0xFC, 0x00, 0xF0, 0xFE, 0x00, 0x7C, 0x7F, 0x00, 0x7F, 0xBF, 0x83, 0x3F,
  0xFF, 0x9F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0xFF,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0x0F, 0xF8, 0x07, 0x07,
  0xF0, 0x01, 0x81, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x0F, 0x87,
  0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x7F, 0xE0,
  0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF,
  0xFC, 0x0F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFC, 0x0F,
  0xFC, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFC, 0xFF,
  0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF,
  0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0xFB, 0xFE, 0x1F, 0xEF, 0xFC, 0x1F, 0x9F, 0xF8, 0x3E, 0x3F,
  0xF0, 0x38, 0x7F, 0xC0, 0x21, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xFC, 0x01, 0xF8, 0x3F, 0xF0,
  0x03, 0xC0, 0xFF, 0xC0, 0x0C, 0x03, 0xFF, 0x00, 0x10, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xF8, 0x3F, 0xF8, 0x07, 0x01, 0xFF, 0xC0, 0x20, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE2, 0x00, 0x07, 0xFE,
  0x18, 0x00, 0x7F, 0xF0, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xC0, 0x0F, 0xE7, 0xFC, 0x00, 0xFF,
  0x3F, 0xE0, 0x07, 0xF3, 0xFF, 0x00, 0x7F, 0x1F, 0xF8, 0x07, 0xF8, 0xFF,
  0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x20, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x80, 0x03, 0xFF, 0x0C, 0x00,
  0x7F, 0xF0, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x20, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF1, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x07,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0x03, 0xFF,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF,
  0x81, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x1F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0x0E, 0x03, 0xFF, 0x08, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x01, 0xF0, 0x0F, 0xC1, 0xFE, 0x07, 0xFF, 0xC7, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF3, 0xF8, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF,
  0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xFC, 0x3F, 0x3F, 0x87, 0xF8, 0xFE, 0x1F,
  0x9F, 0x87, 0xF8, 0x7E, 0x0F, 0xDF, 0xC3, 0xF8, 0x7F, 0x0F, 0xEF, 0xE3,
  0xF8, 0x3F, 0x87, 0xF7, 0xE1, 0xFC, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFB, 0xF8, 0xFE, 0x0F, 0xE0, 0xFD, 0xFC, 0x7F, 0x07, 0xF0, 0xFE,
  0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0x3F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x9F, 0x87, 0xF0, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0xFF,
  0x1F, 0xC7, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFB, 0xFF, 0xC0, 0xFC, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0x80, 0x70, 0x0F, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F,
  0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0x01, 0xC0,
  0x3F, 0xFC, 0x00, 0x80, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0x00, 0x7F, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x0C, 0x03, 0xFF, 0xC0,
  0x02, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xF1, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF1, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x00, 0xFF, 0xBF, 0xCF, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0x9F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x7F, 0x9F, 0xF0, 0x07, 0xFD, 0xFE, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFB, 0xFD, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xF9, 0xFF, 0x00,
  0x7F, 0xCF, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0x3F, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xFE, 0x3F, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0xF0, 0xFF, 0x80, 0x3F,
  0xE3, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x8F, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFF,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFB, 0xFE, 0x3F, 0xE0, 0x1F, 0xF7, 0xFC, 0xFF,
  0xC0, 0x3F, 0xCF, 0xF9, 0xFF, 0x00, 0xFF, 0x9F, 0xF3, 0xFE, 0x01, 0xFF,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0x7F, 0xDF,
  0xE0, 0x0F, 0xF8, 0xFF, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFF,
  0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC7,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0,
  0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFD, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F,
  0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF,
  0x9F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x1E, 0x01, 0xFF, 0x80, 0x20, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x20, 0x01, 0xFF, 0x81, 0x80, 0x0F, 0xFC, 0x0F,
  0x00, 0xFF, 0xE0, 0x7F, 0x9F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F,
  0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF9, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE7, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF0, 0xFF, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F,
  0xC7, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xE7, 0xFE, 0x01, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0x9F, 0xF0, 0x07, 0xFD,
  0xFE, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFD, 0xFC, 0xFF, 0x80, 0x1F, 0xF7,
  0xFB, 0xF9, 0xFF, 0x00, 0x3F, 0xDF, 0xE7, 0xF7, 0xFE, 0x00, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xF0, 0x01, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x1F,
  0xFC, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x82, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF0, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF3, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x07, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xF3, 0xFE, 0x07, 0xFF, 0xDF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xE0, 0x1F, 0xFC, 0xFF, 0x00, 0x7F, 0xC7, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x7E, 0x00, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFC,
  0x07, 0xF8, 0xFF, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFE, 0x1C, 0x0F, 0xFC, 0x02, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x80,
  0xFF, 0xC0, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFE, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFF,
  0x07, 0xFC, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x60, 0x7F, 0xE0, 0x3C, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x98, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0,
  0x01, 0xFC, 0xFF, 0xC0, 0x00, 0xC1, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x7F, 0xE0, 0x1F,
  0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0x80, 0x7F, 0x00, 0x7F, 0x8F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF3, 0xFF, 0x8F,
  0xFF, 0x01, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x3F, 0xFE, 0x7F, 0xE1, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x7F, 0xF8,
  0x07, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8,
  0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB,
  0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0x7F, 0xE7, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x9F,
  0xFC, 0x00, 0x7F, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF,
  0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0x60,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFE, 0x3F,
  0xC0, 0x7F, 0xFB, 0xFE, 0x07, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC,
  0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFC, 0xFF,
  0xC0, 0x01, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0x03, 0xFC, 0x7F, 0x03, 0xFC,
  0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFC, 0xFC, 0x1F, 0xF8, 0x18, 0x1F, 0xF8, 0x08, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x80, 0x1F,
  0xF8, 0xE0, 0x1F, 0xF8, 0xFC, 0x7F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFD, 0xFE, 0x01, 0xFF, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xDF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xDF, 0xF8, 0x7F,
  0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xFC, 0x3F, 0xF7, 0xFE, 0x3F, 0xFE, 0x1F,
  0xF3, 0xFE, 0x1F, 0xFF, 0x1F, 0xF9, 0xFF, 0x0F, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFC, 0x7F, 0xC7, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF,
  0xE3, 0xFE, 0x1F, 0xF3, 0xFF, 0xF3, 0xFF, 0x0F, 0xF9, 0xFF, 0xF9, 0xFF,
  0x07, 0xFD, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFE, 0xFE, 0xFF, 0x81, 0xFF,
  0x7F, 0x7F, 0x7F, 0xC0, 0xFF, 0xBF, 0xBF, 0xBF, 0xC0, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xFC, 0x00, 0x17,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE8, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Condensed_BlackItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 42, 16, 0, -41 },
  { 96, 24, 15, 26, 5, -41 },
  { 141, 34, 41, 32, 0, -41 },
  { 316, 28, 46, 29, 1, -43 },
  { 477, 43, 42, 47, 3, -41 },
  { 703, 36, 42, 36, 0, -41 },
  { 892, 12, 15, 14, 5, -41 },
  { 915, 21, 51, 18, 1, -42 },
  { 1049, 21, 51, 18, -4, -42 },
  { 1183, 25, 27, 27, 4, -44 },
  { 1268, 25, 28, 30, 3, -34 },
  { 1356, 14, 16, 16, -3, -8 },
  { 1384, 16, 9, 18, 1, -20 },
  { 1402, 11, 11, 16, 0, -10 },
  { 1418, 32, 42, 24, -3, -41 },
  { 1586, 27, 42, 29, 2, -41 },
  { 1728, 23, 41, 29, 5, -41 },
  { 1846, 30, 41, 29, -2, -41 },
  { 2000, 29, 42, 29, 0, -41 },
  { 2153, 29, 41, 29, 0, -41 },
  { 2302, 28, 42, 29, 1, -41 },
  { 2449, 28, 42, 29, 2, -41 },
  { 2596, 31, 41, 29, 1, -41 },
  { 2755, 28, 42, 29, 1, -41 },
  { 2902, 28, 42, 29, 1, -41 },
  { 3049, 16, 33, 16, 0, -32 },
  { 3115, 19, 40, 16, -3, -32 },
  { 3210, 26, 29, 30, 2, -35 },
  { 3305, 25, 20, 30, 3, -30 },
  { 3368, 25, 29, 30, 3, -35 },
  { 3459, 24, 42, 23, 2, -41 },
  { 3585, 41, 46, 43, 2, -41 },
  { 3821, 32, 41, 33, -3, -41 },
  { 3985, 32, 41, 31, 0, -41 },
  { 4149, 31, 42, 30, 2, -41 },
  { 4312, 33, 41, 33, 0, -41 },
  { 4482, 29, 41, 26, 0, -41 },
  { 4631, 29, 41, 26, 0, -41 },
  { 4780, 33, 42, 34, 2, -41 },
  { 4954, 36, 41, 35, 0, -41 },
  { 5139, 28, 41, 22, -2, -41 },
  { 5283, 28, 54, 17, -9, -41 },
  { 5472, 37, 41, 32, 0, -41 },
  { 5662, 22, 41, 25, 0, -41 },
  { 5775, 47, 41, 45, 0, -41 },
  { 6016, 39, 41, 38, 0, -41 },
  { 6216, 33, 42, 36, 2, -41 },
  { 6390, 31, 41, 30, 0, -41 },
  { 6549, 33, 51, 36, 2, -41 },
  { 6760, 31, 41, 31, 0, -41 },
  { 6919, 29, 42, 27, 0, -41 },
  { 7072, 27, 41, 27, 4, -41 },
  { 7211, 34, 42, 34, 2, -41 },
  { 7390, 31, 41, 31, 5, -41 },
  { 7549, 47, 41, 46, 4, -41 },
  { 7790, 39, 41, 31, -3, -41 },
  { 7990, 30, 41, 30, 5, -41 },
  { 8144, 32, 41, 27, -2, -41 },
  { 8308, 24, 52, 18, -2, -42 },
  { 8464, 14, 42, 24, 6, -41 },
  { 8538, 24, 52, 18, -4, -42 },
  { 8694, 29, 27, 28, -1, -41 },
  { 8792, 24, 7, 23, -5, 4 },
  { 8813, 13, 9, 19, 8, -44 },
  { 8828, 29, 33, 30, 1, -32 },
  { 8948, 29, 44, 30, 0, -43 },
  { 9108, 25, 33, 25, 1, -32 },
  { 9212, 32, 44, 30, 1, -43 },
  { 9388, 27, 33, 28, 1, -32 },
  { 9500, 32, 58, 19, -6, -44 },
  { 9732, 31, 46, 30, -1, -32 },
  { 9911, 29, 43, 30, 0, -43 },
  { 10067, 18, 44, 16, 0, -44 },
  { 10166, 25, 58, 16, -7, -44 },
  { 10348, 33, 43, 30, 0, -43 },
  { 10526, 19, 43, 16, 0, -43 },
  { 10629, 43, 32, 45, 0, -32 },
  { 10801, 29, 32, 30, 0, -32 },
  { 10917, 27, 33, 29, 1, -32 },
  { 11029, 32, 46, 30, -3, -32 },
  { 11213, 29, 46, 30, 1, -32 },
  { 11380, 24, 32, 21, 0, -32 },
  { 11476, 24, 33, 24, 0, -32 },
  { 11575, 21, 39, 21, 2, -38 },
  { 11678, 29, 33, 30, 2, -32 },
  { 11798, 28, 32, 28, 3, -32 },
  { 11910, 41, 32, 41, 3, -32 },
  { 12074, 34, 32, 28, -3, -32 },
  { 12210, 34, 46, 28, -3, -32 },
  { 12406, 28, 32, 24, -2, -32 },
  { 12518, 24, 50, 20, 0, -41 },
  { 12668, 8, 57, 25, 9, -44 },
  { 12725, 23, 50, 20, -3, -41 },
  { 12869, 26, 11, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_BlackItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC57PT7B_H_
