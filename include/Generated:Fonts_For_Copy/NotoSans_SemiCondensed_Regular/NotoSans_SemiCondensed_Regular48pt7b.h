#ifndef _NOTOSANS_SEMICONDENSED_REGULAR48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x31, 0xFF,
  0xFF, 0xFD, 0xE1, 0x00, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xEE, 0x0F, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x03, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x70, 0x3C, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x0E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0,
  0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xEE, 0x7C, 0xF8,
  0xE0, 0x4F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x0E, 0x00, 0xF8, 0xE0, 0x07, 0xEE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0E, 0xFC, 0x00, 0xE3,
  0xE0, 0x0E, 0x1E, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x0E,
  0x1E, 0x80, 0xE3, 0xEF, 0x0E, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x07, 0x9E, 0x00, 0x70, 0x07, 0x87, 0x00,
  0x78, 0x03, 0x83, 0xC0, 0x38, 0x01, 0xC1, 0xE0, 0x3C, 0x01, 0xE0, 0x70,
  0x1C, 0x00, 0xF0, 0x38, 0x1E, 0x00, 0x78, 0x1C, 0x0E, 0x00, 0x3C, 0x0E,
  0x0F, 0x00, 0x1E, 0x07, 0x07, 0x00, 0x0F, 0x03, 0x87, 0x80, 0x07, 0x81,
  0xC3, 0x80, 0x03, 0xC0, 0xE3, 0xC3, 0xE0, 0xE0, 0xF1, 0xC7, 0xF8, 0x70,
  0x79, 0xE7, 0xFE, 0x3C, 0x38, 0xE3, 0xC7, 0x0F, 0x7C, 0xF3, 0xC3, 0xC7,
  0xFC, 0x71, 0xE0, 0xE1, 0xFC, 0x78, 0xE0, 0x70, 0x3C, 0x38, 0x70, 0x3C,
  0x00, 0x3C, 0x38, 0x1E, 0x00, 0x1E, 0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x07,
  0x80, 0x0F, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xC0,
  0xF0, 0x03, 0x80, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x38, 0x01, 0xC0, 0x3C,
  0x1C, 0x01, 0xE0, 0x0E, 0x1E, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0xF0, 0x01,
  0xFF, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x78, 0x3E, 0x7C, 0x07, 0xC3, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F,
  0xC1, 0xE1, 0xE0, 0x3E, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0xF8, 0x03, 0xE7,
  0x87, 0x80, 0x0F, 0xF8, 0x3C, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x07, 0xE0, 0x3C, 0x00, 0x7F, 0x81, 0xF0, 0x07, 0xFE, 0x0F, 0xE1,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xC0, 0xFF, 0xFC, 0x1F, 0x01, 0xFF, 0x80,
  0x7E, 0xFF, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE0, 0x03, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0xF8, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x08, 0x0E, 0x02, 0xF8, 0xE1, 0xEF, 0xFE,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xBC, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x80,
  0xE0, 0x70, 0x06, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9E,
  0x3C, 0x78, 0xE3, 0xC7, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31,
  0xEF, 0xFF, 0xFD, 0xE1, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xF0, 0x7C, 0x1F, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x03, 0xF1,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xEF, 0xFC, 0xFF, 0x8F, 0x60, 0xF2, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xC0,
  0x7C, 0x18, 0x01, 0xF0, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7C, 0x07, 0xC7, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x03, 0xEF, 0x80, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3D, 0x00, 0x1F, 0xBC, 0x07, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x80, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x08, 0x01, 0xE3, 0xFC, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF, 0xE3, 0xF8,
  0x1F, 0x3F, 0x80, 0x7D, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7D,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0x78, 0x03, 0xC3,
  0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x7E, 0x3E, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x3F, 0x83, 0xE0, 0x7E, 0x3E,
  0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x79, 0xF0,
  0x07, 0xCF, 0xC0, 0x7C, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xE0,
  0x7C, 0x3E, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x8F,
  0xC3, 0xFC, 0x3F, 0xFD, 0xE0, 0xFF, 0xCF, 0x03, 0xFC, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x04, 0x07, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31,
  0xFF, 0xFF, 0xFD, 0xE1, 0x00, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7,
  0xCF, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x1E, 0x38, 0x70, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF2, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x01, 0xFE, 0x07, 0x9E, 0x03, 0xFF, 0xC1,
  0xCF, 0x03, 0xFF, 0xE0, 0xF7, 0x03, 0xE0, 0xF0, 0x7F, 0x81, 0xE0, 0x78,
  0x1F, 0xC1, 0xE0, 0x3C, 0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0xE0, 0x70, 0x0F,
  0x03, 0xF0, 0x78, 0x07, 0x01, 0xF8, 0x3C, 0x03, 0x80, 0xFC, 0x1E, 0x01,
  0xC0, 0x7E, 0x0F, 0x00, 0xE0, 0x3F, 0x07, 0x80, 0xF0, 0x3F, 0x81, 0xC0,
  0x78, 0x1D, 0xC0, 0xE0, 0x3C, 0x0E, 0xE0, 0x78, 0x3F, 0x0F, 0x78, 0x1F,
  0x3B, 0xCF, 0x3C, 0x0F, 0xFC, 0xFF, 0x1E, 0x03, 0xFC, 0x3F, 0x07, 0x80,
  0x78, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x01,
  0xF8, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3C, 0x07, 0xFC, 0xF0, 0x01,
  0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB,
  0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0,
  0x0F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x03, 0xC3,
  0xF0, 0x01, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x01, 0x07, 0xFC, 0x3E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1E,
  0x07, 0xFE, 0x0F, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xE3, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0x87, 0x80, 0x1F, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0x03, 0xF0, 0x00, 0x41, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xFC, 0x00, 0x7C, 0x3F, 0xE0, 0x7F, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0x9F, 0xE3,
  0xF8, 0x00, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xF0, 0x00,
  0xF7, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFB, 0xE0, 0x07, 0xE3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1E, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0x80, 0x00, 0xEF, 0xF7, 0x80, 0x01,
  0xEF, 0xF7, 0x80, 0x01, 0xEF, 0xF3, 0xC0, 0x03, 0xCF, 0xF3, 0xC0, 0x03,
  0xCF, 0xF3, 0xC0, 0x03, 0xCF, 0xF1, 0xE0, 0x07, 0x8F, 0xF1, 0xE0, 0x07,
  0x8F, 0xF1, 0xE0, 0x07, 0x8F, 0xF0, 0xF0, 0x0F, 0x0F, 0xF0, 0xF0, 0x0F,
  0x0F, 0xF0, 0x70, 0x0E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E,
  0x0F, 0xF0, 0x38, 0x1C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C,
  0x0F, 0xF0, 0x1E, 0x38, 0x0F, 0xF0, 0x1E, 0x78, 0x0F, 0xF0, 0x1E, 0x78,
  0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0,
  0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xEF, 0x80, 0x0F, 0xF3, 0xC0,
  0x07, 0xF9, 0xF0, 0x03, 0xFC, 0x78, 0x01, 0xFE, 0x3E, 0x00, 0xFF, 0x0F,
  0x00, 0x7F, 0x87, 0xC0, 0x3F, 0xC1, 0xF0, 0x1F, 0xE0, 0xF8, 0x0F, 0xF0,
  0x3E, 0x07, 0xF8, 0x0F, 0x03, 0xFC, 0x07, 0xC1, 0xFE, 0x01, 0xE0, 0xFF,
  0x00, 0xF8, 0x7F, 0x80, 0x3E, 0x3F, 0xC0, 0x1F, 0x1F, 0xE0, 0x07, 0xCF,
  0xF0, 0x01, 0xE7, 0xF8, 0x00, 0xFB, 0xFC, 0x00, 0x3D, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0x1F, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x07, 0xFC, 0xF0, 0x07, 0xEF,
  0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F,
  0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3C, 0x1F, 0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E,
  0x3C, 0x01, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0x03, 0xC7, 0xC0, 0x04, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0xC0, 0x07, 0xEF, 0xC1,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0xC0,
  0x1F, 0x8F, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x1F,
  0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x00,
  0x77, 0x00, 0x1E, 0x3E, 0x00, 0xF7, 0x80, 0x3E, 0x1E, 0x00, 0xF7, 0x80,
  0x3C, 0x1E, 0x00, 0xF7, 0x80, 0x3C, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0x1F,
  0x01, 0xE3, 0xC0, 0x7C, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE3,
  0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xE0, 0xF8,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0x87,
  0x80, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x01, 0xEE, 0x00,
  0x7B, 0xC0, 0x01, 0xEE, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x3B, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0,
  0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07,
  0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87,
  0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x1C, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x78,
  0x70, 0x00, 0x71, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x87, 0xE0,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x1F, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xE3, 0xDF,
  0x80, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xDF, 0x07, 0xFB, 0xFF, 0xEF, 0x3F,
  0xF9, 0xE3, 0xFE, 0x1C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF,
  0x8F, 0xF8, 0xFC, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0xC0, 0x3E,
  0xFE, 0x07, 0xCE, 0xFF, 0xFC, 0xE7, 0xFF, 0x8E, 0x1F, 0xE0, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xE3, 0xF0, 0x09, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x0E, 0x3F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xFE, 0x1E, 0x0F,
  0xFC, 0xF0, 0xFF, 0xF7, 0x8F, 0xC3, 0xFC, 0xF8, 0x07, 0xE7, 0x80, 0x3F,
  0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00,
  0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x3F, 0x3F, 0x03, 0xF8, 0xFF, 0xFB, 0xC3,
  0xFF, 0x8E, 0x07, 0xF8, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xF8, 0x7C, 0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x02,
  0x1F, 0x80, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x78,
  0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xF8, 0x38, 0x3F, 0xF1, 0xC3, 0xFF, 0xDE, 0x3F, 0x1F, 0xF3, 0xE0,
  0x3F, 0x9E, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x9F, 0x00, 0xFC, 0x7C, 0x0F,
  0xE3, 0xFF, 0xEF, 0x0F, 0xFE, 0x78, 0x1F, 0xE3, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x20, 0x01, 0xF1, 0xE0, 0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC7, 0xF8, 0x79, 0xFF, 0xCF, 0x7F, 0xFD, 0xFF,
  0x3F, 0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF0, 0x7F, 0xFE, 0xF7, 0x00, 0x00, 0x03,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0xFB, 0xFE, 0xFF,
  0x3F, 0x83, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x3E,
  0x3C, 0x0F, 0x87, 0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0x79, 0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFD, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF8, 0xF0, 0x0F, 0x9E, 0x00, 0xF3,
  0xC0, 0x1F, 0x78, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFC, 0x03, 0xF8, 0x71, 0xFF, 0x87, 0xFE, 0x39, 0xFF, 0xE7, 0xFF, 0x9F,
  0xE3, 0xF7, 0xCF, 0xEF, 0xC0, 0x7F, 0x01, 0xF7, 0xC0, 0x1F, 0x80, 0x7F,
  0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x07,
  0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x3F, 0xC0, 0x0F, 0x00,
  0x1F, 0xE0, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x01, 0xE0,
  0x03, 0xFC, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x3C,
  0x00, 0x7F, 0x80, 0x1E, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x07,
  0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0xE1,
  0xFE, 0x1C, 0x7F, 0xF3, 0x9F, 0xFF, 0x7F, 0x8F, 0xEF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3C, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8,
  0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF8,
  0x07, 0xC1, 0xF8, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xE1, 0xFE, 0x0E, 0x3F, 0xF0, 0xE7, 0xFF, 0x8F, 0xF0, 0xFC, 0xFC,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0xC0, 0x3E, 0xFE, 0x07, 0xCF, 0xFF,
  0xFC, 0xF7, 0xFF, 0x8F, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFC, 0x38, 0x3F, 0xF1, 0xC3, 0xFF, 0xDE, 0x3F, 0x1F, 0xF3, 0xE0,
  0x1F, 0x9E, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x1F,
  0xE3, 0xFF, 0xEF, 0x0F, 0xFE, 0x78, 0x1F, 0xE3, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0xE0, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF, 0xFE, 0xE0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x83, 0xCF, 0x80, 0x27, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF4, 0x00, 0x7B, 0xC0, 0x7D,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x84, 0x3F, 0xF0,
  0x7F, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x0F,
  0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0x70, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xDE, 0x00, 0x7C, 0x00, 0xF7, 0x80, 0x3F, 0x00, 0x79, 0xE0, 0x0F, 0xC0,
  0x1E, 0x3C, 0x03, 0xF8, 0x07, 0x8F, 0x00, 0xFE, 0x01, 0xE3, 0xC0, 0x7B,
  0x80, 0xF0, 0xF0, 0x1E, 0xF0, 0x3C, 0x1E, 0x07, 0x3C, 0x0F, 0x07, 0x83,
  0xCF, 0x03, 0xC1, 0xE0, 0xF1, 0xC1, 0xE0, 0x78, 0x3C, 0x78, 0x78, 0x0F,
  0x0E, 0x1E, 0x1E, 0x03, 0xC7, 0x87, 0x87, 0x80, 0xF1, 0xE0, 0xE3, 0xC0,
  0x3C, 0x78, 0x3C, 0xF0, 0x07, 0x9C, 0x0F, 0x3C, 0x01, 0xEF, 0x03, 0xCF,
  0x00, 0x7B, 0xC0, 0x73, 0x80, 0x1E, 0xE0, 0x1F, 0xE0, 0x03, 0xB8, 0x07,
  0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x78, 0x7C, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x83, 0xC0, 0x3C, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x3C, 0xF8, 0x03, 0xE3,
  0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F,
  0x80, 0x3C, 0x78, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x3D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x3F, 0x80, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x0F, 0xF0, 0x3F, 0x80, 0xF8, 0x02,
  0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xE7, 0xFF,
  0xFC, 0x07, 0xFF, 0x40, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 35, 12, 3, -34 },
  { 28, 13, 12, 19, 3, -34 },
  { 48, 26, 34, 28, 1, -34 },
  { 159, 20, 39, 25, 3, -36 },
  { 257, 33, 35, 37, 2, -35 },
  { 402, 29, 35, 31, 2, -35 },
  { 529, 5, 12, 11, 3, -34 },
  { 537, 11, 42, 14, 2, -34 },
  { 595, 11, 42, 14, 1, -34 },
  { 653, 20, 19, 24, 2, -36 },
  { 701, 21, 23, 25, 2, -28 },
  { 762, 7, 12, 12, 2, -6 },
  { 773, 11, 4, 15, 2, -15 },
  { 779, 6, 7, 12, 3, -6 },
  { 785, 16, 34, 18, 1, -34 },
  { 853, 21, 35, 25, 2, -35 },
  { 945, 12, 34, 25, 4, -34 },
  { 996, 21, 35, 25, 2, -35 },
  { 1088, 20, 35, 25, 2, -35 },
  { 1176, 23, 35, 25, 1, -35 },
  { 1277, 19, 34, 25, 3, -34 },
  { 1358, 21, 35, 25, 2, -35 },
  { 1450, 21, 34, 25, 2, -34 },
  { 1540, 21, 35, 25, 2, -35 },
  { 1632, 21, 35, 25, 2, -35 },
  { 1724, 6, 27, 12, 3, -26 },
  { 1745, 7, 32, 12, 2, -26 },
  { 1773, 21, 23, 25, 2, -29 },
  { 1834, 21, 13, 25, 2, -23 },
  { 1869, 21, 23, 25, 2, -29 },
  { 1930, 17, 36, 19, 1, -35 },
  { 2007, 33, 38, 39, 3, -34 },
  { 2164, 27, 34, 27, 0, -34 },
  { 2279, 22, 34, 28, 4, -34 },
  { 2373, 23, 35, 27, 3, -35 },
  { 2474, 25, 34, 31, 4, -34 },
  { 2581, 17, 34, 24, 4, -34 },
  { 2654, 17, 34, 22, 4, -34 },
  { 2727, 26, 35, 32, 3, -35 },
  { 2841, 24, 34, 32, 4, -34 },
  { 2943, 11, 34, 15, 2, -34 },
  { 2990, 11, 43, 12, -3, -34 },
  { 3050, 23, 34, 27, 4, -34 },
  { 3148, 17, 34, 22, 4, -34 },
  { 3221, 32, 34, 40, 4, -34 },
  { 3357, 25, 34, 33, 4, -34 },
  { 3464, 28, 35, 33, 3, -35 },
  { 3587, 20, 34, 26, 4, -34 },
  { 3672, 28, 43, 33, 3, -35 },
  { 3823, 22, 34, 27, 4, -34 },
  { 3917, 20, 35, 24, 2, -35 },
  { 4005, 23, 34, 24, 0, -34 },
  { 4103, 23, 34, 31, 4, -34 },
  { 4201, 26, 34, 26, 0, -34 },
  { 4312, 40, 34, 41, 0, -34 },
  { 4482, 25, 34, 25, 0, -34 },
  { 4589, 24, 34, 24, 0, -34 },
  { 4691, 20, 34, 24, 2, -34 },
  { 4776, 10, 42, 16, 4, -34 },
  { 4829, 16, 34, 18, 1, -34 },
  { 4897, 11, 42, 16, 1, -34 },
  { 4955, 23, 20, 25, 1, -34 },
  { 5013, 21, 3, 21, 0, 4 },
  { 5021, 9, 8, 13, 2, -37 },
  { 5030, 19, 26, 24, 2, -26 },
  { 5092, 20, 36, 27, 4, -36 },
  { 5182, 17, 26, 21, 2, -26 },
  { 5238, 21, 36, 27, 2, -36 },
  { 5333, 20, 26, 24, 2, -26 },
  { 5398, 16, 37, 15, 1, -37 },
  { 5472, 21, 38, 27, 2, -26 },
  { 5572, 19, 36, 27, 4, -36 },
  { 5658, 5, 35, 12, 3, -35 },
  { 5680, 10, 47, 12, -2, -35 },
  { 5739, 19, 36, 23, 4, -36 },
  { 5825, 4, 36, 12, 4, -36 },
  { 5843, 33, 26, 40, 4, -26 },
  { 5951, 19, 26, 27, 4, -26 },
  { 6013, 22, 26, 26, 2, -26 },
  { 6085, 20, 38, 27, 4, -26 },
  { 6180, 21, 38, 27, 2, -26 },
  { 6280, 13, 26, 18, 4, -26 },
  { 6323, 17, 26, 21, 2, -26 },
  { 6379, 14, 32, 16, 1, -32 },
  { 6435, 20, 26, 27, 3, -26 },
  { 6500, 22, 26, 22, 0, -26 },
  { 6572, 34, 26, 35, 0, -26 },
  { 6683, 21, 26, 23, 1, -26 },
  { 6752, 22, 38, 22, 0, -26 },
  { 6857, 16, 26, 20, 2, -26 },
  { 6909, 14, 42, 18, 2, -34 },
  { 6983, 4, 49, 24, 10, -37 },
  { 7008, 14, 42, 18, 2, -34 },
  { 7082, 21, 6, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Regular48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR48PT7B_H_
