#ifndef _NOTOSANS_SEMICONDENSED_REGULAR24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xE6, 0xCD, 0x9B, 0x34, 0x68, 0xC0,
  0x0C, 0x60, 0xC4, 0x08, 0xC0, 0x8C, 0x18, 0xCF, 0xFF, 0x18, 0x81, 0x88,
  0x11, 0x81, 0x18, 0xFF, 0xFF, 0xFF, 0x31, 0x03, 0x10, 0x23, 0x02, 0x30,
  0x63, 0x00, 0x04, 0x01, 0x03, 0xF9, 0xFF, 0xE4, 0x31, 0x0C, 0x41, 0x90,
  0x7C, 0x07, 0xC0, 0x7C, 0x13, 0x04, 0xC1, 0x3C, 0x5F, 0xFE, 0x3E, 0x01,
  0x00, 0x40, 0x78, 0x18, 0x4C, 0x10, 0xC4, 0x30, 0xC6, 0x20, 0xC6, 0x60,
  0xC6, 0x60, 0xC6, 0xC4, 0xC4, 0xDE, 0x6D, 0xB3, 0x79, 0xB3, 0x03, 0x31,
  0x03, 0x31, 0x06, 0x31, 0x06, 0x31, 0x0C, 0x33, 0x0C, 0x33, 0x18, 0x1E,
  0x1F, 0x00, 0xEE, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xDC, 0x6E, 0x39, 0xB0, 0x6E, 0xC0, 0xF3, 0x01,
  0x8E, 0x0F, 0x1F, 0xEE, 0x3F, 0x1C, 0xED, 0xB4, 0x80, 0x19, 0x8C, 0xC6,
  0x33, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x8C, 0x63, 0x8C, 0x31, 0x80, 0xC3,
  0x18, 0x63, 0x18, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x98, 0xCC,
  0x00, 0x0C, 0x03, 0x00, 0xC3, 0xB7, 0xFF, 0xC7, 0x01, 0xE0, 0xCC, 0x73,
  0x84, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x6D, 0xBD, 0x80, 0xFF, 0xC0, 0xFC, 0x03, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0xE0, 0x00, 0x3F, 0x0E, 0xE6, 0x19, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x36,
  0x18, 0xFE, 0x1F, 0x00, 0x1C, 0xF7, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x3D, 0xE4, 0x18, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0x3D, 0xE4, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x38,
  0xFC, 0x3F, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x1F, 0xFE, 0xFF,
  0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x08, 0xC1,
  0x8C, 0x30, 0xC3, 0x0C, 0x60, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x06, 0xC1,
  0xFC, 0x43, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x1F, 0xFE, 0x7F,
  0x00, 0x0F, 0x8F, 0x23, 0x01, 0x80, 0x60, 0x18, 0x0C, 0xF3, 0x7E, 0xF1,
  0xF8, 0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x36, 0x0C, 0xFE, 0x1F, 0x00, 0xFF,
  0xFF, 0xF0, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x3F, 0x1C, 0xE6,
  0x0D, 0x83, 0x60, 0xD8, 0x73, 0x38, 0x7C, 0x1F, 0x1C, 0xE6, 0x1F, 0x03,
  0xC0, 0xF0, 0x3E, 0x0D, 0xEE, 0x3F, 0x00, 0x3F, 0x1F, 0xE6, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x61, 0xCF, 0xB1, 0x8C, 0x03, 0x00, 0xC0,
  0x60, 0x39, 0xFC, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x6D, 0x80, 0x00,
  0x01, 0xB7, 0xB6, 0x00, 0x40, 0x70, 0x78, 0x70, 0x70, 0x30, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x3C, 0x3C,
  0x3C, 0x38, 0x08, 0x00, 0xFE, 0x3B, 0x80, 0xE0, 0x30, 0x18, 0x1C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x70, 0x18, 0x00,
  0x03, 0xF8, 0x07, 0x8E, 0x06, 0x01, 0x86, 0x00, 0x62, 0x04, 0x13, 0x1F,
  0x8D, 0x9C, 0x46, 0x8C, 0x63, 0xC6, 0x31, 0xE2, 0x18, 0xF1, 0x0C, 0x78,
  0xC6, 0x3C, 0x67, 0xB2, 0x1E, 0x71, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0xBC, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x01, 0x60,
  0x0D, 0x80, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x18, 0x60, 0x61, 0x83, 0xFE,
  0x0F, 0xFC, 0x70, 0x31, 0x80, 0xC6, 0x01, 0xB8, 0x06, 0xC0, 0x1C, 0xFF,
  0x1F, 0xFB, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x77, 0xFC, 0xFF, 0x98,
  0x3B, 0x03, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x37, 0xFE, 0xFF, 0x00, 0x0F,
  0xF1, 0xFE, 0x38, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC1, 0xCF,
  0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFE,
  0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x7F, 0xB0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xCE, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0x07, 0xD8,
  0x06, 0xC0, 0x36, 0x01, 0xB8, 0x0C, 0xE0, 0x63, 0xFF, 0x0F, 0xF8, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x1E, 0xFC, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xE7, 0xF9, 0x00, 0xC0, 0xF8, 0x3B, 0x06, 0x61,
  0x8C, 0x71, 0x9C, 0x33, 0x06, 0xC0, 0xFC, 0x1D, 0xC3, 0x18, 0x63, 0x8C,
  0x39, 0x83, 0x30, 0x76, 0x06, 0xC0, 0x60, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xFF, 0xFF, 0x80, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xD8,
  0x1B, 0xD8, 0x1B, 0xD8, 0x1B, 0xCC, 0x33, 0xCC, 0x33, 0xC4, 0x23, 0xC6,
  0x63, 0xC6, 0x63, 0xC3, 0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0x83, 0xC1,
  0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xD8, 0x3D, 0xC3, 0xCC, 0x3C,
  0x63, 0xC6, 0x3C, 0x33, 0xC3, 0xBC, 0x19, 0xC1, 0xDC, 0x0D, 0xC0, 0x7C,
  0x07, 0xC0, 0x30, 0x0F, 0xE0, 0xFB, 0xC3, 0x03, 0x9C, 0x06, 0x60, 0x0D,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xD8, 0x03,
  0x60, 0x1D, 0xC0, 0x63, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0xFF, 0x3F, 0xEC,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0xCC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0xFB, 0xC3, 0x03,
  0x9C, 0x06, 0x60, 0x0D, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xD8, 0x03, 0x60, 0x1D, 0xC0, 0x63, 0x83, 0x87, 0xFC, 0x0F,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0xFF, 0x1F, 0xF3, 0x07,
  0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xFF, 0x1F, 0xC3, 0x1C, 0x61,
  0x8C, 0x39, 0x83, 0x30, 0x76, 0x06, 0xC0, 0xE0, 0x3F, 0xDF, 0xEE, 0x03,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x00,
  0xC0, 0x38, 0x1B, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x06, 0x60, 0x67, 0xFC, 0x1F, 0x80, 0xC0, 0x1B,
  0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x07, 0x18, 0x30, 0xC1, 0x87, 0x1C, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x60, 0x36, 0x07, 0x03, 0x60, 0xF0, 0x76, 0x0F, 0x06,
  0x60, 0xD0, 0x63, 0x0D, 0x86, 0x31, 0x98, 0xE3, 0x19, 0x8C, 0x31, 0x8C,
  0xC1, 0x98, 0xCC, 0x1B, 0x0C, 0xC1, 0xB0, 0xD8, 0x1B, 0x05, 0x80, 0xB0,
  0x78, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0xE0, 0x77, 0x06,
  0x30, 0xE1, 0x8C, 0x19, 0x80, 0xD8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0D, 0x81, 0x98, 0x18, 0xC3, 0x0C, 0x70, 0x66, 0x07, 0xE0, 0x30, 0xE0,
  0x36, 0x06, 0x60, 0x63, 0x0C, 0x30, 0xC1, 0x98, 0x19, 0x80, 0xF0, 0x0F,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C,
  0x01, 0xC0, 0x78, 0x0D, 0x83, 0x30, 0x63, 0x18, 0x63, 0x06, 0xC0, 0xD8,
  0x0C, 0xFF, 0xFF, 0xFC, 0xE3, 0x0E, 0x3F, 0x3F, 0xC0, 0x60, 0x30, 0x18,
  0x7D, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x7E, 0xD7, 0xC8, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0xFF, 0xB7, 0xC0, 0x1F, 0x9F, 0x9C, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07, 0xE1, 0xF0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3C, 0xCF, 0xDB, 0x07, 0x60, 0xFC,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x81, 0xD8, 0x3B, 0x07, 0x7F, 0x67, 0xCC,
  0x1F, 0x0F, 0xE6, 0x1D, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0x1D, 0x38, 0x30, 0x30, 0x7E, 0xFE,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E,
  0x67, 0xED, 0x87, 0xB0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0xEC,
  0x1D, 0x83, 0xBF, 0xB3, 0xE6, 0x00, 0xC0, 0x30, 0x06, 0x41, 0xCF, 0xF0,
  0x78, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x86,
  0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x30, 0xBC, 0x3F, 0xFF, 0xFF, 0xF0, 0x10, 0xC6, 0x00, 0x0C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xDC, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x0F, 0x0D, 0x8C, 0xCC, 0x6E, 0x3E, 0x1F, 0x0E, 0xC6,
  0x73, 0x19, 0x86, 0xC3, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDF,
  0x3E, 0xFF, 0xFF, 0xE1, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xDF, 0x3F, 0xEE, 0x1B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x1F, 0x07, 0xF1, 0x83, 0x30, 0x6E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x6C, 0x1D, 0x83, 0x1D, 0xC1, 0xF0,
  0xDF, 0x3F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x1F, 0xFE, 0xDF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x1E, 0x67, 0xED, 0x87, 0xB0, 0x7E, 0x0F, 0x81, 0xF0, 0x1E, 0x07, 0xC0,
  0xEC, 0x1D, 0x83, 0xBF, 0xB3, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xDF, 0xFB, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x00, 0x3F, 0x7F, 0xC0, 0xC0, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0x03, 0x83, 0xFF, 0xFE, 0x10, 0x60, 0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0F, 0x8F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFB, 0x7C, 0xC0, 0xC0,
  0x7C, 0x19, 0x83, 0x30, 0x67, 0x18, 0x63, 0x0C, 0x61, 0x98, 0x1B, 0x03,
  0x60, 0x68, 0x07, 0x00, 0xE0, 0xC1, 0xC1, 0xB0, 0xE0, 0xD8, 0x70, 0xCC,
  0x2C, 0x66, 0x36, 0x31, 0x9B, 0x18, 0xCC, 0xD8, 0x6C, 0x6C, 0x36, 0x36,
  0x0F, 0x1B, 0x07, 0x85, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x60, 0xEE, 0x18,
  0xC6, 0x0D, 0xC1, 0xB0, 0x1C, 0x03, 0x80, 0x78, 0x1B, 0x03, 0x30, 0xC6,
  0x38, 0x6E, 0x0E, 0xC0, 0x6C, 0x1D, 0x83, 0x30, 0x63, 0x1C, 0x63, 0x0C,
  0x60, 0xDC, 0x1B, 0x03, 0x60, 0x2C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x18, 0x1F, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0x06, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x0E, 0x3C, 0x60, 0xC1, 0x83,
  0x06, 0x1C, 0x31, 0xE3, 0x01, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x18, 0x3C, 0x38, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xC7, 0x8C, 0x00, 0x78, 0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 7, 6, 10, 1, -17 },
  { 12, 12, 17, 14, 1, -17 },
  { 38, 10, 19, 12, 1, -18 },
  { 62, 16, 17, 18, 1, -17 },
  { 96, 14, 17, 15, 1, -17 },
  { 126, 3, 6, 5, 1, -17 },
  { 129, 5, 21, 7, 1, -17 },
  { 143, 5, 21, 7, 1, -17 },
  { 157, 10, 10, 12, 1, -18 },
  { 170, 10, 11, 12, 1, -14 },
  { 184, 3, 6, 6, 1, -3 },
  { 187, 5, 2, 7, 1, -7 },
  { 189, 2, 3, 6, 2, -3 },
  { 190, 9, 17, 9, 0, -17 },
  { 210, 10, 17, 12, 1, -17 },
  { 232, 6, 17, 12, 2, -17 },
  { 245, 10, 17, 12, 1, -17 },
  { 267, 10, 17, 12, 1, -17 },
  { 289, 12, 17, 12, 0, -17 },
  { 315, 10, 17, 12, 1, -17 },
  { 337, 10, 17, 12, 1, -17 },
  { 359, 10, 17, 12, 1, -17 },
  { 381, 10, 17, 12, 1, -17 },
  { 403, 10, 17, 12, 1, -17 },
  { 425, 2, 13, 6, 2, -13 },
  { 429, 3, 16, 6, 1, -13 },
  { 435, 10, 11, 12, 1, -14 },
  { 449, 10, 7, 12, 1, -12 },
  { 458, 10, 11, 12, 1, -14 },
  { 472, 9, 17, 9, 0, -17 },
  { 492, 17, 19, 19, 1, -17 },
  { 533, 14, 17, 14, 0, -17 },
  { 563, 11, 17, 14, 2, -17 },
  { 587, 12, 17, 14, 1, -17 },
  { 613, 12, 17, 16, 2, -17 },
  { 639, 9, 17, 12, 2, -17 },
  { 659, 9, 17, 11, 2, -17 },
  { 679, 13, 17, 16, 1, -17 },
  { 707, 12, 17, 16, 2, -17 },
  { 733, 6, 17, 8, 1, -17 },
  { 746, 6, 22, 6, -2, -17 },
  { 763, 11, 17, 13, 2, -17 },
  { 787, 9, 17, 11, 2, -17 },
  { 807, 16, 17, 20, 2, -17 },
  { 841, 12, 17, 17, 2, -17 },
  { 867, 14, 17, 17, 1, -17 },
  { 897, 10, 17, 13, 2, -17 },
  { 919, 14, 21, 17, 1, -17 },
  { 956, 11, 17, 14, 2, -17 },
  { 980, 10, 17, 12, 1, -17 },
  { 1002, 12, 17, 12, 0, -17 },
  { 1028, 12, 17, 16, 2, -17 },
  { 1054, 13, 17, 13, 0, -17 },
  { 1082, 20, 17, 20, 0, -17 },
  { 1125, 12, 17, 12, 0, -17 },
  { 1151, 12, 17, 12, 0, -17 },
  { 1177, 10, 17, 12, 1, -17 },
  { 1199, 5, 21, 8, 2, -17 },
  { 1213, 9, 17, 9, 0, -17 },
  { 1233, 5, 21, 8, 1, -17 },
  { 1247, 11, 10, 13, 1, -17 },
  { 1261, 11, 2, 11, 0, 2 },
  { 1264, 5, 3, 7, 1, -18 },
  { 1266, 9, 13, 12, 1, -13 },
  { 1281, 10, 18, 13, 2, -18 },
  { 1304, 9, 13, 10, 1, -13 },
  { 1319, 11, 18, 13, 1, -18 },
  { 1344, 10, 13, 12, 1, -13 },
  { 1361, 8, 18, 7, 0, -18 },
  { 1379, 11, 19, 13, 1, -13 },
  { 1406, 10, 18, 13, 2, -18 },
  { 1429, 2, 18, 6, 2, -18 },
  { 1434, 5, 24, 6, -1, -18 },
  { 1449, 9, 18, 12, 2, -18 },
  { 1470, 2, 18, 6, 2, -18 },
  { 1475, 16, 13, 20, 2, -13 },
  { 1501, 10, 13, 13, 2, -13 },
  { 1518, 11, 13, 13, 1, -13 },
  { 1536, 10, 19, 13, 2, -13 },
  { 1560, 11, 19, 13, 1, -13 },
  { 1587, 7, 13, 9, 2, -13 },
  { 1599, 8, 13, 10, 1, -13 },
  { 1612, 7, 16, 8, 0, -16 },
  { 1626, 10, 13, 13, 2, -13 },
  { 1643, 11, 13, 11, 0, -13 },
  { 1661, 17, 13, 17, 0, -13 },
  { 1689, 11, 13, 11, 0, -13 },
  { 1707, 11, 19, 11, 0, -13 },
  { 1734, 8, 13, 10, 1, -13 },
  { 1747, 7, 21, 9, 1, -17 },
  { 1766, 2, 24, 12, 5, -18 },
  { 1772, 7, 21, 9, 1, -17 },
  { 1791, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Regular24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR24PT7B_H_
