#ifndef _NOTOSANS_SEMICONDENSED_REGULAR68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x38, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0xF3, 0xFC, 0x7F, 0x0F, 0x03,
  0x8F, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x07,
  0xFE, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF7, 0xFC, 0x00, 0x0F, 0x0F, 0xE0, 0x00,
  0xF0, 0x7E, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00,
  0x0F, 0x07, 0xE8, 0x00, 0xF0, 0xFE, 0xF0, 0x0F, 0x1F, 0xCF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0xC1, 0xF0, 0xFF, 0x81, 0xE0, 0x1F, 0x0F, 0x87,
  0xFF, 0x87, 0xC0, 0x7C, 0x3E, 0x3F, 0xFE, 0x1F, 0x01, 0xF1, 0xF0, 0xFD,
  0xFC, 0x3E, 0x0F, 0x87, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x3E, 0x1F, 0x03,
  0xE1, 0xFF, 0xF0, 0xF8, 0x78, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xE0, 0x1F,
  0x0F, 0xFC, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xE0, 0xF8, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xF7, 0xF0, 0x00, 0xFC, 0x1F, 0xE3,
  0xF8, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x01,
  0xF8, 0x7F, 0x00, 0x7F, 0x01, 0xF0, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0xFE,
  0x00, 0x3F, 0xC3, 0xF0, 0xFC, 0x00, 0x1F, 0xE7, 0xE0, 0xFC, 0x00, 0x0F,
  0xE7, 0xE0, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x2F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0xFE, 0x0F, 0x0F, 0xEF, 0xFE, 0xF7,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x08, 0x01, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x87, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF, 0xCF,
  0xE3, 0xFF, 0xF0, 0xFD, 0xF8, 0x3F, 0x3C, 0x0F, 0xC6, 0x03, 0xF1, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE1, 0xF8, 0x00, 0x7F, 0x07, 0x00, 0x01, 0xF8, 0x10,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0,
  0x3F, 0xE1, 0xF0, 0x00, 0x7F, 0x07, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x30, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x7F, 0x8F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC7, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0xC0, 0x00, 0x3F, 0xCF,
  0x00, 0x07, 0xF8, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00, 0xFC, 0x1F, 0xF8,
  0x07, 0xE3, 0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0xC1, 0xF3, 0xFF, 0xFF, 0x0F,
  0xBF, 0x8F, 0xFC, 0x7F, 0xE0, 0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFD, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x1F, 0xF9, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x1F, 0x01,
  0xFF, 0xF0, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x0F, 0x83, 0xF8, 0x7F, 0x0F, 0xE3,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7E, 0x01, 0xFE, 0x70, 0x00,
  0xFE, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x10, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0x7F, 0xFF,
  0xC0, 0x7C, 0x7C, 0x01, 0xFF, 0xFF, 0x80, 0x7D, 0xF0, 0x07, 0xE0, 0x1F,
  0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3E, 0x00, 0x3E, 0x00,
  0x7F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x3D,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF7,
  0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xCF, 0x80, 0x3F, 0x07, 0xBE, 0x1F, 0x9F,
  0x00, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x3E,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xFC,
  0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x7E, 0x07, 0xFC, 0x00, 0x0E, 0x07,
  0xF8, 0x00, 0x02, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x07,
  0xFF, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0x1F,
  0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0x80,
  0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x07,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0xE1,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xC0, 0x00,
  0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xDF, 0x80,
  0x00, 0x03, 0xEF, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0x7F, 0xF3, 0xE0, 0x00,
  0x00, 0xFB, 0xFF, 0x9F, 0x80, 0x00, 0x0F, 0x9F, 0xFC, 0x7C, 0x00, 0x00,
  0x7C, 0xFF, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xFF, 0x1F, 0x80, 0x00, 0x3E,
  0x3F, 0xFC, 0x7C, 0x00, 0x01, 0xF1, 0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0x8F,
  0xFF, 0x1F, 0x80, 0x00, 0xF8, 0x7F, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xFF,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xFE, 0x1F, 0x80, 0x03, 0xE0, 0xFF, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xFF, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0xFC, 0x1F,
  0x80, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xFF, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xFF, 0xC0, 0x7C, 0x01,
  0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xFF, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xFF, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x7F,
  0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0xFE,
  0x00, 0x7C, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x80,
  0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x7E,
  0x00, 0x00, 0xFF, 0xEF, 0xE0, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x03, 0xFF,
  0x9F, 0xC0, 0x00, 0x7F, 0xF1, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0x80, 0x01,
  0xFF, 0xC3, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x07, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x0F,
  0xE0, 0x7F, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC1, 0xFF, 0xE0,
  0x01, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0x87, 0xFF, 0x80, 0x03, 0xF8, 0xFF,
  0xF0, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x07, 0xF1, 0xFF, 0xC0, 0x00, 0x7E,
  0x3F, 0xF8, 0x00, 0x0F, 0xE7, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0xE0, 0x00,
  0x0F, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xBC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFC, 0x00, 0x7F, 0xCF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xFC, 0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xC7,
  0xF0, 0x00, 0x04, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0xC0, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xD0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE7, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xC7, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x81,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0xE0, 0x60,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0x3F, 0xC0, 0x07, 0xDF,
  0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFD, 0xF8, 0x01, 0xFF, 0x7F,
  0x81, 0xF7, 0xCF, 0xFF, 0xFD, 0xF3, 0xFF, 0xFE, 0x3C, 0x7F, 0xFF, 0x0F,
  0x07, 0xFF, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x03, 0xF1,
  0xFF, 0xFC, 0x0F, 0xDF, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x1F, 0x8F,
  0xFC, 0x00, 0xFE, 0x3F, 0xFE, 0x1F, 0xF0, 0xF9, 0xFF, 0xFF, 0xC3, 0xE3,
  0xFF, 0xFE, 0x0F, 0x87, 0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1E, 0x1F, 0xE0, 0x02, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x03, 0x0F, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x01, 0xFF, 0xF0, 0xFC,
  0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xEF, 0xC3, 0xFF, 0xFF, 0xBF, 0x1F,
  0xF0, 0x1F, 0xFC, 0x7F, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x7F, 0xCF, 0xC0,
  0x00, 0xFF, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0x7E, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xFE, 0xFC,
  0x1F, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0x87, 0xC0, 0x3F, 0xF8, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x81, 0xFE, 0x00, 0x1C, 0x0F,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0x81, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC1, 0xF0, 0x3F,
  0xFF, 0x87, 0xC1, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xFE, 0xFC, 0x3F, 0xC0,
  0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x03,
  0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F,
  0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x7F, 0xC7,
  0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0xCF, 0xC0, 0x7F, 0xFE, 0x3F, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x38,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0x7F, 0x07,
  0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x80, 0xFC, 0x3F, 0xFE, 0x0F, 0xC7, 0xFF,
  0xF0, 0xFC, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xEF,
  0xFC, 0x00, 0xFE, 0xFF, 0x80, 0x07, 0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x00, 0x78, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xCF,
  0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC3, 0xE3,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC7, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xDF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFC, 0x07, 0xF7, 0xC0, 0x7F, 0xBF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0x83, 0xFF, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F,
  0x8F, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0,
  0x0F, 0xEF, 0xF8, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0xFF, 0xF8, 0x0F, 0x87,
  0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0x8F, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFC,
  0xFF, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0xFE, 0x3F,
  0xF0, 0x07, 0xF8, 0xFF, 0xF8, 0x7F, 0xC3, 0xF7, 0xFF, 0xFE, 0x0F, 0xCF,
  0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0x80, 0xFC, 0x1F, 0xFC, 0x03, 0xF0, 0x0F,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFF, 0x87, 0xC1, 0xFF, 0xFF,
  0x1F, 0x0F, 0xFF, 0xFE, 0xFC, 0x3F, 0xC0, 0x7F, 0xF1, 0xFC, 0x00, 0xFF,
  0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFF, 0x0F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFE,
  0x3F, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xF8, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xE0, 0x0F, 0x3F, 0x80, 0x02, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x30, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7,
  0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0xFB, 0xF1, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xE1, 0xF0, 0x3F, 0xF8, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xE7,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x3E, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFB, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x81, 0xF8,
  0x07, 0xC7, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x07, 0xE0,
  0x3F, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x0F, 0xDF, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x09, 0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 50, 17, 5, -49 },
  { 51, 19, 18, 27, 4, -49 },
  { 94, 36, 49, 39, 2, -49 },
  { 315, 28, 56, 35, 4, -52 },
  { 511, 46, 50, 52, 3, -49 },
  { 799, 40, 50, 43, 3, -49 },
  { 1049, 7, 18, 15, 4, -49 },
  { 1065, 15, 60, 20, 3, -49 },
  { 1178, 15, 60, 20, 2, -49 },
  { 1291, 28, 28, 34, 3, -52 },
  { 1389, 29, 32, 35, 3, -40 },
  { 1505, 10, 17, 17, 3, -8 },
  { 1527, 16, 5, 21, 2, -21 },
  { 1537, 8, 9, 17, 5, -8 },
  { 1546, 24, 49, 25, 1, -49 },
  { 1693, 29, 50, 35, 3, -49 },
  { 1875, 18, 49, 35, 5, -49 },
  { 1986, 29, 49, 35, 3, -49 },
  { 2164, 29, 50, 35, 3, -49 },
  { 2346, 33, 49, 35, 1, -49 },
  { 2549, 28, 50, 35, 4, -49 },
  { 2724, 29, 50, 35, 3, -49 },
  { 2906, 29, 49, 35, 3, -49 },
  { 3084, 29, 50, 35, 3, -49 },
  { 3266, 29, 50, 35, 3, -49 },
  { 3448, 8, 38, 17, 5, -37 },
  { 3486, 11, 46, 17, 2, -37 },
  { 3550, 29, 33, 35, 3, -41 },
  { 3670, 29, 18, 35, 3, -33 },
  { 3736, 29, 33, 35, 3, -41 },
  { 3856, 24, 50, 27, 1, -49 },
  { 4006, 47, 55, 55, 4, -49 },
  { 4330, 39, 49, 39, 0, -49 },
  { 4569, 31, 49, 40, 6, -49 },
  { 4759, 32, 50, 38, 4, -49 },
  { 4959, 34, 49, 44, 6, -49 },
  { 5168, 24, 49, 34, 6, -49 },
  { 5315, 24, 49, 32, 6, -49 },
  { 5462, 36, 50, 45, 4, -49 },
  { 5687, 33, 49, 45, 6, -49 },
  { 5890, 16, 49, 22, 3, -49 },
  { 5988, 17, 62, 17, -5, -49 },
  { 6120, 32, 49, 38, 6, -49 },
  { 6316, 24, 49, 32, 6, -49 },
  { 6463, 45, 49, 57, 6, -49 },
  { 6739, 35, 49, 47, 6, -49 },
  { 6954, 40, 50, 47, 4, -49 },
  { 7204, 28, 49, 37, 6, -49 },
  { 7376, 40, 61, 47, 4, -49 },
  { 7681, 31, 49, 38, 6, -49 },
  { 7871, 28, 50, 34, 3, -49 },
  { 8046, 32, 49, 33, 1, -49 },
  { 8242, 33, 50, 44, 6, -49 },
  { 8449, 37, 49, 37, 0, -49 },
  { 8676, 56, 49, 58, 1, -49 },
  { 9019, 35, 49, 35, 0, -49 },
  { 9234, 34, 49, 34, 0, -49 },
  { 9443, 29, 49, 34, 2, -49 },
  { 9621, 15, 60, 22, 5, -49 },
  { 9734, 24, 49, 25, 1, -49 },
  { 9881, 15, 60, 22, 2, -49 },
  { 9994, 32, 29, 36, 2, -49 },
  { 10110, 30, 4, 30, 0, 6 },
  { 10125, 13, 11, 19, 3, -52 },
  { 10143, 26, 38, 35, 3, -37 },
  { 10267, 30, 53, 38, 5, -52 },
  { 10466, 24, 38, 29, 3, -37 },
  { 10580, 30, 53, 38, 3, -52 },
  { 10779, 29, 38, 35, 3, -37 },
  { 10917, 23, 52, 21, 1, -52 },
  { 11067, 30, 53, 38, 3, -37 },
  { 11266, 28, 52, 38, 5, -52 },
  { 11448, 7, 50, 16, 5, -50 },
  { 11492, 15, 66, 16, -3, -50 },
  { 11616, 27, 52, 33, 5, -52 },
  { 11792, 6, 52, 16, 5, -52 },
  { 11831, 47, 37, 57, 5, -37 },
  { 12049, 28, 37, 38, 5, -37 },
  { 12179, 31, 38, 37, 3, -37 },
  { 12327, 30, 53, 38, 5, -37 },
  { 12526, 30, 53, 38, 3, -37 },
  { 12725, 19, 37, 25, 5, -37 },
  { 12813, 23, 38, 29, 3, -37 },
  { 12923, 20, 46, 22, 1, -45 },
  { 13038, 28, 37, 38, 5, -36 },
  { 13168, 31, 36, 31, 0, -36 },
  { 13308, 47, 37, 49, 1, -37 },
  { 13526, 30, 36, 32, 1, -36 },
  { 13661, 31, 52, 31, 0, -36 },
  { 13863, 24, 36, 28, 2, -36 },
  { 13971, 21, 60, 25, 2, -49 },
  { 14129, 5, 68, 34, 14, -52 },
  { 14172, 21, 60, 25, 2, -49 },
  { 14330, 29, 8, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Regular68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR68PT7B_H_
