#ifndef _NOTOSANS_SEMICONDENSED_REGULAR56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0x00,
  0x00, 0x00, 0xCF, 0xFF, 0xFF, 0xFF, 0xDF, 0x30, 0xFC, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x0E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1, 0xF8,
  0xE0, 0x67, 0xC1, 0xC0, 0x0F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3E, 0x0E,
  0x00, 0x7C, 0x1C, 0x00, 0xF8, 0x38, 0x01, 0xF8, 0x70, 0x01, 0xF8, 0xE0,
  0x03, 0xFD, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xE3, 0xF0,
  0x01, 0xC3, 0xF0, 0x03, 0x83, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x80,
  0x1C, 0x0F, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x7F, 0x00, 0xE1, 0xF7, 0xC1,
  0xCF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x03,
  0xE0, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x3C,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0x1E, 0x1E, 0x06, 0x03, 0xC0, 0xF8, 0xF0, 0xFE, 0x0F, 0x03, 0xC3, 0xC7,
  0xFE, 0x3C, 0x0F, 0x1E, 0x3F, 0xF8, 0x78, 0x3C, 0x78, 0xF1, 0xF1, 0xF1,
  0xE3, 0xC7, 0x83, 0xC3, 0xFF, 0x8F, 0x1E, 0x07, 0x8F, 0xFC, 0x78, 0x78,
  0x1E, 0x0F, 0xE1, 0xE1, 0xE0, 0x78, 0x04, 0x0F, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x00, 0x0F, 0xFF,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xC0, 0xFD, 0xF8, 0x03, 0xE0, 0x7E, 0x3F, 0x00, 0xF8, 0x3F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0xFC, 0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC1, 0xF0, 0x03,
  0xF1, 0xF0, 0x7C, 0x00, 0x7E, 0xF8, 0x3F, 0x00, 0x1F, 0xBE, 0x0F, 0x80,
  0x03, 0xFF, 0x83, 0xE0, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x1F,
  0x00, 0x03, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0x87,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x20, 0x1E, 0x01, 0x78, 0x3C,
  0x3E, 0xFF, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xE7, 0x80,
  0x07, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0x00,
  0xF0, 0x3C, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xE0,
  0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xBC, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xEF, 0x9F, 0x9F,
  0xFE, 0x3E, 0xF8, 0x7C, 0xC0, 0xF8, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x3C, 0x00, 0xFC, 0x10, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x38, 0x00, 0x7C,
  0x20, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0xC0, 0x00, 0x7E, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x10, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFA, 0x00, 0x07, 0xE7, 0x80, 0x1F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F,
  0x80, 0xF8, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0x81,
  0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x81,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x7F,
  0xC0, 0xFC, 0x07, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC1, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x3F, 0x87, 0xF8,
  0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0xC0,
  0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xE0, 0x7E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xEF, 0xE0, 0x7F,
  0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0x3E, 0x07, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x13, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x04, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0x80, 0xFE, 0x40, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xFF, 0x01, 0xE3,
  0xC0, 0x1F, 0xFF, 0x03, 0xC7, 0x80, 0x7F, 0xFE, 0x03, 0x9F, 0x01, 0xF8,
  0x3C, 0x07, 0xBC, 0x07, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0xF0, 0x3E, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x03, 0xC0, 0x7F, 0x80, 0xF0,
  0x07, 0x80, 0xFF, 0x03, 0xE0, 0x0F, 0x01, 0xFE, 0x07, 0xC0, 0x1E, 0x03,
  0xFC, 0x0F, 0x00, 0x3C, 0x07, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0xF0, 0x3C,
  0x01, 0xF0, 0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0xC0, 0xF8, 0x07, 0xC0,
  0x77, 0x80, 0xF0, 0x0F, 0x81, 0xEF, 0x01, 0xE0, 0x3F, 0x03, 0xDE, 0x03,
  0xE0, 0xFF, 0x0F, 0x1E, 0x03, 0xFF, 0xCF, 0xFE, 0x3C, 0x03, 0xFF, 0x1F,
  0xF8, 0x78, 0x03, 0xFC, 0x1F, 0xE0, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x04, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x7F,
  0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8,
  0x01, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0xDF, 0x00,
  0x3F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0x83, 0xF8,
  0x00, 0x20, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1C, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0xF0, 0xF8, 0x00, 0x3F,
  0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF8, 0xF8,
  0x00, 0xFF, 0x0F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x03, 0xE0, 0x7F, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x1F, 0x07, 0xFC, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0x00,
  0x0F, 0xE7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xDE, 0x00, 0x00, 0x3F, 0xFE,
  0xF8, 0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x1E, 0xFF, 0x9E, 0x00, 0x00,
  0xF7, 0xFC, 0xF8, 0x00, 0x0F, 0xBF, 0xE7, 0xC0, 0x00, 0x79, 0xFF, 0x1E,
  0x00, 0x03, 0xCF, 0xF8, 0xF8, 0x00, 0x3E, 0x7F, 0xE7, 0xC0, 0x01, 0xE3,
  0xFF, 0x1E, 0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0xF8, 0xFF, 0xC7, 0xC0,
  0x07, 0x87, 0xFE, 0x1E, 0x00, 0x7C, 0x3F, 0xF0, 0xF8, 0x03, 0xC1, 0xFF,
  0x83, 0xC0, 0x1E, 0x0F, 0xFC, 0x1E, 0x01, 0xF0, 0x7F, 0xE0, 0xF8, 0x0F,
  0x03, 0xFF, 0x03, 0xC0, 0x78, 0x1F, 0xF8, 0x1E, 0x07, 0xC0, 0xFF, 0xC0,
  0xF8, 0x3C, 0x07, 0xFE, 0x03, 0xC1, 0xE0, 0x3F, 0xF0, 0x1F, 0x1F, 0x01,
  0xFF, 0x80, 0xF8, 0xF0, 0x0F, 0xFC, 0x03, 0xC7, 0x80, 0x7F, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xDE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0xF8, 0x00,
  0x1F, 0xF7, 0xE0, 0x00, 0xFF, 0x9F, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x3F,
  0xE3, 0xE0, 0x01, 0xFF, 0x1F, 0x80, 0x0F, 0xF8, 0x7C, 0x00, 0x7F, 0xC1,
  0xF0, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xF8, 0x3E, 0x00, 0xFF, 0xC1, 0xF8,
  0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x0F,
  0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x03, 0xFF, 0x00, 0x7C, 0x1F, 0xF8,
  0x03, 0xF0, 0xFF, 0xC0, 0x0F, 0x87, 0xFE, 0x00, 0x7E, 0x3F, 0xF0, 0x01,
  0xF1, 0xFF, 0x80, 0x0F, 0xCF, 0xFC, 0x00, 0x3E, 0x7F, 0xE0, 0x00, 0xFB,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0x81, 0xFF, 0x9F, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xF7, 0xC0, 0x3F,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x3E, 0x00, 0x7F,
  0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x03, 0xE7, 0xE0, 0x01, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1E,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3D, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x79,
  0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE7,
  0x80, 0x1F, 0x01, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x0F,
  0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x78,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x81, 0xF0,
  0x7C, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x03, 0xC1,
  0xF0, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x1E, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0xC0,
  0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xC7, 0xF8, 0x38, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xF8, 0x3C, 0xFC, 0x00, 0xF7, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x7C,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFD, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0xDF, 0xE3, 0xEF, 0x3F, 0xFF, 0x3C,
  0x7F, 0xF8, 0xF0, 0xFF, 0xC1, 0xC0, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x40,
  0x07, 0xC3, 0xFE, 0x03, 0xE7, 0xFF, 0xC1, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC0, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xCF, 0xC0,
  0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x07,
  0xEF, 0xE0, 0x03, 0xE7, 0xF0, 0x03, 0xF3, 0xFE, 0x03, 0xF1, 0xFF, 0xEF,
  0xF8, 0xFB, 0xFF, 0xF8, 0x78, 0xFF, 0xF8, 0x3C, 0x1F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xF8, 0x04, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x61, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x70,
  0x1F, 0x03, 0xFF, 0x1F, 0x07, 0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xEF,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x1F, 0xEF, 0xEF, 0x1F, 0xFF,
  0xCF, 0x07, 0xFF, 0x8F, 0x03, 0xFE, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x7F,
  0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x08, 0x7E, 0x00, 0x70, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x00,
  0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0xFF, 0x1F, 0xEF, 0xFF, 0x1F, 0xFF, 0xDF, 0x07, 0xFF,
  0x9F, 0x03, 0xFF, 0x1F, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x20, 0x00, 0x7E, 0x38, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x40, 0x1F, 0x0F, 0xFC, 0x3E,
  0x7F, 0xFC, 0x7D, 0xFF, 0xFC, 0xFB, 0xFF, 0xFD, 0xFF, 0x01, 0xFB, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x7B,
  0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0xFF, 0xCF, 0xFC,
  0xFF, 0x8F, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFC,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00,
  0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xEF, 0x80, 0x3F, 0x9F, 0x80, 0x7E, 0x1F, 0x00, 0xF8,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x06, 0x01, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xC7, 0xFF, 0x83, 0xFF,
  0xC7, 0xDF, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xBF, 0x80, 0x3F, 0xC0, 0x1F, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0xFF, 0xC3,
  0xC7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xBF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x3F,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x3F, 0xE0, 0x3C, 0x7F,
  0xFC, 0x1F, 0x7F, 0xFF, 0x0F, 0xFF, 0x7F, 0xC7, 0xF8, 0x07, 0xE3, 0xF8,
  0x01, 0xF9, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7C, 0xFE, 0x00, 0x3E, 0x7F, 0x00,
  0x3F, 0x3F, 0xE0, 0x3F, 0x1F, 0xFE, 0xFF, 0x8F, 0xBF, 0xFF, 0x87, 0xCF,
  0xFF, 0x83, 0xE1, 0xFF, 0x01, 0xF0, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xFF, 0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F, 0xEF,
  0xEF, 0x3F, 0x00, 0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xDF, 0x07, 0xFF, 0x9F, 0x03, 0xFF, 0x1F, 0x00, 0x20, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0E,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xCF,
  0xC7, 0xC0, 0x0C, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x3E, 0x60, 0x07, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xF7, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x18,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0xFE,
  0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0xF1, 0xFF, 0xF1, 0xE0,
  0xFF, 0x83, 0xC0, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x03, 0xC1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xF8, 0x01, 0xF7, 0xC0,
  0x07, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0xC0,
  0x0F, 0x1F, 0x00, 0x7F, 0xC0, 0x3E, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x3E,
  0x03, 0xCF, 0x00, 0xF8, 0x7C, 0x07, 0x9E, 0x01, 0xE0, 0xF8, 0x0F, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x78, 0x1F, 0x03,
  0xE0, 0xF0, 0xF0, 0x3C, 0x07, 0xC1, 0xE1, 0xF0, 0xF8, 0x07, 0x87, 0xC1,
  0xE1, 0xF0, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x07, 0xC7, 0x80,
  0x3E, 0x7C, 0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x0F, 0x3E, 0x00, 0x79, 0xE0,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x01, 0xF7, 0x80, 0x7D, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF6, 0x00, 0x3F, 0xF2, 0x00, 0x03,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 41, 14, 4, -40 },
  { 32, 16, 14, 22, 3, -40 },
  { 60, 30, 40, 32, 1, -40 },
  { 210, 23, 46, 29, 3, -43 },
  { 343, 38, 42, 43, 3, -41 },
  { 543, 34, 42, 36, 2, -41 },
  { 722, 6, 14, 12, 3, -40 },
  { 733, 13, 49, 17, 2, -40 },
  { 813, 12, 49, 17, 2, -40 },
  { 887, 23, 23, 28, 2, -43 },
  { 954, 25, 27, 29, 2, -33 },
  { 1039, 8, 13, 14, 2, -6 },
  { 1052, 13, 4, 17, 2, -17 },
  { 1059, 6, 8, 14, 4, -7 },
  { 1065, 19, 40, 21, 1, -40 },
  { 1160, 23, 42, 29, 3, -41 },
  { 1281, 15, 40, 29, 4, -40 },
  { 1356, 24, 41, 29, 2, -41 },
  { 1479, 24, 42, 29, 2, -41 },
  { 1605, 27, 40, 29, 1, -40 },
  { 1740, 23, 41, 29, 3, -40 },
  { 1858, 24, 42, 29, 3, -41 },
  { 1984, 25, 40, 29, 2, -40 },
  { 2109, 25, 42, 29, 2, -41 },
  { 2241, 23, 42, 29, 3, -41 },
  { 2362, 6, 32, 14, 4, -31 },
  { 2386, 8, 38, 14, 2, -31 },
  { 2424, 25, 26, 29, 2, -33 },
  { 2506, 23, 15, 29, 3, -27 },
  { 2550, 25, 26, 29, 2, -33 },
  { 2632, 20, 42, 22, 1, -41 },
  { 2737, 39, 45, 45, 3, -40 },
  { 2957, 32, 40, 32, 0, -40 },
  { 3117, 25, 40, 33, 5, -40 },
  { 3242, 27, 42, 32, 3, -41 },
  { 3384, 28, 40, 37, 5, -40 },
  { 3524, 20, 40, 28, 5, -40 },
  { 3624, 20, 40, 26, 5, -40 },
  { 3724, 30, 42, 37, 3, -41 },
  { 3882, 27, 40, 37, 5, -40 },
  { 4017, 14, 40, 18, 2, -40 },
  { 4087, 14, 51, 14, -4, -40 },
  { 4177, 26, 40, 31, 5, -40 },
  { 4307, 20, 40, 26, 5, -40 },
  { 4407, 37, 40, 47, 5, -40 },
  { 4592, 29, 40, 39, 5, -40 },
  { 4737, 33, 42, 39, 3, -41 },
  { 4911, 23, 40, 31, 5, -40 },
  { 5026, 33, 51, 39, 3, -41 },
  { 5237, 26, 40, 32, 5, -40 },
  { 5367, 22, 42, 28, 3, -41 },
  { 5483, 26, 40, 28, 1, -40 },
  { 5613, 27, 41, 37, 5, -40 },
  { 5752, 30, 40, 30, 0, -40 },
  { 5902, 47, 40, 48, 0, -40 },
  { 6137, 29, 40, 29, 0, -40 },
  { 6282, 28, 40, 28, 0, -40 },
  { 6422, 24, 40, 28, 2, -40 },
  { 6542, 13, 49, 18, 4, -40 },
  { 6622, 19, 40, 21, 1, -40 },
  { 6717, 12, 49, 18, 2, -40 },
  { 6791, 26, 24, 29, 2, -40 },
  { 6869, 25, 3, 25, 0, 5 },
  { 6879, 11, 9, 15, 2, -43 },
  { 6892, 22, 32, 28, 2, -31 },
  { 6980, 25, 44, 31, 4, -43 },
  { 7118, 20, 32, 24, 3, -31 },
  { 7198, 24, 44, 31, 3, -43 },
  { 7330, 23, 32, 29, 3, -31 },
  { 7422, 18, 43, 17, 1, -43 },
  { 7519, 24, 44, 31, 3, -31 },
  { 7651, 23, 43, 31, 4, -43 },
  { 7775, 6, 41, 14, 4, -41 },
  { 7806, 12, 54, 14, -2, -41 },
  { 7887, 23, 43, 27, 4, -43 },
  { 8011, 5, 43, 13, 4, -43 },
  { 8038, 39, 31, 47, 4, -31 },
  { 8190, 23, 31, 31, 4, -31 },
  { 8280, 25, 32, 31, 3, -31 },
  { 8380, 25, 44, 31, 4, -31 },
  { 8518, 24, 44, 31, 3, -31 },
  { 8650, 16, 31, 21, 4, -31 },
  { 8712, 20, 32, 24, 2, -31 },
  { 8792, 16, 38, 18, 1, -37 },
  { 8868, 23, 31, 31, 4, -30 },
  { 8958, 26, 30, 26, 0, -30 },
  { 9056, 39, 30, 40, 1, -30 },
  { 9203, 25, 30, 26, 1, -30 },
  { 9297, 26, 43, 26, 0, -30 },
  { 9437, 19, 30, 23, 2, -30 },
  { 9509, 17, 49, 21, 2, -40 },
  { 9614, 4, 56, 28, 12, -43 },
  { 9642, 17, 49, 21, 2, -40 },
  { 9747, 25, 7, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Regular56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR56PT7B_H_
