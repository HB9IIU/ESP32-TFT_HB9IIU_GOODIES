#ifndef _NOTOSANS_SEMICONDENSED_REGULAR11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x4F, 0xCC,
  0x35, 0xF4, 0x40, 0x66, 0x94, 0x98, 0x9A, 0x6D, 0x15, 0x15, 0x27, 0x30,
  0x91, 0x41, 0x85, 0x29, 0xB3, 0x3F, 0xE0, 0x29, 0x29, 0x12, 0x44, 0xC9,
  0x12, 0x4A, 0x50, 0x27, 0xCC, 0xA0, 0x21, 0x09, 0xF2, 0x10, 0x70, 0xE0,
  0x80, 0x11, 0x22, 0x44, 0x48, 0x72, 0x53, 0x18, 0xA5, 0x2E, 0x74, 0x92,
  0x49, 0x72, 0x42, 0x11, 0x11, 0x1F, 0xF0, 0x42, 0x61, 0x84, 0x3E, 0x18,
  0x62, 0x92, 0x4B, 0xF0, 0x82, 0xF8, 0x8E, 0x11, 0x1E, 0x78, 0x8E, 0x99,
  0x9F, 0xF8, 0x42, 0x21, 0x10, 0x8C, 0x72, 0x52, 0xE5, 0xA6, 0x2F, 0x72,
  0x62, 0x97, 0x84, 0x2E, 0x84, 0x40, 0x1C, 0x08, 0xD9, 0xC1, 0x84, 0xF8,
  0x3E, 0x83, 0x06, 0x36, 0x40, 0xE1, 0x12, 0x44, 0x04, 0x3C, 0x86, 0x6D,
  0x5A, 0xB5, 0x6D, 0x40, 0x78, 0x10, 0xC3, 0x12, 0x49, 0xE8, 0x61, 0xF4,
  0x63, 0xE9, 0xC6, 0x3E, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0xF2, 0x28, 0xA1,
  0x86, 0x28, 0xBC, 0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x7B,
  0x08, 0x20, 0x9E, 0x18, 0x5F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xE9, 0x24,
  0x97, 0x24, 0x92, 0x49, 0x38, 0x8C, 0xA9, 0x8A, 0x5A, 0x51, 0x88, 0x88,
  0x88, 0x8F, 0x83, 0x8F, 0x1D, 0x3A, 0xB5, 0x66, 0xC9, 0x87, 0x1C, 0x69,
  0x96, 0x58, 0xE3, 0x7A, 0x28, 0x61, 0x86, 0x18, 0xDE, 0xF4, 0xA3, 0x2F,
  0x42, 0x10, 0x7A, 0x28, 0x61, 0x86, 0x18, 0xDE, 0x18, 0x30, 0xF4, 0xA3,
  0x2E, 0x4A, 0x51, 0x7A, 0x10, 0xC1, 0x84, 0x3E, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x86, 0x14, 0x92, 0x48, 0xC3, 0x0C,
  0x88, 0xC4, 0x53, 0x2A, 0xA5, 0x52, 0x98, 0x8C, 0x44, 0x8D, 0x23, 0x0C,
  0x31, 0x44, 0xA3, 0x8D, 0x25, 0x0C, 0x20, 0x82, 0x08, 0xF8, 0x44, 0x62,
  0x21, 0x1F, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49,
  0x3C, 0x21, 0x94, 0x98, 0x80, 0xF8, 0xE0, 0x70, 0x4E, 0x98, 0xBC, 0x84,
  0x3D, 0x28, 0xC6, 0x5E, 0xF2, 0x49, 0xC0, 0x11, 0xF9, 0x99, 0x9F, 0xE9,
  0xF8, 0x8F, 0x74, 0xE4, 0x44, 0x44, 0xF9, 0x99, 0x9F, 0x19, 0x60, 0x88,
  0xF9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x58, 0x88, 0x9A, 0xCA, 0xA9, 0xFF,
  0xFF, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xF9, 0x99, 0x99, 0xE9, 0x99, 0x9F,
  0xF4, 0xA3, 0x19, 0x7A, 0x10, 0x80, 0xF9, 0x99, 0x9F, 0x11, 0x10, 0xF2,
  0x49, 0x00, 0x78, 0x43, 0x1F, 0x5D, 0x24, 0x98, 0x99, 0x99, 0x9F, 0x8C,
  0x54, 0xA5, 0x10, 0x99, 0x9A, 0x5A, 0x6A, 0x66, 0x64, 0xCA, 0x88, 0x45,
  0x64, 0x8C, 0x54, 0xA5, 0x10, 0x8C, 0xC0, 0x71, 0x24, 0x4F, 0x32, 0x22,
  0xC4, 0x22, 0x23, 0xFF, 0xE0, 0xC4, 0x22, 0x32, 0x22, 0x4C, 0x6C, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 8, 8, 8, 0, -8 },
  { 23, 7, 8, 7, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 3, 10, 3, 0, -8 },
  { 39, 5, 4, 5, 0, -8 },
  { 42, 5, 6, 6, 0, -7 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 8, 4, 0, -8 },
  { 53, 5, 8, 6, 0, -8 },
  { 58, 3, 8, 6, 1, -8 },
  { 61, 5, 8, 6, 0, -8 },
  { 66, 5, 8, 6, 0, -8 },
  { 71, 6, 8, 6, 0, -8 },
  { 77, 4, 8, 6, 1, -8 },
  { 81, 4, 8, 6, 1, -8 },
  { 85, 5, 8, 6, 0, -8 },
  { 90, 5, 8, 6, 0, -8 },
  { 95, 5, 8, 6, 0, -8 },
  { 100, 1, 6, 3, 1, -6 },
  { 101, 2, 7, 3, 0, -6 },
  { 103, 5, 6, 6, 0, -7 },
  { 107, 5, 3, 6, 0, -5 },
  { 109, 5, 6, 6, 0, -7 },
  { 113, 4, 8, 4, 0, -8 },
  { 117, 7, 9, 9, 1, -8 },
  { 125, 6, 8, 6, 0, -8 },
  { 131, 5, 8, 6, 1, -8 },
  { 136, 5, 8, 6, 1, -8 },
  { 141, 6, 8, 7, 1, -8 },
  { 147, 4, 8, 6, 1, -8 },
  { 151, 4, 8, 5, 1, -8 },
  { 155, 6, 8, 7, 1, -8 },
  { 161, 5, 8, 7, 1, -8 },
  { 166, 3, 8, 4, 0, -8 },
  { 169, 3, 10, 3, -1, -8 },
  { 173, 5, 8, 6, 1, -8 },
  { 178, 4, 8, 5, 1, -8 },
  { 182, 7, 8, 9, 1, -8 },
  { 189, 6, 8, 8, 1, -8 },
  { 195, 6, 8, 8, 1, -8 },
  { 201, 5, 8, 6, 1, -8 },
  { 206, 6, 10, 8, 1, -8 },
  { 214, 5, 8, 6, 1, -8 },
  { 219, 5, 8, 5, 0, -8 },
  { 224, 5, 8, 5, 0, -8 },
  { 229, 5, 8, 7, 1, -8 },
  { 234, 6, 8, 6, 0, -8 },
  { 240, 9, 8, 9, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 5, 8, 5, 0, -8 },
  { 266, 2, 10, 4, 1, -8 },
  { 269, 4, 8, 4, 0, -8 },
  { 273, 3, 10, 4, 0, -8 },
  { 277, 5, 5, 6, 0, -8 },
  { 281, 5, 1, 5, 0, 1 },
  { 282, 3, 1, 3, 0, -8 },
  { 283, 5, 6, 6, 0, -6 },
  { 287, 5, 8, 6, 1, -8 },
  { 292, 3, 6, 5, 1, -6 },
  { 295, 4, 8, 6, 1, -8 },
  { 299, 4, 6, 6, 1, -6 },
  { 302, 4, 8, 3, 0, -8 },
  { 306, 4, 9, 6, 1, -6 },
  { 311, 4, 8, 6, 1, -8 },
  { 315, 1, 8, 3, 1, -8 },
  { 316, 2, 11, 3, 0, -8 },
  { 319, 4, 8, 5, 1, -8 },
  { 323, 1, 8, 3, 1, -8 },
  { 324, 7, 6, 9, 1, -6 },
  { 330, 4, 6, 6, 1, -6 },
  { 333, 4, 6, 6, 1, -6 },
  { 336, 5, 9, 6, 1, -6 },
  { 342, 4, 9, 6, 1, -6 },
  { 347, 3, 6, 4, 1, -6 },
  { 350, 4, 6, 5, 0, -6 },
  { 353, 3, 7, 4, 0, -7 },
  { 356, 4, 6, 6, 1, -6 },
  { 359, 5, 6, 5, 0, -6 },
  { 363, 8, 6, 8, 0, -6 },
  { 369, 5, 6, 5, 0, -6 },
  { 373, 5, 9, 5, 0, -6 },
  { 379, 4, 6, 5, 0, -6 },
  { 382, 4, 10, 4, 0, -8 },
  { 387, 1, 11, 5, 2, -8 },
  { 389, 4, 10, 4, 0, -8 },
  { 394, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Regular11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR11PT7B_H_
