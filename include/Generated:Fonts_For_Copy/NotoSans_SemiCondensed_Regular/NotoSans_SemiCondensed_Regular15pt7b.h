#ifndef _NOTOSANS_SEMICONDENSED_REGULAR15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEA, 0x3C, 0x99, 0x99, 0x12, 0x12, 0x12, 0x7F, 0x14, 0x24,
  0x24, 0xFF, 0x24, 0x24, 0x68, 0x21, 0xFA, 0x68, 0xE1, 0xC2, 0xC9, 0x27,
  0xE2, 0x08, 0x61, 0x28, 0x89, 0x22, 0x50, 0x95, 0x2A, 0xA6, 0xA4, 0x49,
  0x12, 0x48, 0x92, 0x38, 0x30, 0x24, 0x12, 0x09, 0x07, 0x03, 0x83, 0x65,
  0x14, 0x86, 0x47, 0x1E, 0xE0, 0xF0, 0x2B, 0x49, 0x24, 0x93, 0x26, 0xC4,
  0x22, 0x33, 0x33, 0x33, 0x22, 0xC0, 0x22, 0x9F, 0xCC, 0xD9, 0x40, 0x20,
  0x82, 0x3F, 0x20, 0x82, 0x00, 0xEA, 0xFC, 0xF0, 0x08, 0x46, 0x21, 0x10,
  0x8C, 0x42, 0x30, 0x73, 0x28, 0xE1, 0x86, 0x18, 0x61, 0x87, 0x27, 0x80,
  0x17, 0xD1, 0x11, 0x11, 0x11, 0x10, 0x72, 0x20, 0xC3, 0x08, 0x61, 0x08,
  0x42, 0x0F, 0xC0, 0x72, 0x20, 0xC3, 0x09, 0xC0, 0xC1, 0x06, 0x3F, 0x80,
  0x04, 0x0C, 0x1C, 0x14, 0x24, 0x24, 0x44, 0xFF, 0xFF, 0x04, 0x04, 0xFB,
  0x08, 0x20, 0xB3, 0xE0, 0xC1, 0x06, 0x3F, 0x80, 0x39, 0x8C, 0x20, 0xBB,
  0x38, 0x61, 0x87, 0x37, 0x80, 0xFC, 0x10, 0xC2, 0x08, 0x41, 0x0C, 0x21,
  0x84, 0x00, 0x7B, 0x38, 0x63, 0x58, 0xCC, 0xA1, 0x86, 0x37, 0x80, 0x73,
  0x28, 0xE1, 0x87, 0x37, 0x41, 0x08, 0x6F, 0x00, 0xF0, 0x0F, 0x6C, 0x00,
  0x1A, 0x58, 0x04, 0x77, 0x20, 0xE0, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x83,
  0x03, 0x03, 0x19, 0x88, 0x00, 0x72, 0x20, 0xC2, 0x18, 0x42, 0x08, 0x00,
  0x82, 0x00, 0x0E, 0x0C, 0x64, 0x0F, 0x39, 0x92, 0x64, 0x99, 0x26, 0x49,
  0x9D, 0xE0, 0x04, 0x00, 0xFC, 0x08, 0x0C, 0x07, 0x02, 0x82, 0x41, 0x30,
  0xF8, 0xFC, 0x43, 0x20, 0xB0, 0x60, 0xF9, 0x9B, 0x1E, 0x3C, 0x5F, 0x31,
  0xE1, 0xC3, 0x8F, 0xF0, 0x1E, 0xC5, 0x06, 0x08, 0x10, 0x20, 0x40, 0xC0,
  0xC0, 0xF8, 0xF8, 0xCE, 0xC2, 0xC3, 0xC3, 0xC1, 0xC3, 0xC3, 0xC2, 0xC6,
  0xF8, 0xFF, 0x0C, 0x30, 0xC3, 0xEC, 0x30, 0xC3, 0x0F, 0xC0, 0xFF, 0x0C,
  0x30, 0xC3, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x1E, 0x73, 0x40, 0xC0, 0x80,
  0x87, 0x87, 0x81, 0xC1, 0x61, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x2C, 0xC3, 0x8B, 0x26, 0xCD, 0x1E, 0x36, 0x64,
  0xCD, 0x8B, 0x08, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0,
  0xC0, 0xF8, 0x3A, 0x0F, 0x85, 0xF1, 0x74, 0x5D, 0x27, 0x69, 0xCE, 0x73,
  0x1C, 0x44, 0xC1, 0xE1, 0xA1, 0xF1, 0xD1, 0xD9, 0xC9, 0xCD, 0xC7, 0xC3,
  0xC3, 0x3C, 0x33, 0x30, 0x50, 0x28, 0x1C, 0x0E, 0x07, 0x02, 0xC1, 0x31,
  0x8F, 0x80, 0xF9, 0x9B, 0x16, 0x3C, 0x59, 0xBE, 0x60, 0xC1, 0x83, 0x00,
  0x3C, 0x33, 0x30, 0x50, 0x28, 0x1C, 0x0E, 0x07, 0x02, 0xC1, 0x31, 0x8F,
  0x80, 0x80, 0x20, 0x18, 0xF9, 0x9B, 0x16, 0x3C, 0x5F, 0xBE, 0x64, 0xCD,
  0x8B, 0x18, 0x7F, 0x28, 0x20, 0xC1, 0xC1, 0x83, 0x0E, 0x3F, 0x80, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x42, 0x3C, 0x81, 0xC3, 0x42, 0x42,
  0x66, 0x24, 0x24, 0x34, 0x1C, 0x18, 0x18, 0xC2, 0x1E, 0x30, 0x91, 0xC4,
  0x8A, 0x24, 0x53, 0x36, 0x90, 0xA6, 0x85, 0x14, 0x28, 0xE1, 0xC6, 0x04,
  0x30, 0xC3, 0x46, 0x24, 0x2C, 0x18, 0x18, 0x18, 0x2C, 0x64, 0x46, 0xC3,
  0x83, 0x42, 0x44, 0x24, 0x2C, 0x38, 0x18, 0x10, 0x10, 0x10, 0x10, 0xFC,
  0x30, 0x86, 0x10, 0x86, 0x10, 0xC2, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0x92,
  0x4E, 0xC2, 0x10, 0xC2, 0x10, 0xC2, 0x10, 0x42, 0xF3, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xF0, 0x10, 0x30, 0xA1, 0x26, 0x48, 0x70, 0x80, 0xFE, 0xCC,
  0xF8, 0x20, 0x9F, 0xCE, 0x38, 0xFF, 0x81, 0x02, 0x05, 0xEC, 0x58, 0xE1,
  0xC3, 0xC7, 0x8A, 0xE0, 0x7E, 0x21, 0x08, 0x43, 0x0F, 0x04, 0x10, 0x5F,
  0xCE, 0x18, 0x61, 0x87, 0x37, 0x40, 0x7B, 0x38, 0x7F, 0x82, 0x0C, 0x5F,
  0x39, 0x19, 0xE6, 0x31, 0x8C, 0x63, 0x18, 0x7F, 0x38, 0x61, 0x86, 0x1C,
  0xDD, 0x04, 0x1F, 0xCC, 0x82, 0x08, 0x2F, 0xC7, 0x18, 0x61, 0x86, 0x18,
  0x40, 0xE2, 0xAA, 0xA8, 0x32, 0x02, 0x22, 0x22, 0x22, 0x22, 0x2E, 0x40,
  0x82, 0x08, 0x23, 0x9A, 0xCA, 0x34, 0x9A, 0x28, 0xC0, 0xFF, 0xE0, 0xBB,
  0xD9, 0x8B, 0x11, 0xC2, 0x38, 0x47, 0x08, 0xE1, 0x1C, 0x23, 0xBF, 0x1C,
  0x61, 0x86, 0x18, 0x61, 0x7B, 0x18, 0x61, 0x86, 0x1C, 0xDE, 0xBD, 0x8B,
  0x1C, 0x38, 0x78, 0xB1, 0x5C, 0x81, 0x02, 0x04, 0x00, 0x7F, 0x38, 0x61,
  0x86, 0x1C, 0xDD, 0x04, 0x10, 0x41, 0xBC, 0xC8, 0x88, 0x88, 0xFC, 0x21,
  0xC3, 0x0E, 0x7E, 0x23, 0x3C, 0xC6, 0x31, 0x8C, 0x61, 0xC0, 0x86, 0x18,
  0x61, 0x86, 0x1C, 0xDD, 0xC6, 0x89, 0x12, 0x62, 0x85, 0x0A, 0x08, 0xC4,
  0x69, 0xC9, 0x29, 0x25, 0x67, 0xA8, 0x67, 0x0C, 0x61, 0x8C, 0xC6, 0xD8,
  0xA0, 0xC3, 0x85, 0x19, 0x63, 0xC6, 0x89, 0x13, 0x62, 0x85, 0x0A, 0x08,
  0x10, 0x63, 0x86, 0x00, 0xF8, 0x8C, 0x44, 0x62, 0x1F, 0x09, 0x88, 0x42,
  0x13, 0x8C, 0x21, 0x08, 0x61, 0x80, 0xFF, 0xFE, 0x8C, 0x44, 0x44, 0x36,
  0x44, 0x44, 0xC0, 0xF6, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 8, 11, 9, 0, -11 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 10, 11, 12, 1, -11 },
  { 40, 9, 11, 10, 1, -11 },
  { 53, 1, 4, 3, 1, -11 },
  { 54, 3, 13, 4, 1, -11 },
  { 59, 4, 13, 4, 0, -11 },
  { 66, 6, 6, 7, 1, -11 },
  { 71, 6, 7, 8, 1, -9 },
  { 77, 2, 4, 4, 1, -2 },
  { 78, 3, 2, 5, 1, -5 },
  { 79, 2, 2, 4, 1, -2 },
  { 80, 5, 11, 6, 0, -11 },
  { 87, 6, 11, 8, 1, -11 },
  { 96, 4, 11, 8, 1, -11 },
  { 102, 6, 11, 8, 1, -11 },
  { 111, 6, 11, 8, 1, -11 },
  { 120, 8, 11, 8, 0, -11 },
  { 131, 6, 11, 8, 1, -11 },
  { 140, 6, 11, 8, 1, -11 },
  { 149, 6, 11, 8, 1, -11 },
  { 158, 6, 11, 8, 1, -11 },
  { 167, 6, 11, 8, 1, -11 },
  { 176, 2, 8, 4, 1, -8 },
  { 178, 3, 10, 4, 0, -8 },
  { 182, 6, 7, 8, 1, -9 },
  { 188, 6, 4, 8, 1, -7 },
  { 191, 6, 7, 8, 1, -9 },
  { 197, 6, 11, 6, 0, -11 },
  { 206, 10, 12, 12, 1, -11 },
  { 221, 9, 11, 9, 0, -11 },
  { 234, 7, 11, 9, 1, -11 },
  { 244, 7, 11, 8, 1, -11 },
  { 254, 8, 11, 10, 1, -11 },
  { 265, 6, 11, 8, 1, -11 },
  { 274, 6, 11, 7, 1, -11 },
  { 283, 8, 11, 10, 1, -11 },
  { 294, 8, 11, 10, 1, -11 },
  { 305, 3, 11, 5, 1, -11 },
  { 310, 4, 14, 4, -1, -11 },
  { 317, 7, 11, 8, 1, -11 },
  { 327, 6, 11, 7, 1, -11 },
  { 336, 10, 11, 13, 1, -11 },
  { 350, 8, 11, 10, 1, -11 },
  { 361, 9, 11, 10, 1, -11 },
  { 374, 7, 11, 8, 1, -11 },
  { 384, 9, 14, 10, 1, -11 },
  { 400, 7, 11, 8, 1, -11 },
  { 410, 6, 11, 7, 1, -11 },
  { 419, 7, 11, 7, 0, -11 },
  { 429, 8, 11, 10, 1, -11 },
  { 440, 8, 11, 8, 0, -11 },
  { 451, 13, 11, 13, 0, -11 },
  { 469, 8, 11, 8, 0, -11 },
  { 480, 8, 11, 8, 0, -11 },
  { 491, 6, 11, 7, 1, -11 },
  { 500, 3, 13, 5, 1, -11 },
  { 505, 5, 11, 6, 0, -11 },
  { 512, 4, 13, 5, 0, -11 },
  { 519, 7, 7, 8, 0, -11 },
  { 526, 7, 1, 7, 0, 1 },
  { 527, 3, 2, 4, 1, -11 },
  { 528, 6, 8, 8, 1, -8 },
  { 534, 7, 11, 8, 1, -11 },
  { 544, 5, 8, 6, 1, -8 },
  { 549, 6, 11, 8, 1, -11 },
  { 558, 6, 8, 8, 1, -8 },
  { 564, 5, 11, 5, 0, -11 },
  { 571, 6, 12, 8, 1, -8 },
  { 580, 6, 11, 8, 1, -11 },
  { 589, 2, 11, 4, 1, -11 },
  { 592, 4, 15, 4, -1, -11 },
  { 600, 6, 11, 7, 1, -11 },
  { 609, 1, 11, 4, 1, -11 },
  { 611, 11, 8, 13, 1, -8 },
  { 622, 6, 8, 8, 1, -8 },
  { 628, 6, 8, 8, 1, -8 },
  { 634, 7, 12, 8, 1, -8 },
  { 645, 6, 12, 8, 1, -8 },
  { 654, 4, 8, 6, 1, -8 },
  { 658, 5, 8, 6, 1, -8 },
  { 663, 5, 10, 5, 0, -10 },
  { 670, 6, 8, 8, 1, -8 },
  { 676, 7, 8, 7, 0, -8 },
  { 683, 11, 8, 11, 0, -8 },
  { 694, 7, 8, 7, 0, -8 },
  { 701, 7, 12, 7, 0, -8 },
  { 712, 5, 8, 6, 1, -8 },
  { 717, 5, 13, 6, 0, -11 },
  { 726, 1, 15, 7, 3, -11 },
  { 728, 4, 13, 6, 1, -11 },
  { 735, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Regular15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR15PT7B_H_
