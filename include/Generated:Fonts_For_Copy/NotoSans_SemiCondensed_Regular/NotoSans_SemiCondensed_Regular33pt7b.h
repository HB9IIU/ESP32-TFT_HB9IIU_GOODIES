#ifndef _NOTOSANS_SEMICONDENSED_REGULAR33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x60, 0x00, 0x7F,
  0xF7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC7, 0x61, 0x80,
  0x03, 0x06, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x38,
  0x60, 0x18, 0x30, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0x0C, 0x03, 0x86, 0x01,
  0xC3, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xC1, 0xFF, 0xFE, 0xFF, 0xFF,
  0x0E, 0x18, 0x06, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1,
  0x80, 0x70, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x7F, 0xFB,
  0xED, 0xCE, 0x30, 0x38, 0xC0, 0xC3, 0x03, 0x8C, 0x0F, 0x30, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xDE, 0x03, 0x38, 0x0C, 0x70, 0x31,
  0x80, 0xCE, 0xE3, 0x7B, 0xFF, 0xCF, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x3C, 0x01, 0xC1, 0xF8, 0x06, 0x0E, 0x70, 0x38, 0x30,
  0xC0, 0xC0, 0xC3, 0x07, 0x03, 0x0C, 0x18, 0x0C, 0x30, 0xE0, 0x30, 0xE3,
  0x00, 0xC3, 0x9C, 0x03, 0x0C, 0x60, 0x0C, 0x33, 0x9F, 0x30, 0xCC, 0xFE,
  0xE7, 0x73, 0x19, 0xF9, 0x9C, 0x73, 0xCE, 0x61, 0xC0, 0x31, 0x87, 0x01,
  0xC6, 0x0C, 0x06, 0x18, 0x30, 0x38, 0x61, 0xC0, 0xC1, 0x87, 0x07, 0x07,
  0x18, 0x18, 0x0C, 0x60, 0x60, 0x3F, 0x83, 0x80, 0x7C, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xC3, 0x80, 0x18, 0x38, 0x03, 0x83, 0x80,
  0x18, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0xE3, 0xDE, 0x0E, 0x78, 0xF1, 0xC7, 0x07,
  0x1C, 0x70, 0x39, 0xCE, 0x01, 0xF8, 0xE0, 0x0F, 0x87, 0x00, 0xF0, 0x70,
  0x1F, 0x87, 0xC7, 0xFC, 0x3F, 0xF9, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFB,
  0x60, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0xC1, 0xC1, 0xC3, 0x83, 0x87,
  0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xC3, 0x8E, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x63, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0xC0,
  0x33, 0x01, 0xCE, 0x0F, 0x1C, 0x18, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x39, 0xCE, 0xE7, 0x39, 0x9C, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x80,
  0xFF, 0x83, 0xFE, 0x1C, 0x1C, 0x70, 0x33, 0x80, 0xEE, 0x03, 0xB8, 0x0E,
  0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0x70, 0x71, 0xE3,
  0xC3, 0xFE, 0x07, 0xF0, 0x07, 0x0F, 0x1F, 0x3F, 0x77, 0xE7, 0xC7, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9C, 0x0E, 0x20,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0xFF, 0xCF, 0xFF, 0x98, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x3F, 0x81,
  0xEF, 0xFF, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xB8, 0x03, 0xB8, 0x03, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0C, 0x38,
  0x1C, 0x38, 0x18, 0x38, 0x38, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xF1, 0xFF, 0xE0,
  0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x07, 0xF0, 0xFB, 0xFF, 0x8F, 0xF0, 0x03, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x8F,
  0x0E, 0xFE, 0x3F, 0xFC, 0xF0, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x0E, 0x70, 0x38, 0xE1, 0xC3, 0xFF, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xFB, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x38, 0x38, 0x78, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0xFE, 0x07, 0x9F,
  0x0E, 0x0F, 0x38, 0x0E, 0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x00, 0x77,
  0x01, 0xCF, 0x07, 0x8F, 0xFE, 0x07, 0xF0, 0x07, 0xC0, 0x7F, 0x83, 0xFF,
  0x1E, 0x0E, 0x70, 0x19, 0xC0, 0x77, 0x01, 0xF8, 0x03, 0xE0, 0x0D, 0xC0,
  0x77, 0x01, 0xDC, 0x0F, 0x38, 0x7C, 0xFF, 0xB0, 0xFD, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07, 0xC3, 0xFE, 0x0F,
  0xE0, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0x3B, 0xDE,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0x73, 0x9C, 0xCE, 0x70,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x40, 0x00, 0x1F, 0x8F, 0xFC, 0x7F, 0xE4, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xDF,
  0x80, 0x78, 0x07, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x07,
  0x38, 0x3F, 0x86, 0x60, 0xFF, 0x0D, 0xC3, 0x86, 0x1F, 0x8E, 0x0C, 0x1E,
  0x1C, 0x18, 0x3C, 0x30, 0x30, 0x78, 0x60, 0x60, 0xF0, 0xC0, 0xC3, 0xE1,
  0x83, 0x87, 0xC3, 0x87, 0x0D, 0x87, 0x0A, 0x3B, 0x87, 0xF7, 0xE7, 0x07,
  0xC7, 0x86, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x20, 0x0F, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x18, 0x1C, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1C,
  0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE3, 0xFF,
  0xE7, 0x03, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x73, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0x1C, 0x07, 0xB8, 0x07, 0x70,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x03, 0xDC, 0x3F,
  0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x3E, 0x02,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x06,
  0x0F, 0xFE, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1C, 0x0F,
  0x8E, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0xCE, 0x03,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x78, 0x04, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1D, 0xE0, 0x07, 0x3C, 0x01, 0xC7, 0xC1, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0x3E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0F, 0x0E, 0x9E, 0xFC, 0xF8, 0xE0, 0x0F, 0xC0, 0x3B, 0x80,
  0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0x81,
  0xCE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x38, 0xE0, 0x70,
  0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0x81, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07,
  0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xDC, 0x00, 0xFF, 0x70, 0x03, 0x7F, 0xC0, 0x1D, 0xFB,
  0x80, 0x77, 0xEE, 0x01, 0x9F, 0x98, 0x0E, 0x7E, 0x70, 0x39, 0xF9, 0xC0,
  0xC7, 0xE3, 0x07, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x61, 0xF8, 0x63, 0x87,
  0xE1, 0xCE, 0x1F, 0x87, 0x30, 0x7E, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xE0, 0x1F, 0x38,
  0x0F, 0xDC, 0x07, 0xE7, 0x03, 0xF3, 0x81, 0xF8, 0xE0, 0xFC, 0x78, 0x7E,
  0x1C, 0x3F, 0x07, 0x1F, 0x83, 0x8F, 0xC0, 0xE7, 0xE0, 0x73, 0xF0, 0x1D,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC7, 0x80,
  0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x01,
  0xE3, 0xC0, 0x78, 0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0xFC, 0x03,
  0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF0,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E,
  0x03, 0xC7, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0,
  0x07, 0x3C, 0x01, 0xE3, 0xC0, 0x78, 0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x80,
  0xE7, 0x07, 0x8F, 0xFE, 0x1F, 0xF0, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE1,
  0xC1, 0xE3, 0x81, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x70,
  0x07, 0x0F, 0xC1, 0xFF, 0xDF, 0xFD, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0x70,
  0xFB, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x7C, 0x3C,
  0x3F, 0xF8, 0x0F, 0xF0, 0xE0, 0x01, 0xF8, 0x00, 0xF7, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x18, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x37, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x06,
  0x00, 0x77, 0x00, 0xF0, 0x07, 0x70, 0x0F, 0x00, 0xE7, 0x00, 0xF0, 0x0E,
  0x70, 0x1F, 0x80, 0xE3, 0x01, 0xF8, 0x0E, 0x38, 0x1F, 0x81, 0xC3, 0x81,
  0x98, 0x1C, 0x38, 0x39, 0xC1, 0xC3, 0x83, 0x9C, 0x1C, 0x1C, 0x39, 0xC3,
  0x81, 0xC3, 0x0C, 0x38, 0x1C, 0x70, 0xE3, 0x81, 0xC7, 0x0E, 0x38, 0x0E,
  0x70, 0xE3, 0x00, 0xE6, 0x06, 0x70, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07,
  0x70, 0x06, 0xE0, 0x36, 0x00, 0x7C, 0x03, 0x60, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x07,
  0xB8, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x38,
  0xE0, 0x0E, 0x70, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x38, 0x07, 0x1C,
  0x07, 0x07, 0x03, 0x83, 0x83, 0x80, 0xE1, 0xC0, 0x79, 0xC0, 0x1D, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x01, 0xCF, 0x01, 0xC3, 0x80, 0xE1,
  0xC0, 0xE0, 0x70, 0x70, 0x38, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x01, 0xDC,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xE0, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x6C, 0x01,
  0xDC, 0x03, 0x18, 0x0E, 0x38, 0x18, 0x30, 0x70, 0x70, 0xC0, 0x63, 0x80,
  0xE6, 0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x0F, 0xC1, 0xFF, 0x87, 0x1E, 0x40, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x3F, 0x1F, 0xF9, 0xF8, 0xDC, 0x06, 0xE0, 0x7E, 0x03, 0xF0,
  0x1D, 0xC1, 0xEE, 0x1F, 0x7F, 0xD9, 0xFC, 0xC0, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF0, 0xDF, 0xE3,
  0xF7, 0xCF, 0x07, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0xC0, 0xEF, 0x87,
  0x37, 0xFC, 0xCF, 0xC0, 0x0F, 0xC7, 0xFC, 0xFF, 0xB8, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0xC1, 0x3F, 0xE3, 0xFC, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xE7, 0x3F, 0xDD, 0xF7, 0xF7, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0xF7, 0x1F,
  0x8C, 0x0F, 0x81, 0xFF, 0x1F, 0x3C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x03, 0x3F, 0xF8, 0x7F, 0x80, 0x07, 0xE1, 0xFC, 0x38, 0x8E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xFE, 0xFF, 0xDF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x8C, 0xFF, 0x77, 0xDF, 0xDC,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0xDE, 0x1F, 0x3F, 0xDC,
  0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE4, 0x03, 0x9F, 0x7C,
  0x7F, 0xE0, 0x7E, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0xF8, 0xDF, 0xE6, 0xEF, 0xBC, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38, 0x6F, 0x60, 0x00,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x0C, 0x3C, 0x30,
  0x00, 0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xD7, 0xBE,
  0x78, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x0E, 0xC0, 0xE6, 0x0F, 0x30, 0x71, 0x87, 0x0C, 0x70, 0x67, 0x03,
  0x70, 0x1B, 0xC0, 0xFE, 0x07, 0x38, 0x31, 0xE1, 0x87, 0x0C, 0x1C, 0x60,
  0xF3, 0x03, 0x98, 0x0E, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC7, 0xC1, 0xF3, 0x7F, 0x9F, 0xEF, 0xDF, 0xF7, 0xFC, 0x1F, 0x07,
  0xE0, 0x78, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30,
  0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x30, 0xC7, 0xC6, 0xFF, 0xBF, 0x7D, 0xE0, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x0F, 0xC0, 0xFF,
  0xC7, 0xEF, 0x1C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9E,
  0x1E, 0x3F, 0xF0, 0x3F, 0x00, 0xC7, 0xC3, 0x7F, 0x8D, 0xDF, 0x3C, 0x1E,
  0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x3B, 0x80, 0xEF, 0x03, 0xBE, 0x1C, 0xDF, 0xF3, 0x3F,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x0F, 0x8C, 0xFF, 0x77, 0xDF, 0xDC, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x77, 0x03, 0xDE, 0x1F, 0x3F, 0xDC, 0x7E, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0xC7, 0xE7, 0xF7, 0xFF, 0x0F, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0xC3,
  0xFF, 0x78, 0xE6, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x0E, 0xFF, 0xE7,
  0xF8, 0x18, 0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFE, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xF8, 0xFC, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1D, 0x80, 0xF7, 0x03, 0xDE, 0x1F, 0x3F, 0xDC, 0x7E, 0x30, 0xE0, 0x0F,
  0xC0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xC7, 0x07, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x71, 0xC0, 0x73, 0x00, 0xEE, 0x01, 0xDC,
  0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0xE0, 0x3C, 0x0E, 0xE0,
  0x78, 0x1D, 0xC0, 0xF0, 0x3B, 0x83, 0xE0, 0x77, 0x07, 0xE0, 0xC6, 0x0D,
  0xC3, 0x8E, 0x19, 0x87, 0x1C, 0x73, 0x0E, 0x38, 0xE7, 0x18, 0x31, 0x8E,
  0x70, 0x73, 0x0C, 0xE0, 0xEE, 0x19, 0xC1, 0xDC, 0x3B, 0x01, 0xB0, 0x7E,
  0x03, 0x60, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x0E, 0x03, 0xC0,
  0xE0, 0x1D, 0xC0, 0xE7, 0x07, 0x0E, 0x1C, 0x38, 0xE0, 0x73, 0x80, 0xFC,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1C, 0xE0, 0xE3,
  0x83, 0x87, 0x1C, 0x1E, 0xF0, 0x3B, 0x80, 0x70, 0xE0, 0x0F, 0xC0, 0x1D,
  0xC0, 0x73, 0x80, 0xE3, 0x01, 0xC7, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x30, 0x38, 0xE0, 0x31, 0xC0, 0x73, 0x00, 0xEE, 0x00, 0xDC, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0xEF, 0xFD,
  0xFF, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0xF0, 0x7C, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x1F, 0x0F, 0x03, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x3E, 0x0F, 0xC0,
  0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E,
  0x01, 0xE0, 0x3C, 0x1F, 0x0F, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x03, 0xC3, 0xE0, 0xF0, 0x00, 0x1C, 0x02, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xE8, 0x03, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 17, 24, 19, 1, -24 },
  { 75, 14, 27, 17, 2, -25 },
  { 123, 22, 24, 25, 2, -24 },
  { 189, 20, 24, 21, 1, -24 },
  { 249, 3, 9, 7, 2, -24 },
  { 253, 8, 29, 10, 1, -24 },
  { 282, 7, 29, 10, 1, -24 },
  { 308, 14, 13, 16, 1, -25 },
  { 331, 15, 16, 17, 1, -20 },
  { 361, 5, 8, 8, 1, -4 },
  { 366, 8, 2, 10, 1, -10 },
  { 368, 4, 4, 8, 2, -4 },
  { 370, 12, 24, 12, 0, -24 },
  { 406, 14, 24, 17, 2, -24 },
  { 448, 8, 24, 17, 3, -24 },
  { 472, 14, 24, 17, 1, -24 },
  { 514, 14, 24, 17, 1, -24 },
  { 556, 16, 24, 17, 1, -24 },
  { 604, 13, 24, 17, 2, -24 },
  { 643, 14, 24, 17, 2, -24 },
  { 685, 15, 24, 17, 1, -24 },
  { 730, 15, 24, 17, 1, -24 },
  { 775, 14, 24, 17, 1, -24 },
  { 817, 4, 18, 8, 2, -18 },
  { 826, 5, 22, 8, 1, -18 },
  { 840, 15, 16, 17, 1, -20 },
  { 870, 14, 9, 17, 2, -16 },
  { 886, 15, 16, 17, 1, -20 },
  { 916, 12, 24, 13, 0, -24 },
  { 952, 23, 27, 27, 2, -24 },
  { 1030, 19, 24, 19, 0, -24 },
  { 1087, 15, 24, 19, 3, -24 },
  { 1132, 16, 24, 19, 2, -24 },
  { 1180, 17, 24, 22, 3, -24 },
  { 1231, 12, 24, 17, 3, -24 },
  { 1267, 12, 24, 15, 3, -24 },
  { 1303, 18, 24, 22, 2, -24 },
  { 1357, 16, 24, 22, 3, -24 },
  { 1405, 8, 24, 11, 1, -24 },
  { 1429, 8, 30, 8, -2, -24 },
  { 1459, 15, 24, 18, 3, -24 },
  { 1504, 12, 24, 15, 3, -24 },
  { 1540, 22, 24, 28, 3, -24 },
  { 1606, 17, 24, 23, 3, -24 },
  { 1657, 19, 24, 23, 2, -24 },
  { 1714, 14, 24, 18, 3, -24 },
  { 1756, 19, 30, 23, 2, -24 },
  { 1828, 15, 24, 19, 3, -24 },
  { 1873, 13, 24, 16, 2, -24 },
  { 1912, 16, 24, 16, 0, -24 },
  { 1960, 16, 24, 22, 3, -24 },
  { 2008, 18, 24, 18, 0, -24 },
  { 2062, 28, 24, 28, 0, -24 },
  { 2146, 17, 24, 17, 0, -24 },
  { 2197, 17, 24, 17, 0, -24 },
  { 2248, 14, 24, 16, 1, -24 },
  { 2290, 7, 29, 11, 3, -24 },
  { 2316, 12, 24, 12, 0, -24 },
  { 2352, 7, 29, 11, 1, -24 },
  { 2378, 15, 14, 17, 1, -24 },
  { 2405, 15, 2, 15, 0, 3 },
  { 2409, 7, 5, 9, 1, -25 },
  { 2414, 13, 18, 17, 1, -18 },
  { 2444, 14, 25, 18, 3, -25 },
  { 2488, 11, 18, 14, 2, -18 },
  { 2513, 14, 25, 18, 2, -25 },
  { 2557, 13, 18, 17, 2, -18 },
  { 2587, 11, 25, 10, 0, -25 },
  { 2622, 14, 26, 18, 2, -18 },
  { 2668, 13, 25, 18, 3, -25 },
  { 2709, 4, 24, 8, 2, -24 },
  { 2721, 7, 32, 8, -1, -24 },
  { 2749, 13, 25, 16, 3, -25 },
  { 2790, 2, 25, 8, 3, -25 },
  { 2797, 22, 18, 28, 3, -18 },
  { 2847, 13, 18, 18, 3, -18 },
  { 2877, 14, 18, 18, 2, -18 },
  { 2909, 14, 26, 18, 3, -18 },
  { 2955, 14, 26, 18, 2, -18 },
  { 3001, 9, 18, 12, 3, -18 },
  { 3022, 12, 18, 14, 1, -18 },
  { 3049, 9, 22, 11, 1, -22 },
  { 3074, 14, 18, 18, 2, -18 },
  { 3106, 15, 18, 15, 0, -18 },
  { 3140, 23, 18, 24, 0, -18 },
  { 3192, 14, 18, 16, 1, -18 },
  { 3224, 15, 26, 15, 0, -18 },
  { 3273, 11, 18, 14, 1, -18 },
  { 3298, 10, 29, 12, 1, -24 },
  { 3335, 2, 33, 16, 7, -25 },
  { 3344, 10, 29, 12, 1, -24 },
  { 3381, 15, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Regular33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR33PT7B_H_
