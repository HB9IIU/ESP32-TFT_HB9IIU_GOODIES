#ifndef _NOTOSANS_SEMICONDENSED_REGULAR44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE4, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0x60, 0xE0, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xC7, 0x0C, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70,
  0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0E, 0x7C, 0x01, 0xC3,
  0x80, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x7B, 0x03, 0x9F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xE0, 0x1C, 0x78, 0x07,
  0x80, 0x70, 0xE0, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x0E, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x70, 0x03, 0x81, 0xC1, 0xC0, 0x0E,
  0x07, 0x0E, 0x00, 0x38, 0x1C, 0x38, 0x00, 0xE0, 0x71, 0xC0, 0x03, 0x81,
  0xC7, 0x1F, 0x8F, 0x0F, 0x38, 0xFF, 0x1C, 0x38, 0xE7, 0xFC, 0x79, 0xE7,
  0x1C, 0x38, 0xFF, 0x1C, 0xF0, 0xE3, 0xFC, 0xE3, 0x83, 0x83, 0xC3, 0x8E,
  0x07, 0x00, 0x1E, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x70, 0x03, 0xC3, 0x81,
  0xC0, 0x0E, 0x0E, 0x07, 0x00, 0x78, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x70,
  0x0F, 0x03, 0x83, 0xC0, 0x38, 0x0F, 0x0E, 0x01, 0xE0, 0x1C, 0x38, 0x07,
  0x00, 0x7B, 0xE0, 0x3C, 0x00, 0xFF, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1E, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x03, 0xC3, 0xC7, 0xC0, 0xF1,
  0xE0, 0xF8, 0x3C, 0xF8, 0x1F, 0x0E, 0x3C, 0x03, 0xE7, 0x8F, 0x00, 0x7D,
  0xE3, 0xC0, 0x0F, 0xF0, 0xF0, 0x01, 0xFC, 0x3C, 0x00, 0x7E, 0x0F, 0x00,
  0x1F, 0x81, 0xE0, 0x0F, 0xF0, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0xE7, 0xC1,
  0xFF, 0xF0, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x60,
  0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x30, 0x70, 0x6F, 0xCC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x01, 0xE1, 0xE0,
  0xF8, 0x7C, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7,
  0x3C, 0xE3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF,
  0x90, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xDF, 0x83, 0xE0, 0xF8,
  0x78, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x7B,
  0xC0, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x73, 0x80, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xE0, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1E, 0xF7,
  0xCF, 0xF8, 0xF7, 0x0F, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xBF,
  0x87, 0x80, 0xF8, 0x40, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x81,
  0xFF, 0xFC, 0x7F, 0xBF, 0x87, 0x00, 0xF8, 0x80, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x40,
  0x03, 0xEE, 0x01, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x80, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE8, 0x00, 0xF3,
  0x00, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xF8, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x07, 0x80, 0xE7, 0xFC, 0x3D, 0xFF, 0xC7, 0xFC, 0xFC, 0xFC,
  0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x38, 0xF0,
  0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x8F,
  0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xE0, 0xF0, 0x3F, 0x7C,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0xE0, 0xF8, 0x7E,
  0x3C, 0x03, 0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x01, 0xE7, 0xC0, 0x7C,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xDF, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0x1C, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x3F, 0x7C, 0x0F, 0xE7,
  0xFF, 0xBC, 0x7F, 0xE7, 0x07, 0xF8, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x77,
  0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x20, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xE7, 0x8F, 0x1E,
  0x38, 0xF1, 0xE3, 0x87, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xE4, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x07, 0xF0, 0x38, 0xE0, 0x3F,
  0xF8, 0x71, 0xC0, 0xFF, 0xF0, 0x77, 0x83, 0xC1, 0xC0, 0xEE, 0x07, 0x03,
  0x81, 0xDC, 0x1E, 0x07, 0x03, 0xB8, 0x38, 0x0E, 0x07, 0x70, 0x70, 0x1C,
  0x0F, 0xE1, 0xE0, 0x38, 0x1F, 0x83, 0xC0, 0x70, 0x3F, 0x07, 0x80, 0xE0,
  0x7E, 0x0F, 0x01, 0xC0, 0xFE, 0x0E, 0x07, 0x83, 0xDC, 0x1C, 0x0F, 0x07,
  0x38, 0x3C, 0x3F, 0x1E, 0x70, 0x3F, 0xEF, 0xF8, 0xE0, 0x7F, 0x8F, 0xE1,
  0xE0, 0x3E, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x07,
  0xE0, 0x0E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xF0,
  0x1F, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x03, 0xEF, 0x01, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xF8, 0x02, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x06, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x03, 0xF8,
  0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x0F,
  0xCF, 0x00, 0x7E, 0x3C, 0x1F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF8, 0x01, 0xC3, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0xF1, 0xFC, 0x01, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFC, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0xFF, 0xFF, 0xF3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x7F, 0xBF, 0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x03, 0xEF, 0xF9, 0xFE, 0x3F, 0x80, 0xF0, 0x01,
  0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78,
  0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80,
  0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xE0, 0x07, 0xCF, 0x80, 0x3C, 0x3E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0xE0, 0x00, 0x3F, 0xF7, 0x80, 0x03, 0xFF, 0xBC, 0x00, 0x1D, 0xFC,
  0xE0, 0x00, 0xEF, 0xE7, 0x80, 0x0F, 0x7F, 0x3C, 0x00, 0x73, 0xF8, 0xE0,
  0x03, 0x9F, 0xC7, 0x80, 0x3C, 0xFE, 0x3C, 0x01, 0xC7, 0xF0, 0xE0, 0x0E,
  0x3F, 0x87, 0x80, 0xF1, 0xFC, 0x3C, 0x07, 0x0F, 0xE0, 0xE0, 0x38, 0x7F,
  0x07, 0x83, 0xC3, 0xF8, 0x3C, 0x1C, 0x1F, 0xC0, 0xE1, 0xE0, 0xFE, 0x07,
  0x8F, 0x07, 0xF0, 0x3C, 0x70, 0x3F, 0x80, 0xE7, 0x81, 0xFC, 0x07, 0xBC,
  0x0F, 0xE0, 0x3D, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80,
  0x3C, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xBC, 0x00, 0x7E, 0xF0, 0x01, 0xF9, 0xE0,
  0x07, 0xE7, 0x80, 0x1F, 0x8F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x78, 0x07,
  0xE0, 0xF0, 0x1F, 0x83, 0xC0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0,
  0x3C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F,
  0x1F, 0x80, 0x1E, 0x7E, 0x00, 0x79, 0xF8, 0x00, 0xF7, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF8, 0x1F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0xC1, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF8,
  0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x7C,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x7F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x7C, 0x03, 0x9E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1E, 0xF0, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0x9F, 0x00, 0x7C,
  0x7C, 0x07, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xC7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7B, 0xC0, 0x07, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0x00, 0x3C, 0xF0, 0x01,
  0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0xC0, 0x0F, 0x1E, 0x00, 0xFE, 0x00, 0x78,
  0xF0, 0x07, 0x70, 0x07, 0x87, 0x80, 0x3B, 0xC0, 0x3C, 0x1C, 0x03, 0xDE,
  0x01, 0xE0, 0xF0, 0x1E, 0x70, 0x0F, 0x07, 0x80, 0xE3, 0x80, 0x70, 0x3C,
  0x07, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0x83, 0xC3, 0x81,
  0xE0, 0x3C, 0x1C, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0xF0, 0xF0, 0x07, 0x0F,
  0x03, 0x87, 0x80, 0x3C, 0x78, 0x1C, 0x3C, 0x01, 0xE3, 0x80, 0xF1, 0xE0,
  0x0F, 0x1C, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x1C, 0xF0, 0x01, 0xCF, 0x00,
  0xE7, 0x80, 0x0F, 0x70, 0x07, 0xBC, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x03,
  0xDC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x78,
  0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x0E,
  0x70, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x38, 0x03, 0xC1, 0xC0,
  0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x03, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0x83, 0xE1, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFF, 0xE3,
  0xFF, 0xF3, 0xFF, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFB, 0xFF, 0xDC, 0xFF,
  0xCE, 0x3F, 0xC7, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x1F, 0x83, 0xCF, 0xF8, 0x7B, 0xFF, 0xCF, 0xF0, 0xF9, 0xF8, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xEF, 0xC0, 0x3D,
  0xFC, 0x0F, 0xBF, 0xFF, 0xE7, 0xBF, 0xF8, 0xE1, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0x1F, 0xFE, 0x1F, 0x8E, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x02, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7E, 0x3C, 0x3F, 0xF7,
  0x8F, 0xFF, 0x73, 0xF0, 0xFE, 0x78, 0x0F, 0xDE, 0x00, 0xFB, 0xC0, 0x0F,
  0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0xC7, 0xFF, 0xB8,
  0x7F, 0xE7, 0x07, 0xF8, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0x78, 0x3E, 0x3C, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3F, 0x01, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x70, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0xE1, 0xFF, 0x9C, 0x7F, 0xFB, 0x9F, 0x87, 0x73, 0xC0, 0x7E, 0xF0,
  0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0x70, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0,
  0x7E, 0x3F, 0xFD, 0xC3, 0xFF, 0x78, 0x3F, 0xCF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x8C, 0x01,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x3F, 0x0F, 0x3F, 0xF3,
  0xDF, 0xFE, 0xFF, 0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0xF7, 0xBF, 0xE2, 0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x07, 0x81,
  0xE0, 0x7C, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7B, 0xFC,
  0xFF, 0x3F, 0x83, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xDF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDE, 0x03, 0xE3, 0xC0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0xCF,
  0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0xFC, 0x07, 0xE1, 0xE7, 0xFC, 0x3F, 0xF3, 0xDF, 0xFC, 0xFF, 0xE7,
  0xF8, 0xFF, 0xC3, 0xEF, 0xC0, 0x7E, 0x03, 0xDF, 0x00, 0xFC, 0x03, 0xFE,
  0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xE0,
  0x07, 0x80, 0x3F, 0xC0, 0x0E, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0xFF, 0x00,
  0x38, 0x01, 0xFE, 0x00, 0x70, 0x03, 0xFC, 0x00, 0xE0, 0x07, 0xF8, 0x01,
  0xC0, 0x0F, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x3F, 0xC0, 0x0E,
  0x00, 0x7F, 0x80, 0x1C, 0x00, 0xFF, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x70,
  0x03, 0xFC, 0x00, 0xE0, 0x07, 0xF8, 0x01, 0xC0, 0x0F, 0xE0, 0xFC, 0x3C,
  0xFF, 0xCF, 0x7F, 0xFB, 0xFC, 0x3E, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xF0,
  0xF8, 0x3C, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0xE0, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0x87,
  0xCF, 0xC0, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0x7E, 0x01, 0xEF, 0xE0, 0x7D, 0xEF, 0xFF, 0x3D, 0xFF, 0xC7, 0x8F, 0xF0,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0xE1, 0xFF, 0x9C, 0x7F, 0xFB, 0x9F, 0x87,
  0x73, 0xC0, 0x7E, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F,
  0xBE, 0x01, 0xF3, 0xE0, 0x7E, 0x3F, 0xFD, 0xC3, 0xFF, 0x78, 0x3F, 0xCF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0xE0, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xEF, 0xE0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xF0, 0x7F, 0xFD, 0xFF, 0xF3,
  0xC0, 0xEF, 0x00, 0x5E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xDF, 0xFF, 0xBF,
  0xFE, 0x3F, 0xF0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F, 0xCF, 0xFF,
  0x73, 0xFF, 0x9C, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x39, 0xC0, 0x03, 0xDC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x0F, 0x80,
  0x3D, 0xE0, 0x1F, 0x80, 0x7B, 0xC0, 0x3F, 0x00, 0xE7, 0x80, 0x7E, 0x03,
  0xC7, 0x81, 0xFC, 0x07, 0x8F, 0x03, 0xBC, 0x0F, 0x1E, 0x07, 0x38, 0x1C,
  0x1C, 0x0E, 0x70, 0x78, 0x38, 0x3C, 0xE0, 0xF0, 0x78, 0x71, 0xE1, 0xE0,
  0xF0, 0xE1, 0xC3, 0x80, 0xE3, 0xC3, 0x8F, 0x01, 0xC7, 0x87, 0x1E, 0x03,
  0xCE, 0x0F, 0x3C, 0x07, 0x9C, 0x0E, 0x70, 0x07, 0x78, 0x1C, 0xE0, 0x0E,
  0xE0, 0x3B, 0xC0, 0x1D, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1E, 0x1E, 0x03, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x07, 0xBC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x78, 0x3C, 0x0F,
  0x07, 0x83, 0xC0, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0xF7, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xE3,
  0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1E, 0x03, 0x81, 0xE0, 0x78,
  0x0E, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x8E,
  0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0, 0x03, 0xDC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x03, 0xF8, 0x0F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xFC, 0x0F, 0x80, 0x70, 0x00, 0x3F, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE8, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 32, 11, 3, -31 },
  { 21, 12, 11, 17, 3, -31 },
  { 38, 23, 31, 25, 1, -31 },
  { 128, 19, 36, 23, 2, -33 },
  { 214, 30, 32, 34, 2, -32 },
  { 334, 26, 32, 28, 2, -32 },
  { 438, 4, 11, 10, 3, -31 },
  { 444, 10, 39, 13, 2, -32 },
  { 493, 10, 39, 13, 1, -32 },
  { 542, 18, 17, 22, 2, -33 },
  { 581, 19, 21, 23, 2, -26 },
  { 631, 6, 11, 11, 2, -5 },
  { 640, 10, 4, 13, 2, -14 },
  { 645, 5, 6, 11, 3, -5 },
  { 649, 15, 31, 16, 1, -31 },
  { 708, 19, 32, 23, 2, -32 },
  { 784, 12, 31, 23, 3, -31 },
  { 831, 19, 32, 23, 2, -32 },
  { 907, 19, 32, 23, 2, -32 },
  { 983, 21, 32, 23, 1, -32 },
  { 1067, 18, 31, 23, 3, -31 },
  { 1137, 19, 32, 23, 2, -32 },
  { 1213, 19, 31, 23, 2, -31 },
  { 1287, 19, 32, 23, 2, -32 },
  { 1363, 19, 32, 23, 2, -32 },
  { 1439, 5, 25, 11, 3, -24 },
  { 1455, 7, 30, 11, 1, -24 },
  { 1482, 19, 21, 23, 2, -26 },
  { 1532, 19, 13, 23, 2, -22 },
  { 1563, 19, 21, 23, 2, -26 },
  { 1613, 15, 33, 17, 1, -32 },
  { 1675, 31, 36, 36, 2, -32 },
  { 1815, 25, 32, 25, 0, -32 },
  { 1915, 20, 31, 26, 4, -31 },
  { 1993, 21, 32, 25, 3, -32 },
  { 2077, 22, 31, 29, 4, -31 },
  { 2163, 16, 31, 22, 4, -31 },
  { 2225, 16, 31, 21, 4, -31 },
  { 2287, 23, 32, 29, 3, -32 },
  { 2379, 21, 31, 29, 4, -31 },
  { 2461, 10, 31, 14, 2, -31 },
  { 2500, 11, 39, 11, -3, -31 },
  { 2554, 21, 31, 24, 4, -31 },
  { 2636, 16, 31, 21, 4, -31 },
  { 2698, 29, 31, 37, 4, -31 },
  { 2811, 22, 31, 30, 4, -31 },
  { 2897, 25, 32, 31, 3, -32 },
  { 2997, 18, 31, 24, 4, -31 },
  { 3067, 25, 39, 31, 3, -32 },
  { 3189, 20, 31, 25, 4, -31 },
  { 3267, 18, 32, 22, 2, -32 },
  { 3339, 21, 31, 22, 0, -31 },
  { 3421, 21, 31, 29, 4, -31 },
  { 3503, 24, 31, 24, 0, -31 },
  { 3596, 37, 31, 38, 0, -31 },
  { 3740, 23, 31, 23, 0, -31 },
  { 3830, 22, 31, 22, 0, -31 },
  { 3916, 19, 31, 22, 1, -31 },
  { 3990, 10, 39, 14, 3, -32 },
  { 4039, 15, 31, 16, 1, -31 },
  { 4098, 10, 39, 14, 1, -32 },
  { 4147, 21, 19, 23, 1, -32 },
  { 4197, 19, 3, 19, 0, 4 },
  { 4205, 8, 7, 12, 2, -34 },
  { 4212, 17, 24, 22, 2, -24 },
  { 4263, 19, 33, 25, 3, -33 },
  { 4342, 16, 24, 19, 2, -24 },
  { 4390, 19, 33, 25, 2, -33 },
  { 4469, 18, 24, 22, 2, -24 },
  { 4523, 14, 34, 14, 1, -34 },
  { 4583, 19, 35, 25, 2, -24 },
  { 4667, 18, 33, 25, 3, -33 },
  { 4742, 5, 32, 11, 3, -32 },
  { 4762, 10, 43, 11, -2, -32 },
  { 4816, 18, 33, 21, 3, -33 },
  { 4891, 4, 33, 11, 3, -33 },
  { 4908, 31, 24, 37, 3, -24 },
  { 5001, 18, 24, 25, 3, -24 },
  { 5055, 20, 24, 24, 2, -24 },
  { 5115, 19, 35, 25, 3, -24 },
  { 5199, 19, 35, 25, 2, -24 },
  { 5283, 13, 24, 16, 3, -24 },
  { 5322, 15, 24, 19, 2, -24 },
  { 5367, 12, 29, 14, 1, -29 },
  { 5411, 18, 24, 25, 3, -24 },
  { 5465, 20, 24, 20, 0, -24 },
  { 5525, 31, 24, 32, 0, -24 },
  { 5618, 19, 24, 21, 1, -24 },
  { 5675, 20, 35, 20, 0, -24 },
  { 5763, 16, 24, 18, 1, -24 },
  { 5811, 14, 38, 16, 1, -31 },
  { 5878, 4, 44, 22, 9, -33 },
  { 5900, 13, 38, 16, 2, -31 },
  { 5962, 19, 5, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Regular44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR44PT7B_H_
