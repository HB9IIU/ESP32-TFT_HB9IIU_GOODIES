#ifndef _NOTOSANS_SEMICONDENSED_REGULAR32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xFF,
  0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E, 0x37, 0x1B, 0x8C, 0xC6, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x18,
  0x60, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x61, 0x83, 0xFF, 0xFD, 0xFF, 0xFE, 0x18, 0x70, 0x0C, 0x30,
  0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x06,
  0x00, 0x30, 0x01, 0xC0, 0x7F, 0xE7, 0xFF, 0x73, 0x0B, 0x98, 0x18, 0xC0,
  0xC6, 0x07, 0x30, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1B, 0xC0,
  0xC7, 0x06, 0x38, 0x31, 0xC1, 0x8F, 0x8C, 0xEF, 0xFF, 0x7F, 0xE0, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x1E, 0x01, 0xC0, 0xFC, 0x06, 0x06,
  0x30, 0x38, 0x18, 0x60, 0xC0, 0x61, 0x83, 0x01, 0x86, 0x18, 0x0E, 0x18,
  0x60, 0x38, 0x63, 0x00, 0x61, 0x8C, 0x01, 0x86, 0x63, 0xC6, 0x19, 0x9F,
  0x9C, 0xCE, 0xE6, 0x3F, 0x33, 0x1C, 0x79, 0xCC, 0x30, 0x06, 0x30, 0xC0,
  0x39, 0xC3, 0x00, 0xC7, 0x0C, 0x07, 0x0C, 0x30, 0x18, 0x30, 0xC0, 0xE0,
  0xC3, 0x03, 0x03, 0x1C, 0x1C, 0x07, 0xE0, 0x60, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xFE, 0x00, 0x71, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x80, 0x70, 0x60,
  0x06, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x03, 0xDC, 0x1C, 0xF1, 0xC3, 0x9C, 0x3C, 0x63, 0x03, 0xDC,
  0xE0, 0x3F, 0x9C, 0x03, 0xE3, 0x80, 0x38, 0x38, 0x0F, 0x87, 0x87, 0xF8,
  0x7F, 0xE3, 0x87, 0xF8, 0x78, 0xFF, 0xFF, 0xFB, 0x07, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0x61, 0xC7,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x73, 0x3B, 0xFF, 0xE3,
  0xFF, 0x41, 0xE0, 0x0D, 0xC0, 0x73, 0x01, 0xCE, 0x0E, 0x1C, 0x08, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x39, 0xDC, 0xE7, 0x31, 0x9C, 0xFF, 0xFF, 0xFF, 0x6F,
  0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x7F, 0x83, 0xC7, 0x0E, 0x0E, 0x70, 0x39, 0xC0, 0x67, 0x01,
  0xD8, 0x07, 0x60, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80,
  0x76, 0x01, 0xD8, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x03, 0x8E, 0x0E, 0x3C,
  0x70, 0x7F, 0xC0, 0xFC, 0x00, 0x07, 0x0F, 0x1F, 0x7F, 0xF7, 0xE7, 0x47,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x1F, 0xC0, 0xFF, 0xC7, 0x8F, 0x18, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF,
  0xCF, 0x8F, 0x90, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0xC1, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0xE0, 0x7B, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x3F, 0x00,
  0x6E, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC3,
  0x83, 0x07, 0x0C, 0x0E, 0x38, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0xFC, 0x3F, 0xF8, 0xC3, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xEC, 0x1F, 0x7F, 0xF3, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0x8F, 0x84, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x7E, 0x37, 0xFD, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0xE7, 0x8F, 0x1F, 0xF0,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0x87,
  0x9C, 0x0E, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0x9C, 0x0E, 0x38, 0x78, 0x7B,
  0xC0, 0xFC, 0x03, 0xF0, 0x1D, 0xF0, 0xE1, 0xE7, 0x03, 0xD8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x07, 0x78, 0x38, 0xFF, 0xC1, 0xFE, 0x00,
  0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1C, 0x0E, 0x70, 0x39, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0xDE, 0x1F, 0x3F, 0xFC, 0x7F,
  0x70, 0x21, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0xF0, 0x7B, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xEE,
  0x73, 0x99, 0xCC, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x0C,
  0x00, 0x00, 0x3F, 0x8F, 0xFC, 0x71, 0xE4, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x3C,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0xE7, 0x03, 0xC1, 0x98, 0x3F, 0xC7, 0x61,
  0xC7, 0x0F, 0x8E, 0x1C, 0x3C, 0x30, 0x70, 0xF0, 0xC1, 0xC3, 0xC3, 0x07,
  0x0F, 0x0C, 0x1C, 0x3C, 0x30, 0x70, 0xF0, 0xC1, 0xC7, 0xC3, 0x8F, 0x1B,
  0x0F, 0xEF, 0xEE, 0x1F, 0x9F, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x08, 0x07, 0xC1, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xCC, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x07, 0x18, 0x01, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0x30, 0x0C, 0x0E, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xFC, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0xB8, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xB8, 0x0E,
  0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xCF, 0xFE,
  0x3F, 0xF8, 0xE0, 0xFB, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE1, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xFC, 0x7C, 0x79, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8,
  0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE3, 0xF8,
  0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xFE, 0x07, 0xFF,
  0xC7, 0xE3, 0xC7, 0x80, 0x23, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDE, 0x00,
  0xE7, 0x80, 0x71, 0xF0, 0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0x80, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0xBE, 0xFC, 0xF8, 0xE0, 0x1F, 0xC0,
  0x73, 0x80, 0xE7, 0x03, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0,
  0xE7, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x70, 0x1C, 0x70, 0x38,
  0xE0, 0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0x81, 0xC7, 0x03, 0xCE, 0x03,
  0x9C, 0x03, 0xB8, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFD,
  0x80, 0x1F, 0xEE, 0x00, 0xFF, 0x70, 0x06, 0xF9, 0x80, 0x77, 0xCE, 0x03,
  0xBE, 0x70, 0x19, 0xF1, 0x81, 0xCF, 0x8E, 0x0C, 0x7C, 0x30, 0x63, 0xE1,
  0x87, 0x1F, 0x0E, 0x30, 0xF8, 0x31, 0x87, 0xC1, 0xDC, 0x3E, 0x0E, 0xC1,
  0xF0, 0x36, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x38, 0x1F, 0x01,
  0xC0, 0xE0, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xDC, 0x03,
  0xDC, 0x03, 0xCE, 0x03, 0xCE, 0x03, 0xC7, 0x03, 0xC7, 0x03, 0xC3, 0x83,
  0xC3, 0xC3, 0xC1, 0xC3, 0xC0, 0xE3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x73,
  0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0x07, 0xF8, 0x03, 0xFF, 0x83, 0xF1, 0xF0, 0xE0, 0x1C, 0x70, 0x03, 0x9C,
  0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x38, 0xE0, 0x1E, 0x3E, 0x1F, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x07, 0xFF, 0x3F, 0xFD, 0xC0, 0xEE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC7, 0xEF,
  0xFE, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xF1,
  0xF0, 0xE0, 0x1E, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00,
  0x38, 0xE0, 0x1E, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC7, 0x03, 0x8E, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0xF3, 0x83, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x38,
  0x70, 0x70, 0xE0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xC7, 0x03, 0xCE, 0x03,
  0x9C, 0x03, 0xB8, 0x07, 0x80, 0x0F, 0xF0, 0xFF, 0xE3, 0xE7, 0x9C, 0x02,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0xF0, 0xFB, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xE7, 0x83, 0xC7, 0xFF, 0x07,
  0xFC, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00,
  0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x18, 0x0E, 0x0E, 0x06, 0x07,
  0x07, 0x01, 0x83, 0x80, 0xE1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70,
  0x07, 0x70, 0x03, 0xB8, 0x00, 0xDC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x01, 0xC0, 0x1D, 0xC0, 0x3C,
  0x03, 0x38, 0x0F, 0x80, 0xE7, 0x01, 0xB0, 0x1C, 0x60, 0x36, 0x03, 0x8E,
  0x06, 0xE0, 0x61, 0xC1, 0xDC, 0x1C, 0x38, 0x39, 0x83, 0x83, 0x06, 0x30,
  0x70, 0x71, 0xC7, 0x0C, 0x0E, 0x38, 0xE3, 0x81, 0xC7, 0x0C, 0x70, 0x18,
  0xC1, 0x8E, 0x03, 0xB8, 0x39, 0x80, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0x6E,
  0x00, 0xD8, 0x0D, 0xC0, 0x1B, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x70,
  0x0E, 0x38, 0x0E, 0x18, 0x1C, 0x1C, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x07,
  0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38,
  0x1E, 0x30, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70,
  0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x18, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFC,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x03,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0x9C, 0x07, 0x18,
  0x0C, 0x38, 0x38, 0x30, 0x60, 0x71, 0xC0, 0x63, 0x00, 0xE6, 0x00, 0xDC,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE1, 0xC1, 0xC0, 0xC0,
  0x1F, 0xE1, 0xFF, 0x84, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE1,
  0xFF, 0x3F, 0xFB, 0xC1, 0xDC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3D, 0xC3,
  0xEF, 0xFB, 0x3F, 0x18, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xE0, 0xEF, 0x03, 0xBC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x3B, 0xE1, 0xEE, 0xFF, 0x39, 0xF8, 0x1F, 0xE7,
  0xF9, 0xE1, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x19, 0xFF, 0x1F, 0xC0, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xF3, 0x3F,
  0xDB, 0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xBC, 0x3C, 0xFF, 0x63,
  0xF3, 0x1F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0xC7, 0xFE, 0x1F, 0xE0, 0x07, 0xE1, 0xFC, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x03, 0xFE, 0xFF, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1F, 0x99, 0xFE, 0xDC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8,
  0x1D, 0xE1, 0xE7, 0xFB, 0x1F, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0xA0, 0x3D, 0xFF, 0xCF, 0xFC, 0x1F, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xFE, 0xEF, 0xF7, 0xC1, 0xFC,
  0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0x7F, 0xB0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x71, 0xC3, 0x00, 0x00,
  0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xB8, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xE0, 0xF7, 0x07, 0x38,
  0x71, 0xC7, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0xE0, 0xF7, 0x87, 0x1C,
  0x38, 0x71, 0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0x81, 0xDC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xE3, 0xF9, 0xDF, 0xEF,
  0xFB, 0xE1, 0xF8, 0x77, 0x81, 0xE0, 0xEF, 0x03, 0x80, 0xFC, 0x07, 0x01,
  0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F,
  0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8,
  0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0E, 0xE7, 0xF7, 0x7F, 0xBE,
  0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x18,
  0x1F, 0xC0, 0xFF, 0xC7, 0x07, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x39, 0xC0,
  0xE7, 0x87, 0x0F, 0xF8, 0x1F, 0xC0, 0xE7, 0xE3, 0xBF, 0xCF, 0x83, 0xBC,
  0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x87, 0xBB, 0xFC, 0xE7, 0xE3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1F, 0x99, 0xFE, 0xDC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8,
  0x1D, 0xE1, 0xE7, 0xFB, 0x1F, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xE7, 0xFB, 0xEF, 0xC3, 0xE0,
  0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xEF, 0xFD, 0xC1, 0x70, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xF0, 0x3F, 0xFE, 0x7F, 0x80, 0x10, 0x18, 0x0C, 0x06, 0x0F, 0xFF, 0xFC,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0xF1, 0xF8, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xB8, 0x1D, 0xC3, 0xEF, 0xFB, 0x1F, 0x98, 0xE0, 0x1E, 0xC0,
  0x39, 0xC0, 0x73, 0x80, 0xC3, 0x03, 0x87, 0x07, 0x0E, 0x0C, 0x0C, 0x38,
  0x1C, 0x70, 0x38, 0xC0, 0x33, 0x80, 0x77, 0x00, 0xEC, 0x00, 0xD8, 0x01,
  0xF0, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x19, 0xC1,
  0xF0, 0x73, 0x83, 0x60, 0xE7, 0x06, 0xC1, 0xC6, 0x1D, 0xC3, 0x0E, 0x3B,
  0x8E, 0x1C, 0x63, 0x1C, 0x18, 0xC6, 0x30, 0x33, 0x8E, 0x60, 0x77, 0x1D,
  0xC0, 0xEC, 0x1B, 0x80, 0xD8, 0x36, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF8,
  0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0xE0, 0x39, 0xC1, 0xC7, 0x07, 0x0E,
  0x38, 0x1C, 0xC0, 0x77, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x00,
  0xDC, 0x07, 0x70, 0x38, 0xE0, 0xE3, 0x87, 0x07, 0x38, 0x0E, 0xE0, 0x3C,
  0xE0, 0x0E, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0xC3, 0x03, 0x87, 0x07, 0x0E,
  0x0C, 0x0C, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x33, 0x80, 0x77, 0x00, 0x6C,
  0x00, 0xD8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0x7F,
  0xEF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xC1, 0xF0, 0xF8, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x3C, 0x3E, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0xC0, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x70, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0F, 0x01, 0xF0,
  0x3C, 0x3C, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x0F, 0x0F, 0x83, 0x80, 0x7E, 0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0x1C,
};

const GFXglyph NotoSans_SemiCondensed_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 9, 8, 13, 2, -23 },
  { 22, 17, 23, 19, 1, -23 },
  { 71, 13, 26, 17, 2, -24 },
  { 114, 22, 23, 25, 1, -23 },
  { 178, 19, 23, 20, 1, -23 },
  { 233, 3, 8, 7, 2, -23 },
  { 236, 8, 28, 10, 1, -23 },
  { 264, 7, 28, 10, 1, -23 },
  { 289, 14, 13, 16, 1, -24 },
  { 312, 14, 15, 17, 1, -19 },
  { 339, 5, 8, 8, 1, -4 },
  { 344, 8, 3, 10, 1, -10 },
  { 347, 4, 4, 8, 2, -4 },
  { 349, 12, 23, 12, 0, -23 },
  { 384, 14, 23, 17, 1, -23 },
  { 425, 8, 23, 17, 3, -23 },
  { 448, 14, 23, 17, 1, -23 },
  { 489, 14, 23, 17, 1, -23 },
  { 530, 15, 23, 17, 1, -23 },
  { 574, 13, 23, 17, 2, -23 },
  { 612, 13, 23, 17, 2, -23 },
  { 650, 14, 23, 17, 1, -23 },
  { 691, 14, 23, 17, 1, -23 },
  { 732, 14, 23, 17, 1, -23 },
  { 773, 4, 17, 8, 2, -17 },
  { 782, 5, 21, 8, 1, -17 },
  { 796, 14, 15, 17, 1, -19 },
  { 823, 14, 9, 17, 1, -16 },
  { 839, 14, 15, 17, 1, -19 },
  { 866, 12, 23, 13, 0, -23 },
  { 901, 22, 26, 26, 2, -23 },
  { 973, 18, 23, 18, 0, -23 },
  { 1025, 14, 23, 19, 3, -23 },
  { 1066, 15, 23, 18, 2, -23 },
  { 1110, 16, 23, 21, 3, -23 },
  { 1156, 11, 23, 16, 3, -23 },
  { 1188, 11, 23, 15, 3, -23 },
  { 1220, 17, 23, 21, 2, -23 },
  { 1269, 15, 23, 21, 3, -23 },
  { 1313, 8, 23, 10, 1, -23 },
  { 1336, 8, 29, 8, -2, -23 },
  { 1365, 15, 23, 18, 3, -23 },
  { 1409, 11, 23, 15, 3, -23 },
  { 1441, 21, 23, 27, 3, -23 },
  { 1502, 16, 23, 22, 3, -23 },
  { 1548, 18, 23, 22, 2, -23 },
  { 1600, 13, 23, 17, 3, -23 },
  { 1638, 18, 28, 22, 2, -23 },
  { 1701, 15, 23, 18, 3, -23 },
  { 1745, 14, 23, 16, 1, -23 },
  { 1786, 15, 23, 16, 0, -23 },
  { 1830, 15, 23, 21, 3, -23 },
  { 1874, 17, 23, 17, 0, -23 },
  { 1923, 27, 23, 27, 0, -23 },
  { 2001, 16, 23, 17, 0, -23 },
  { 2047, 16, 23, 16, 0, -23 },
  { 2093, 14, 23, 16, 1, -23 },
  { 2134, 7, 28, 10, 2, -23 },
  { 2159, 12, 23, 12, 0, -23 },
  { 2194, 7, 28, 10, 1, -23 },
  { 2219, 15, 14, 17, 1, -23 },
  { 2246, 14, 2, 14, 0, 3 },
  { 2250, 7, 6, 9, 1, -25 },
  { 2256, 13, 17, 16, 1, -17 },
  { 2284, 14, 24, 18, 2, -24 },
  { 2326, 11, 17, 14, 2, -17 },
  { 2350, 13, 24, 18, 2, -24 },
  { 2389, 13, 17, 16, 2, -17 },
  { 2417, 11, 24, 10, 0, -24 },
  { 2450, 13, 25, 18, 2, -17 },
  { 2491, 13, 24, 18, 2, -24 },
  { 2530, 3, 24, 8, 2, -24 },
  { 2539, 6, 32, 8, -1, -24 },
  { 2563, 13, 24, 16, 2, -24 },
  { 2602, 3, 24, 8, 2, -24 },
  { 2611, 23, 17, 27, 2, -17 },
  { 2660, 13, 17, 18, 2, -17 },
  { 2688, 14, 17, 17, 2, -17 },
  { 2718, 14, 25, 18, 2, -17 },
  { 2762, 13, 25, 18, 2, -17 },
  { 2803, 10, 17, 12, 2, -17 },
  { 2825, 11, 17, 14, 1, -17 },
  { 2849, 9, 21, 10, 1, -21 },
  { 2873, 13, 17, 18, 2, -17 },
  { 2901, 15, 17, 15, 0, -17 },
  { 2933, 23, 17, 23, 0, -17 },
  { 2982, 14, 17, 15, 1, -17 },
  { 3012, 15, 25, 15, 0, -17 },
  { 3059, 11, 17, 13, 1, -17 },
  { 3083, 10, 28, 12, 1, -23 },
  { 3118, 2, 32, 16, 7, -24 },
  { 3126, 10, 28, 12, 1, -23 },
  { 3161, 14, 4, 17, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Regular32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR32PT7B_H_
