#ifndef _NOTOSANS_SEMICONDENSED_REGULAR51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7,
  0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0x3E, 0xFB, 0xFF, 0xBE, 0x20, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F,
  0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE3, 0x83, 0x3E, 0x1C, 0x01, 0xE0,
  0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1F, 0x0E, 0x00,
  0xFC, 0x70, 0x03, 0xFB, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0E, 0xFE, 0x00, 0x71, 0xF0,
  0x03, 0x87, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x38,
  0x3C, 0x01, 0xC3, 0xF8, 0x0E, 0x3E, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x1E, 0x7C,
  0x00, 0xF0, 0x07, 0x87, 0x80, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0x00,
  0x1E, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x38, 0x00, 0x78, 0x0E, 0x0F,
  0x00, 0x0F, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0x38, 0x78, 0x00, 0x3C, 0x0F,
  0x0F, 0x00, 0x03, 0x81, 0xE3, 0xC3, 0xF0, 0x70, 0x3C, 0x78, 0xFF, 0x0F,
  0x07, 0x9E, 0x3F, 0xF1, 0xE1, 0xE3, 0xCF, 0x0F, 0x1E, 0x7C, 0xF1, 0xE1,
  0xE3, 0xFF, 0x1E, 0x38, 0x1C, 0x3F, 0xC7, 0x8F, 0x03, 0xC1, 0xF0, 0xF1,
  0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x07, 0x87, 0x81, 0xE0, 0x00,
  0xE0, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0x38, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x78, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x0E, 0x00,
  0x78, 0x78, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x1E,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xC1, 0xFB, 0xF0, 0x0F, 0x07, 0xC3, 0xF0, 0x1E, 0x1F, 0x83, 0xF0,
  0x7C, 0x3E, 0x03, 0xF0, 0xF0, 0x78, 0x03, 0xE1, 0xE1, 0xF0, 0x03, 0xE7,
  0xC3, 0xE0, 0x03, 0xEF, 0x07, 0xC0, 0x03, 0xFE, 0x0F, 0x80, 0x07, 0xF8,
  0x1F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0xE0,
  0x7E, 0x01, 0xFF, 0xE0, 0x7F, 0xBF, 0xF7, 0xC0, 0x7F, 0xFF, 0x87, 0xC0,
  0x7F, 0xFE, 0x07, 0xC0, 0x7F, 0xF0, 0x0F, 0xE0, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x02, 0x01,
  0xC0, 0x2E, 0x0E, 0x0F, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0xF1,
  0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xC7, 0x9F, 0x3C, 0x78, 0xF1, 0xC7, 0x8E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x79, 0xFF, 0xFF, 0x7D, 0xF1, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x78, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7F, 0x3F, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x9F, 0xBD, 0xF9, 0xFF, 0x8F,
  0x70, 0x79, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFE, 0x07, 0xE0,
  0xE0, 0x07, 0xC3, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7C, 0x03, 0xF0, 0xC0, 0x07, 0xC2, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xA0, 0x00, 0x3E, 0xC0, 0x03, 0xF3, 0xF0,
  0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xF3, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFA, 0x00, 0x0F, 0xD8, 0x00, 0xFC, 0xFC, 0x1F, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC1, 0xF8, 0x1E, 0x3F, 0xF0, 0xF3, 0xFF, 0xC7, 0xBF, 0xFF, 0x3F, 0xC0,
  0xFD, 0xF8, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3E,
  0x03, 0xF0, 0xFC, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x07,
  0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x3E, 0x03,
  0xF3, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x0F, 0x8F, 0xE0, 0x7C, 0x0F, 0xC3, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0x78, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00,
  0xF8, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xCF, 0xE1, 0xFF, 0x1F, 0xFF,
  0x7C, 0x3F, 0xFD, 0xF0, 0x7F, 0xC7, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x40, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x39, 0xF7, 0xFF, 0x7D, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFF, 0xF7, 0xDF, 0x10, 0x1C, 0x7D,
  0xFB, 0xF7, 0xE7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x79, 0xF3, 0xE7, 0x8F,
  0x1E, 0x78, 0xF1, 0xC3, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x78, 0x1F, 0x90, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x30, 0x03, 0xC3,
  0xC0, 0x3F, 0xF8, 0x1C, 0x78, 0x07, 0xFF, 0x81, 0xE7, 0x80, 0xFD, 0xF8,
  0x1E, 0x78, 0x1E, 0x03, 0x80, 0xE7, 0x03, 0xE0, 0x38, 0x0E, 0xF0, 0x3C,
  0x07, 0x80, 0xEF, 0x03, 0xC0, 0x78, 0x0E, 0xF0, 0x78, 0x07, 0x80, 0xFE,
  0x07, 0x80, 0x78, 0x0E, 0xE0, 0x78, 0x07, 0x80, 0xEE, 0x07, 0x80, 0x78,
  0x0E, 0xE0, 0x78, 0x07, 0x80, 0xEE, 0x07, 0x80, 0x78, 0x0E, 0xE0, 0x78,
  0x07, 0x81, 0xEF, 0x07, 0x80, 0xF8, 0x1C, 0xF0, 0x3C, 0x0F, 0x83, 0xCF,
  0x03, 0xE1, 0xDC, 0x3C, 0xF0, 0x1F, 0xFD, 0xFF, 0x87, 0x01, 0xFF, 0x8F,
  0xF0, 0x78, 0x07, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x7C,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xC0, 0xFF, 0xCF, 0x80, 0x1F, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0,
  0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0xC0, 0x0F, 0xCF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x7C,
  0x00, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xF0, 0x1E, 0x0F, 0xC0, 0x02, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x02, 0x07, 0xFE, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x02, 0x80, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0xF8, 0x01, 0xFC,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0xE3, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x7C, 0x1F, 0xC0, 0x01, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xFC, 0x00, 0x0F, 0x0F, 0xE0, 0x01,
  0xE0, 0xFF, 0xE7, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE8, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF,
  0x07, 0x80, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF9,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFD, 0xE0, 0x00, 0x0F, 0xFF, 0x78, 0x00, 0x07, 0xBF, 0xCF, 0x00,
  0x01, 0xEF, 0xFB, 0xC0, 0x00, 0x7B, 0xFE, 0xF0, 0x00, 0x3C, 0xFF, 0x9E,
  0x00, 0x0F, 0x3F, 0xE7, 0x80, 0x03, 0xCF, 0xF9, 0xE0, 0x01, 0xE3, 0xFE,
  0x3C, 0x00, 0x78, 0xFF, 0x8F, 0x00, 0x1E, 0x3F, 0xE3, 0xC0, 0x0F, 0x0F,
  0xF8, 0x78, 0x03, 0xC3, 0xFE, 0x1E, 0x00, 0xF0, 0xFF, 0x87, 0x80, 0x78,
  0x3F, 0xE0, 0xF0, 0x1E, 0x0F, 0xF8, 0x3C, 0x0F, 0x03, 0xFE, 0x0F, 0x83,
  0xC0, 0xFF, 0x81, 0xE0, 0xF0, 0x3F, 0xE0, 0x78, 0x78, 0x0F, 0xF8, 0x1F,
  0x1E, 0x03, 0xFE, 0x03, 0xC7, 0x80, 0xFF, 0x80, 0xF3, 0xC0, 0x3F, 0xE0,
  0x3E, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0x80,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFD, 0xF0, 0x00,
  0x7F, 0xBE, 0x00, 0x0F, 0xF3, 0xE0, 0x01, 0xFF, 0x7C, 0x00, 0x3F, 0xE7,
  0xC0, 0x07, 0xFC, 0x7C, 0x00, 0xFF, 0x8F, 0x80, 0x1F, 0xF0, 0xF8, 0x03,
  0xFE, 0x1F, 0x00, 0x7F, 0xC1, 0xF0, 0x0F, 0xF8, 0x3E, 0x01, 0xFF, 0x03,
  0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0x7C, 0x1F,
  0xF0, 0x0F, 0x83, 0xFE, 0x00, 0xF8, 0x7F, 0xC0, 0x1F, 0x0F, 0xF8, 0x01,
  0xF1, 0xFF, 0x00, 0x3E, 0x3F, 0xE0, 0x03, 0xE7, 0xFC, 0x00, 0x3E, 0xFF,
  0x80, 0x07, 0xDF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3E, 0x1F,
  0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x03,
  0xF3, 0xE0, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1B, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x07,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x1F, 0x1F,
  0x00, 0x11, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0xE0, 0x03,
  0xF7, 0xFD, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07,
  0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x03,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0xC0,
  0x03, 0xE3, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x7F, 0x00, 0x0F,
  0x8F, 0x80, 0x0E, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xDE, 0x00, 0x3C, 0x1E,
  0x00, 0x7B, 0xC0, 0x0F, 0x83, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0x7C, 0x01,
  0xE7, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x1E,
  0x01, 0xF0, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x3C, 0x07,
  0x80, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x00,
  0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0x03, 0xE1,
  0xE0, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x07, 0x87, 0xC0, 0x07, 0x87, 0x80,
  0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x01, 0xE3,
  0xC0, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x03, 0xDF, 0x00,
  0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x1F,
  0xF0, 0x01, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0xC0,
  0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x78, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xFB, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0,
  0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7B, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x00, 0x0F, 0x0F, 0x00, 0x1E,
  0x0E, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x38, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x03, 0xE0, 0x80, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x0F,
  0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xF7, 0x80, 0x7F, 0x7E, 0x0F, 0xF3, 0xFF,
  0xEF, 0x3F, 0xFC, 0x70, 0xFF, 0x87, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0xF1, 0xFF, 0x83, 0xCF, 0xFF, 0x0F,
  0x7F, 0xFE, 0x3F, 0xC0, 0xFC, 0xFE, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00,
  0x1E, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xE0, 0x1F, 0x3F, 0xE1, 0xFC,
  0xF7, 0xFF, 0xE3, 0xCF, 0xFF, 0x0E, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x03, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x02, 0x3F, 0x87, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x1F, 0x07, 0xFE, 0x7C, 0x7F, 0xFD, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0,
  0xFF, 0x7C, 0x01, 0xFD, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC1, 0xFF, 0x1F, 0xFF, 0x3C, 0x3F,
  0xF8, 0xF0, 0x7F, 0xC3, 0xC0, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x7E, 0x3E, 0x01, 0xF1, 0xE0,
  0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x04, 0x3F, 0xC3,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0xF1, 0xFF, 0xF3, 0xCF, 0xFF, 0xEF, 0x3F, 0x07,
  0xFD, 0xF0, 0x07, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF7,
  0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x3F, 0x07, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF,
  0xE7, 0xC1, 0xFF, 0x1F, 0x00, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x9C,
  0x00, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x1F, 0xF8, 0x79,
  0xFF, 0xE3, 0xDF, 0xFF, 0x9F, 0xE0, 0x7E, 0xFE, 0x01, 0xF7, 0xE0, 0x07,
  0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x67, 0xBF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x01, 0x80, 0x78, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0xBF,
  0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F,
  0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x7E, 0x00, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0xFE, 0xF0,
  0x0F, 0xCF, 0x80, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01,
  0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x7C, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x1E, 0x3F, 0xF0, 0x7F, 0xE3,
  0xCF, 0xFF, 0x1F, 0xFE, 0x7B, 0xFF, 0xE7, 0xFF, 0xEF, 0xF0, 0x7F, 0xE0,
  0x7D, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xE0,
  0x07, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xE0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0x80,
  0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x07,
  0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xE0,
  0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x0F,
  0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC0,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x07, 0x8F, 0xFC, 0x3C,
  0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xF0, 0x3F, 0x7E, 0x00, 0xFB, 0xF0, 0x03,
  0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F,
  0x80, 0x7C, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x03, 0xC7, 0xFE, 0x0F, 0x3F, 0xFC,
  0x3D, 0xFF, 0xF8, 0xFF, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xF8,
  0x00, 0x7B, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x7C, 0xFF, 0x87,
  0xE3, 0xDF, 0xFF, 0x8F, 0x3F, 0xFC, 0x3C, 0x3F, 0xC0, 0xF0, 0x18, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0xF1,
  0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0x03, 0xFD, 0xF0, 0x07, 0xF7, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x7F,
  0x3F, 0x07, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC1, 0xFF, 0x1F, 0x00,
  0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xC7, 0xFF,
  0x3F, 0xFD, 0xFF, 0xF7, 0xC7, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7C, 0x03, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x3E, 0xF8, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xF0, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0x80, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xE1, 0xFF,
  0x7F, 0xFE, 0x79, 0xFF, 0xE3, 0xC3, 0xFE, 0x1E, 0x03, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0,
  0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00,
  0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x1E,
  0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC7, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0x7C, 0x01, 0xFC, 0x01, 0xE7, 0x80,
  0x3F, 0x80, 0x3C, 0xF0, 0x0F, 0x70, 0x0F, 0x9F, 0x01, 0xEF, 0x01, 0xE1,
  0xE0, 0x3D, 0xE0, 0x3C, 0x3C, 0x07, 0x3C, 0x07, 0x87, 0x81, 0xE3, 0x81,
  0xF0, 0xF8, 0x3C, 0x78, 0x3C, 0x0F, 0x07, 0x8F, 0x07, 0x81, 0xE1, 0xE1,
  0xE0, 0xF0, 0x3C, 0x3C, 0x1E, 0x3E, 0x07, 0xC7, 0x83, 0xC7, 0x80, 0x78,
  0xF0, 0x78, 0xF0, 0x0F, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x03, 0xDC, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x7B,
  0xC0, 0x0F, 0xF0, 0x07, 0x78, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE3, 0xE0, 0x1F,
  0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x7C, 0x01,
  0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x7C, 0x00,
  0xF9, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x02,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x0F,
  0xF0, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0xC0,
  0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFE, 0x7F, 0xFF, 0xC0, 0x3F, 0xFA,
  0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 37, 13, 4, -36 },
  { 29, 14, 13, 20, 3, -36 },
  { 52, 27, 36, 29, 1, -36 },
  { 174, 21, 42, 27, 3, -39 },
  { 285, 35, 38, 39, 2, -37 },
  { 452, 31, 38, 33, 2, -37 },
  { 600, 5, 13, 11, 3, -36 },
  { 609, 12, 45, 15, 2, -37 },
  { 677, 11, 45, 15, 2, -37 },
  { 739, 21, 21, 25, 2, -39 },
  { 795, 22, 24, 27, 2, -30 },
  { 861, 7, 13, 13, 2, -6 },
  { 873, 12, 4, 16, 2, -16 },
  { 879, 6, 7, 13, 3, -6 },
  { 885, 17, 36, 19, 1, -36 },
  { 962, 22, 38, 27, 2, -37 },
  { 1067, 13, 36, 27, 4, -36 },
  { 1126, 22, 37, 27, 2, -37 },
  { 1228, 22, 38, 27, 2, -37 },
  { 1333, 25, 37, 27, 1, -37 },
  { 1449, 21, 37, 27, 3, -36 },
  { 1547, 21, 38, 27, 3, -37 },
  { 1647, 22, 36, 27, 2, -36 },
  { 1746, 22, 38, 27, 2, -37 },
  { 1851, 22, 38, 27, 2, -37 },
  { 1956, 6, 29, 13, 3, -28 },
  { 1978, 7, 35, 13, 2, -28 },
  { 2009, 22, 24, 27, 2, -30 },
  { 2075, 22, 14, 27, 2, -25 },
  { 2114, 22, 24, 27, 2, -30 },
  { 2180, 18, 38, 20, 1, -37 },
  { 2266, 36, 41, 41, 3, -37 },
  { 2451, 29, 37, 29, 0, -37 },
  { 2586, 23, 36, 30, 4, -36 },
  { 2690, 24, 38, 29, 3, -37 },
  { 2804, 26, 36, 33, 4, -36 },
  { 2921, 19, 36, 26, 4, -36 },
  { 3007, 19, 36, 24, 4, -36 },
  { 3093, 27, 38, 34, 3, -37 },
  { 3222, 25, 36, 34, 4, -36 },
  { 3335, 12, 36, 16, 2, -36 },
  { 3389, 12, 46, 13, -3, -36 },
  { 3458, 24, 36, 28, 4, -36 },
  { 3566, 19, 36, 24, 4, -36 },
  { 3652, 34, 36, 43, 4, -36 },
  { 3805, 27, 36, 35, 4, -36 },
  { 3927, 30, 38, 36, 3, -37 },
  { 4070, 22, 36, 28, 4, -36 },
  { 4169, 30, 46, 36, 3, -37 },
  { 4342, 24, 36, 29, 4, -36 },
  { 4450, 21, 38, 25, 2, -37 },
  { 4550, 24, 36, 25, 1, -36 },
  { 4658, 25, 37, 33, 4, -36 },
  { 4774, 28, 36, 28, 0, -36 },
  { 4900, 43, 36, 44, 0, -36 },
  { 5094, 26, 36, 26, 0, -36 },
  { 5211, 26, 36, 26, 0, -36 },
  { 5328, 22, 36, 25, 2, -36 },
  { 5427, 11, 45, 16, 4, -37 },
  { 5489, 17, 36, 19, 1, -36 },
  { 5566, 12, 45, 16, 1, -37 },
  { 5634, 23, 22, 27, 2, -37 },
  { 5698, 23, 4, 22, 0, 4 },
  { 5710, 10, 8, 14, 2, -39 },
  { 5720, 20, 29, 26, 2, -28 },
  { 5793, 22, 40, 29, 4, -39 },
  { 5903, 18, 29, 22, 3, -28 },
  { 5969, 22, 40, 29, 3, -39 },
  { 6079, 21, 29, 26, 3, -28 },
  { 6156, 17, 39, 16, 1, -39 },
  { 6239, 22, 40, 29, 3, -28 },
  { 6349, 21, 39, 29, 4, -39 },
  { 6452, 5, 38, 12, 4, -38 },
  { 6476, 11, 50, 12, -2, -38 },
  { 6545, 20, 39, 25, 4, -39 },
  { 6643, 4, 39, 12, 4, -39 },
  { 6663, 35, 28, 43, 4, -28 },
  { 6786, 21, 28, 29, 4, -28 },
  { 6860, 22, 29, 28, 3, -28 },
  { 6940, 22, 40, 29, 4, -28 },
  { 7050, 22, 40, 29, 3, -28 },
  { 7160, 14, 28, 19, 4, -28 },
  { 7209, 18, 29, 22, 2, -28 },
  { 7275, 15, 35, 17, 1, -34 },
  { 7341, 21, 28, 29, 4, -27 },
  { 7415, 23, 27, 23, 0, -27 },
  { 7493, 35, 27, 37, 1, -27 },
  { 7612, 22, 27, 24, 1, -27 },
  { 7687, 23, 39, 23, 0, -27 },
  { 7800, 17, 27, 21, 2, -27 },
  { 7858, 15, 44, 19, 2, -36 },
  { 7941, 4, 51, 25, 11, -39 },
  { 7967, 15, 44, 19, 2, -36 },
  { 8050, 22, 6, 27, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Regular51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR51PT7B_H_
