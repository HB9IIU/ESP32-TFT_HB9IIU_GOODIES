#ifndef _NOTOSANS_SEMICONDENSED_REGULAR59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E, 0x3C, 0x78,
  0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0x87, 0x07, 0x0F, 0x83, 0x80, 0x4F, 0x81,
  0xC0, 0x07, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0xF8,
  0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x1F, 0x07, 0x00, 0x0F, 0xE3, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x9F,
  0xE0, 0x01, 0xC3, 0xF0, 0x00, 0xE0, 0xF8, 0x00, 0x70, 0x3E, 0x00, 0x38,
  0x1F, 0x00, 0x1C, 0x0F, 0x80, 0x0E, 0x07, 0xC0, 0x07, 0x07, 0xD0, 0x03,
  0x83, 0xEE, 0x01, 0xC7, 0xF7, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x0F, 0x07, 0xC0, 0xF0, 0x1E, 0x1F,
  0x1F, 0xF0, 0xF0, 0x1E, 0x1E, 0x3F, 0xF8, 0x78, 0x1E, 0x3E, 0x3F, 0xFC,
  0x78, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x3E, 0x3F, 0xFC,
  0x78, 0xF8, 0x1E, 0x1F, 0xF8, 0xF8, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0xF0,
  0x1E, 0x03, 0x81, 0xF0, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x1F,
  0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC0,
  0xFE, 0xFC, 0x00, 0xF8, 0x3F, 0x8F, 0xC0, 0x1F, 0x0F, 0xE0, 0xFC, 0x03,
  0xE1, 0xF8, 0x0F, 0xC0, 0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0x0F, 0x80, 0x1F,
  0xC3, 0xE1, 0xF0, 0x01, 0xFC, 0xF8, 0x3E, 0x00, 0x1F, 0xBF, 0x07, 0xC0,
  0x01, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x01, 0xFE, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFF,
  0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0xF3, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE7, 0x39, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7E, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x80, 0x38, 0x02, 0x78, 0x1C, 0x0F, 0x3F, 0xCE, 0x7F, 0x9F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07,
  0xE0, 0x1E, 0x03, 0xC0, 0x03, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F,
  0x07, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0xFC, 0x03,
  0xF0, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xEF, 0xBF, 0x9F,
  0xFE, 0x3F, 0xF0, 0x7D, 0xC0, 0xF9, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xE0,
  0x03, 0xF0, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F,
  0x80, 0x3F, 0x83, 0x80, 0x03, 0xF0, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x30, 0x00, 0x1F, 0xCF, 0x80,
  0x0F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7D, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xCC, 0x00, 0x0F, 0xE7, 0xC0,
  0x1F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x3F, 0xF0, 0x3E, 0x3F, 0xFC, 0x1F, 0x3F, 0xFF, 0x8F, 0xBF, 0xFF, 0xC7,
  0xFC, 0x07, 0xF3, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xF0,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xF8, 0x07, 0xF1,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0xFC, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xDF, 0xF0, 0x1F, 0x83, 0xFC, 0x1F,
  0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xEF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xF7, 0xC0, 0x03, 0xFB, 0xF0, 0x03, 0xFC, 0xFC, 0x07, 0xFE, 0x7F,
  0xFF, 0xDE, 0x1F, 0xFF, 0xDF, 0x07, 0xFF, 0xCF, 0x80, 0xFF, 0x87, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x38, 0x1F, 0x1F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x87, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E,
  0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3C, 0x03, 0xF9,
  0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7F, 0xFC, 0x0F,
  0x0F, 0x80, 0x7F, 0xFF, 0x03, 0xE3, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0xF0,
  0x1F, 0x81, 0xF0, 0x1E, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x9E, 0x03, 0xE0,
  0x1F, 0x01, 0xE7, 0x80, 0xF0, 0x07, 0xC0, 0x79, 0xE0, 0x3C, 0x01, 0xF0,
  0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x1F, 0x01, 0xFF,
  0x01, 0xE0, 0x07, 0x80, 0x7B, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0xBC, 0x07, 0x80, 0x1E, 0x01, 0xEF, 0x01, 0xE0, 0x07,
  0x80, 0x7B, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x3E, 0x03, 0xC0, 0x3F, 0x03, 0xC7, 0x80, 0xF8, 0x1D, 0xC1, 0xF1, 0xE0,
  0x3F, 0x0F, 0x78, 0xF8, 0x78, 0x07, 0xFF, 0x9F, 0xFC, 0x1F, 0x00, 0xFF,
  0xC3, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xF0, 0x00, 0xC0, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0x80, 0x7F, 0xF1, 0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0xC3, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x3E, 0x00, 0x3F, 0xC7, 0xC0, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0xDF, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xEF,
  0x80, 0x03, 0xF9, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFE, 0x00, 0xF0, 0x1F, 0xC0, 0x01, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x10, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xD0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0x0F, 0x80,
  0x01, 0xFC, 0x3E, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFE, 0x3E,
  0x00, 0x07, 0xF0, 0xF8, 0x00, 0xFF, 0x83, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x0C,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F,
  0x07, 0xF8, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0xC7, 0xFB, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x0F,
  0xBF, 0xC0, 0x00, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFB, 0xE0, 0x00, 0x07, 0xBF, 0xF7, 0xC0, 0x00, 0x1F, 0x7F,
  0xE7, 0x80, 0x00, 0x3E, 0xFF, 0xCF, 0x80, 0x00, 0x79, 0xFF, 0x9F, 0x00,
  0x01, 0xF3, 0xFF, 0x1E, 0x00, 0x03, 0xE7, 0xFE, 0x3E, 0x00, 0x07, 0x8F,
  0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0xF8, 0x78, 0x00, 0x3E, 0x3F, 0xF0, 0xF8,
  0x00, 0x78, 0x7F, 0xE1, 0xF0, 0x01, 0xF0, 0xFF, 0xC1, 0xE0, 0x03, 0xE1,
  0xFF, 0x83, 0xE0, 0x07, 0x83, 0xFF, 0x07, 0xC0, 0x1F, 0x07, 0xFE, 0x07,
  0xC0, 0x3E, 0x0F, 0xFC, 0x0F, 0x80, 0x78, 0x1F, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0xF0, 0x1F, 0x03, 0xC0, 0x7F, 0xE0, 0x3E, 0x0F, 0x80, 0xFF, 0xC0,
  0x7C, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x3C, 0x03, 0xFF, 0x00, 0xF8, 0xF8,
  0x07, 0xFE, 0x01, 0xF1, 0xF0, 0x0F, 0xFC, 0x01, 0xF3, 0xC0, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0x3F, 0xF7,
  0xE0, 0x00, 0x7F, 0xE7, 0xC0, 0x00, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0x8F,
  0x80, 0x03, 0xFF, 0x1F, 0x80, 0x07, 0xFE, 0x1F, 0x80, 0x0F, 0xFC, 0x3F,
  0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x7F, 0xE0, 0x7E,
  0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x00, 0xFC,
  0x07, 0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x01, 0xF8, 0x1F, 0xF8, 0x01, 0xF0,
  0x3F, 0xF0, 0x03, 0xF0, 0x7F, 0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0x07, 0xE1,
  0xFF, 0x80, 0x07, 0xE3, 0xFF, 0x00, 0x0F, 0xC7, 0xFE, 0x00, 0x0F, 0xCF,
  0xFC, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0x1F, 0xBF, 0xF0, 0x00, 0x1F, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0xFF, 0xC7,
  0xC0, 0x07, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0xCF, 0x80,
  0x3F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0x81, 0xFF, 0xE1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0xC7,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x3F, 0x80, 0x7C, 0x7E, 0x00, 0x0C, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0xC0, 0x00, 0xFC, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x9E, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF0, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0x1F,
  0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xF0, 0x00,
  0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0xCF, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0x80, 0xFC, 0x06, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xDF, 0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7C, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x3F,
  0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x0F, 0x07, 0xFE, 0x0F, 0x00,
  0x60, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xFC, 0x03, 0xE7, 0xFF,
  0x81, 0xE7, 0xFF, 0xF0, 0xF7, 0xFF, 0xFC, 0x7B, 0xE0, 0xFE, 0x3F, 0xC0,
  0x1F, 0x9F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFC, 0xFF, 0x80, 0xFE, 0x7B, 0xFF,
  0xFE, 0x3C, 0xFF, 0xFE, 0x1E, 0x3F, 0xFE, 0x0F, 0x0F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFE, 0x1F, 0x1F, 0xC0, 0x08, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x61, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xF8,
  0x7C, 0x0F, 0xFF, 0x3E, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xF7, 0x8F, 0xE0,
  0xFF, 0xCF, 0xC0, 0x1F, 0xE7, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFB, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x80,
  0xFF, 0x8F, 0xFF, 0xFB, 0xC3, 0xFF, 0xF9, 0xE0, 0xFF, 0xF8, 0xF0, 0x1F,
  0xF0, 0x78, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x02, 0x1F, 0xC0, 0x0E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x04, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x07, 0x81, 0xFF,
  0xC3, 0xC3, 0xFF, 0xF9, 0xE1, 0xFF, 0xFE, 0xF1, 0xFC, 0x1F, 0x79, 0xF8,
  0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF1, 0xFF,
  0xFF, 0x78, 0x7F, 0xFF, 0x7C, 0x1F, 0xFF, 0x3E, 0x03, 0xFE, 0x1F, 0x00,
  0x10, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x30, 0x00, 0x7F, 0x1F, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F,
  0xC0, 0xF8, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xF7, 0xFF, 0xFC, 0xF7, 0xC1,
  0xFC, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x11, 0xEF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x40, 0x1E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE8, 0x7E, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x07,
  0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xE0,
  0x03, 0xCF, 0xC0, 0x07, 0xBF, 0x80, 0x0F, 0x7F, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xBF, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0xF3,
  0xFF, 0xF0, 0xFF, 0xFC, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xF7, 0x83, 0xFB,
  0xE0, 0xFE, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xF0, 0xFF, 0xF0, 0xF3,
  0xFF, 0xF8, 0xF7, 0xFF, 0xFC, 0xF7, 0xC1, 0xFC, 0xFF, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x7F, 0x80, 0x78, 0xFF, 0xF0, 0x3C,
  0xFF, 0xFE, 0x1E, 0xFF, 0xFF, 0x8F, 0x78, 0x1F, 0xC7, 0xF8, 0x03, 0xF3,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0x3F, 0x80, 0x1F, 0x9F, 0xF0, 0x1F, 0x8F, 0x7F, 0xFF, 0xC7,
  0x9F, 0xFF, 0xC3, 0xE7, 0xFF, 0xC1, 0xF0, 0xFF, 0x80, 0xF8, 0x0C, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x07, 0x81, 0xFF, 0xE3, 0xC3,
  0xFF, 0xF9, 0xE1, 0xFF, 0xFE, 0xF1, 0xFC, 0x1F, 0x79, 0xF8, 0x03, 0xFC,
  0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0x78,
  0x7F, 0xFF, 0x7C, 0x1F, 0xFF, 0x3E, 0x03, 0xFE, 0x1F, 0x00, 0x10, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xF7, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x03, 0xCF, 0x80, 0x04,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xEE, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x30, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x01, 0xFF, 0x3F, 0xFF, 0xEF,
  0x1F, 0xFF, 0xCF, 0x0F, 0xFF, 0x8F, 0x07, 0xFE, 0x0F, 0x00, 0xB0, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xFE, 0x00, 0xF8,
  0xF8, 0x01, 0xEF, 0x00, 0x7C, 0x3E, 0x01, 0xF7, 0x80, 0x3E, 0x1F, 0x00,
  0xF3, 0xE0, 0x1E, 0x0F, 0x80, 0x79, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x78,
  0x0F, 0x81, 0xF0, 0x3E, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x1F, 0x03, 0xC0,
  0x7C, 0x0F, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x0F, 0x87,
  0xC1, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0x1F, 0x00,
  0x3E, 0x78, 0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x0F, 0xBE,
  0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x7F,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x47,
  0xFC, 0x00, 0x17, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF2, 0x00, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 43, 15, 4, -42 },
  { 39, 16, 15, 23, 4, -42 },
  { 69, 32, 42, 34, 1, -42 },
  { 237, 25, 48, 31, 3, -45 },
  { 387, 40, 44, 45, 3, -43 },
  { 607, 35, 44, 38, 3, -43 },
  { 800, 5, 15, 13, 4, -42 },
  { 810, 13, 51, 18, 3, -42 },
  { 893, 13, 51, 18, 2, -42 },
  { 976, 25, 24, 29, 2, -45 },
  { 1051, 25, 28, 31, 3, -35 },
  { 1139, 9, 15, 15, 2, -7 },
  { 1156, 14, 4, 18, 2, -18 },
  { 1163, 7, 8, 15, 4, -7 },
  { 1170, 20, 42, 22, 1, -42 },
  { 1275, 25, 44, 31, 3, -43 },
  { 1413, 15, 42, 31, 5, -42 },
  { 1492, 25, 43, 31, 3, -43 },
  { 1627, 26, 44, 31, 2, -43 },
  { 1770, 29, 42, 31, 1, -42 },
  { 1923, 25, 43, 31, 3, -42 },
  { 2058, 25, 44, 31, 3, -43 },
  { 2196, 26, 42, 31, 2, -42 },
  { 2333, 25, 44, 31, 3, -43 },
  { 2471, 25, 44, 31, 3, -43 },
  { 2609, 7, 33, 15, 4, -32 },
  { 2638, 9, 40, 15, 2, -32 },
  { 2683, 26, 28, 31, 2, -35 },
  { 2774, 25, 16, 31, 3, -29 },
  { 2824, 25, 28, 31, 3, -35 },
  { 2912, 21, 44, 23, 1, -43 },
  { 3028, 42, 47, 48, 3, -42 },
  { 3275, 34, 42, 34, 0, -42 },
  { 3454, 27, 42, 35, 5, -42 },
  { 3596, 29, 44, 33, 3, -43 },
  { 3756, 30, 42, 38, 5, -42 },
  { 3914, 21, 42, 30, 5, -42 },
  { 4025, 21, 42, 28, 5, -42 },
  { 4136, 32, 44, 39, 3, -43 },
  { 4312, 29, 42, 39, 5, -42 },
  { 4465, 15, 42, 19, 2, -42 },
  { 4544, 14, 53, 15, -4, -42 },
  { 4637, 28, 42, 33, 5, -42 },
  { 4784, 21, 42, 28, 5, -42 },
  { 4895, 39, 42, 49, 5, -42 },
  { 5100, 31, 42, 41, 5, -42 },
  { 5263, 35, 44, 41, 3, -43 },
  { 5456, 25, 42, 32, 5, -42 },
  { 5588, 35, 53, 41, 3, -43 },
  { 5820, 27, 42, 33, 5, -42 },
  { 5962, 24, 44, 29, 3, -43 },
  { 6094, 27, 42, 29, 1, -42 },
  { 6236, 29, 43, 39, 5, -42 },
  { 6392, 32, 42, 32, 0, -42 },
  { 6560, 49, 42, 50, 1, -42 },
  { 6818, 30, 42, 31, 0, -42 },
  { 6976, 30, 42, 30, 0, -42 },
  { 7134, 25, 42, 29, 2, -42 },
  { 7266, 12, 51, 19, 5, -42 },
  { 7343, 20, 42, 22, 1, -42 },
  { 7448, 13, 51, 19, 2, -42 },
  { 7531, 27, 25, 31, 2, -42 },
  { 7616, 26, 4, 26, 0, 5 },
  { 7629, 12, 9, 16, 2, -45 },
  { 7643, 24, 33, 30, 2, -32 },
  { 7742, 25, 46, 33, 5, -45 },
  { 7886, 21, 33, 25, 3, -32 },
  { 7973, 25, 46, 33, 3, -45 },
  { 8117, 24, 33, 30, 3, -32 },
  { 8216, 19, 45, 18, 1, -45 },
  { 8323, 25, 46, 33, 3, -32 },
  { 8467, 24, 45, 33, 5, -45 },
  { 8602, 6, 44, 14, 4, -44 },
  { 8635, 12, 58, 14, -2, -44 },
  { 8722, 23, 45, 29, 5, -45 },
  { 8852, 5, 45, 14, 5, -45 },
  { 8881, 40, 32, 50, 5, -32 },
  { 9041, 24, 32, 33, 5, -32 },
  { 9137, 26, 33, 32, 3, -32 },
  { 9245, 25, 46, 33, 5, -32 },
  { 9389, 25, 46, 33, 3, -32 },
  { 9533, 16, 32, 22, 5, -32 },
  { 9597, 20, 33, 25, 3, -32 },
  { 9680, 17, 40, 19, 1, -39 },
  { 9765, 24, 33, 33, 4, -32 },
  { 9864, 27, 32, 27, 0, -32 },
  { 9972, 41, 32, 42, 1, -32 },
  { 10136, 26, 32, 28, 1, -32 },
  { 10240, 27, 46, 27, 0, -32 },
  { 10396, 20, 32, 24, 2, -32 },
  { 10476, 18, 51, 22, 2, -42 },
  { 10591, 4, 59, 29, 13, -45 },
  { 10621, 18, 51, 22, 2, -42 },
  { 10736, 26, 8, 31, 2, -25 },
};

const GFXfont NotoSans_SemiCondensed_Regular59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR59PT7B_H_
