#ifndef _NOTOSANS_SEMICONDENSED_REGULAR46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x0C, 0x00, 0x00, 0x08, 0x7B, 0xFF,
  0xFF, 0x78, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x76, 0x07, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0xF0, 0x70, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x83, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x0F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF6,
  0xFC, 0x7C, 0x60, 0xC7, 0x86, 0x00, 0x70, 0x60, 0x0F, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x86, 0x00, 0x7C, 0x60, 0x07, 0xF6, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x06, 0x7E,
  0x00, 0x61, 0xE0, 0x06, 0x0F, 0x00, 0x60, 0xF0, 0x06, 0x0F, 0x00, 0x60,
  0xE8, 0x06, 0x1E, 0xE0, 0x63, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF,
  0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x7F, 0x80, 0x0F, 0x00,
  0xFF, 0x80, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x07, 0x00, 0xE0, 0x1E,
  0x0E, 0x03, 0xC0, 0x3C, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x1E, 0x00, 0xE0,
  0x78, 0x38, 0x01, 0xC0, 0xF0, 0xF0, 0x03, 0x81, 0xE1, 0xC0, 0x07, 0x03,
  0xC7, 0x80, 0x0E, 0x07, 0x8E, 0x00, 0x1E, 0x0E, 0x3C, 0x7E, 0x1C, 0x1C,
  0x71, 0xFE, 0x38, 0x38, 0xE7, 0xFE, 0x78, 0xF3, 0x8E, 0x1C, 0x7F, 0xC7,
  0x3C, 0x3C, 0xFF, 0x1C, 0x70, 0x38, 0xFC, 0x38, 0xE0, 0x70, 0x00, 0xE1,
  0xC0, 0xE0, 0x01, 0xC3, 0x81, 0xC0, 0x07, 0x87, 0x03, 0x80, 0x0E, 0x0E,
  0x07, 0x00, 0x3C, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x1C, 0x01, 0xE0, 0x70,
  0x38, 0x03, 0x80, 0xE0, 0x70, 0x0F, 0x01, 0xE1, 0xE0, 0x1C, 0x01, 0xC3,
  0x80, 0x78, 0x03, 0xFF, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x03, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0xF8, 0xF8, 0xF0, 0x1E, 0x3E, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0x79, 0xF0,
  0x1F, 0x1E, 0x3C, 0x01, 0xF3, 0xC7, 0x80, 0x1F, 0xF0, 0xF0, 0x01, 0xFE,
  0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0,
  0x3F, 0xE0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xF3, 0xE0, 0xFF, 0xF8, 0x3E,
  0x0F, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x76, 0x03, 0xC0,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x38, 0x77,
  0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7B, 0x80, 0x0E, 0x78, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x01,
  0xC1, 0xC0, 0x10, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xC3, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x21, 0xEF, 0xBF, 0xF9, 0xE2, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0xF8,
  0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE3, 0xC0, 0x3C,
  0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7D, 0xFF, 0x7F, 0x8F,
  0x61, 0xE8, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE1, 0xF8, 0x70, 0x07, 0xC2,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0x00, 0x7C, 0x40, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7D, 0xE0, 0x1F, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xF0,
  0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x30, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xB8, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE,
  0x04, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x38, 0x07,
  0x1F, 0xF0, 0x73, 0xFF, 0x8F, 0x7F, 0xFC, 0xFE, 0x03, 0xCF, 0xC0, 0x1E,
  0xF8, 0x01, 0xEF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE3, 0xC0,
  0x1E, 0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x7C,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xF9, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x1F,
  0x83, 0xC0, 0x7C, 0x78, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xF0, 0xF8, 0x7C, 0x07,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x3F, 0x7C, 0x07, 0xF3, 0xFB, 0xEE, 0x1F, 0xFC, 0xE0,
  0xFF, 0x9E, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7B,
  0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x7B, 0xEF, 0xFE, 0x78, 0x80, 0x3D, 0xF7, 0xDF, 0x7C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xF7,
  0xDE, 0x79, 0xE7, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0x40, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x0E,
  0x01, 0xFE, 0x07, 0x8F, 0x01, 0xFF, 0xC1, 0xC7, 0x03, 0xFF, 0xE0, 0xE7,
  0x81, 0xE0, 0xF0, 0x73, 0xC1, 0xE0, 0x78, 0x3D, 0xC0, 0xE0, 0x38, 0x1E,
  0xE0, 0xF0, 0x1C, 0x07, 0x70, 0x78, 0x0E, 0x03, 0xB8, 0x38, 0x07, 0x01,
  0xFC, 0x1C, 0x03, 0x81, 0xFE, 0x0E, 0x01, 0xC0, 0xFF, 0x07, 0x00, 0xE0,
  0x73, 0x83, 0x80, 0xF0, 0x39, 0xC1, 0xE0, 0x78, 0x1C, 0xE0, 0xF0, 0x3C,
  0x1C, 0x70, 0x3C, 0x3F, 0x1E, 0x38, 0x1F, 0xF9, 0xFE, 0x1E, 0x07, 0xF8,
  0xFE, 0x07, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x80, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x7E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D,
  0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x03, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x3F, 0x78,
  0x1F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0x7E, 0x1F, 0x80, 0x10,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0x7F, 0x1E, 0x00, 0x3F, 0x3C, 0x00,
  0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x03, 0xE7, 0x80,
  0x0F, 0x8F, 0x00, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7E, 0x1F, 0xC0, 0x06, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3E, 0x00,
  0x0F, 0x3F, 0x00, 0x0F, 0x1F, 0x80, 0x0F, 0x0F, 0xE0, 0x1F, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x3F,
  0xF7, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0xBF, 0xF7, 0xFC, 0xFF,
  0x0F, 0x80, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0xF8, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF1,
  0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3D, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x7C, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0,
  0x3E, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3B, 0xFF, 0xC0, 0x00, 0xF7, 0xFB,
  0x80, 0x01, 0xEF, 0xF7, 0x80, 0x03, 0x9F, 0xEF, 0x00, 0x0F, 0x3F, 0xCE,
  0x00, 0x1E, 0x7F, 0x9E, 0x00, 0x38, 0xFF, 0x3C, 0x00, 0xF1, 0xFE, 0x3C,
  0x01, 0xE3, 0xFC, 0x78, 0x03, 0x87, 0xF8, 0xF0, 0x0F, 0x0F, 0xF0, 0xF0,
  0x1E, 0x1F, 0xE1, 0xE0, 0x38, 0x3F, 0xC3, 0xC0, 0xF0, 0x7F, 0x83, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0x81, 0xFE, 0x0F, 0x0F, 0x03, 0xFC, 0x0F, 0x1C,
  0x07, 0xF8, 0x1E, 0x38, 0x0F, 0xF0, 0x1C, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x01,
  0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x0F,
  0xF0, 0x07, 0x80, 0x1E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F, 0xF3, 0xE0,
  0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x78,
  0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x1E,
  0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07,
  0x8F, 0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xEF, 0xF0, 0x01, 0xEF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF0, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00, 0xFD, 0xE0, 0x0F, 0xBC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x7E, 0xF0, 0x3F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0x87, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0x9F,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0x00, 0xFC, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x03, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x8F, 0xE7, 0xC0, 0x08, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE8, 0x00, 0x7D, 0xF0, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xDE,
  0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0x00, 0x79, 0xE0, 0x01,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0xE0, 0x03,
  0xC7, 0x80, 0x1D, 0xC0, 0x0F, 0x8F, 0x00, 0x3B, 0x80, 0x1E, 0x1E, 0x00,
  0x77, 0x00, 0x3C, 0x3E, 0x01, 0xEF, 0x00, 0x78, 0x3C, 0x03, 0xDE, 0x01,
  0xF0, 0x78, 0x07, 0x9C, 0x03, 0xC0, 0xF0, 0x0E, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x03, 0xC0, 0xE0, 0xE0,
  0x78, 0x07, 0x81, 0xC1, 0xE0, 0xF0, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x0F,
  0x0F, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x07, 0x0F, 0x00, 0x3C, 0x78, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x3C, 0x78, 0x00,
  0xF3, 0x80, 0x39, 0xE0, 0x01, 0xE7, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0x0F, 0xE0, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03,
  0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1F, 0x03,
  0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0x87,
  0x00, 0x1E, 0x1E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0,
  0x78, 0x07, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xE0,
  0x01, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x0E, 0x03,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x78, 0x3E, 0x10, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFC,
  0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xC0, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xDE, 0x07,
  0xF7, 0xFF, 0x9C, 0xFF, 0xC7, 0x1F, 0xE1, 0xC0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x87, 0xF0, 0x73, 0xFF,
  0x0E, 0xFF, 0xF1, 0xDE, 0x3F, 0x3F, 0x01, 0xF7, 0xC0, 0x1E, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xF0, 0x7C,
  0xEF, 0xFF, 0x9C, 0xFF, 0xE3, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC3, 0xF1, 0xE3, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x18, 0x7F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x03, 0xF8, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xF0,
  0xFF, 0x3E, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0xC0, 0x1F, 0x3C, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFF,
  0x70, 0xFF, 0xE7, 0x07, 0xF8, 0x70, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0x87, 0xC3, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x02, 0x3E, 0x01, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x7C, 0x20, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xE7, 0xFF, 0xCF, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x03, 0xF8, 0x70, 0xFF, 0xC7, 0x1F, 0xFE, 0x71, 0xF0, 0xFF, 0x3E, 0x03,
  0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0xC0, 0x1F, 0x3C, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0xFF, 0xEF,
  0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE2, 0x00, 0x3E, 0x3F, 0x1F, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x1F, 0xC3, 0x9F, 0xFC, 0xEF, 0xFF, 0xBB,
  0xC7, 0xEF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3C, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0xA3, 0xEF, 0xF3, 0xFC, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7B, 0x80, 0x3C, 0xE0,
  0x1F, 0x38, 0x0F, 0x8E, 0x07, 0xC3, 0x81, 0xE0, 0xE0, 0xF0, 0x38, 0x78,
  0x0E, 0x3E, 0x03, 0x9F, 0x00, 0xE7, 0x80, 0x3B, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xF9, 0xE0, 0x3C, 0x3C, 0x0E, 0x0F, 0x83, 0x81, 0xE0, 0xE0,
  0x7C, 0x38, 0x0F, 0x0E, 0x01, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x03,
  0xEE, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xF8, 0x07,
  0xE1, 0xCF, 0xFC, 0x3F, 0xF3, 0xBF, 0xFC, 0xFF, 0xF7, 0x70, 0xFB, 0xC3,
  0xEF, 0xC0, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x01, 0xF0, 0x07,
  0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0x00, 0x3F,
  0xC0, 0x0E, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0xFF, 0x00, 0x38, 0x01, 0xFE,
  0x00, 0x70, 0x03, 0xFC, 0x00, 0xE0, 0x07, 0xF8, 0x01, 0xC0, 0x0F, 0xF0,
  0x03, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x3F, 0xC0, 0x0E, 0x00, 0x7F, 0x80,
  0x1C, 0x00, 0xFF, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x70, 0x03, 0xFC, 0x00,
  0xE0, 0x07, 0xF8, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0x80, 0x1E, 0xE1, 0xFC,
  0x39, 0xFF, 0xCE, 0xFF, 0xFB, 0xBC, 0x7E, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xE3,
  0xE0, 0x1E, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0xE1, 0xFC, 0x1C, 0xFF, 0xC3, 0xBF, 0xFC, 0x77, 0x0F, 0xCF, 0xC0,
  0x7D, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01,
  0xEF, 0x80, 0x7D, 0xFC, 0x1F, 0x3B, 0xFF, 0xE7, 0x3F, 0xF8, 0xE3, 0xFC,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xF8, 0x70, 0xFF, 0xC7, 0x1F, 0xFE, 0x71, 0xF0,
  0xFF, 0x3E, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0xC0, 0x1F, 0x3C, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFF,
  0xF0, 0xFF, 0xEF, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0x1F,
  0xB9, 0xFD, 0xDF, 0xEE, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1E, 0xF0, 0x04,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x7E, 0xF8, 0x1F, 0xCF, 0xFF, 0xB8,
  0xFF, 0xE7, 0x0F, 0xF0, 0xE0, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x70, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x03, 0xCF,
  0x00, 0x7E, 0x01, 0xE3, 0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0x3B, 0x80, 0xF0,
  0xF0, 0x1D, 0xC0, 0x78, 0x78, 0x1E, 0xF0, 0x3C, 0x1C, 0x0F, 0x78, 0x1E,
  0x0F, 0x07, 0x1C, 0x1E, 0x07, 0x83, 0x8E, 0x0F, 0x03, 0xC3, 0xC7, 0x87,
  0x80, 0xE1, 0xE3, 0xC3, 0xC0, 0x78, 0xE0, 0xE3, 0xC0, 0x3C, 0xF0, 0x79,
  0xE0, 0x1E, 0x78, 0x3C, 0xF0, 0x07, 0x3C, 0x1E, 0x70, 0x03, 0xDC, 0x07,
  0x38, 0x01, 0xEE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1E,
  0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0x9E, 0x00, 0xF9, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x83,
  0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0xF7, 0x80,
  0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x8F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x03, 0xF0,
  0x3F, 0xC0, 0xFE, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x7C, 0x0F, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0x80,
  0x17, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE8, 0x00,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 34, 12, 3, -33 },
  { 27, 12, 12, 18, 3, -33 },
  { 45, 25, 33, 27, 1, -33 },
  { 149, 20, 38, 24, 2, -35 },
  { 244, 31, 33, 35, 2, -33 },
  { 372, 27, 33, 29, 2, -33 },
  { 484, 4, 12, 10, 3, -33 },
  { 490, 10, 40, 14, 2, -33 },
  { 540, 11, 40, 14, 1, -33 },
  { 595, 19, 19, 23, 2, -35 },
  { 641, 20, 22, 24, 2, -27 },
  { 696, 7, 11, 12, 2, -5 },
  { 706, 10, 3, 14, 2, -14 },
  { 710, 6, 7, 12, 3, -6 },
  { 716, 16, 33, 17, 1, -33 },
  { 782, 20, 33, 24, 2, -33 },
  { 865, 11, 33, 24, 4, -33 },
  { 911, 20, 33, 24, 2, -33 },
  { 994, 19, 33, 24, 2, -33 },
  { 1073, 22, 33, 24, 1, -33 },
  { 1164, 18, 33, 24, 3, -33 },
  { 1239, 20, 33, 24, 2, -33 },
  { 1322, 20, 33, 24, 2, -33 },
  { 1405, 20, 33, 24, 2, -33 },
  { 1488, 20, 33, 24, 2, -33 },
  { 1571, 6, 26, 12, 3, -25 },
  { 1591, 6, 31, 12, 2, -25 },
  { 1615, 20, 21, 24, 2, -27 },
  { 1668, 20, 13, 24, 2, -23 },
  { 1701, 20, 21, 24, 2, -27 },
  { 1754, 16, 34, 18, 1, -33 },
  { 1822, 33, 37, 37, 2, -33 },
  { 1975, 26, 33, 26, 0, -33 },
  { 2083, 21, 33, 27, 4, -33 },
  { 2170, 22, 33, 26, 3, -33 },
  { 2261, 23, 33, 30, 4, -33 },
  { 2356, 16, 33, 23, 4, -33 },
  { 2422, 16, 33, 22, 4, -33 },
  { 2488, 24, 33, 30, 3, -33 },
  { 2587, 23, 33, 31, 4, -33 },
  { 2682, 11, 33, 15, 2, -33 },
  { 2728, 11, 42, 12, -3, -33 },
  { 2786, 22, 33, 26, 4, -33 },
  { 2877, 17, 33, 22, 4, -33 },
  { 2948, 31, 33, 39, 4, -33 },
  { 3076, 24, 33, 32, 4, -33 },
  { 3175, 26, 33, 32, 3, -33 },
  { 3283, 19, 33, 25, 4, -33 },
  { 3362, 26, 41, 32, 3, -33 },
  { 3496, 21, 33, 26, 4, -33 },
  { 3583, 19, 33, 23, 2, -33 },
  { 3662, 22, 33, 23, 0, -33 },
  { 3753, 22, 33, 30, 4, -33 },
  { 3844, 25, 33, 25, 0, -33 },
  { 3948, 39, 33, 39, 0, -33 },
  { 4109, 24, 33, 24, 0, -33 },
  { 4208, 23, 33, 23, 0, -33 },
  { 4303, 19, 33, 23, 2, -33 },
  { 4382, 10, 40, 15, 4, -33 },
  { 4432, 16, 33, 17, 1, -33 },
  { 4498, 10, 40, 15, 1, -33 },
  { 4548, 22, 20, 24, 1, -33 },
  { 4603, 20, 3, 20, 0, 4 },
  { 4611, 9, 7, 13, 2, -35 },
  { 4619, 18, 25, 23, 2, -25 },
  { 4676, 19, 35, 26, 4, -35 },
  { 4760, 17, 25, 20, 2, -25 },
  { 4814, 20, 35, 26, 2, -35 },
  { 4902, 19, 25, 23, 2, -25 },
  { 4962, 15, 35, 14, 1, -35 },
  { 5028, 20, 36, 26, 2, -25 },
  { 5118, 18, 35, 26, 4, -35 },
  { 5197, 5, 34, 11, 3, -34 },
  { 5219, 10, 45, 11, -2, -34 },
  { 5276, 18, 35, 22, 4, -35 },
  { 5355, 4, 35, 11, 4, -35 },
  { 5373, 31, 25, 39, 4, -25 },
  { 5470, 18, 25, 26, 4, -25 },
  { 5527, 21, 25, 25, 2, -25 },
  { 5593, 19, 36, 26, 4, -25 },
  { 5679, 20, 36, 26, 2, -25 },
  { 5769, 13, 25, 17, 4, -25 },
  { 5810, 16, 25, 20, 2, -25 },
  { 5860, 13, 30, 15, 1, -30 },
  { 5909, 19, 25, 26, 3, -25 },
  { 5969, 21, 25, 21, 0, -25 },
  { 6035, 33, 25, 33, 0, -25 },
  { 6139, 20, 25, 22, 1, -25 },
  { 6202, 21, 36, 21, 0, -25 },
  { 6297, 15, 25, 19, 2, -25 },
  { 6344, 14, 40, 17, 2, -33 },
  { 6414, 3, 46, 23, 10, -35 },
  { 6432, 14, 40, 17, 2, -33 },
  { 6502, 20, 6, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Regular46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR46PT7B_H_
