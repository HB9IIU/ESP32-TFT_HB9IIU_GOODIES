#ifndef _NOTOSANS_SEMICONDENSED_REGULAR17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x4F, 0xDE, 0xE7, 0x20, 0x09, 0x0C, 0x84, 0x4F, 0xF7,
  0xF8, 0x90, 0x49, 0xFF, 0x22, 0x13, 0x09, 0x04, 0x80, 0x10, 0x21, 0xFE,
  0x89, 0x1A, 0x1C, 0x0E, 0x16, 0x26, 0x5F, 0xE1, 0x02, 0x00, 0xF0, 0x92,
  0x22, 0x44, 0x49, 0x09, 0x21, 0x2B, 0xFD, 0x48, 0x49, 0x09, 0x22, 0x24,
  0x44, 0x90, 0x70, 0x7C, 0x11, 0x04, 0x41, 0xB0, 0x38, 0x0C, 0x07, 0x8B,
  0x36, 0x87, 0x20, 0xCC, 0x71, 0xF3, 0xFA, 0x36, 0x4C, 0x88, 0x88, 0x88,
  0xCC, 0x46, 0x30, 0x89, 0x32, 0x49, 0x25, 0xB5, 0xA0, 0x30, 0x22, 0x5F,
  0xF3, 0x0D, 0x13, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08, 0xFA,
  0xF0, 0xF0, 0x0C, 0x30, 0x86, 0x10, 0x43, 0x08, 0x21, 0x84, 0x30, 0x7C,
  0x8B, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x87, 0x8D, 0x13, 0xC0, 0x1B, 0xF6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x7D, 0x08, 0x18, 0x30, 0x41, 0x86,
  0x08, 0x20, 0xC3, 0x07, 0xF0, 0xFD, 0x08, 0x18, 0x30, 0xCF, 0x03, 0x03,
  0x06, 0x0E, 0x37, 0xC0, 0x06, 0x07, 0x02, 0x82, 0x41, 0x21, 0x11, 0x88,
  0x84, 0xFF, 0x81, 0x00, 0x80, 0x40, 0x7C, 0x83, 0x06, 0x0C, 0x1F, 0x81,
  0x83, 0x06, 0x0E, 0x37, 0xC0, 0x3C, 0xC1, 0x06, 0x09, 0x97, 0xB1, 0xC1,
  0x83, 0x8D, 0x19, 0xE0, 0xFE, 0x0C, 0x10, 0x20, 0xC1, 0x06, 0x08, 0x10,
  0x60, 0x83, 0x00, 0x7D, 0x8F, 0x1E, 0x36, 0xC7, 0x1B, 0x63, 0x83, 0x07,
  0x1B, 0xE0, 0x79, 0x8A, 0x1C, 0x38, 0x78, 0xDF, 0x93, 0x06, 0x08, 0x33,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE8, 0x02, 0x18, 0xC6, 0x0C, 0x07,
  0x03, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0xE7, 0x38,
  0x40, 0xFA, 0x30, 0x41, 0x0C, 0x63, 0x08, 0x20, 0x03, 0x0C, 0x1F, 0x83,
  0x04, 0x60, 0x24, 0x72, 0xC9, 0x19, 0x91, 0x91, 0x19, 0x11, 0x99, 0x28,
  0xEE, 0x40, 0x06, 0x00, 0x3F, 0x80, 0x0C, 0x03, 0x01, 0xC0, 0x58, 0x12,
  0x0C, 0x82, 0x30, 0xFC, 0x61, 0x10, 0x64, 0x0B, 0x03, 0xFE, 0xC3, 0xC3,
  0xC3, 0xC2, 0xFC, 0xC6, 0xC3, 0xC1, 0xC3, 0xC7, 0xFE, 0x3F, 0x61, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x71, 0x3F, 0xFE, 0x63, 0xB0,
  0x58, 0x3C, 0x1E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xB1, 0xDF, 0x80, 0xFF,
  0x83, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0x07, 0xF0, 0xFF, 0x83,
  0x06, 0x0C, 0x1F, 0xBF, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x3F, 0xB8, 0x50,
  0x18, 0x0C, 0x06, 0x03, 0x1F, 0x81, 0xC0, 0xA0, 0x5C, 0x23, 0xF0, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x30, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xE0, 0xC3, 0xC6, 0xC4, 0xC8, 0xD8, 0xF0, 0xF8, 0xCC, 0xC4,
  0xC6, 0xC3, 0xC3, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xF0, 0xE0, 0x7E, 0x07, 0xF0, 0x7D, 0x0F, 0xD0, 0xBD, 0x8B, 0xC9,
  0xBC, 0x93, 0xCD, 0x3C, 0x73, 0xC6, 0x3C, 0x63, 0xE0, 0xF0, 0x7C, 0x3A,
  0x1D, 0x8E, 0x47, 0x33, 0x8D, 0xC2, 0xE1, 0xF0, 0x78, 0x30, 0x3F, 0x18,
  0x64, 0x0B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD0, 0x26, 0x38,
  0xFC, 0xFC, 0xC6, 0xC2, 0xC3, 0xC2, 0xC6, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x3F, 0x18, 0x64, 0x0B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xD0, 0x26, 0x38, 0xFC, 0x02, 0x00, 0xC0, 0x18, 0xFC, 0xC6, 0xC2, 0xC3,
  0xC2, 0xC6, 0xF8, 0xCC, 0xC4, 0xC6, 0xC3, 0xC3, 0x7F, 0x8A, 0x06, 0x0C,
  0x0E, 0x07, 0x03, 0x06, 0x0E, 0x37, 0xC0, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xA0, 0xD8, 0xC7, 0xC0, 0xC1, 0xA0, 0xD0,
  0x4C, 0x26, 0x31, 0x10, 0xC8, 0x6C, 0x14, 0x0A, 0x07, 0x01, 0x80, 0xC3,
  0x05, 0x0C, 0x34, 0x38, 0xD8, 0xA2, 0x66, 0x88, 0x92, 0x62, 0x4D, 0x8B,
  0x14, 0x3C, 0x50, 0x61, 0x41, 0x87, 0x06, 0x08, 0xC1, 0xB1, 0x88, 0x86,
  0x81, 0xC0, 0xC0, 0x70, 0x28, 0x36, 0x31, 0x10, 0xD8, 0x30, 0xC1, 0xA1,
  0x98, 0x84, 0xC3, 0x40, 0xE0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFE, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x30, 0x61, 0x82, 0x07, 0xF0, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1,
  0x04, 0x18, 0x20, 0xC1, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0,
  0x10, 0x70, 0xA2, 0x64, 0x58, 0xE0, 0x80, 0xFF, 0xFF, 0xC8, 0x80, 0x7D,
  0x10, 0x41, 0x7E, 0x18, 0x63, 0xF4, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0xC6,
  0xC2, 0xC3, 0xC3, 0xC3, 0xC2, 0xE6, 0xFC, 0x7F, 0x0C, 0x20, 0x82, 0x0C,
  0x11, 0x7C, 0x02, 0x04, 0x08, 0x17, 0xB8, 0xF0, 0xC1, 0x83, 0x07, 0x0E,
  0x37, 0xA0, 0x7D, 0x8B, 0x1C, 0x3F, 0xF0, 0x30, 0x21, 0x3E, 0x1C, 0xC2,
  0x08, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7B, 0x8F, 0x0C, 0x18,
  0x30, 0x70, 0xE3, 0x7A, 0x04, 0x0C, 0x3F, 0xC0, 0xC1, 0x83, 0x06, 0x0F,
  0xDC, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x20, 0x70, 0xFF, 0xFF, 0xC0,
  0x13, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x79, 0xB6, 0x78, 0xF1, 0xB3, 0x36, 0x6C, 0x60, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFD, 0xEC, 0x73, 0xC6, 0x1C, 0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x1C,
  0x61, 0xC6, 0x10, 0xFF, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x7D,
  0x8F, 0x0C, 0x18, 0x30, 0x70, 0xA3, 0x7C, 0xFC, 0xE6, 0xC2, 0xC3, 0xC3,
  0xC3, 0xC2, 0xE6, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x7B, 0x8F, 0x0C, 0x18,
  0x30, 0x70, 0xE3, 0x7A, 0x04, 0x08, 0x10, 0x20, 0xFF, 0x31, 0x8C, 0x63,
  0x18, 0xC0, 0xFA, 0x08, 0x38, 0x38, 0x60, 0xE2, 0xF8, 0x21, 0x3E, 0xC6,
  0x31, 0x8C, 0x61, 0x0E, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x7A,
  0xC3, 0x42, 0x46, 0x66, 0x24, 0x2C, 0x3C, 0x18, 0x18, 0xC6, 0x34, 0x63,
  0x47, 0x26, 0xD2, 0x69, 0x62, 0x96, 0x29, 0xC3, 0x8C, 0x30, 0xC0, 0xC3,
  0x66, 0x3C, 0x18, 0x18, 0x3C, 0x24, 0x66, 0xC3, 0xC3, 0x42, 0x46, 0x66,
  0x24, 0x2C, 0x3C, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0, 0xF8, 0xC4, 0x62,
  0x33, 0x10, 0xF8, 0x39, 0x18, 0xC6, 0x31, 0x98, 0x63, 0x18, 0xC2, 0x1C,
  0x60, 0xFF, 0xFF, 0x80, 0xC3, 0x18, 0xC6, 0x30, 0xC3, 0x23, 0x18, 0xC6,
  0x62, 0x00, 0xF3, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 9, 12, 10, 0, -12 },
  { 21, 7, 14, 9, 1, -13 },
  { 34, 11, 12, 13, 1, -12 },
  { 51, 10, 12, 11, 1, -12 },
  { 66, 2, 4, 4, 1, -12 },
  { 67, 4, 15, 5, 1, -12 },
  { 75, 3, 15, 5, 1, -12 },
  { 81, 7, 7, 8, 1, -13 },
  { 88, 7, 8, 9, 1, -10 },
  { 95, 2, 4, 4, 1, -2 },
  { 96, 4, 1, 5, 1, -5 },
  { 97, 2, 2, 4, 1, -2 },
  { 98, 6, 12, 6, 0, -12 },
  { 107, 7, 12, 9, 1, -12 },
  { 118, 5, 12, 9, 1, -12 },
  { 126, 7, 12, 9, 1, -12 },
  { 137, 7, 12, 9, 1, -12 },
  { 148, 9, 12, 9, 0, -12 },
  { 162, 7, 12, 9, 1, -12 },
  { 173, 7, 12, 9, 1, -12 },
  { 184, 7, 12, 9, 1, -12 },
  { 195, 7, 12, 9, 1, -12 },
  { 206, 7, 12, 9, 1, -12 },
  { 217, 2, 9, 4, 1, -9 },
  { 220, 2, 11, 4, 1, -9 },
  { 223, 7, 8, 9, 1, -10 },
  { 230, 7, 4, 9, 1, -8 },
  { 234, 7, 8, 9, 1, -10 },
  { 241, 6, 12, 7, 0, -12 },
  { 250, 12, 13, 14, 1, -12 },
  { 270, 10, 12, 10, 0, -12 },
  { 285, 8, 12, 10, 1, -12 },
  { 297, 8, 12, 10, 1, -12 },
  { 309, 9, 12, 11, 1, -12 },
  { 323, 7, 12, 9, 1, -12 },
  { 334, 7, 12, 8, 1, -12 },
  { 345, 9, 12, 11, 1, -12 },
  { 359, 9, 12, 11, 1, -12 },
  { 373, 4, 12, 5, 1, -12 },
  { 379, 4, 15, 4, -1, -12 },
  { 387, 8, 12, 9, 1, -12 },
  { 399, 7, 12, 8, 1, -12 },
  { 410, 12, 12, 14, 1, -12 },
  { 428, 9, 12, 12, 1, -12 },
  { 442, 10, 12, 12, 1, -12 },
  { 457, 8, 12, 9, 1, -12 },
  { 469, 10, 15, 12, 1, -12 },
  { 488, 8, 12, 10, 1, -12 },
  { 500, 7, 12, 8, 1, -12 },
  { 511, 8, 12, 8, 0, -12 },
  { 523, 9, 12, 11, 1, -12 },
  { 537, 9, 12, 9, 0, -12 },
  { 551, 14, 12, 15, 0, -12 },
  { 572, 9, 12, 9, 0, -12 },
  { 586, 9, 12, 9, 0, -12 },
  { 600, 7, 12, 8, 1, -12 },
  { 611, 4, 15, 5, 1, -12 },
  { 619, 6, 12, 6, 0, -12 },
  { 628, 4, 15, 5, 0, -12 },
  { 636, 7, 7, 9, 1, -12 },
  { 643, 8, 2, 8, 0, 1 },
  { 645, 3, 3, 5, 1, -13 },
  { 647, 6, 9, 9, 1, -9 },
  { 654, 8, 13, 10, 1, -13 },
  { 667, 6, 9, 7, 1, -9 },
  { 674, 7, 13, 10, 1, -13 },
  { 686, 7, 9, 9, 1, -9 },
  { 694, 6, 13, 5, 0, -13 },
  { 704, 7, 13, 10, 1, -9 },
  { 716, 7, 13, 10, 1, -13 },
  { 728, 2, 13, 4, 1, -13 },
  { 732, 4, 17, 4, -1, -13 },
  { 741, 7, 13, 8, 1, -13 },
  { 753, 2, 13, 4, 1, -13 },
  { 757, 12, 9, 14, 1, -9 },
  { 771, 7, 9, 10, 1, -9 },
  { 779, 7, 9, 9, 1, -9 },
  { 787, 8, 13, 10, 1, -9 },
  { 800, 7, 13, 10, 1, -9 },
  { 812, 5, 9, 6, 1, -9 },
  { 818, 6, 9, 7, 1, -9 },
  { 825, 5, 11, 6, 0, -11 },
  { 832, 7, 9, 10, 1, -9 },
  { 840, 8, 9, 8, 0, -9 },
  { 849, 12, 9, 12, 0, -9 },
  { 863, 8, 9, 8, 0, -9 },
  { 872, 8, 13, 8, 0, -9 },
  { 885, 5, 9, 7, 1, -9 },
  { 891, 5, 15, 6, 1, -12 },
  { 901, 1, 17, 8, 4, -13 },
  { 904, 5, 15, 6, 1, -12 },
  { 914, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Regular17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR17PT7B_H_
