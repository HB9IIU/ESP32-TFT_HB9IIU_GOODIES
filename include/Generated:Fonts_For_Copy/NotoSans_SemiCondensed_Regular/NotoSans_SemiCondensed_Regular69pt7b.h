#ifndef _NOTOSANS_SEMICONDENSED_REGULAR69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07,
  0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0xF0, 0x7C, 0x7E, 0x0F, 0x00,
  0x8F, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x7F, 0xCF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF3, 0xFE, 0x00, 0x0F, 0x0F, 0xF0, 0x00,
  0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3F, 0x00,
  0x0F, 0x03, 0xFC, 0x00, 0xF0, 0x7E, 0xF8, 0x0F, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x1F, 0x03, 0xF8, 0x0F, 0x00,
  0x78, 0x3E, 0x1F, 0xFC, 0x1F, 0x01, 0xF0, 0xF8, 0x7F, 0xFC, 0x3E, 0x03,
  0xE1, 0xF0, 0xFF, 0xF8, 0x7C, 0x07, 0xC7, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x01, 0xF0, 0xFF, 0xF8,
  0x7C, 0x3E, 0x03, 0xE0, 0xFF, 0xE1, 0xF8, 0x7C, 0x07, 0xC0, 0xFF, 0x83,
  0xE0, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x3F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0xFE, 0x00,
  0xFF, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0xFC, 0x0F,
  0xC0, 0x00, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x60,
  0x0F, 0x00, 0x2F, 0xC0, 0xF0, 0x3F, 0xFF, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7C,
  0x03, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xBF, 0x1F, 0xCF, 0xDF, 0xE3, 0xFF, 0xF0, 0xFD, 0xF8,
  0x3F, 0x3C, 0x0F, 0xC4, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE1, 0xFC,
  0x00, 0x7F, 0x07, 0x80, 0x01, 0xFC, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE1, 0xF8, 0x00, 0x7F, 0x87, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFD, 0x80, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xFE, 0x7F, 0xF3,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE8, 0x00, 0x01, 0xFC, 0xC0, 0x00, 0x3F, 0xCF,
  0x80, 0x07, 0xF8, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x40, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0,
  0x0F, 0xC3, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x83, 0xF7, 0xFF, 0xFE, 0x1F,
  0x3F, 0xFF, 0xF8, 0xFB, 0xE0, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x3F, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0x3F, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0xF8, 0xFC, 0x07, 0xFF,
  0x87, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x0F, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x03, 0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0x87, 0xFE,
  0x78, 0x00, 0xFE, 0x20, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0x3F,
  0xFF, 0xC0, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x3E, 0x7E, 0x00, 0xFE,
  0x0F, 0xC0, 0x1E, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xE0,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1E, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x1E, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7C, 0xF8, 0x07, 0xE0,
  0x3D, 0xE0, 0x7C, 0xF8, 0x03, 0xF0, 0x7D, 0xF0, 0xF8, 0xFC, 0x01, 0xFF,
  0xF9, 0xFF, 0xF8, 0x7C, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x7C, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x07, 0xFE, 0x3F, 0x00, 0x01, 0xFE, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0x00, 0x7F, 0xC7, 0xE0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x07, 0xFB, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xF8, 0x0F, 0xF8, 0x00, 0x78, 0x0F,
  0xF8, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x3F, 0xF0, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xFF, 0x07, 0xE0, 0x00, 0x1F, 0xF0,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFF, 0x3F,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0x80, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x00, 0x18, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xC3, 0xFE,
  0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0xC1, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xC0, 0x00, 0xFF,
  0x8F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFB,
  0xF0, 0x00, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x00, 0x00, 0xFB, 0xFF, 0x9F,
  0x80, 0x00, 0x07, 0xEF, 0xFF, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0xFC, 0xF8,
  0x00, 0x00, 0x7C, 0xFF, 0xF3, 0xF0, 0x00, 0x03, 0xF3, 0xFF, 0xCF, 0xC0,
  0x00, 0x0F, 0x8F, 0xFF, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFF, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xFF, 0xC3, 0xE0, 0x00,
  0x3F, 0x0F, 0xFF, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0xFC, 0x3F, 0x00, 0x03,
  0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x00, 0x7C,
  0x0F, 0xFF, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0xF8, 0x0F,
  0xFF, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xF0,
  0x07, 0xC1, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xFF, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xF0, 0x00, 0x03, 0xFF,
  0xBF, 0x80, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xC0, 0x00,
  0x3F, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F,
  0x00, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x03, 0xFF,
  0xC1, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xE0,
  0x3F, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x00,
  0x3F, 0x83, 0xFF, 0xC0, 0x01, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xC3, 0xFF,
  0xC0, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0xC0, 0x00, 0x7E,
  0x3F, 0xFC, 0x00, 0x07, 0xF3, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0xFC, 0x00,
  0x03, 0xFB, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x7F,
  0xE3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x7F, 0x9F, 0x80, 0x0F, 0xF8, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC0, 0x03, 0xC3, 0xF8, 0x00, 0x0C, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xEE, 0x00, 0x01,
  0xFE, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3E, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC7, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFF, 0x01, 0xC0, 0x07, 0xF0, 0x20, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0x80, 0x7E, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xEF, 0xF0,
  0x3F, 0x7C, 0xFF, 0xFF, 0xCF, 0x9F, 0xFF, 0xF1, 0xF1, 0xFF, 0xFC, 0x3E,
  0x0F, 0xFE, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x0C, 0x00, 0x3F, 0x07, 0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0x03, 0xF3,
  0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFC, 0x3F, 0x7F, 0x1F, 0xF8, 0xFF, 0xE0,
  0x0F, 0xE3, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x1F,
  0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x03, 0xF3, 0xFE, 0x00, 0x1F, 0xCF,
  0xFE, 0x00, 0xFE, 0x3F, 0xFE, 0x0F, 0xF8, 0xFD, 0xFF, 0xFF, 0xC3, 0xE3,
  0xFF, 0xFE, 0x0F, 0x87, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0x0C, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0x06, 0x1F, 0xFC, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0x01,
  0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xE7, 0xC3, 0xFE,
  0x1F, 0xDF, 0x1F, 0xE0, 0x0F, 0xFC, 0x7F, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xDF, 0x07,
  0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0x87, 0xC0, 0x3F,
  0xFC, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x1F, 0xE0,
  0x01, 0xC0, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xC3, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0xC1, 0xF0, 0x1F, 0xFF, 0x87, 0xC0, 0xFF, 0xFF, 0x1F, 0x07,
  0xFF, 0xFE, 0x7C, 0x3F, 0xF3, 0xFD, 0xF1, 0xFE, 0x00, 0xFF, 0xC7, 0xF0,
  0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFD, 0xF0, 0x7F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0x3F, 0x01,
  0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x84, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x03, 0xC0, 0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x7F, 0xFF, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xDF, 0xC7, 0xFE, 0xFF, 0xE0, 0x0F,
  0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x00, 0x38,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFF, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFC, 0x00,
  0xFF, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xF8,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFD,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFD, 0xFC, 0xFF, 0xDF, 0xC7, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0x8F, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xDF, 0xC7, 0xFE, 0xFF, 0xE0, 0x0F, 0xEF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x7F, 0xF0, 0x0F, 0x87, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xE0, 0xFD,
  0xFF, 0xFF, 0xC3, 0xF7, 0xF1, 0xFF, 0x8F, 0xFE, 0x00, 0xFE, 0x3F, 0xE0,
  0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x0F,
  0xEF, 0xF8, 0x00, 0x3F, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0xE0, 0x0F, 0xE3,
  0xFF, 0xF1, 0xFF, 0x8F, 0xDF, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xE0, 0xFC,
  0x7F, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xF0, 0x1F, 0xFF, 0x87, 0xC0, 0xFF,
  0xFF, 0x1F, 0x07, 0xFF, 0xFE, 0x7C, 0x3F, 0xE1, 0xFD, 0xF1, 0xFE, 0x00,
  0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFF, 0x1F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xE1, 0xFD, 0xF0, 0x7F, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFF, 0x3F, 0x01, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xC3, 0xF0, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xEF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFE,
  0xF8, 0xFF, 0xEF, 0xDF, 0xFE, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFC, 0x7E, 0x00, 0x1C, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x7E, 0xF0, 0x00, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x30, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0x3F, 0xE3, 0xFD,
  0xF3, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xF1, 0xF0, 0xFF, 0xFE, 0x1F, 0x03,
  0xFF, 0x81, 0xF0, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1E, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x7C, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x67, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xB0, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 50, 18, 5, -49 },
  { 51, 19, 18, 27, 4, -49 },
  { 94, 36, 49, 40, 2, -49 },
  { 315, 28, 56, 36, 4, -52 },
  { 511, 47, 51, 53, 3, -50 },
  { 811, 41, 51, 44, 3, -50 },
  { 1073, 7, 18, 15, 4, -49 },
  { 1089, 15, 60, 21, 3, -49 },
  { 1202, 15, 60, 21, 2, -49 },
  { 1315, 28, 28, 34, 3, -52 },
  { 1413, 30, 33, 36, 3, -41 },
  { 1537, 10, 17, 17, 3, -8 },
  { 1559, 17, 5, 21, 2, -21 },
  { 1570, 8, 9, 17, 5, -8 },
  { 1579, 24, 49, 26, 1, -49 },
  { 1726, 30, 51, 36, 3, -50 },
  { 1918, 18, 49, 36, 5, -49 },
  { 2029, 29, 50, 36, 3, -50 },
  { 2211, 29, 51, 36, 3, -50 },
  { 2396, 34, 50, 36, 1, -50 },
  { 2609, 28, 50, 36, 4, -49 },
  { 2784, 29, 51, 36, 4, -50 },
  { 2969, 30, 49, 36, 3, -49 },
  { 3153, 30, 51, 36, 3, -50 },
  { 3345, 29, 51, 36, 3, -50 },
  { 3530, 8, 39, 17, 5, -38 },
  { 3569, 11, 47, 17, 2, -38 },
  { 3634, 30, 33, 36, 3, -41 },
  { 3758, 30, 19, 36, 3, -34 },
  { 3830, 30, 33, 36, 3, -41 },
  { 3954, 24, 51, 27, 1, -50 },
  { 4107, 48, 55, 56, 4, -49 },
  { 4437, 39, 49, 39, 0, -49 },
  { 4676, 31, 49, 41, 6, -49 },
  { 4866, 33, 51, 39, 4, -50 },
  { 5077, 35, 49, 45, 6, -49 },
  { 5292, 25, 49, 35, 6, -49 },
  { 5446, 25, 49, 32, 6, -49 },
  { 5600, 37, 51, 46, 4, -50 },
  { 5836, 34, 49, 46, 6, -49 },
  { 6045, 16, 49, 22, 3, -49 },
  { 6143, 17, 62, 18, -5, -49 },
  { 6275, 32, 49, 38, 6, -49 },
  { 6471, 25, 49, 32, 6, -49 },
  { 6625, 46, 49, 58, 6, -49 },
  { 6907, 36, 49, 48, 6, -49 },
  { 7128, 40, 51, 48, 4, -50 },
  { 7383, 29, 49, 38, 6, -49 },
  { 7561, 40, 62, 48, 4, -50 },
  { 7871, 32, 49, 39, 6, -49 },
  { 8067, 28, 51, 34, 3, -50 },
  { 8246, 32, 49, 34, 1, -49 },
  { 8442, 33, 50, 45, 6, -49 },
  { 8649, 37, 49, 37, 0, -49 },
  { 8876, 57, 49, 59, 1, -49 },
  { 9226, 35, 49, 36, 0, -49 },
  { 9441, 35, 49, 35, 0, -49 },
  { 9656, 30, 49, 34, 2, -49 },
  { 9840, 15, 60, 22, 5, -49 },
  { 9953, 24, 49, 26, 1, -49 },
  { 10100, 15, 60, 22, 2, -49 },
  { 10213, 32, 29, 36, 2, -49 },
  { 10329, 31, 4, 30, 0, 6 },
  { 10345, 13, 11, 19, 3, -53 },
  { 10363, 27, 39, 35, 3, -38 },
  { 10495, 30, 53, 39, 5, -52 },
  { 10694, 24, 39, 30, 4, -38 },
  { 10811, 30, 53, 39, 3, -52 },
  { 11010, 28, 39, 35, 4, -38 },
  { 11147, 23, 53, 21, 1, -53 },
  { 11300, 30, 55, 39, 3, -38 },
  { 11507, 28, 52, 39, 5, -52 },
  { 11689, 7, 51, 17, 5, -51 },
  { 11734, 15, 68, 17, -3, -51 },
  { 11862, 28, 52, 33, 5, -52 },
  { 12044, 6, 52, 17, 5, -52 },
  { 12083, 48, 38, 58, 5, -38 },
  { 12311, 28, 38, 39, 5, -38 },
  { 12444, 31, 39, 38, 3, -38 },
  { 12596, 30, 55, 39, 5, -38 },
  { 12803, 30, 55, 39, 3, -38 },
  { 13010, 20, 38, 26, 5, -38 },
  { 13105, 24, 39, 30, 3, -38 },
  { 13222, 20, 46, 22, 1, -45 },
  { 13337, 28, 38, 39, 5, -37 },
  { 13470, 31, 37, 32, 0, -37 },
  { 13614, 48, 37, 50, 1, -37 },
  { 13836, 30, 37, 33, 1, -37 },
  { 13975, 32, 54, 32, 0, -37 },
  { 14191, 24, 37, 28, 2, -37 },
  { 14302, 21, 60, 26, 2, -49 },
  { 14460, 5, 70, 34, 15, -53 },
  { 14504, 21, 60, 26, 2, -49 },
  { 14662, 30, 9, 36, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_Regular69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR69PT7B_H_
