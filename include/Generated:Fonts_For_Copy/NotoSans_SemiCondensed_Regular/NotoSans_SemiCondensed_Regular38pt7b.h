#ifndef _NOTOSANS_SEMICONDENSED_REGULAR38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x60, 0x00,
  0x4F, 0xFF, 0xF0, 0xF1, 0xFE, 0x3D, 0xC7, 0xB8, 0xE7, 0x1C, 0xE1, 0x9C,
  0x33, 0x06, 0x60, 0xCC, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0x83,
  0x80, 0x18, 0x38, 0x03, 0x83, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00, 0x38,
  0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x06, 0x00, 0x70, 0x60, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xE0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0xC0,
  0x1C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x38,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x1F, 0xFE, 0x3F,
  0xFE, 0x79, 0x9C, 0xF1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xF1,
  0x80, 0x79, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x01,
  0xBE, 0x01, 0x8F, 0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0x01, 0x8F, 0xC1,
  0x9E, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x08, 0x00, 0x08, 0x0F, 0xC0, 0x1C, 0x07, 0xF8, 0x07,
  0x01, 0x8E, 0x03, 0x80, 0xE1, 0xC0, 0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1C,
  0x1C, 0x03, 0x87, 0x06, 0x00, 0xC1, 0xC3, 0x80, 0x30, 0x70, 0xC0, 0x0C,
  0x1C, 0x70, 0x03, 0x87, 0x18, 0x70, 0xE1, 0xCE, 0x7E, 0x38, 0x73, 0x3F,
  0xC7, 0x39, 0xCE, 0x39, 0xFE, 0x73, 0x0E, 0x3F, 0x39, 0xC1, 0x82, 0x0E,
  0x70, 0x60, 0x07, 0x1C, 0x18, 0x01, 0xC7, 0x07, 0x00, 0xE1, 0xC1, 0xC0,
  0x38, 0x70, 0x60, 0x1C, 0x1C, 0x18, 0x07, 0x03, 0x0E, 0x03, 0x80, 0xC3,
  0x80, 0xE0, 0x38, 0xE0, 0x70, 0x07, 0xF0, 0x1C, 0x00, 0xF8, 0x00, 0x80,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0x70,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0x78, 0x1E, 0x78, 0xF0, 0x73, 0xC1, 0xE1, 0xCF,
  0x03, 0xCF, 0x38, 0x07, 0xB8, 0xE0, 0x1F, 0xE3, 0x80, 0x3F, 0x0E, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0x1F, 0xE1, 0xFF, 0xFB, 0xC3, 0xFF, 0x87,
  0x87, 0xFC, 0x0F, 0xFF, 0x77, 0x77, 0x76, 0x66, 0x07, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0,
  0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83,
  0x81, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x71, 0xC7, 0x7F, 0xBF, 0x7F, 0xFF, 0x83,
  0xC0, 0x03, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E, 0x3C, 0x0C,
  0x18, 0x04, 0x10, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x3C, 0xF3, 0x8E, 0x79, 0xC7, 0x1C, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x4F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3E, 0x7C, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x7D, 0xFC, 0xF6, 0x3D,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x01, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFC, 0xFC, 0x60, 0x3C, 0x40,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x3F,
  0xF0, 0x7F, 0xF8, 0xF8, 0x7C, 0x60, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x80, 0x3E, 0xFD,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x37, 0x80, 0x1D, 0xE0, 0x0E, 0x78, 0x03,
  0x9E, 0x01, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x78, 0x1C, 0x1E, 0x07, 0x07,
  0x83, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x38, 0x07, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x77, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x20, 0x7C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x80, 0x3C, 0xFD, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x30, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0x84, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE3, 0xF0,
  0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0E,
  0x3C, 0x1E, 0x3F, 0x7C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC,
  0x7C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x78, 0x1C, 0x3C, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x3E, 0xF8, 0x78, 0x3C, 0x70, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x7C, 0x7E, 0x3F, 0xFC,
  0x1F, 0xF0, 0x01, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x7E, 0x7C, 0x78, 0x3C,
  0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x78, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF,
  0x0F, 0x8E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x63, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x6F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0xF0, 0x18, 0xF3, 0xCF,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x8E,
  0x79, 0xC7, 0x1C, 0x63, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x80, 0x00, 0x03, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0x3E, 0x40, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xC1, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x7C, 0x0E, 0x70, 0x3F, 0xE1, 0xCE, 0x0F,
  0xBC, 0x19, 0xC3, 0x83, 0x83, 0x30, 0x70, 0x70, 0x7E, 0x1C, 0x0E, 0x0F,
  0xC3, 0x81, 0xC1, 0xF8, 0x70, 0x38, 0x3F, 0x0E, 0x07, 0x07, 0xE1, 0xC0,
  0xE0, 0xDC, 0x38, 0x1C, 0x1B, 0x87, 0x07, 0x87, 0x70, 0x70, 0xF0, 0xCE,
  0x0F, 0xF7, 0xF8, 0xE0, 0xFE, 0x7E, 0x1C, 0x07, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x40, 0x07,
  0xE0, 0x78, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0x77,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x03,
  0xDF, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xE3, 0xC0, 0xFD, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xBF, 0x1F, 0x00, 0x8F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x43, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x01, 0xF8,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F,
  0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xEF, 0xE1, 0xF0, 0x02, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0,
  0x0F, 0x1F, 0x00, 0x78, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xF1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x3F, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x7B, 0xFE, 0xFF, 0x3F, 0x80, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0E, 0x0F,
  0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xDE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xE7, 0x80, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xEE, 0x00, 0x1F, 0xFB, 0x80, 0x07, 0xFE, 0xE0, 0x03, 0xBF, 0x9C, 0x00,
  0xEF, 0xE7, 0x00, 0x3B, 0xF9, 0xE0, 0x1C, 0xFE, 0x38, 0x07, 0x3F, 0x8E,
  0x01, 0xCF, 0xE3, 0xC0, 0xE3, 0xF8, 0x70, 0x38, 0xFE, 0x1C, 0x0E, 0x3F,
  0x87, 0x87, 0x0F, 0xE0, 0xE1, 0xC3, 0xF8, 0x38, 0x70, 0xFE, 0x0F, 0x38,
  0x3F, 0x81, 0xCE, 0x0F, 0xE0, 0x77, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE,
  0x01, 0xC0, 0x3C, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7E, 0xE0, 0x07, 0xEF, 0x00, 0x7E, 0x78, 0x07, 0xE3,
  0x80, 0x7E, 0x3C, 0x07, 0xE1, 0xC0, 0x7E, 0x1E, 0x07, 0xE0, 0xE0, 0x7E,
  0x0F, 0x07, 0xE0, 0x78, 0x7E, 0x07, 0x87, 0xE0, 0x3C, 0x7E, 0x01, 0xC7,
  0xE0, 0x1E, 0x7E, 0x00, 0xE7, 0xE0, 0x0F, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00,
  0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFB, 0xF8, 0x1E, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3D,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFB, 0xF8, 0x1E, 0x01, 0xF0,
  0xF0, 0x03, 0xC3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x8F, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xC0, 0xF8, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0,
  0x3E, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x03, 0x83, 0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x8F, 0x00, 0xE3,
  0xC0, 0x3C, 0xF0, 0x07, 0x3C, 0x01, 0xEF, 0x00, 0x3C, 0x01, 0x80, 0x1F,
  0xF8, 0xFF, 0xFB, 0xFF, 0xE7, 0x80, 0x5E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x3D, 0xFF, 0xFB, 0xFF, 0xE3,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1C, 0xE0, 0x03, 0x9E, 0x00, 0xF3, 0xE0, 0x3C,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x7B, 0x80,
  0x03, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x78, 0x07, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE1, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x38,
  0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x70,
  0x03, 0xC0, 0x0F, 0x70, 0x03, 0xC0, 0x0E, 0x78, 0x03, 0xE0, 0x0E, 0x78,
  0x07, 0xE0, 0x0E, 0x38, 0x07, 0xE0, 0x1E, 0x38, 0x07, 0x70, 0x1C, 0x3C,
  0x0E, 0x70, 0x1C, 0x3C, 0x0E, 0x70, 0x1C, 0x1C, 0x0E, 0x70, 0x3C, 0x1C,
  0x0E, 0x38, 0x38, 0x1E, 0x1E, 0x38, 0x38, 0x1E, 0x1C, 0x38, 0x38, 0x0E,
  0x1C, 0x38, 0x78, 0x0E, 0x1C, 0x1C, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0F,
  0x38, 0x1C, 0x70, 0x07, 0x38, 0x1C, 0xF0, 0x07, 0x38, 0x0E, 0xF0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x03, 0xF0, 0x0E, 0xE0, 0x03,
  0xF0, 0x06, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE3, 0x80, 0x1C,
  0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0E,
  0x00, 0x71, 0xE0, 0x03, 0x9C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xBC, 0x00, 0x79, 0xC0, 0x07, 0x1E, 0x00, 0xF0, 0xE0, 0x0E, 0x0F, 0x01,
  0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x00, 0x1E,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x1C, 0x01,
  0xC3, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0x70, 0x70, 0x0E, 0x0E,
  0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0x70, 0x01,
  0xCE, 0x00, 0x63, 0x80, 0x38, 0x70, 0x0C, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1,
  0xC0, 0x07, 0xC0, 0xFF, 0xC3, 0xFF, 0x8E, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF3, 0xFF, 0xDF, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x8E, 0xDF, 0xF3,
  0x3F, 0x8C, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xE0, 0xE7, 0xF8, 0xEF, 0xFC,
  0xFC, 0x3E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0E, 0xF8, 0x1E, 0xFF, 0x7C, 0xEF, 0xFC, 0xE7, 0xF0,
  0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0x27, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x4F, 0xDE, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x07, 0x87, 0x1F, 0xE7, 0x3F, 0xF7, 0x3C, 0x3F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x1F, 0xF7, 0x0F, 0xE3, 0x03, 0xC0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x02, 0x3F, 0x3E, 0x1F,
  0xFE, 0x07, 0xFC, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xFF, 0x3F, 0xF8, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xE7, 0x3F, 0xF7, 0x3C, 0x3F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x1F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x60, 0x1E, 0x7F, 0xFE, 0x7F,
  0xFC, 0x1F, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE1, 0xE1, 0xCF, 0xF3, 0xBF, 0xF7,
  0xE1, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0xEE, 0xFE,
  0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x07, 0x03, 0x81, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0xBF, 0xDF, 0xCF, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x7B, 0x81, 0xE7, 0x03, 0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0xF0, 0x73, 0xC0,
  0xE7, 0x01, 0xDE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x3C, 0x1C, 0x38, 0x38,
  0x78, 0x70, 0x78, 0xE0, 0x71, 0xC0, 0xF3, 0x80, 0xF7, 0x01, 0xEE, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0x3C, 0x39, 0xFE, 0x3F, 0xCE, 0xFF, 0xDF, 0xFB, 0xF0, 0xFE,
  0x1F, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x1F, 0x80,
  0x78, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F,
  0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0,
  0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01,
  0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xC0, 0x01, 0xE1, 0xCF,
  0xF3, 0xBF, 0xF7, 0xE1, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xE0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3,
  0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x0F, 0x3C, 0x07, 0x0F, 0x9F, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xE0,
  0xE7, 0xF8, 0xEF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0xF8, 0x1E, 0xFE, 0x7C,
  0xEF, 0xFC, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x1F, 0xE3, 0x3F, 0xF7, 0x3C, 0x3F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x1F, 0x3E, 0x7F,
  0x1F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xFC,
  0xFF, 0xBF, 0x77, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x07, 0x81, 0xFF, 0x9F, 0xFD, 0xE0, 0x6E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x7C, 0x03, 0xBE, 0x7D, 0xFF, 0xCF,
  0xFC, 0x00, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x81, 0xFF, 0xBF, 0xF1,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x98, 0xFF, 0x0F,
  0xE0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x3E, 0xF9, 0xFD, 0xFF,
  0xB8, 0xFE, 0x30, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCF, 0x00, 0xE3,
  0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0F, 0x0E,
  0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x0F,
  0x01, 0xEE, 0x03, 0xE0, 0x39, 0xC0, 0x7C, 0x07, 0x3C, 0x0F, 0xC0, 0xE3,
  0x81, 0xB8, 0x3C, 0x70, 0x77, 0x07, 0x0E, 0x0E, 0xE0, 0xE1, 0xE1, 0xCE,
  0x1C, 0x1C, 0x71, 0xC3, 0x83, 0x8E, 0x38, 0xE0, 0x71, 0xC7, 0x1C, 0x0F,
  0x38, 0x73, 0x80, 0xEE, 0x0E, 0x70, 0x1D, 0xC1, 0xDC, 0x03, 0xB8, 0x1B,
  0x80, 0x76, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x38, 0x1C,
  0x3C, 0x3C, 0x1C, 0x38, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1C, 0x78,
  0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xF0, 0x03,
  0xB8, 0x03, 0xDC, 0x01, 0xCF, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xF0,
  0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x3F,
  0x07, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0xFE,
  0x0F, 0xC0, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF,
  0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 27, 10, 3, -27 },
  { 15, 11, 10, 15, 2, -27 },
  { 29, 20, 27, 22, 1, -27 },
  { 97, 16, 31, 20, 2, -29 },
  { 159, 26, 28, 29, 2, -28 },
  { 250, 22, 28, 24, 2, -28 },
  { 327, 4, 10, 8, 2, -27 },
  { 332, 8, 33, 11, 2, -27 },
  { 365, 9, 33, 11, 1, -27 },
  { 403, 16, 16, 19, 1, -29 },
  { 435, 16, 19, 20, 2, -23 },
  { 473, 6, 9, 10, 1, -4 },
  { 480, 9, 3, 12, 1, -12 },
  { 484, 4, 5, 10, 3, -5 },
  { 487, 14, 27, 14, 0, -27 },
  { 535, 16, 28, 20, 2, -28 },
  { 591, 10, 27, 20, 3, -27 },
  { 625, 16, 28, 20, 2, -28 },
  { 681, 16, 28, 20, 2, -28 },
  { 737, 18, 27, 20, 1, -27 },
  { 798, 16, 27, 20, 2, -27 },
  { 852, 16, 28, 20, 2, -28 },
  { 908, 17, 27, 20, 1, -27 },
  { 966, 16, 28, 20, 2, -28 },
  { 1022, 16, 28, 20, 2, -28 },
  { 1078, 4, 21, 10, 3, -21 },
  { 1089, 6, 26, 10, 1, -21 },
  { 1109, 16, 18, 20, 2, -23 },
  { 1145, 16, 11, 20, 2, -19 },
  { 1167, 16, 18, 20, 2, -23 },
  { 1203, 14, 28, 15, 0, -28 },
  { 1252, 27, 30, 31, 2, -27 },
  { 1354, 22, 27, 22, 0, -27 },
  { 1429, 17, 27, 22, 3, -27 },
  { 1487, 18, 28, 21, 2, -28 },
  { 1550, 20, 27, 25, 3, -27 },
  { 1618, 14, 27, 19, 3, -27 },
  { 1666, 14, 27, 18, 3, -27 },
  { 1714, 21, 28, 25, 2, -28 },
  { 1788, 19, 27, 25, 3, -27 },
  { 1853, 10, 27, 12, 1, -27 },
  { 1887, 10, 34, 10, -3, -27 },
  { 1930, 18, 27, 21, 3, -27 },
  { 1991, 14, 27, 18, 3, -27 },
  { 2039, 26, 27, 32, 3, -27 },
  { 2127, 20, 27, 26, 3, -27 },
  { 2195, 22, 28, 26, 2, -28 },
  { 2272, 16, 27, 21, 3, -27 },
  { 2326, 22, 34, 26, 2, -28 },
  { 2420, 18, 27, 21, 3, -27 },
  { 2481, 15, 28, 19, 2, -28 },
  { 2534, 18, 27, 19, 0, -27 },
  { 2595, 19, 27, 25, 3, -27 },
  { 2660, 21, 27, 21, 0, -27 },
  { 2731, 32, 27, 32, 0, -27 },
  { 2839, 20, 27, 20, 0, -27 },
  { 2907, 19, 27, 19, 0, -27 },
  { 2972, 17, 27, 19, 1, -27 },
  { 3030, 8, 33, 12, 3, -27 },
  { 3063, 14, 27, 14, 0, -27 },
  { 3111, 8, 33, 12, 1, -27 },
  { 3144, 18, 16, 20, 1, -27 },
  { 3180, 17, 3, 17, 0, 3 },
  { 3187, 7, 6, 10, 2, -29 },
  { 3193, 14, 21, 19, 2, -21 },
  { 3230, 16, 29, 21, 3, -29 },
  { 3288, 13, 21, 16, 2, -21 },
  { 3323, 16, 29, 21, 2, -29 },
  { 3381, 16, 21, 19, 2, -21 },
  { 3423, 13, 29, 12, 0, -29 },
  { 3471, 16, 30, 21, 2, -21 },
  { 3531, 15, 29, 21, 3, -29 },
  { 3586, 4, 28, 9, 3, -28 },
  { 3600, 9, 37, 9, -2, -28 },
  { 3642, 15, 29, 18, 3, -29 },
  { 3697, 3, 29, 9, 3, -29 },
  { 3708, 26, 21, 32, 3, -21 },
  { 3777, 15, 21, 21, 3, -21 },
  { 3817, 17, 21, 21, 2, -21 },
  { 3862, 16, 30, 21, 3, -21 },
  { 3922, 16, 30, 21, 2, -21 },
  { 3982, 11, 21, 14, 3, -21 },
  { 4011, 13, 21, 16, 2, -21 },
  { 4046, 11, 25, 12, 1, -25 },
  { 4081, 15, 20, 21, 3, -20 },
  { 4119, 17, 20, 17, 0, -20 },
  { 4162, 27, 20, 27, 0, -20 },
  { 4230, 16, 20, 18, 1, -20 },
  { 4270, 17, 29, 17, 0, -20 },
  { 4332, 13, 20, 16, 1, -20 },
  { 4365, 12, 33, 14, 1, -27 },
  { 4415, 3, 38, 19, 8, -29 },
  { 4430, 12, 33, 14, 1, -27 },
  { 4480, 16, 5, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Regular38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR38PT7B_H_
