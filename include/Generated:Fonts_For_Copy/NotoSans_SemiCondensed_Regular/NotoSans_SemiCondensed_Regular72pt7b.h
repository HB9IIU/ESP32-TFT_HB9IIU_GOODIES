#ifndef _NOTOSANS_SEMICONDENSED_REGULAR72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC7, 0x87, 0xE1, 0xFC, 0x1E, 0x01, 0x8F, 0xE0, 0x78,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x03, 0xF0, 0x1E, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x03,
  0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x7F,
  0xE7, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x7F,
  0xC0, 0x00, 0x78, 0x7F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x07, 0x81, 0xFC,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0x78, 0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0xA0, 0x01,
  0xE0, 0xFE, 0xE0, 0x07, 0x87, 0xFB, 0xF8, 0x1E, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x10, 0x03, 0xE0, 0x1F, 0x87, 0xE0,
  0xFF, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0xFF, 0xE0, 0xF8, 0x07, 0xC3, 0xF0,
  0xFF, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0x03, 0xF1, 0xF8,
  0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x7C, 0x0F, 0xC3, 0xF3, 0xF8, 0xFC,
  0x3E, 0x03, 0xE1, 0xFF, 0xF8, 0x7C, 0x3E, 0x01, 0xF0, 0x7F, 0xF8, 0x3E,
  0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0x0F, 0x80, 0x3E, 0x03, 0xF8, 0x1F,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x3F, 0xC0, 0x03, 0xF0,
  0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x81, 0xFC,
  0x03, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0x7E, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x9F, 0x81, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x8F, 0x1E, 0x3C,
  0x78, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x00,
  0x3E, 0x00, 0x67, 0xC0, 0xF8, 0x0F, 0xBF, 0xE1, 0xE3, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xBF, 0x3F, 0xCF, 0xDF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0x78, 0x0F, 0xCC, 0x03, 0xF1, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0x00,
  0x03, 0xF8, 0x18, 0x00, 0x07, 0xF0, 0x20, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1E, 0x00, 0x03, 0xF8,
  0x10, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x00, 0x3F, 0x9C,
  0x00, 0x01, 0xFF, 0x3F, 0x00, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x20, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x20, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x1F, 0xE3, 0xF0, 0x01, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0x80, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xFC, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8,
  0x3F, 0x3F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xCF,
  0xFC, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xCF, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x01,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00,
  0x03, 0xFE, 0x7F, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x83,
  0xFB, 0xF0, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xFE,
  0x3F, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0xC3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFE,
  0x3F, 0xF9, 0xF0, 0x01, 0xFC, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x06,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x7E, 0x1F, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0x8F, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xE3, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xF8, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x7E, 0x01,
  0xFC, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF7, 0xC0,
  0x3F, 0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xFC,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xBE, 0x00, 0xFC, 0x03,
  0xFC, 0x07, 0xCF, 0xC0, 0x1F, 0x81, 0xEF, 0x83, 0xF1, 0xF0, 0x07, 0xF9,
  0xF9, 0xFB, 0xF8, 0x7C, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0x00, 0x1F,
  0xFE, 0x0F, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0xE3,
  0xF8, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x3F, 0xE7, 0xF0, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xE0, 0x1F, 0xF0, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x1F,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0x00, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xA0, 0x3F, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0x80, 0x00,
  0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3F,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xF9, 0xFC, 0x00,
  0x03, 0xFF, 0xCF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xF1,
  0xFC, 0x00, 0x07, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x01,
  0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x1F,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF8,
  0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0,
  0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xFC, 0x00,
  0x1F, 0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x3F,
  0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0x9F, 0xFC,
  0x00, 0x00, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x5E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF8, 0x03, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0xE3, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x18,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x80, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x81,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xFE,
  0x07, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFE, 0x03, 0xF3, 0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x1F, 0xF7, 0xF0,
  0x07, 0xFF, 0x7F, 0xE1, 0xFD, 0xF3, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xF1,
  0xF0, 0xFF, 0xFE, 0x1F, 0x07, 0xFF, 0x80, 0xF0, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x7F, 0xFC, 0x03, 0xF3, 0xFF, 0xFE,
  0x07, 0xEF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x7E, 0x07, 0xFC,
  0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0xC0, 0x00,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0xFF, 0x80, 0x07, 0xF1, 0xFF, 0xC0, 0x1F,
  0xE3, 0xEF, 0xFB, 0xFF, 0x87, 0xCF, 0xFF, 0xFE, 0x0F, 0x8F, 0xFF, 0xF8,
  0x1F, 0x0F, 0xFF, 0xE0, 0x3C, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x7F, 0x80, 0x08, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x8F, 0xF8, 0x01, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7E, 0x03,
  0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x7F, 0xFF, 0xF3, 0xF0, 0xFF,
  0xFF, 0xF7, 0xE3, 0xFE, 0x03, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0x9F, 0xC0,
  0x01, 0xFF, 0x7F, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFF, 0x3F,
  0xC0, 0x07, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFD, 0xF8, 0x7F,
  0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x7F, 0xFF, 0x0F, 0xC0, 0x3F,
  0xFC, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0xFF, 0x80, 0x07, 0x83, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0x0E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0xF0, 0xFC,
  0x0F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xE3,
  0xFE, 0x07, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x7F,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFE,
  0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xF3, 0xF0,
  0x7F, 0xFF, 0xC7, 0xE0, 0x7F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x1F, 0x80,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x00,
  0x03, 0xF8, 0x70, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x0F, 0xFC, 0x07, 0xE1, 0xFF, 0xF8, 0x3F, 0x3F,
  0xFF, 0xE1, 0xFB, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7D, 0xF8, 0x0F,
  0xF3, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x83, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0xFB,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7C, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x3E, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xDF, 0x01, 0xFE, 0xFC, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0xF8, 0x0F, 0xFC, 0x07, 0xC1, 0xFF,
  0xF8, 0x3E, 0x3F, 0xFF, 0xE1, 0xF3, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF, 0xFE,
  0x7D, 0xF8, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xF8, 0x01,
  0xF0, 0x7F, 0xFC, 0x03, 0xE3, 0xFF, 0xFE, 0x07, 0xCF, 0xFF, 0xFE, 0x0F,
  0x9F, 0xFF, 0xFE, 0x1F, 0x7E, 0x03, 0xFC, 0x3F, 0xF0, 0x03, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0xF1, 0xFF, 0xC0, 0x3F, 0xE3, 0xEF, 0xFB, 0xFF, 0x87,
  0xEF, 0xFF, 0xFE, 0x0F, 0xCF, 0xFF, 0xF8, 0x1F, 0x8F, 0xFF, 0xE0, 0x3F,
  0x07, 0xFF, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x3E, 0x03, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFF, 0xF7, 0xE3, 0xFE, 0x03, 0xEF, 0xCF, 0xF0, 0x03, 0xFF,
  0x9F, 0xC0, 0x01, 0xFF, 0x7F, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x01,
  0xFF, 0x3F, 0xC0, 0x07, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFD,
  0xF8, 0x7F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x7F, 0xFF, 0x0F,
  0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFE, 0xF9, 0xFF, 0xEF, 0x9F,
  0xFE, 0xFB, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE3, 0xFC, 0x01, 0xF1, 0xF8, 0x00, 0x11, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xDE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0x7F,
  0x80, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xC7, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xF8, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xDF, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x05, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x60, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 52, 19, 5, -51 },
  { 53, 20, 18, 29, 4, -51 },
  { 98, 38, 51, 42, 2, -51 },
  { 341, 30, 59, 37, 4, -55 },
  { 563, 49, 53, 55, 3, -52 },
  { 888, 43, 53, 46, 3, -52 },
  { 1173, 7, 18, 16, 4, -51 },
  { 1189, 16, 63, 21, 3, -52 },
  { 1315, 16, 63, 21, 2, -52 },
  { 1441, 30, 30, 36, 3, -55 },
  { 1554, 31, 35, 37, 3, -43 },
  { 1690, 10, 17, 18, 3, -8 },
  { 1712, 16, 6, 22, 3, -22 },
  { 1724, 8, 10, 18, 5, -9 },
  { 1734, 25, 51, 27, 1, -51 },
  { 1894, 31, 53, 37, 3, -52 },
  { 2100, 18, 51, 37, 6, -51 },
  { 2215, 31, 52, 37, 3, -52 },
  { 2417, 31, 53, 37, 3, -52 },
  { 2623, 35, 52, 37, 1, -52 },
  { 2851, 30, 52, 37, 4, -51 },
  { 3046, 30, 53, 37, 4, -52 },
  { 3245, 31, 51, 37, 3, -51 },
  { 3443, 31, 53, 37, 3, -52 },
  { 3649, 31, 53, 37, 3, -52 },
  { 3855, 8, 40, 18, 5, -39 },
  { 3895, 11, 48, 18, 2, -39 },
  { 3961, 31, 34, 37, 3, -43 },
  { 4093, 31, 20, 37, 3, -35 },
  { 4171, 31, 34, 37, 3, -43 },
  { 4303, 25, 53, 28, 1, -52 },
  { 4469, 50, 58, 58, 4, -52 },
  { 4832, 41, 52, 41, 0, -52 },
  { 5099, 33, 51, 42, 6, -51 },
  { 5310, 35, 53, 41, 4, -52 },
  { 5542, 37, 51, 47, 6, -51 },
  { 5778, 26, 51, 36, 6, -51 },
  { 5944, 26, 51, 34, 6, -51 },
  { 6110, 39, 53, 48, 4, -52 },
  { 6369, 35, 51, 48, 6, -51 },
  { 6593, 17, 51, 23, 3, -51 },
  { 6702, 17, 65, 18, -5, -51 },
  { 6841, 34, 51, 40, 6, -51 },
  { 7058, 26, 51, 34, 6, -51 },
  { 7224, 48, 51, 60, 6, -51 },
  { 7530, 37, 51, 50, 6, -51 },
  { 7766, 42, 53, 50, 4, -52 },
  { 8045, 30, 51, 39, 6, -51 },
  { 8237, 42, 64, 50, 4, -52 },
  { 8573, 34, 51, 41, 6, -51 },
  { 8790, 30, 53, 36, 3, -52 },
  { 8989, 34, 51, 35, 1, -51 },
  { 9206, 35, 52, 47, 6, -51 },
  { 9434, 39, 51, 39, 0, -51 },
  { 9683, 60, 51, 61, 1, -51 },
  { 10066, 37, 51, 37, 0, -51 },
  { 10302, 36, 51, 36, 0, -51 },
  { 10532, 31, 51, 36, 2, -51 },
  { 10730, 15, 63, 23, 6, -52 },
  { 10849, 25, 51, 27, 1, -51 },
  { 11009, 16, 63, 23, 2, -52 },
  { 11135, 34, 31, 38, 2, -52 },
  { 11267, 32, 5, 32, 0, 6 },
  { 11287, 14, 11, 20, 3, -55 },
  { 11307, 28, 40, 37, 3, -39 },
  { 11447, 31, 56, 40, 6, -55 },
  { 11664, 25, 40, 31, 4, -39 },
  { 11789, 31, 56, 40, 4, -55 },
  { 12006, 29, 40, 37, 4, -39 },
  { 12151, 24, 55, 22, 1, -55 },
  { 12316, 31, 56, 40, 4, -39 },
  { 12533, 29, 55, 40, 6, -55 },
  { 12733, 7, 53, 17, 5, -53 },
  { 12780, 15, 70, 17, -3, -53 },
  { 12912, 28, 55, 35, 6, -55 },
  { 13105, 6, 55, 17, 6, -55 },
  { 13147, 49, 39, 61, 6, -39 },
  { 13386, 29, 39, 40, 6, -39 },
  { 13528, 32, 40, 39, 4, -39 },
  { 13688, 31, 56, 40, 6, -39 },
  { 13905, 31, 56, 40, 4, -39 },
  { 14122, 20, 39, 27, 6, -39 },
  { 14220, 25, 40, 31, 3, -39 },
  { 14345, 21, 48, 23, 1, -47 },
  { 14471, 30, 40, 40, 5, -39 },
  { 14621, 33, 39, 33, 0, -39 },
  { 14782, 50, 39, 52, 1, -39 },
  { 15026, 32, 39, 34, 1, -39 },
  { 15182, 33, 56, 33, 0, -39 },
  { 15413, 25, 39, 29, 2, -39 },
  { 15535, 22, 62, 27, 2, -51 },
  { 15706, 6, 72, 36, 15, -55 },
  { 15760, 21, 62, 27, 3, -51 },
  { 15923, 31, 9, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_Regular72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR72PT7B_H_
