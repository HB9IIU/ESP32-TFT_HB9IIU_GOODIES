#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_Regular
// Headers: 67

#include "NotoSans_SemiCondensed_Regular6pt7b.h"
#include "NotoSans_SemiCondensed_Regular7pt7b.h"
#include "NotoSans_SemiCondensed_Regular8pt7b.h"
#include "NotoSans_SemiCondensed_Regular9pt7b.h"
#include "NotoSans_SemiCondensed_Regular10pt7b.h"
#include "NotoSans_SemiCondensed_Regular11pt7b.h"
#include "NotoSans_SemiCondensed_Regular12pt7b.h"
#include "NotoSans_SemiCondensed_Regular13pt7b.h"
#include "NotoSans_SemiCondensed_Regular14pt7b.h"
#include "NotoSans_SemiCondensed_Regular15pt7b.h"
#include "NotoSans_SemiCondensed_Regular16pt7b.h"
#include "NotoSans_SemiCondensed_Regular17pt7b.h"
#include "NotoSans_SemiCondensed_Regular18pt7b.h"
#include "NotoSans_SemiCondensed_Regular19pt7b.h"
#include "NotoSans_SemiCondensed_Regular20pt7b.h"
#include "NotoSans_SemiCondensed_Regular21pt7b.h"
#include "NotoSans_SemiCondensed_Regular22pt7b.h"
#include "NotoSans_SemiCondensed_Regular23pt7b.h"
#include "NotoSans_SemiCondensed_Regular24pt7b.h"
#include "NotoSans_SemiCondensed_Regular25pt7b.h"
#include "NotoSans_SemiCondensed_Regular26pt7b.h"
#include "NotoSans_SemiCondensed_Regular27pt7b.h"
#include "NotoSans_SemiCondensed_Regular28pt7b.h"
#include "NotoSans_SemiCondensed_Regular29pt7b.h"
#include "NotoSans_SemiCondensed_Regular30pt7b.h"
#include "NotoSans_SemiCondensed_Regular31pt7b.h"
#include "NotoSans_SemiCondensed_Regular32pt7b.h"
#include "NotoSans_SemiCondensed_Regular33pt7b.h"
#include "NotoSans_SemiCondensed_Regular34pt7b.h"
#include "NotoSans_SemiCondensed_Regular35pt7b.h"
#include "NotoSans_SemiCondensed_Regular36pt7b.h"
#include "NotoSans_SemiCondensed_Regular37pt7b.h"
#include "NotoSans_SemiCondensed_Regular38pt7b.h"
#include "NotoSans_SemiCondensed_Regular39pt7b.h"
#include "NotoSans_SemiCondensed_Regular40pt7b.h"
#include "NotoSans_SemiCondensed_Regular41pt7b.h"
#include "NotoSans_SemiCondensed_Regular42pt7b.h"
#include "NotoSans_SemiCondensed_Regular43pt7b.h"
#include "NotoSans_SemiCondensed_Regular44pt7b.h"
#include "NotoSans_SemiCondensed_Regular45pt7b.h"
#include "NotoSans_SemiCondensed_Regular46pt7b.h"
#include "NotoSans_SemiCondensed_Regular47pt7b.h"
#include "NotoSans_SemiCondensed_Regular48pt7b.h"
#include "NotoSans_SemiCondensed_Regular49pt7b.h"
#include "NotoSans_SemiCondensed_Regular50pt7b.h"
#include "NotoSans_SemiCondensed_Regular51pt7b.h"
#include "NotoSans_SemiCondensed_Regular52pt7b.h"
#include "NotoSans_SemiCondensed_Regular53pt7b.h"
#include "NotoSans_SemiCondensed_Regular54pt7b.h"
#include "NotoSans_SemiCondensed_Regular55pt7b.h"
#include "NotoSans_SemiCondensed_Regular56pt7b.h"
#include "NotoSans_SemiCondensed_Regular57pt7b.h"
#include "NotoSans_SemiCondensed_Regular58pt7b.h"
#include "NotoSans_SemiCondensed_Regular59pt7b.h"
#include "NotoSans_SemiCondensed_Regular60pt7b.h"
#include "NotoSans_SemiCondensed_Regular61pt7b.h"
#include "NotoSans_SemiCondensed_Regular62pt7b.h"
#include "NotoSans_SemiCondensed_Regular63pt7b.h"
#include "NotoSans_SemiCondensed_Regular64pt7b.h"
#include "NotoSans_SemiCondensed_Regular65pt7b.h"
#include "NotoSans_SemiCondensed_Regular66pt7b.h"
#include "NotoSans_SemiCondensed_Regular67pt7b.h"
#include "NotoSans_SemiCondensed_Regular68pt7b.h"
#include "NotoSans_SemiCondensed_Regular69pt7b.h"
#include "NotoSans_SemiCondensed_Regular70pt7b.h"
#include "NotoSans_SemiCondensed_Regular71pt7b.h"
#include "NotoSans_SemiCondensed_Regular72pt7b.h"
