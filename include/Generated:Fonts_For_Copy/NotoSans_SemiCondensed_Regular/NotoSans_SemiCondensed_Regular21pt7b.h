#ifndef _NOTOSANS_SEMICONDENSED_REGULAR21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xD2, 0x49, 0x05, 0xD8, 0xCF, 0x3C, 0xD3, 0x4C, 0x0C,
  0x40, 0xCC, 0x0C, 0xC0, 0x88, 0x7F, 0xF7, 0xFF, 0x18, 0x81, 0x98, 0x19,
  0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x31, 0x03, 0x30, 0x33, 0x00, 0x08, 0x04,
  0x0F, 0xCD, 0x6C, 0x86, 0x43, 0x20, 0xF0, 0x3E, 0x07, 0x82, 0x61, 0x30,
  0x9F, 0xF9, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x23, 0x21, 0x8C, 0xC4, 0x23,
  0x30, 0x8C, 0x82, 0x36, 0x0C, 0xD3, 0xB2, 0xDB, 0x7A, 0x44, 0x19, 0x10,
  0x4C, 0x43, 0x11, 0x08, 0x44, 0x61, 0xB1, 0x03, 0x80, 0x3E, 0x03, 0x70,
  0x63, 0x06, 0x30, 0x63, 0x03, 0x60, 0x1C, 0x03, 0xC1, 0x6E, 0x2C, 0x66,
  0xC3, 0x6C, 0x1C, 0xC1, 0xC6, 0x76, 0x7E, 0x30, 0xFD, 0x40, 0x19, 0x98,
  0xC4, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x61, 0x8C, 0x21, 0xC0, 0xC4, 0x66,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x26, 0x6C, 0x18, 0x0C, 0x06, 0x1D, 0xE7,
  0xE8, 0xE0, 0xD8, 0xCC, 0x24, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x6B, 0x68, 0xF8, 0x5D, 0x80, 0x03,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60,
  0x60, 0xC0, 0x3E, 0x3B, 0x98, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x36, 0x33, 0xB8, 0xF8, 0x19, 0xDF, 0xB1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x60, 0x7E, 0x73, 0x90, 0xC0, 0x20, 0x30, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x07, 0xFF, 0xFE, 0x7E, 0x73,
  0xA0, 0xC0, 0x20, 0x30, 0x18, 0xF8, 0x7C, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x36, 0x3B, 0xF8, 0x03, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0xD8, 0x33, 0x04,
  0x61, 0x8C, 0x61, 0x88, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60,
  0x7F, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x03, 0xF8, 0x8E, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x36, 0x3B, 0xF8, 0x1F, 0x1C, 0x98, 0x0C, 0x04, 0x06, 0x03,
  0x7D, 0xC6, 0xC1, 0xE0, 0xF0, 0x78, 0x36, 0x1B, 0x98, 0xF8, 0xFF, 0xFF,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x3E, 0x31, 0xB0, 0x58, 0x34, 0x13, 0x18, 0xF8, 0x7C,
  0x67, 0x60, 0xF0, 0x78, 0x3C, 0x1B, 0x18, 0xF8, 0x3E, 0x33, 0xB0, 0xD8,
  0x3C, 0x1E, 0x0F, 0x06, 0xC7, 0x7D, 0x80, 0xC0, 0x40, 0x60, 0x32, 0x71,
  0xF0, 0xFC, 0x00, 0x00, 0x5D, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x6D, 0x00,
  0x00, 0x80, 0xC1, 0xC3, 0x87, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x1C, 0x38, 0x70, 0x60, 0x00, 0x7C, 0xE6, 0x03, 0x03, 0x03, 0x06,
  0x0C, 0x18, 0x18, 0x10, 0x10, 0x00, 0x10, 0x38, 0x38, 0x07, 0xE0, 0x38,
  0x60, 0xC0, 0x61, 0x00, 0x66, 0x3E, 0x48, 0xCC, 0xF3, 0x19, 0xE6, 0x33,
  0xCC, 0x67, 0x98, 0x8F, 0x31, 0x96, 0x3D, 0xE4, 0x31, 0x8C, 0x00, 0x0C,
  0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x06, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x09,
  0x01, 0x98, 0x19, 0x81, 0x08, 0x30, 0xC3, 0xFC, 0x20, 0x46, 0x06, 0x60,
  0x64, 0x02, 0xC0, 0x30, 0xFE, 0x7F, 0xB0, 0x78, 0x3C, 0x1E, 0x0B, 0xFD,
  0xFC, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFB, 0xF8, 0x0F, 0xCF, 0x77,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x70, 0x0F, 0x31, 0xFC, 0xFE, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x16, 0x03, 0xC0, 0x58, 0x1B, 0x03, 0x60, 0x6C, 0x19, 0xFE, 0x3F,
  0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0C,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x00, 0x0F, 0xE7, 0x9C, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x0F, 0xC1, 0xF8, 0x05, 0x80, 0xB0, 0x17, 0x02, 0x79,
  0xC3, 0xF8, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFB, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xE0, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x37, 0xB8, 0xC1, 0xB0, 0xCC, 0x33, 0x18,
  0xCC, 0x36, 0x0F, 0x03, 0xE0, 0xDC, 0x33, 0x0C, 0x63, 0x18, 0xC3, 0x30,
  0x6C, 0x1C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0x80, 0xE0, 0x1F, 0x80, 0x7A, 0x03, 0xFC, 0x0B, 0xF0,
  0x2F, 0x41, 0xBD, 0x84, 0xF6, 0x33, 0xC8, 0xCF, 0x32, 0x3C, 0xD8, 0xF1,
  0x63, 0xC7, 0x0F, 0x1C, 0x3C, 0x30, 0xC0, 0xC0, 0x7C, 0x0F, 0x81, 0xD8,
  0x3D, 0x87, 0xB0, 0xF3, 0x1E, 0x63, 0xC6, 0x78, 0xCF, 0x0D, 0xE1, 0xFC,
  0x1F, 0x81, 0xF0, 0x38, 0x1F, 0x83, 0x9E, 0x70, 0x66, 0x03, 0x40, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x03, 0x70, 0x63,
  0x9E, 0x1F, 0x80, 0xFC, 0x7F, 0xB0, 0xD8, 0x2C, 0x1E, 0x0B, 0x0D, 0x9E,
  0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0x83, 0x9E, 0x70,
  0x66, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40,
  0x36, 0x03, 0x70, 0x63, 0x9E, 0x1F, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0xFC, 0x3F, 0xCC, 0x33, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0xF8, 0xFC,
  0x31, 0x0C, 0x63, 0x0C, 0xC3, 0x30, 0x6C, 0x1C, 0x3F, 0x3B, 0xB0, 0x18,
  0x0C, 0x07, 0x01, 0xE0, 0x7C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x37, 0x3B,
  0xF8, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xDC, 0xE3, 0xF0, 0xC0, 0x78, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0x61, 0x8C,
  0x61, 0x8C, 0x11, 0x83, 0x20, 0x6C, 0x05, 0x80, 0xE0, 0x1C, 0x01, 0x80,
  0xC0, 0xC0, 0xD0, 0x30, 0x66, 0x1C, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x88,
  0x48, 0x43, 0x33, 0x30, 0xCC, 0xCC, 0x32, 0x33, 0x04, 0x84, 0x81, 0xE1,
  0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0xE0, 0xEC,
  0x18, 0xC6, 0x18, 0xC1, 0xB0, 0x34, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x60,
  0x4C, 0x18, 0xC6, 0x18, 0xC1, 0xB0, 0x38, 0xC0, 0xEC, 0x19, 0x86, 0x18,
  0xC3, 0x10, 0x26, 0x06, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x07, 0xFF, 0xFE, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x03, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x08, 0x0E, 0x05, 0x06, 0xC2, 0x23,
  0x19, 0x05, 0x83, 0x80, 0x80, 0xFF, 0x80, 0xC6, 0x30, 0x7E, 0x43, 0x03,
  0x03, 0x1F, 0x7F, 0xC3, 0xC3, 0xC3, 0xC7, 0x79, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x05, 0xF3, 0x8D, 0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x3C, 0x16, 0x1B,
  0x9D, 0x7C, 0x3E, 0xC5, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xE4, 0xF8,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x19, 0xFD, 0x8F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1A, 0x0D, 0xCE, 0x79, 0x3E, 0x31, 0x90, 0x58, 0x3F, 0xFF,
  0xFF, 0x01, 0x80, 0x60, 0x38, 0x8F, 0xC0, 0x1E, 0x74, 0xC1, 0x83, 0x1F,
  0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3E, 0xB1, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x41, 0xB9, 0xCF, 0x60, 0x30, 0x18,
  0x0D, 0xFC, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xE3, 0xC3, 0xC3,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x5D, 0x00, 0x92, 0x49, 0x24,
  0x92, 0x11, 0xC4, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x85, 0xEE, 0x00, 0x80, 0x80, 0x80, 0x80, 0x81, 0x86, 0x8C, 0x98, 0x98,
  0xB0, 0xF8, 0xD8, 0x8C, 0x8C, 0x86, 0x83, 0xFF, 0xFF, 0xBE, 0xFB, 0x9E,
  0x3C, 0x30, 0xF0, 0xC3, 0x83, 0x0E, 0x0C, 0x38, 0x30, 0xE0, 0xC3, 0x83,
  0x0E, 0x0C, 0x38, 0x30, 0xC0, 0xBE, 0xE3, 0xC3, 0xC3, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x3F, 0x31, 0xB0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0x83, 0x61, 0xB9, 0x8F, 0x80, 0xBE, 0x71, 0xB0, 0xD8, 0x38, 0x1C, 0x0E,
  0x07, 0x82, 0xC3, 0x73, 0xAF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00, 0x3E,
  0xB1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x41, 0xB9, 0xCF, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xBE, 0x8C, 0x30, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x7F, 0x87, 0x06, 0x07, 0x07, 0x83, 0x83, 0x07, 0x9F, 0xF0,
  0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x34, 0x70, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE7, 0x79, 0xC1, 0xD0,
  0x66, 0x19, 0x84, 0x23, 0x0C, 0xC3, 0x20, 0x58, 0x1E, 0x07, 0x00, 0xC0,
  0xC3, 0x86, 0x87, 0x09, 0x8A, 0x33, 0x16, 0x66, 0x6C, 0xC4, 0xD9, 0x0D,
  0x16, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0x60, 0x60, 0xC0, 0x61, 0x8C, 0xC3,
  0x30, 0x78, 0x1C, 0x03, 0x01, 0xE0, 0x48, 0x33, 0x18, 0x6E, 0x1C, 0xC1,
  0xD8, 0x66, 0x19, 0x84, 0x33, 0x0C, 0xC3, 0x20, 0x58, 0x1E, 0x07, 0x00,
  0xC0, 0x30, 0x18, 0x06, 0x0B, 0x03, 0x80, 0xFE, 0x08, 0x30, 0xC1, 0x86,
  0x0C, 0x30, 0xC1, 0x83, 0xF8, 0x0C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0xE3,
  0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC3, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x73, 0x0C, 0x30, 0xC3,
  0x0C, 0x63, 0x80, 0x70, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 6, 5, 8, 1, -15 },
  { 11, 12, 15, 12, 0, -15 },
  { 34, 9, 17, 11, 1, -16 },
  { 54, 14, 15, 16, 1, -15 },
  { 81, 12, 15, 13, 1, -15 },
  { 104, 2, 5, 5, 1, -15 },
  { 106, 5, 18, 6, 1, -15 },
  { 118, 4, 18, 6, 1, -15 },
  { 127, 9, 9, 10, 1, -16 },
  { 138, 9, 10, 11, 1, -12 },
  { 150, 3, 5, 5, 1, -2 },
  { 152, 5, 1, 6, 1, -6 },
  { 153, 3, 3, 5, 1, -3 },
  { 155, 8, 15, 8, 0, -15 },
  { 170, 9, 15, 11, 1, -15 },
  { 187, 5, 15, 11, 2, -15 },
  { 197, 9, 15, 11, 1, -15 },
  { 214, 9, 15, 11, 1, -15 },
  { 231, 11, 15, 11, 0, -15 },
  { 252, 9, 15, 11, 1, -15 },
  { 269, 9, 15, 11, 1, -15 },
  { 286, 9, 15, 11, 1, -15 },
  { 303, 9, 15, 11, 1, -15 },
  { 320, 9, 15, 11, 1, -15 },
  { 337, 3, 11, 5, 1, -11 },
  { 342, 3, 14, 5, 1, -11 },
  { 348, 9, 10, 11, 1, -13 },
  { 360, 9, 5, 11, 1, -10 },
  { 366, 9, 10, 11, 1, -13 },
  { 378, 8, 15, 8, 0, -15 },
  { 393, 15, 17, 17, 1, -15 },
  { 425, 12, 15, 12, 0, -15 },
  { 448, 9, 15, 12, 2, -15 },
  { 465, 10, 15, 12, 1, -15 },
  { 484, 11, 15, 14, 2, -15 },
  { 505, 7, 15, 11, 2, -15 },
  { 519, 7, 15, 10, 2, -15 },
  { 533, 11, 15, 14, 1, -15 },
  { 554, 10, 15, 14, 2, -15 },
  { 573, 5, 15, 7, 1, -15 },
  { 583, 5, 19, 5, -1, -15 },
  { 595, 10, 15, 12, 2, -15 },
  { 614, 7, 15, 10, 2, -15 },
  { 628, 14, 15, 18, 2, -15 },
  { 655, 11, 15, 14, 2, -15 },
  { 676, 12, 15, 15, 1, -15 },
  { 699, 9, 15, 11, 2, -15 },
  { 716, 12, 19, 15, 1, -15 },
  { 745, 10, 15, 12, 2, -15 },
  { 764, 9, 15, 10, 1, -15 },
  { 781, 10, 15, 10, 0, -15 },
  { 800, 10, 15, 14, 2, -15 },
  { 819, 11, 15, 11, 0, -15 },
  { 840, 18, 15, 18, 0, -15 },
  { 874, 11, 15, 11, 0, -15 },
  { 895, 11, 15, 11, 0, -15 },
  { 916, 9, 15, 10, 1, -15 },
  { 933, 4, 18, 7, 2, -15 },
  { 942, 8, 15, 8, 0, -15 },
  { 957, 4, 18, 7, 1, -15 },
  { 966, 9, 9, 11, 1, -15 },
  { 977, 9, 1, 9, 0, 2 },
  { 979, 4, 3, 6, 1, -16 },
  { 981, 8, 11, 11, 1, -11 },
  { 992, 9, 16, 12, 2, -16 },
  { 1010, 7, 11, 9, 1, -11 },
  { 1020, 9, 16, 12, 1, -16 },
  { 1038, 9, 11, 11, 1, -11 },
  { 1051, 7, 16, 7, 0, -16 },
  { 1065, 9, 16, 12, 1, -11 },
  { 1083, 8, 16, 12, 2, -16 },
  { 1099, 3, 16, 5, 1, -16 },
  { 1105, 5, 21, 5, -1, -16 },
  { 1119, 8, 16, 10, 2, -16 },
  { 1135, 1, 16, 5, 2, -16 },
  { 1137, 14, 11, 18, 2, -11 },
  { 1157, 8, 11, 12, 2, -11 },
  { 1168, 9, 11, 11, 1, -11 },
  { 1181, 9, 16, 12, 2, -11 },
  { 1199, 9, 16, 12, 1, -11 },
  { 1217, 6, 11, 8, 2, -11 },
  { 1226, 7, 11, 9, 1, -11 },
  { 1236, 6, 14, 7, 0, -14 },
  { 1247, 8, 11, 12, 2, -11 },
  { 1258, 10, 11, 10, 0, -11 },
  { 1272, 15, 11, 15, 0, -11 },
  { 1293, 10, 11, 10, 0, -11 },
  { 1307, 10, 16, 10, 0, -11 },
  { 1327, 7, 11, 9, 1, -11 },
  { 1337, 6, 18, 8, 1, -15 },
  { 1351, 2, 21, 10, 4, -16 },
  { 1357, 6, 18, 8, 1, -15 },
  { 1371, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Regular21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR21PT7B_H_
