#ifndef _NOTOSANS_SEMICONDENSED_REGULAR36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71,
  0x8C, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0x61,
  0xD8, 0x76, 0x1D, 0x87, 0x61, 0x98, 0x60, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x38, 0x03, 0x06, 0x00,
  0x60, 0xC0, 0x0C, 0x18, 0x03, 0x87, 0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x30, 0x60, 0x06, 0x0C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xEF, 0xBC, 0xC1, 0x71, 0x80,
  0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x03, 0xD8, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x03, 0x3C, 0x06, 0x3C, 0x0C, 0x38, 0x18, 0x70, 0x30,
  0xF0, 0x63, 0xBF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x60, 0x7F, 0x00, 0xE0, 0x63, 0x00,
  0xC0, 0xE3, 0x81, 0xC0, 0xE1, 0x81, 0x80, 0xC1, 0x83, 0x80, 0xC1, 0x83,
  0x00, 0xC1, 0x87, 0x00, 0xC1, 0x86, 0x00, 0xC1, 0x8E, 0x00, 0xC1, 0x8C,
  0x38, 0xE1, 0x9C, 0xFC, 0xE3, 0x99, 0xFE, 0x77, 0x39, 0xC6, 0x7F, 0x39,
  0x87, 0x3E, 0x73, 0x87, 0x00, 0x73, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xE3,
  0x87, 0x01, 0xC3, 0x87, 0x01, 0xC3, 0x87, 0x01, 0x81, 0x87, 0x03, 0x81,
  0x87, 0x03, 0x01, 0xCE, 0x07, 0x00, 0xFE, 0x0E, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x70, 0x00, 0xE7, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x79, 0xE7,
  0x83, 0x8E, 0x1E, 0x1C, 0xF0, 0x78, 0xE7, 0x03, 0xCE, 0x38, 0x0F, 0x71,
  0xC0, 0x3F, 0x0E, 0x00, 0xF8, 0x70, 0x07, 0xC3, 0xC0, 0x7F, 0x0F, 0x9F,
  0xBC, 0x7F, 0xF8, 0xF0, 0xFF, 0x03, 0xC0, 0xFF, 0xFE, 0x66, 0x66, 0x66,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x06,
  0x18, 0x6F, 0xB7, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xC0, 0x0D, 0xC0, 0x39,
  0xC0, 0xF3, 0xC3, 0xC3, 0x81, 0x86, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x3C, 0xE3, 0x8E, 0x71, 0xC7, 0x18, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x77, 0xFE, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xC7, 0x03, 0xCE, 0x03, 0xB8,
  0x07, 0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xEF, 0x01, 0xCE, 0x03, 0x9E, 0x0E, 0x1F, 0x7C, 0x1F, 0xF0, 0x1F,
  0xC0, 0x03, 0x83, 0xC3, 0xE3, 0xF7, 0xBF, 0x9F, 0x8E, 0x87, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF,
  0xE7, 0x03, 0xC4, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x01, 0xE4, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0xFF, 0x81, 0xF8, 0x03, 0xFE, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xA0, 0x0F, 0x78, 0xFC, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x0E, 0xE0, 0x06, 0x70,
  0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0x83, 0x81, 0xC1,
  0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xA0, 0x0F,
  0x7C, 0x7C, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0,
  0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x9F, 0x87, 0x7F, 0xCF, 0xEF, 0xDF, 0x03, 0xBC, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x03, 0xDE,
  0x07, 0x1E, 0x3E, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0x70, 0x1C, 0xF0, 0x70, 0xF1, 0xE0, 0xFF, 0x00, 0xFC, 0x03,
  0xFE, 0x0F, 0x3E, 0x38, 0x1E, 0xF0, 0x1D, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0x3C, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0x81, 0xCF, 0x03, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x03,
  0xEF, 0x0F, 0xCF, 0xFB, 0x8F, 0xE7, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x21, 0xF8, 0x7F, 0xC0, 0xFF,
  0x00, 0x23, 0xBE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77,
  0xFE, 0xE0, 0x10, 0xE7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0xE3, 0x9E, 0x71, 0xC6, 0x38, 0xE0, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0x80, 0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x1F, 0xC7, 0xFF, 0x1F,
  0xFC, 0xC0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0xF0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x60, 0x3E, 0x06, 0x70, 0x7F, 0xC3, 0xB8, 0x78, 0xE1, 0xD8, 0x38,
  0x70, 0xFC, 0x38, 0x38, 0x3E, 0x1C, 0x1C, 0x1F, 0x0C, 0x0E, 0x0F, 0x86,
  0x07, 0x07, 0x83, 0x03, 0x83, 0xC1, 0x81, 0xC3, 0xF0, 0xC0, 0xE1, 0xF8,
  0x70, 0xF0, 0xDC, 0x3C, 0xFC, 0xEE, 0x0F, 0xE7, 0xE3, 0x83, 0xE1, 0xE1,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x10,
  0x03, 0xE0, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1D,
  0xC0, 0x01, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1C, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xE0, 0x23, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xDE, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x80, 0xF8,
  0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0E,
  0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x03, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFB, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xDC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F,
  0x80, 0x63, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0,
  0x03, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0x78, 0x01, 0xC7, 0x80, 0x38, 0x7F,
  0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xCF, 0xC3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE, 0xFC, 0xF0, 0xE0, 0x07, 0xF0, 0x07,
  0xB8, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0xC3, 0x83, 0xC1, 0xC1,
  0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0xF8, 0x07,
  0xFC, 0x03, 0xEF, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1C,
  0x1C, 0x0F, 0x0E, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0,
  0x0F, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xEE, 0x00, 0x37, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xE7,
  0x00, 0x67, 0xE7, 0x00, 0xE7, 0xE7, 0x00, 0xE7, 0xE3, 0x80, 0xC7, 0xE3,
  0x81, 0xC7, 0xE3, 0x81, 0xC7, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1,
  0xC3, 0x87, 0xE0, 0xE7, 0x07, 0xE0, 0xE7, 0x07, 0xE0, 0xE7, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFB, 0x80, 0x3F, 0x38, 0x07,
  0xE7, 0x80, 0xFC, 0x70, 0x1F, 0x8F, 0x03, 0xF0, 0xE0, 0x7E, 0x1E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x3C, 0x3F, 0x03, 0xC7, 0xE0, 0x38, 0xFC, 0x07, 0x9F,
  0x80, 0x73, 0xF0, 0x0F, 0x7E, 0x00, 0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0,
  0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE7,
  0x80, 0x0F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE,
  0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xEE, 0x03, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xCE,
  0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x80, 0x0F,
  0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1C,
  0x0F, 0x8E, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x8E, 0x0F, 0x87, 0xFF, 0x83, 0xFF,
  0x01, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E,
  0x03, 0xC7, 0x00, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x03,
  0xC0, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0x9E, 0x06, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x03, 0xFF, 0x7E, 0xFF, 0xF3, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x03, 0x9C, 0x01, 0xE7, 0x80, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70,
  0x01, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3,
  0x80, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x78, 0x1C, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C,
  0x00, 0x79, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x03, 0x80, 0x1D, 0xC0, 0x1E, 0x00, 0x77, 0x00, 0x78, 0x01, 0xDC, 0x01,
  0xF0, 0x0F, 0x78, 0x07, 0xC0, 0x38, 0xE0, 0x3F, 0x00, 0xE3, 0x80, 0xEC,
  0x03, 0x8E, 0x03, 0xB8, 0x1E, 0x3C, 0x0C, 0xE0, 0x70, 0x70, 0x73, 0x81,
  0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x07, 0x1C, 0x3C, 0x1C, 0x18, 0x70, 0xE0,
  0x38, 0xE1, 0xC3, 0x80, 0xE3, 0x83, 0x8E, 0x03, 0x8E, 0x0E, 0x38, 0x0E,
  0x70, 0x39, 0xC0, 0x1D, 0xC0, 0xE7, 0x00, 0x77, 0x01, 0xDC, 0x01, 0xDC,
  0x07, 0x70, 0x07, 0x60, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xDE, 0x00, 0xE3, 0x80, 0x78, 0x70, 0x1C, 0x1C, 0x0F,
  0x03, 0x83, 0x80, 0xE1, 0xE0, 0x1C, 0x70, 0x07, 0xBC, 0x00, 0xEE, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0E,
  0xE0, 0x07, 0xB8, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x0E, 0x70, 0x03, 0xFC, 0x00, 0x70,
  0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0F,
  0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0xCF, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x76,
  0x00, 0x33, 0x80, 0x38, 0xC0, 0x1C, 0x70, 0x1C, 0x18, 0x0E, 0x0E, 0x0E,
  0x03, 0x07, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x39, 0x80, 0x0D, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x00,
  0xFF, 0xC7, 0xFF, 0x8C, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x01, 0xFC, 0x7F, 0xF7, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0xC3, 0xF7, 0xFD, 0xCF, 0xE7, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0xE0,
  0xEF, 0xF1, 0xFF, 0xF3, 0xE0, 0xF7, 0x80, 0xEF, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0E, 0xFC, 0x7D, 0x9F, 0xF3, 0x1F, 0xC0,
  0x01, 0x80, 0x7F, 0xCF, 0xFC, 0x78, 0x67, 0x80, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE1, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0x87,
  0x1F, 0xEE, 0x7F, 0xFD, 0xE0, 0xFB, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x07, 0xBC, 0x0F, 0x7C, 0x7E, 0x7F, 0xCC, 0x3F, 0x18,
  0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xE1, 0xC1, 0xC7, 0x01, 0xCE, 0x03, 0xB8,
  0x07, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x04, 0x7C, 0x78, 0x7F, 0xF0,
  0x7F, 0xC0, 0x00, 0x40, 0x3F, 0x07, 0xF0, 0xF1, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x07, 0xFE, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xCC,
  0xFF, 0xDB, 0xC1, 0xF7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xB8, 0x07, 0x78, 0x1E, 0xF8, 0xFC, 0xFF, 0xB8, 0xFE, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0xC0, 0x79, 0xFF, 0xE3, 0xFF,
  0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x70, 0xE7, 0xF3, 0xFF, 0xEF, 0x83, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xC0, 0x5F, 0xF4, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x1C, 0x38, 0x70, 0x40, 0x00, 0x00, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1F, 0xFB, 0xE3, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x3B, 0x81, 0xCE, 0x0E, 0x38, 0x78, 0xE3, 0xC3, 0x9E, 0x0E, 0x70,
  0x3B, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x38, 0xE0, 0xE1, 0xC3, 0x87,
  0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x30,
  0x67, 0xF8, 0xFF, 0x3F, 0xFE, 0xFF, 0xDF, 0x0F, 0xE1, 0xEF, 0x03, 0xE0,
  0x77, 0x81, 0xE0, 0x3F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C,
  0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01,
  0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x70,
  0x01, 0x83, 0x3F, 0xCF, 0xFF, 0xBE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x01,
  0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7C, 0x3C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x01, 0xC1, 0x9F, 0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x01,
  0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1D, 0xF8,
  0xFB, 0xBF, 0xE7, 0x3F, 0x8E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x3F, 0xCC, 0xFF, 0xDB, 0xC1, 0xF7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0x78, 0x1E, 0xF8, 0xFC, 0xFF, 0xB8, 0x7E, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xF1, 0xFC, 0xFF, 0xF9, 0xF8, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0x03, 0xFF, 0x7F, 0xEF, 0x06,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xFE, 0x1E, 0xFF, 0xEF, 0xF8,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x3F, 0xFF, 0xFC, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x11, 0xFC, 0x3F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0xFD,
  0xFF, 0x33, 0xF8, 0xC0, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0E,
  0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38,
  0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xDC, 0x07, 0x80,
  0xE7, 0x03, 0xE0, 0x39, 0xC0, 0xFC, 0x1E, 0x38, 0x3F, 0x07, 0x0E, 0x0D,
  0xC1, 0xC3, 0x87, 0x38, 0x70, 0xE1, 0xCE, 0x1C, 0x1C, 0x73, 0x8E, 0x07,
  0x18, 0x63, 0x81, 0xCE, 0x1C, 0xE0, 0x73, 0x87, 0x38, 0x0E, 0xE1, 0xDC,
  0x03, 0xB0, 0x37, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0x80,
  0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0xE0, 0x38,
  0xE0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x77, 0x00, 0xEE, 0x03, 0x8E, 0x0F, 0x1E,
  0x1C, 0x1C, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x38, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x78, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x60, 0x7C, 0x1F, 0x83, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0F, 0x07, 0xC0, 0xF8, 0x07, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0xC0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE1, 0xF8, 0x3E, 0x06, 0x00,
  0x7C, 0x03, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xE8, 0x03, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 10, 10, 14, 2, -26 },
  { 31, 19, 26, 21, 1, -26 },
  { 93, 15, 29, 19, 2, -27 },
  { 148, 24, 26, 28, 2, -26 },
  { 226, 21, 26, 23, 2, -26 },
  { 295, 4, 10, 8, 2, -26 },
  { 300, 8, 32, 11, 2, -26 },
  { 332, 8, 32, 11, 1, -26 },
  { 364, 15, 14, 18, 1, -27 },
  { 391, 15, 17, 19, 2, -21 },
  { 423, 6, 9, 9, 1, -4 },
  { 430, 9, 3, 11, 1, -11 },
  { 434, 5, 4, 9, 2, -4 },
  { 437, 13, 26, 13, 0, -26 },
  { 480, 15, 26, 19, 2, -26 },
  { 529, 9, 26, 19, 3, -26 },
  { 559, 15, 26, 19, 2, -26 },
  { 608, 15, 26, 19, 2, -26 },
  { 657, 17, 26, 19, 1, -26 },
  { 713, 15, 26, 19, 2, -26 },
  { 762, 15, 26, 19, 2, -26 },
  { 811, 16, 26, 19, 1, -26 },
  { 863, 15, 26, 19, 2, -26 },
  { 912, 15, 26, 19, 2, -26 },
  { 961, 5, 20, 9, 2, -20 },
  { 974, 6, 25, 9, 1, -20 },
  { 993, 15, 17, 19, 2, -21 },
  { 1025, 15, 10, 19, 2, -18 },
  { 1044, 15, 17, 19, 2, -21 },
  { 1076, 13, 26, 14, 0, -26 },
  { 1119, 25, 29, 29, 2, -26 },
  { 1210, 20, 26, 21, 0, -26 },
  { 1275, 16, 26, 21, 3, -26 },
  { 1327, 17, 26, 20, 2, -26 },
  { 1383, 18, 26, 23, 3, -26 },
  { 1442, 13, 26, 18, 3, -26 },
  { 1485, 13, 26, 17, 3, -26 },
  { 1528, 19, 26, 24, 2, -26 },
  { 1590, 18, 26, 24, 3, -26 },
  { 1649, 9, 26, 11, 1, -26 },
  { 1679, 8, 33, 9, -2, -26 },
  { 1712, 17, 26, 20, 3, -26 },
  { 1768, 13, 26, 17, 3, -26 },
  { 1811, 24, 26, 30, 3, -26 },
  { 1889, 19, 26, 25, 3, -26 },
  { 1951, 21, 26, 25, 2, -26 },
  { 2020, 15, 26, 20, 3, -26 },
  { 2069, 21, 32, 25, 2, -26 },
  { 2153, 17, 26, 20, 3, -26 },
  { 2209, 14, 26, 18, 2, -26 },
  { 2255, 17, 26, 18, 0, -26 },
  { 2311, 18, 26, 24, 3, -26 },
  { 2370, 20, 26, 20, 0, -26 },
  { 2435, 30, 26, 31, 0, -26 },
  { 2533, 18, 26, 19, 0, -26 },
  { 2592, 18, 26, 18, 0, -26 },
  { 2651, 16, 26, 18, 1, -26 },
  { 2703, 8, 32, 12, 3, -26 },
  { 2735, 13, 26, 13, 0, -26 },
  { 2778, 8, 32, 12, 1, -26 },
  { 2810, 17, 16, 19, 1, -26 },
  { 2844, 16, 2, 16, 0, 3 },
  { 2848, 8, 6, 10, 1, -28 },
  { 2854, 14, 20, 18, 2, -20 },
  { 2889, 15, 27, 20, 3, -27 },
  { 2940, 13, 20, 16, 2, -20 },
  { 2973, 15, 27, 20, 2, -27 },
  { 3024, 15, 20, 18, 2, -20 },
  { 3062, 12, 28, 11, 0, -28 },
  { 3104, 15, 29, 20, 2, -20 },
  { 3159, 14, 27, 20, 3, -27 },
  { 3207, 3, 27, 9, 3, -27 },
  { 3218, 7, 36, 9, -1, -27 },
  { 3250, 14, 27, 17, 3, -27 },
  { 3298, 3, 27, 9, 3, -27 },
  { 3309, 25, 20, 30, 3, -20 },
  { 3372, 14, 20, 20, 3, -20 },
  { 3407, 16, 20, 20, 2, -20 },
  { 3447, 15, 29, 20, 3, -20 },
  { 3502, 15, 29, 20, 2, -20 },
  { 3557, 10, 20, 13, 3, -20 },
  { 3582, 12, 20, 15, 2, -20 },
  { 3612, 10, 24, 12, 1, -24 },
  { 3642, 14, 19, 20, 3, -19 },
  { 3676, 16, 19, 16, 0, -19 },
  { 3714, 26, 19, 26, 0, -19 },
  { 3776, 15, 19, 17, 1, -19 },
  { 3812, 16, 28, 17, 0, -19 },
  { 3868, 13, 19, 15, 1, -19 },
  { 3899, 11, 32, 13, 1, -26 },
  { 3943, 2, 36, 18, 8, -27 },
  { 3952, 11, 32, 13, 1, -26 },
  { 3996, 15, 5, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Regular36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR36PT7B_H_
