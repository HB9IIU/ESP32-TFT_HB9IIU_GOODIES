#ifndef _NOTOSANS_SEMICONDENSED_REGULAR9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x37, 0xD5, 0xF5, 0x28, 0x27, 0xA6, 0x3B, 0x62, 0x41,
  0x52, 0xA5, 0xE5, 0xA5, 0x4B, 0x00, 0x21, 0x45, 0x08, 0x5A, 0x67, 0xC0,
  0xC0, 0x5A, 0x94, 0xD5, 0x5C, 0x2F, 0x25, 0x2F, 0x22, 0x60, 0xC0, 0x80,
  0x25, 0x25, 0x00, 0x25, 0x99, 0x99, 0x70, 0xD5, 0x50, 0x69, 0x11, 0x24,
  0xF0, 0x69, 0x16, 0x11, 0xF0, 0x31, 0x95, 0x2F, 0x88, 0xF3, 0x93, 0xC0,
  0x34, 0x4F, 0x99, 0x70, 0xF1, 0x22, 0x24, 0x25, 0x56, 0x59, 0x70, 0x25,
  0x99, 0x71, 0x60, 0x88, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x2C, 0x54,
  0x94, 0x10, 0x7C, 0xB6, 0xAD, 0x5B, 0x48, 0x0E, 0x00, 0x22, 0x94, 0xE8,
  0xC4, 0xF9, 0xE9, 0x9E, 0x69, 0x88, 0x88, 0xF0, 0xF9, 0x99, 0x9E, 0xF3,
  0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x2D, 0x8A, 0x99, 0x70, 0x99, 0xF9, 0x99,
  0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4E, 0xBC, 0xCC, 0xA9, 0x92, 0x49, 0xC0,
  0x8F, 0x3D, 0x75, 0xB6, 0x90, 0x9D, 0xDB, 0x99, 0x64, 0xA3, 0x18, 0xC7,
  0xC0, 0xE9, 0xAC, 0x88, 0x64, 0xA3, 0x18, 0xC7, 0xC2, 0x10, 0xE9, 0xAE,
  0xA9, 0x25, 0x86, 0x11, 0xF0, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x9F, 0x8C,
  0x94, 0xA6, 0x10, 0x93, 0x9A, 0x5A, 0x6A, 0x64, 0x24, 0xDA, 0x88, 0xC5,
  0x4C, 0x9A, 0x98, 0x42, 0x10, 0xF2, 0x24, 0x4F, 0xEA, 0xAC, 0x89, 0x22,
  0x40, 0xD5, 0x5C, 0x25, 0xD0, 0xF0, 0xD0, 0x71, 0x79, 0x70, 0x88, 0xE9,
  0x99, 0xE0, 0x78, 0x88, 0x70, 0x11, 0x79, 0x99, 0x70, 0x79, 0xF8, 0x70,
  0x6B, 0xA4, 0x90, 0x79, 0x99, 0x71, 0x70, 0x93, 0xDB, 0x68, 0xBE, 0x45,
  0x55, 0x80, 0x92, 0xED, 0xA8, 0xFE, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA,
  0x79, 0x99, 0x70, 0xE9, 0x99, 0xE8, 0x80, 0x79, 0x99, 0x71, 0x10, 0xEA,
  0x80, 0x71, 0x9E, 0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x99, 0x66, 0x60, 0x96,
  0xD7, 0x5B, 0x48, 0x96, 0x26, 0x90, 0x99, 0x66, 0x24, 0xC0, 0xE5, 0x2E,
  0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 7, 7, 7, 0, -7 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 1, 2, 2, 0, -6 },
  { 25, 2, 7, 3, 0, -6 },
  { 27, 2, 7, 3, 0, -6 },
  { 29, 4, 4, 4, 0, -7 },
  { 31, 4, 4, 5, 0, -5 },
  { 33, 2, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 1, 1, 2, 1, -1 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 4, 7, 5, 0, -7 },
  { 43, 2, 6, 5, 1, -6 },
  { 45, 4, 7, 5, 0, -7 },
  { 49, 4, 7, 5, 0, -7 },
  { 53, 5, 6, 5, 0, -6 },
  { 57, 3, 6, 5, 1, -6 },
  { 60, 4, 7, 5, 0, -7 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 4, 7, 5, 0, -7 },
  { 75, 1, 5, 2, 1, -5 },
  { 76, 2, 6, 2, 0, -5 },
  { 78, 4, 4, 5, 0, -5 },
  { 80, 4, 2, 5, 0, -4 },
  { 81, 4, 4, 5, 0, -5 },
  { 83, 3, 7, 4, 0, -7 },
  { 86, 7, 7, 7, 0, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 4, 6, 6, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 3, 6, 4, 1, -6 },
  { 113, 4, 7, 6, 1, -7 },
  { 117, 4, 6, 6, 1, -6 },
  { 120, 3, 6, 3, 0, -6 },
  { 123, 3, 8, 2, -1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 3, 6, 4, 1, -6 },
  { 132, 6, 6, 8, 1, -6 },
  { 137, 4, 6, 6, 1, -6 },
  { 140, 5, 7, 6, 1, -7 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 5, 9, 6, 1, -7 },
  { 154, 4, 6, 5, 1, -6 },
  { 157, 4, 7, 4, 0, -7 },
  { 161, 4, 6, 4, 0, -6 },
  { 164, 4, 6, 6, 1, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 8, 6, 8, 0, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 4, 6, 4, 0, -6 },
  { 188, 2, 7, 3, 1, -6 },
  { 190, 3, 6, 3, 0, -6 },
  { 193, 2, 7, 3, 0, -6 },
  { 195, 4, 3, 5, 0, -6 },
  { 197, 4, 1, 4, 0, 1 },
  { 198, 2, 2, 2, 0, -7 },
  { 199, 4, 5, 5, 0, -5 },
  { 202, 4, 7, 5, 1, -7 },
  { 206, 4, 5, 4, 0, -5 },
  { 209, 4, 7, 5, 0, -7 },
  { 213, 4, 5, 5, 0, -5 },
  { 216, 3, 7, 3, 0, -7 },
  { 219, 4, 7, 5, 0, -5 },
  { 223, 3, 7, 5, 1, -7 },
  { 226, 1, 7, 2, 1, -7 },
  { 227, 2, 9, 2, 0, -7 },
  { 230, 3, 7, 4, 1, -7 },
  { 233, 1, 7, 2, 1, -7 },
  { 234, 6, 5, 8, 1, -5 },
  { 238, 3, 5, 5, 1, -5 },
  { 240, 4, 5, 5, 0, -5 },
  { 243, 4, 7, 5, 1, -5 },
  { 247, 4, 7, 5, 0, -5 },
  { 251, 2, 5, 3, 1, -5 },
  { 253, 3, 5, 4, 0, -5 },
  { 255, 3, 6, 3, 0, -6 },
  { 258, 3, 5, 5, 1, -5 },
  { 260, 4, 5, 4, 0, -5 },
  { 263, 6, 5, 6, 0, -5 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 4, 7, 4, 0, -5 },
  { 274, 3, 5, 4, 0, -5 },
  { 276, 3, 7, 3, 0, -6 },
  { 279, 1, 9, 4, 2, -7 },
  { 281, 3, 7, 3, 0, -6 },
  { 284, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Regular9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR9PT7B_H_
