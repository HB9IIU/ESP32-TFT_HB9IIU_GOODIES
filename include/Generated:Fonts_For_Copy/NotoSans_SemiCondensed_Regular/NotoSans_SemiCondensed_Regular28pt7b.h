#ifndef _NOTOSANS_SEMICONDENSED_REGULAR28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_REGULAR28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0x80, 0x1F, 0xF0, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80,
  0xC3, 0x01, 0x86, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x30, 0xC0, 0x61,
  0x80, 0xC3, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x61, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x0C, 0x01, 0x80, 0x7E, 0x3F, 0xFF,
  0xCD, 0x98, 0x33, 0x06, 0x60, 0xEC, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0xDC,
  0x19, 0xC3, 0x18, 0x63, 0x8C, 0xFF, 0xFB, 0xFE, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x3C, 0x07, 0x0F, 0xC0, 0xC1, 0x98, 0x30, 0x61, 0x86, 0x0C,
  0x31, 0x81, 0x86, 0x30, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC3, 0x77, 0xCC,
  0xCD, 0xF9, 0xFB, 0xB1, 0x9E, 0x66, 0x30, 0x0C, 0xC6, 0x03, 0x18, 0xC0,
  0x63, 0x18, 0x18, 0x63, 0x03, 0x0C, 0x60, 0xC1, 0x8C, 0x18, 0x1F, 0x06,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xE0, 0x0E, 0x38, 0x06, 0x1C, 0x03, 0x0E,
  0x01, 0xC7, 0x00, 0x63, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0xC1, 0xCE, 0x70, 0xC6, 0x1C, 0x67, 0x07, 0x73, 0x81, 0xF1, 0xC0, 0x78,
  0xE0, 0x3C, 0x38, 0x3F, 0x1F, 0xFB, 0xC3, 0xF0, 0xF0, 0xFF, 0xFC, 0x0C,
  0x61, 0x8C, 0x31, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x61,
  0x87, 0x1C, 0x30, 0xE1, 0x83, 0xC1, 0x87, 0x0C, 0x38, 0x61, 0x87, 0x1C,
  0x70, 0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x8E, 0x30, 0xC6, 0x38, 0x06,
  0x00, 0x60, 0x06, 0x0C, 0x62, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xF0, 0x19,
  0x83, 0x9C, 0x10, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x77, 0x66, 0x6C, 0xC0, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0x1F,
  0x83, 0xFC, 0x30, 0xE7, 0x06, 0x60, 0x76, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x76, 0x07, 0x70,
  0x63, 0x0E, 0x3F, 0xC1, 0xF8, 0x06, 0x1C, 0xFB, 0xBE, 0x68, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x3F,
  0x8F, 0xFC, 0x60, 0xE4, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFC, 0x60, 0xE0, 0x06, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x07, 0xC1, 0xF0, 0x1F, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x07, 0x00, 0x78, 0x0E, 0xFF, 0xE7, 0xF8, 0x00,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x03, 0x18,
  0x18, 0xC1, 0x86, 0x1C, 0x30, 0xC1, 0x8C, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x7F, 0xCF, 0xFB, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x1F, 0xF8, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xF0, 0x3B, 0xFE, 0x7F, 0x80,
  0x07, 0xE1, 0xFE, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x06, 0x10,
  0x6F, 0xCF, 0xDE, 0xF0, 0x7E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x70, 0x73, 0x86, 0x3F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x1F, 0xC3, 0xFE, 0x70, 0x66, 0x07, 0x60, 0x76, 0x07, 0x70, 0x63, 0x8E,
  0x1F, 0xC0, 0xF0, 0x1F, 0xC7, 0x0E, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x37, 0x07, 0x7F, 0xE1, 0xFC, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x77, 0x07, 0x79, 0xB3, 0xFB,
  0x04, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x3F, 0x83, 0xF0,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x77, 0x66, 0xEC, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x7F, 0x3F,
  0xE4, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x00, 0xC7, 0x00, 0x0C, 0xC0,
  0xE1, 0xB8, 0x7F, 0x1E, 0x18, 0xE3, 0xC6, 0x1C, 0x78, 0xC3, 0x0F, 0x18,
  0x61, 0xC3, 0x0C, 0x38, 0x61, 0x87, 0x8C, 0x30, 0xF1, 0x8F, 0x36, 0x1F,
  0x7E, 0xC1, 0xC7, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF3,
  0xC0, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x38, 0x18, 0x18, 0x1F, 0xF8, 0x3F, 0xFC, 0x30, 0x0C, 0x70, 0x0C,
  0x70, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x38,
  0x3D, 0xC0, 0x6E, 0x03, 0xF0, 0x1B, 0x80, 0xDC, 0x0E, 0xE3, 0xE7, 0xFC,
  0x3F, 0xF9, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xBF, 0xF9, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xCF, 0x04, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x47, 0xFC,
  0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0x83, 0xC7, 0x01, 0xCE, 0x01, 0xDC,
  0x03, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xDC, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC1, 0xE3,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x07, 0xF8, 0x3F, 0xF8, 0xF0, 0x33,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB0, 0x07,
  0x70, 0x0E, 0x78, 0x1C, 0x7F, 0xF8, 0x7F, 0xE0, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x73, 0xFF,
  0xF0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x7E, 0xF8, 0xE0,
  0x3B, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x30, 0x39,
  0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xF0, 0x3D, 0xC0, 0xE3, 0x83, 0x86, 0x0E,
  0x1C, 0x38, 0x38, 0xE0, 0x63, 0x81, 0xCE, 0x03, 0xB8, 0x0F, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xBF, 0xC0, 0x37, 0xD8,
  0x06, 0xFB, 0x01, 0x9F, 0x70, 0x33, 0xE6, 0x0E, 0x7C, 0xC1, 0x8F, 0x9C,
  0x31, 0xF1, 0x8E, 0x3E, 0x31, 0x87, 0xC7, 0x30, 0xF8, 0x6E, 0x1F, 0x0D,
  0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0x81, 0xF0, 0x70, 0x30, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7D, 0x80, 0xFB, 0x81,
  0xF3, 0x83, 0xE7, 0x07, 0xC7, 0x0F, 0x86, 0x1F, 0x0E, 0x3E, 0x0C, 0x7C,
  0x1C, 0xF8, 0x1D, 0xF0, 0x3B, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x70, 0x0F, 0xE0, 0x3F, 0xF8, 0x38, 0x3C, 0x70, 0x0C, 0xE0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x0C, 0x38,
  0x3C, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xCF, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F,
  0xE0, 0x3F, 0xF8, 0x38, 0x3C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x38, 0x3C, 0x1F,
  0xF8, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0xFF, 0x87, 0xFE, 0x38, 0x79, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x81,
  0xDC, 0x0E, 0xE0, 0x67, 0x1F, 0x3F, 0xF1, 0xFF, 0x0E, 0x18, 0x70, 0xE3,
  0x83, 0x1C, 0x1C, 0xE0, 0x67, 0x03, 0xB8, 0x0F, 0xC0, 0x70, 0x1F, 0xE3,
  0xFE, 0x70, 0x66, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x6C,
  0x0E, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xD8, 0x07, 0x70, 0x19, 0xE0, 0xE3, 0xFF, 0x07, 0xF8,
  0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE7, 0x01, 0xC6, 0x03, 0x0E,
  0x06, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0x71, 0xC0, 0x63, 0x80, 0xC6,
  0x01, 0xDC, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x18, 0x07, 0x60, 0x3C, 0x06, 0x60, 0x3C, 0x0E, 0x70,
  0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x30, 0x6E, 0x0C, 0x30, 0x66, 0x0C, 0x38,
  0x66, 0x1C, 0x38, 0xE6, 0x1C, 0x18, 0xC7, 0x18, 0x18, 0xC3, 0x18, 0x18,
  0xC3, 0x38, 0x1D, 0xC3, 0x38, 0x0D, 0x83, 0xB0, 0x0D, 0x81, 0xB0, 0x0D,
  0x81, 0xB0, 0x0D, 0x81, 0xF0, 0x07, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x70, 0x1D, 0xC0, 0x63, 0x83, 0x86, 0x0C, 0x1C, 0x70, 0x33,
  0x80, 0xEC, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x0E,
  0xC0, 0x33, 0x81, 0xC6, 0x06, 0x1C, 0x38, 0x30, 0xC0, 0xE7, 0x01, 0xF8,
  0x07, 0xE0, 0x1D, 0x80, 0x67, 0x03, 0x8C, 0x0C, 0x38, 0x70, 0x61, 0x81,
  0xCE, 0x03, 0x38, 0x0C, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x06, 0x00, 0x38, 0x03, 0xC0,
  0x1B, 0x01, 0x98, 0x0C, 0x60, 0xC3, 0x06, 0x0C, 0x70, 0x63, 0x01, 0xB8,
  0x0D, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xE1, 0xC3, 0x87, 0x1F, 0x87, 0xF8,
  0x83, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xF9, 0xFF, 0x70, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x1E, 0xFE, 0xCF, 0x98, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xEF, 0xCD, 0xFE, 0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0xED, 0xFE,
  0xCF, 0xC0, 0x0F, 0xCF, 0xF3, 0x81, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x78, 0x4F, 0xF1, 0xFC, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7E, 0xE7, 0xFF, 0x70, 0x7B,
  0x83, 0xD8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEC, 0x07, 0x60,
  0x3B, 0x83, 0xDC, 0x1E, 0x7F, 0xF1, 0xFB, 0x80, 0x1F, 0x83, 0xFC, 0x30,
  0xE7, 0x07, 0x60, 0x76, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x13, 0xFE, 0x0F, 0xE0, 0x0F, 0xC7, 0xE1, 0xC0, 0x60,
  0x18, 0x06, 0x07, 0xF3, 0xFC, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x1F, 0xB9,
  0xFF, 0xDC, 0x1E, 0xE0, 0xF6, 0x03, 0xB0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x9F, 0xFC, 0x7E, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0xF3, 0xC7, 0xFC, 0x0F, 0x80, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0xCD, 0xFE, 0xF0, 0xEE,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x5F, 0xA0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x08, 0x71, 0xC2, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1A, 0xEF, 0xB8, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x0E, 0xE3, 0x9C,
  0xE3, 0x98, 0x76, 0x0D, 0xC1, 0xFC, 0x3D, 0x87, 0x38, 0xE3, 0x9C, 0x73,
  0x87, 0x70, 0x6E, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xCF, 0x8F, 0xCD, 0xFD, 0xFE, 0xF0, 0xF0, 0xEE, 0x0F, 0x06, 0xE0, 0x60,
  0x6E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06,
  0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x70, 0xCF, 0xCD, 0xFE, 0xF0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0x1F, 0xC1, 0xFF, 0x0C, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0x63, 0x07, 0x1F, 0xF0,
  0x3F, 0x00, 0xCF, 0xCD, 0xFE, 0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0xED, 0xFE, 0xEF,
  0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F,
  0xB9, 0xFF, 0xDC, 0x1E, 0xE0, 0xF6, 0x03, 0xB0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0xF7, 0x07, 0x9F, 0xFC, 0x7E, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xCF,
  0xDF, 0xD8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x3F, 0xDF, 0xEE, 0x0B, 0x80, 0xE0, 0x1C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xFF, 0xEF, 0xF0, 0x18, 0x0C, 0x0E,
  0x0F, 0xEF, 0xF1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x1F, 0x87, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x7E, 0x0E,
  0xFF, 0xCF, 0xD8, 0xE0, 0x3B, 0x01, 0x98, 0x1C, 0xE0, 0xE3, 0x06, 0x18,
  0x30, 0xE3, 0x83, 0x18, 0x18, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xF8,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x76, 0x0F, 0x06, 0x60, 0xF0, 0x67,
  0x0F, 0x06, 0x70, 0xF8, 0xE3, 0x19, 0x8C, 0x31, 0x98, 0xC3, 0x99, 0x8C,
  0x3B, 0x8D, 0xC1, 0xB0, 0xD8, 0x1B, 0x0D, 0x81, 0xB0, 0xD8, 0x1E, 0x07,
  0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x39, 0x83, 0x8E, 0x38, 0x31,
  0x81, 0xDC, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x70,
  0x31, 0xC3, 0x86, 0x38, 0x3B, 0x80, 0xE0, 0xE0, 0x3B, 0x01, 0x98, 0x1C,
  0xE0, 0xE3, 0x06, 0x18, 0x30, 0xE3, 0x83, 0x18, 0x18, 0xC0, 0xEE, 0x03,
  0x60, 0x1B, 0x00, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x0F, 0x80, 0x78, 0x00, 0xFF, 0xBF, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0x0F, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x38, 0xF0, 0xE0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0xF0, 0x78,
  0x70, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC3, 0xE1, 0xE0,
  0x38, 0x1F, 0xE1, 0xEF, 0xF8, 0x1E,
};

const GFXglyph NotoSans_SemiCondensed_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 7, 7, 11, 2, -20 },
  { 16, 15, 20, 16, 1, -20 },
  { 54, 11, 23, 15, 2, -21 },
  { 86, 19, 20, 22, 1, -20 },
  { 134, 17, 20, 18, 1, -20 },
  { 177, 2, 7, 6, 2, -20 },
  { 179, 6, 24, 8, 1, -20 },
  { 197, 6, 24, 8, 1, -20 },
  { 215, 12, 11, 14, 1, -21 },
  { 232, 12, 14, 15, 1, -17 },
  { 253, 4, 7, 7, 1, -3 },
  { 257, 7, 3, 9, 1, -9 },
  { 260, 3, 3, 7, 2, -3 },
  { 262, 10, 20, 10, 0, -20 },
  { 287, 12, 20, 15, 1, -20 },
  { 317, 7, 20, 15, 2, -20 },
  { 335, 12, 20, 15, 1, -20 },
  { 365, 12, 20, 15, 1, -20 },
  { 395, 13, 20, 15, 1, -20 },
  { 428, 11, 20, 15, 2, -20 },
  { 456, 12, 20, 15, 1, -20 },
  { 486, 12, 20, 15, 1, -20 },
  { 516, 12, 20, 15, 1, -20 },
  { 546, 12, 20, 15, 1, -20 },
  { 576, 3, 15, 7, 2, -15 },
  { 582, 4, 19, 7, 1, -15 },
  { 592, 12, 14, 15, 1, -17 },
  { 613, 12, 8, 15, 1, -14 },
  { 625, 12, 14, 15, 1, -17 },
  { 646, 10, 20, 11, 0, -20 },
  { 671, 19, 22, 23, 2, -20 },
  { 724, 16, 20, 16, 0, -20 },
  { 764, 13, 20, 16, 2, -20 },
  { 797, 13, 20, 16, 2, -20 },
  { 830, 15, 20, 18, 2, -20 },
  { 868, 10, 20, 14, 2, -20 },
  { 893, 10, 20, 13, 2, -20 },
  { 918, 15, 20, 19, 2, -20 },
  { 956, 14, 20, 19, 2, -20 },
  { 991, 7, 20, 9, 1, -20 },
  { 1009, 7, 25, 7, -2, -20 },
  { 1031, 14, 20, 16, 2, -20 },
  { 1066, 10, 20, 13, 2, -20 },
  { 1091, 19, 20, 23, 2, -20 },
  { 1139, 15, 20, 19, 2, -20 },
  { 1177, 16, 20, 19, 2, -20 },
  { 1217, 12, 20, 15, 2, -20 },
  { 1247, 16, 25, 19, 2, -20 },
  { 1297, 13, 20, 16, 2, -20 },
  { 1330, 12, 20, 14, 1, -20 },
  { 1360, 13, 20, 14, 0, -20 },
  { 1393, 14, 20, 18, 2, -20 },
  { 1428, 15, 20, 15, 0, -20 },
  { 1466, 24, 20, 24, 0, -20 },
  { 1526, 14, 20, 15, 0, -20 },
  { 1561, 14, 20, 14, 0, -20 },
  { 1596, 12, 20, 14, 1, -20 },
  { 1626, 6, 24, 9, 2, -20 },
  { 1644, 10, 20, 10, 0, -20 },
  { 1669, 6, 24, 9, 1, -20 },
  { 1687, 13, 12, 15, 1, -20 },
  { 1707, 12, 2, 12, 0, 2 },
  { 1710, 6, 4, 8, 1, -21 },
  { 1713, 11, 15, 14, 1, -15 },
  { 1734, 12, 21, 16, 2, -21 },
  { 1766, 10, 15, 12, 1, -15 },
  { 1785, 13, 21, 16, 1, -21 },
  { 1820, 12, 15, 14, 1, -15 },
  { 1843, 10, 21, 9, 0, -21 },
  { 1870, 13, 22, 16, 1, -15 },
  { 1906, 12, 21, 16, 2, -21 },
  { 1938, 3, 21, 7, 2, -21 },
  { 1946, 6, 28, 7, -1, -21 },
  { 1967, 11, 21, 14, 2, -21 },
  { 1996, 3, 21, 7, 2, -21 },
  { 2004, 20, 15, 24, 2, -15 },
  { 2042, 12, 15, 16, 2, -15 },
  { 2065, 13, 15, 15, 1, -15 },
  { 2090, 12, 22, 16, 2, -15 },
  { 2123, 13, 22, 16, 1, -15 },
  { 2159, 8, 15, 10, 2, -15 },
  { 2174, 10, 15, 12, 1, -15 },
  { 2193, 9, 18, 9, 0, -18 },
  { 2214, 11, 15, 16, 2, -15 },
  { 2235, 13, 15, 13, 0, -15 },
  { 2260, 20, 15, 20, 0, -15 },
  { 2298, 13, 15, 13, 0, -15 },
  { 2323, 13, 22, 13, 0, -15 },
  { 2359, 10, 15, 11, 1, -15 },
  { 2378, 8, 24, 10, 1, -20 },
  { 2402, 2, 28, 14, 6, -21 },
  { 2409, 9, 24, 10, 1, -20 },
  { 2436, 12, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Regular28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Regular28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Regular28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_REGULAR28PT7B_H_
