#ifndef _JETBRAINSMONO_BOLD40PT7B_H_
#define _JETBRAINSMONO_BOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFC, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDE, 0x1E, 0x01, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0x70,
  0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x67, 0xE7, 0xC6, 0x3E, 0x7C, 0x63,
  0xE7, 0xC6, 0x00, 0x7C, 0x60, 0x07, 0xC6, 0x00, 0x7E, 0x60, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x06, 0xFE, 0x00, 0x63, 0xE0, 0x06, 0x3F, 0x00, 0x61, 0xFF,
  0x86, 0x1F, 0xF8, 0x61, 0xF7, 0xC6, 0x3E, 0x7E, 0x67, 0xE7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xC0, 0x0F, 0x3F, 0xE0, 0x1E, 0x7F, 0xF0, 0x1C, 0x70, 0xF0, 0x3C, 0xF0,
  0x70, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xE0, 0xF0, 0x71, 0xE0, 0x70,
  0xF3, 0xC0, 0x78, 0xF3, 0x80, 0x7F, 0xE7, 0x80, 0x3F, 0xEF, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x71, 0xF8, 0x00, 0xF7, 0xFC, 0x01, 0xEF, 0xFE, 0x01, 0xCF, 0x1E, 0x03,
  0xCE, 0x0E, 0x07, 0x8E, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x0F, 0x1E,
  0x0E, 0x0E, 0x3C, 0x0F, 0x1E, 0x38, 0x0F, 0xFE, 0x78, 0x07, 0xFC, 0xF0,
  0x01, 0xF8, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE1, 0xF7, 0xCF,
  0x8F, 0xBE, 0x3E, 0xF9, 0xE1, 0xFF, 0xCF, 0x07, 0xFC, 0x78, 0x1F, 0xE3,
  0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xC1, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x1F, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0x01,
  0xF0, 0x07, 0x00, 0x10, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x0E,
  0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0xC1, 0xE0, 0xE7, 0xC7, 0x8F, 0x9F, 0xCC,
  0xFE, 0xFF, 0xB7, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0x38, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0x87, 0xC0, 0x7E, 0x1F, 0x80, 0xF0, 0x3C, 0x01, 0x80, 0x60, 0x02, 0x01,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF,
  0x3F, 0x3F, 0xCF, 0xCF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x87, 0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x81,
  0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xC0, 0xF8, 0x10, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F,
  0x01, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x07, 0xDF,
  0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x9F,
  0xC1, 0xEF, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFF, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xDF, 0xFF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF3, 0xE0,
  0x3E, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03,
  0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x3F,
  0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0x1F, 0xCF,
  0xE7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xF7, 0xC0, 0x3E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF,
  0x7C, 0x03, 0xCF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xFF, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C,
  0x1F, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0x80,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0x83,
  0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x43, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1,
  0xF3, 0xFF, 0x0F, 0x87, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0,
  0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF,
  0x0F, 0x03, 0xFC, 0x3E, 0x1F, 0xF0, 0x7C, 0xFF, 0xC1, 0xFE, 0xFF, 0x83,
  0xFB, 0xFE, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00,
  0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81,
  0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x1F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x83, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x87, 0xF7, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xF8, 0x7F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x83, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83,
  0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0x70, 0xEF, 0xF7, 0x0E, 0xFF, 0x78, 0xEF, 0xF7, 0x9E, 0xFF, 0x39,
  0xCF, 0xF3, 0x9D, 0xFF, 0xBF, 0xDF, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0xF9,
  0xF9, 0xFF, 0x9F, 0x9F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xF0, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xDE, 0x0F, 0xF7, 0x83, 0xFD, 0xE0, 0xFF,
  0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x0F, 0x3F, 0xC1, 0xEF, 0xF0, 0x7B,
  0xFC, 0x1E, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x03, 0xEF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF9,
  0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0xDF,
  0xC3, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0,
  0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80,
  0x7E, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7E,
  0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF,
  0x8F, 0xC3, 0xFE, 0x3F, 0x1F, 0x78, 0xEC, 0x79, 0xE3, 0x31, 0xE7, 0x8C,
  0xC7, 0x9E, 0x33, 0x1E, 0x79, 0xCE, 0x79, 0xE7, 0x39, 0xE7, 0x9C, 0xE7,
  0x9E, 0x73, 0x9E, 0x79, 0xCE, 0x79, 0xE7, 0x39, 0xC3, 0xD8, 0x6F, 0x0F,
  0x61, 0xBC, 0x3D, 0x86, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x07,
  0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF3,
  0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF,
  0x80, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0xF8,
  0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0,
  0x3F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F, 0x87,
  0xC3, 0xC0, 0xF1, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xE0, 0x7E, 0xF8, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7,
  0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0xFD, 0xFC, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x3F, 0xE7, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE7, 0xF8, 0xFB, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF,
  0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xEF, 0xBF,
  0xFB, 0xEF, 0xFC, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x7F, 0x9F, 0x3F, 0xF7, 0xDF, 0xFD, 0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0x7C, 0xFF, 0xDF, 0x1F,
  0xE7, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C,
  0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE7, 0xCF, 0xFD, 0xF7, 0xFF, 0x7D,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C,
  0x7F, 0x9F, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE7, 0xF8, 0xFB, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF, 0xFB,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x01, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E,
  0x0F, 0x87, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xF3, 0xC7, 0xCF, 0x7E, 0xFE, 0xFF, 0xEF,
  0xFF, 0x9F, 0x9F, 0xF8, 0xF1, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0xF9, 0xFE, 0x3E, 0xFF, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E,
  0x1F, 0xBF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0xF9, 0xFE, 0x3E, 0xFF, 0xCF, 0xBF, 0xFB, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFB, 0xEF,
  0xFE, 0xFB, 0xFF, 0x3E, 0x7F, 0x8F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE7,
  0xCF, 0xFD, 0xF7, 0xFF, 0x7D, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xDF, 0x3F, 0xF7, 0xC7, 0xF9, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0xF1, 0xFE, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xDF,
  0xFE, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF8, 0xFC, 0x3D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x33,
  0x1E, 0x78, 0xCC, 0x79, 0xE3, 0x31, 0xE7, 0x9C, 0xE7, 0x8F, 0x73, 0x9C,
  0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC3, 0xD8, 0x6F, 0x0F, 0x61, 0xBC, 0x3D,
  0x86, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7C, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x7E,
  0x01, 0xFB, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03,
  0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0,
  0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x0F, 0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF9, 0xF0,
  0xFF, 0x0F, 0x9F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0xF0, 0x1F, 0xC0, 0x00,
  0x60,
};

const GFXglyph JetBrainsMono_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 29, 24, 9, -29 },
  { 23, 14, 12, 24, 5, -29 },
  { 44, 22, 29, 24, 1, -29 },
  { 124, 20, 41, 24, 2, -35 },
  { 227, 24, 29, 24, 0, -29 },
  { 314, 21, 30, 24, 2, -30 },
  { 393, 5, 12, 24, 9, -29 },
  { 401, 12, 39, 24, 7, -34 },
  { 460, 12, 39, 24, 5, -34 },
  { 519, 22, 21, 24, 1, -24 },
  { 577, 20, 19, 24, 2, -23 },
  { 625, 10, 12, 24, 6, -6 },
  { 640, 12, 5, 24, 6, -16 },
  { 648, 8, 7, 24, 8, -7 },
  { 655, 20, 37, 24, 2, -33 },
  { 748, 18, 30, 24, 3, -30 },
  { 816, 19, 29, 24, 3, -29 },
  { 885, 19, 30, 24, 2, -30 },
  { 957, 19, 29, 24, 2, -29 },
  { 1026, 18, 29, 24, 3, -29 },
  { 1092, 18, 29, 24, 3, -29 },
  { 1158, 20, 29, 24, 2, -29 },
  { 1231, 20, 29, 24, 2, -29 },
  { 1304, 18, 30, 24, 3, -30 },
  { 1372, 20, 30, 24, 2, -30 },
  { 1447, 8, 22, 24, 8, -22 },
  { 1469, 10, 28, 24, 6, -22 },
  { 1504, 18, 22, 24, 3, -24 },
  { 1554, 18, 14, 24, 3, -20 },
  { 1586, 18, 22, 24, 3, -24 },
  { 1636, 15, 29, 24, 5, -29 },
  { 1691, 22, 37, 24, 1, -30 },
  { 1793, 22, 29, 24, 1, -29 },
  { 1873, 19, 29, 24, 3, -29 },
  { 1942, 18, 30, 24, 3, -30 },
  { 2010, 18, 29, 24, 3, -29 },
  { 2076, 17, 29, 24, 4, -29 },
  { 2138, 18, 29, 24, 3, -29 },
  { 2204, 18, 30, 24, 3, -30 },
  { 2272, 18, 29, 24, 3, -29 },
  { 2338, 16, 29, 24, 4, -29 },
  { 2396, 19, 29, 24, 1, -29 },
  { 2465, 20, 29, 24, 3, -29 },
  { 2538, 18, 29, 24, 4, -29 },
  { 2604, 20, 29, 24, 2, -29 },
  { 2677, 18, 29, 24, 3, -29 },
  { 2743, 18, 30, 24, 3, -30 },
  { 2811, 19, 29, 24, 3, -29 },
  { 2880, 19, 37, 24, 3, -30 },
  { 2968, 19, 29, 24, 3, -29 },
  { 3037, 20, 30, 24, 2, -30 },
  { 3112, 20, 29, 24, 2, -29 },
  { 3185, 18, 29, 24, 3, -29 },
  { 3251, 22, 29, 24, 1, -29 },
  { 3331, 22, 29, 24, 1, -29 },
  { 3411, 22, 29, 24, 1, -29 },
  { 3491, 22, 29, 24, 1, -29 },
  { 3571, 18, 29, 24, 3, -29 },
  { 3637, 12, 37, 24, 7, -33 },
  { 3693, 20, 37, 24, 2, -33 },
  { 3786, 12, 37, 24, 5, -33 },
  { 3842, 18, 15, 24, 3, -29 },
  { 3876, 20, 5, 24, 2, 1 },
  { 3889, 9, 5, 24, 7, -31 },
  { 3895, 19, 22, 24, 2, -22 },
  { 3948, 18, 29, 24, 3, -29 },
  { 4014, 18, 22, 24, 3, -22 },
  { 4064, 18, 29, 24, 3, -29 },
  { 4130, 18, 22, 24, 3, -22 },
  { 4180, 20, 29, 24, 2, -29 },
  { 4253, 18, 29, 24, 3, -22 },
  { 4319, 18, 29, 24, 3, -29 },
  { 4385, 19, 31, 24, 3, -31 },
  { 4459, 16, 38, 24, 3, -31 },
  { 4535, 20, 29, 24, 3, -29 },
  { 4608, 21, 29, 24, 1, -29 },
  { 4685, 20, 22, 24, 2, -22 },
  { 4740, 18, 22, 24, 3, -22 },
  { 4790, 18, 22, 24, 3, -22 },
  { 4840, 18, 29, 24, 3, -22 },
  { 4906, 18, 29, 24, 3, -22 },
  { 4972, 18, 22, 24, 4, -22 },
  { 5022, 19, 22, 24, 3, -22 },
  { 5075, 19, 28, 24, 2, -28 },
  { 5142, 18, 22, 24, 3, -22 },
  { 5192, 20, 22, 24, 2, -22 },
  { 5247, 22, 22, 24, 1, -22 },
  { 5308, 22, 22, 24, 1, -22 },
  { 5369, 20, 29, 24, 2, -22 },
  { 5442, 18, 22, 24, 3, -22 },
  { 5492, 18, 37, 24, 3, -33 },
  { 5576, 6, 37, 24, 9, -33 },
  { 5604, 18, 37, 24, 3, -33 },
  { 5688, 20, 10, 24, 2, -19 },
};

const GFXfont JetBrainsMono_Bold40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_BOLD40PT7B_H_
