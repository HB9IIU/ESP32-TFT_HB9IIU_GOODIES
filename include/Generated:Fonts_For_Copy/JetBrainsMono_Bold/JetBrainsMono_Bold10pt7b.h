#ifndef _JETBRAINSMONO_BOLD10PT7B_H_
#define _JETBRAINSMONO_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x8C, 0xF9, 0x90, 0x28, 0xF4, 0x92, 0xF9, 0x45, 0x00, 0x44,
  0xFD, 0xC7, 0x5D, 0xF4, 0xE6, 0xAF, 0x08, 0x3D, 0x59, 0xC0, 0x79, 0x06,
  0x1B, 0xDB, 0x67, 0xC0, 0xFC, 0x7A, 0x49, 0x26, 0x60, 0xCC, 0x92, 0x4B,
  0xC0, 0x31, 0xAF, 0xCC, 0x48, 0x66, 0xF6, 0x60, 0x69, 0x60, 0xF0, 0xF0,
  0x13, 0x22, 0x64, 0x4C, 0x80, 0xF9, 0x9F, 0x99, 0xF0, 0xE5, 0x08, 0x42,
  0x13, 0xE0, 0xF9, 0x13, 0x6C, 0xF0, 0xF2, 0x63, 0x19, 0xF0, 0x36, 0x49,
  0xFF, 0x10, 0xF8, 0xF9, 0x19, 0xF0, 0x64, 0xCF, 0x99, 0xF0, 0xF9, 0x32,
  0x26, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x9F, 0x32, 0x40, 0xB0, 0xB0,
  0xB0, 0xFA, 0x16, 0x8E, 0x30, 0xF0, 0xFF, 0x86, 0x17, 0xC0, 0xF1, 0x16,
  0x40, 0x40, 0x7B, 0x19, 0xE9, 0xA6, 0xF8, 0x10, 0x30, 0x30, 0xC7, 0x92,
  0x79, 0x2C, 0xC0, 0xF9, 0x9F, 0x99, 0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xF9,
  0x99, 0x99, 0xF0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9,
  0x8B, 0x99, 0xF0, 0x99, 0x9F, 0x99, 0x90, 0xF6, 0x66, 0x66, 0xF0, 0x38,
  0x42, 0x10, 0xE5, 0xC0, 0x9D, 0xA9, 0xCB, 0x4A, 0x60, 0x88, 0x88, 0x88,
  0xF0, 0x9F, 0xFF, 0x99, 0x90, 0xDD, 0xDB, 0xBB, 0x90, 0xF9, 0x99, 0x99,
  0xF0, 0xF4, 0xE7, 0xE8, 0x42, 0x00, 0xF9, 0x99, 0x99, 0xF3, 0x10, 0xF4,
  0xA5, 0xEA, 0x4A, 0x60, 0xF9, 0xC7, 0x19, 0xF0, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x00, 0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x9A, 0x30, 0xC3, 0x00,
  0xB6, 0xDB, 0x5E, 0x79, 0x24, 0x80, 0xCD, 0xE3, 0x0C, 0x31, 0x2C, 0xC0,
  0xCD, 0x23, 0x0C, 0x30, 0xC3, 0x00, 0xF3, 0x26, 0x48, 0xF0, 0xF2, 0x49,
  0x24, 0xE0, 0x8C, 0x44, 0x62, 0x23, 0x10, 0xE4, 0x92, 0x49, 0xE0, 0x66,
  0x99, 0xF0, 0x90, 0x6F, 0x1F, 0x9F, 0x8A, 0xF9, 0x99, 0xF0, 0x6F, 0x88,
  0x9F, 0x15, 0xF9, 0x99, 0xF0, 0x69, 0x9F, 0x8F, 0x74, 0xF4, 0x44, 0x40,
  0x5F, 0x99, 0xB5, 0x16, 0x8A, 0xF9, 0x99, 0x90, 0x61, 0x39, 0xC2, 0x10,
  0x9F, 0x32, 0xFF, 0x33, 0x33, 0x2E, 0x84, 0xE5, 0x4E, 0x5A, 0x60, 0xE0,
  0x82, 0x08, 0x20, 0x81, 0xC0, 0xDF, 0xDD, 0xDD, 0xAF, 0x99, 0x99, 0x6F,
  0x99, 0x9F, 0xAF, 0x99, 0x9F, 0x88, 0x5F, 0x99, 0x9F, 0x11, 0xA6, 0xA7,
  0x08, 0x40, 0x69, 0x87, 0x9F, 0x27, 0xFE, 0x42, 0x10, 0xE0, 0x99, 0x99,
  0x9F, 0xCD, 0x24, 0x9E, 0x30, 0xC0, 0xA6, 0xD7, 0x9E, 0x79, 0x20, 0xCD,
  0xE3, 0x0C, 0x7B, 0x30, 0xCD, 0x24, 0x8E, 0x30, 0xC2, 0x08, 0xFF, 0x24,
  0xCF, 0x32, 0x22, 0xC2, 0x22, 0x30, 0xFF, 0xFF, 0xC0, 0xC4, 0x44, 0x34,
  0x44, 0xC0, 0x6D, 0xE9, 0x80,
};

const GFXglyph JetBrainsMono_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 4, 10, 6, 1, -9 },
  { 16, 6, 7, 6, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 3, 6, 2, -7 },
  { 29, 3, 9, 6, 2, -8 },
  { 33, 3, 9, 6, 1, -8 },
  { 37, 6, 5, 6, 0, -6 },
  { 41, 4, 5, 6, 1, -6 },
  { 44, 3, 4, 6, 1, -2 },
  { 46, 4, 1, 6, 1, -4 },
  { 47, 2, 2, 6, 2, -2 },
  { 48, 4, 9, 6, 1, -8 },
  { 53, 4, 7, 6, 1, -7 },
  { 57, 5, 7, 6, 1, -7 },
  { 62, 4, 7, 6, 1, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 4, 7, 6, 1, -7 },
  { 94, 2, 6, 6, 2, -6 },
  { 96, 2, 8, 6, 2, -6 },
  { 98, 4, 5, 6, 1, -6 },
  { 101, 4, 4, 6, 1, -5 },
  { 103, 4, 5, 6, 1, -6 },
  { 106, 4, 7, 6, 1, -7 },
  { 110, 6, 9, 6, 0, -7 },
  { 117, 6, 7, 6, 0, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 5, 7, 6, 0, -7 },
  { 160, 5, 7, 6, 1, -7 },
  { 165, 4, 7, 6, 1, -7 },
  { 169, 4, 7, 6, 1, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 5, 7, 6, 1, -7 },
  { 186, 4, 9, 6, 1, -7 },
  { 191, 5, 7, 6, 1, -7 },
  { 196, 4, 7, 6, 1, -7 },
  { 200, 6, 7, 6, 0, -7 },
  { 206, 4, 7, 6, 1, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 6, 7, 6, 0, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 4, 7, 6, 1, -7 },
  { 238, 3, 9, 6, 2, -8 },
  { 242, 4, 9, 6, 1, -8 },
  { 247, 3, 9, 6, 1, -8 },
  { 251, 4, 4, 6, 1, -7 },
  { 253, 4, 1, 6, 1, 0 },
  { 254, 2, 2, 6, 2, -8 },
  { 255, 4, 6, 6, 1, -6 },
  { 258, 4, 7, 6, 1, -7 },
  { 262, 4, 6, 6, 1, -6 },
  { 265, 4, 7, 6, 1, -7 },
  { 269, 4, 6, 6, 1, -6 },
  { 272, 4, 7, 6, 1, -7 },
  { 276, 4, 8, 6, 1, -6 },
  { 280, 4, 7, 6, 1, -7 },
  { 284, 5, 8, 6, 1, -8 },
  { 289, 4, 10, 6, 1, -8 },
  { 294, 5, 7, 6, 1, -7 },
  { 299, 6, 7, 6, 0, -7 },
  { 305, 4, 6, 6, 1, -6 },
  { 308, 4, 6, 6, 1, -6 },
  { 311, 4, 6, 6, 1, -6 },
  { 314, 4, 8, 6, 1, -6 },
  { 318, 4, 8, 6, 1, -6 },
  { 322, 5, 6, 6, 1, -6 },
  { 326, 4, 6, 6, 1, -6 },
  { 329, 5, 7, 6, 0, -7 },
  { 334, 4, 6, 6, 1, -6 },
  { 337, 6, 6, 6, 0, -6 },
  { 342, 6, 6, 6, 0, -6 },
  { 347, 6, 6, 6, 0, -6 },
  { 352, 6, 8, 6, 0, -6 },
  { 358, 4, 6, 6, 1, -6 },
  { 361, 4, 9, 6, 1, -8 },
  { 366, 2, 9, 6, 2, -8 },
  { 369, 4, 9, 6, 1, -8 },
  { 374, 6, 3, 6, 0, -5 },
};

const GFXfont JetBrainsMono_Bold10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_BOLD10PT7B_H_
