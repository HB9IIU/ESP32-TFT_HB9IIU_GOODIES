#ifndef _JETBRAINSMONO_BOLD33PT7B_H_
#define _JETBRAINSMONO_BOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9C, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xDE, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0x70, 0xE7, 0x0E, 0x03, 0x87,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0x87,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x83, 0x80, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE3, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03,
  0x87, 0x01, 0xE1, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7D, 0xBE, 0x79, 0x9E,
  0xF9, 0x9F, 0xF9, 0x80, 0xF9, 0x80, 0x79, 0x80, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x8F,
  0x01, 0x8F, 0xF1, 0x8F, 0xF9, 0x9F, 0xFD, 0xBE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x3F, 0x00, 0xF7, 0xF8, 0x0E, 0x7B, 0xC1, 0xCE, 0x1C, 0x38, 0xE1, 0xC3,
  0x8E, 0x1C, 0x70, 0xE1, 0xCE, 0x07, 0x1C, 0xE0, 0x7F, 0xDC, 0x03, 0xFB,
  0x80, 0x1E, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xF8, 0x01,
  0xDF, 0xC0, 0x3B, 0xFE, 0x07, 0x38, 0xE0, 0xE3, 0x8E, 0x0E, 0x38, 0xE1,
  0xC3, 0x8E, 0x38, 0x38, 0xE3, 0x83, 0xDE, 0x70, 0x1F, 0xEE, 0x00, 0xF8,
  0x07, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC3, 0xDE, 0xF9, 0xEF, 0x1E, 0x7B, 0xC3, 0xFC,
  0xF0, 0xFE, 0x3C, 0x1F, 0x8F, 0x03, 0xC1, 0xE0, 0xF8, 0x78, 0x7E, 0x1F,
  0xFF, 0xC3, 0xFF, 0x78, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x40, 0x70, 0x7C, 0x3F, 0x1F, 0x8F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xFE, 0x1F, 0xC1,
  0xF0, 0x3C, 0x03, 0x80, 0x38, 0x0F, 0x83, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8,
  0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE1,
  0xF1, 0xF8, 0xFC, 0x3E, 0x0F, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x41, 0xC1, 0x9E, 0x31, 0xEF, 0xCD, 0xFB, 0xFF,
  0xFF, 0x1F, 0xFE, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C,
  0x07, 0xCF, 0x03, 0xE1, 0xE0, 0x70, 0x7C, 0x0C, 0x08, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E,
  0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x7C, 0x7E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x07, 0xFE, 0x0F,
  0xBC, 0x1C, 0x78, 0x30, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0xF8, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xF7, 0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x7B, 0xE0, 0xF7, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79, 0xF0,
  0xF7, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC7, 0xEF, 0xFF,
  0x8F, 0xFE, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0x7E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C,
  0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x7C, 0x3E, 0xF8, 0x1E,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E,
  0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0x7E, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x3E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0,
  0x3E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x8F, 0xFC,
  0x7F, 0xC3, 0xFC, 0x1F, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0xF9, 0xFC, 0x7F, 0x7F, 0x1E, 0x7F, 0xC7, 0x0F,
  0xF1, 0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x0F, 0xF1, 0xC3, 0xFC,
  0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x9F, 0xF1, 0xFD, 0xFC, 0x3E, 0x7F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xC0, 0xF1,
  0xE0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9E,
  0x0F, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x1F, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1E,
  0x7E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F,
  0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xFF, 0xF9,
  0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0x78, 0x1E, 0x7E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0,
  0xF0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x37, 0xEC, 0x77, 0xEE, 0x77, 0xEE, 0x7F,
  0xE6, 0x6F, 0xE7, 0xEF, 0xE7, 0xEF, 0xF7, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFB, 0x87, 0xF7,
  0x0F, 0xEF, 0x1F, 0xCE, 0x3F, 0x9C, 0x7F, 0x3C, 0xFE, 0x39, 0xFC, 0x73,
  0xF8, 0xF7, 0xF0, 0xEF, 0xE1, 0xDF, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3,
  0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFE,
  0x07, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xF7, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFC, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3,
  0xC3, 0xE7, 0x83, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0x0F,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0,
  0xF7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xF8, 0x07, 0xDE, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x3F, 0x87, 0x8F, 0xE1,
  0xE3, 0xFC, 0x78, 0xFF, 0x3E, 0x3F, 0xCD, 0xCE, 0xF3, 0x73, 0x9C, 0xCC,
  0xE7, 0x33, 0x39, 0xCC, 0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xE7, 0x73, 0x79,
  0xDC, 0xDE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0xF8, 0x07, 0x9F, 0x03,
  0xE3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0xCF, 0x00, 0xF3, 0xC0,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x7C, 0x07, 0xCF,
  0x01, 0xE3, 0xE0, 0xF8, 0x78, 0x3C, 0x1F, 0x1F, 0x03, 0xE7, 0x80, 0xFB,
  0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C,
  0x38, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x0F, 0xF0, 0x7F,
  0xF8, 0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0x3C, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x7F, 0x3F, 0xFE, 0xFF, 0xFF, 0xE1,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0xF8,
  0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x1F, 0x78, 0x1E, 0x7E, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC7, 0xF7, 0x9F, 0xEF, 0x7F, 0xFE, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7B, 0xC0, 0xF7, 0xC7, 0xEF, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF, 0x0F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x03,
  0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F, 0xDE, 0x7F, 0xFD,
  0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0xFF, 0xCF, 0xFF,
  0x9F, 0xEF, 0x0F, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xE3,
  0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x7F, 0x3F, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x03,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xEF, 0xFE, 0x7F,
  0xF3, 0xFF, 0x1F, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78,
  0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xEF, 0x3E, 0xFF, 0xBF, 0xF7,
  0xFF, 0xE3, 0xCF, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3,
  0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3,
  0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE1, 0xF7, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x9F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xE0, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFB, 0xDF, 0xCF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0xDE, 0x7F, 0xBD, 0xFF,
  0xFB, 0xE1, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x1F, 0xBF,
  0xFF, 0x3F, 0xDE, 0x3F, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0xF3, 0xF9, 0xEF, 0xFB, 0xFF, 0xF7, 0xE1, 0xFF,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81,
  0xEF, 0x03, 0xDF, 0x9F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0xF8, 0x07,
  0xDE, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x3F, 0xC7, 0x8F,
  0xF1, 0xE3, 0x9C, 0xF8, 0xE7, 0x37, 0x39, 0xCC, 0xCE, 0x73, 0x33, 0x9C,
  0xCD, 0xE7, 0xB3, 0x71, 0xFC, 0xDC, 0x3F, 0x37, 0x0F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x80, 0x7C, 0x0F, 0x8F, 0x07,
  0xC3, 0xE1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0x7C, 0x07, 0xCF, 0x81, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0xBE, 0x01,
  0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xFB, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFC, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xFC, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0x07, 0xFF, 0x87, 0xFF, 0x87, 0xE3, 0xCF, 0xE1, 0xFF, 0xE1, 0xFE, 0xE0,
  0x7C,
};

const GFXglyph JetBrainsMono_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 12, 10, 20, 4, -24 },
  { 34, 18, 24, 20, 1, -24 },
  { 88, 16, 34, 20, 2, -29 },
  { 156, 20, 24, 20, 0, -24 },
  { 216, 18, 24, 20, 1, -24 },
  { 270, 4, 10, 20, 8, -24 },
  { 275, 10, 32, 20, 6, -28 },
  { 315, 10, 32, 20, 4, -28 },
  { 355, 18, 17, 20, 1, -20 },
  { 394, 16, 16, 20, 2, -19 },
  { 426, 8, 10, 20, 5, -5 },
  { 436, 10, 4, 20, 5, -13 },
  { 441, 6, 6, 20, 7, -6 },
  { 446, 16, 31, 20, 2, -27 },
  { 508, 16, 24, 20, 2, -24 },
  { 556, 15, 24, 20, 3, -24 },
  { 601, 16, 24, 20, 2, -24 },
  { 649, 15, 24, 20, 2, -24 },
  { 694, 15, 24, 20, 2, -24 },
  { 739, 15, 24, 20, 2, -24 },
  { 784, 16, 24, 20, 2, -24 },
  { 832, 16, 24, 20, 2, -24 },
  { 880, 16, 24, 20, 2, -24 },
  { 928, 16, 24, 20, 2, -24 },
  { 976, 6, 18, 20, 7, -18 },
  { 990, 8, 23, 20, 5, -18 },
  { 1013, 14, 18, 20, 3, -20 },
  { 1045, 14, 12, 20, 3, -17 },
  { 1066, 14, 18, 20, 3, -20 },
  { 1098, 13, 24, 20, 4, -24 },
  { 1137, 18, 30, 20, 1, -24 },
  { 1205, 18, 24, 20, 1, -24 },
  { 1259, 15, 24, 20, 3, -24 },
  { 1304, 16, 24, 20, 2, -24 },
  { 1352, 16, 24, 20, 2, -24 },
  { 1400, 14, 24, 20, 3, -24 },
  { 1442, 15, 24, 20, 3, -24 },
  { 1487, 16, 24, 20, 2, -24 },
  { 1535, 14, 24, 20, 3, -24 },
  { 1577, 14, 24, 20, 3, -24 },
  { 1619, 16, 24, 20, 1, -24 },
  { 1667, 16, 24, 20, 3, -24 },
  { 1715, 15, 24, 20, 3, -24 },
  { 1760, 16, 24, 20, 2, -24 },
  { 1808, 15, 24, 20, 2, -24 },
  { 1853, 15, 24, 20, 2, -24 },
  { 1898, 16, 24, 20, 3, -24 },
  { 1946, 16, 30, 20, 2, -24 },
  { 2006, 15, 24, 20, 3, -24 },
  { 2051, 16, 24, 20, 2, -24 },
  { 2099, 16, 24, 20, 2, -24 },
  { 2147, 15, 24, 20, 2, -24 },
  { 2192, 18, 24, 20, 1, -24 },
  { 2246, 18, 24, 20, 1, -24 },
  { 2300, 18, 24, 20, 1, -24 },
  { 2354, 18, 24, 20, 1, -24 },
  { 2408, 14, 24, 20, 3, -24 },
  { 2450, 9, 31, 20, 6, -27 },
  { 2485, 16, 31, 20, 2, -27 },
  { 2547, 10, 31, 20, 4, -27 },
  { 2586, 16, 13, 20, 2, -24 },
  { 2612, 16, 4, 20, 2, 1 },
  { 2620, 8, 5, 20, 5, -26 },
  { 2625, 15, 18, 20, 2, -18 },
  { 2659, 14, 24, 20, 3, -24 },
  { 2701, 16, 18, 20, 2, -18 },
  { 2737, 15, 24, 20, 2, -24 },
  { 2782, 15, 18, 20, 2, -18 },
  { 2816, 16, 24, 20, 2, -24 },
  { 2864, 15, 24, 20, 2, -18 },
  { 2909, 14, 24, 20, 3, -24 },
  { 2951, 15, 26, 20, 3, -26 },
  { 3000, 13, 32, 20, 3, -26 },
  { 3052, 16, 24, 20, 3, -24 },
  { 3100, 17, 24, 20, 1, -24 },
  { 3151, 16, 18, 20, 2, -18 },
  { 3187, 14, 18, 20, 3, -18 },
  { 3219, 15, 18, 20, 2, -18 },
  { 3253, 14, 24, 20, 3, -18 },
  { 3295, 15, 24, 20, 2, -18 },
  { 3340, 15, 18, 20, 3, -18 },
  { 3374, 16, 18, 20, 2, -18 },
  { 3410, 16, 23, 20, 1, -23 },
  { 3456, 15, 18, 20, 2, -18 },
  { 3490, 18, 18, 20, 1, -18 },
  { 3531, 18, 18, 20, 1, -18 },
  { 3572, 18, 18, 20, 1, -18 },
  { 3613, 18, 24, 20, 1, -18 },
  { 3667, 14, 18, 20, 3, -18 },
  { 3699, 14, 31, 20, 3, -27 },
  { 3754, 4, 31, 20, 8, -27 },
  { 3770, 14, 31, 20, 3, -27 },
  { 3825, 16, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_Bold33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_BOLD33PT7B_H_
