#ifndef _JETBRAINSMONO_BOLD61PT7B_H_
#define _JETBRAINSMONO_BOLD61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x80, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC7, 0x87, 0xF8, 0xFF, 0x1E,
  0x1F, 0xE7, 0xF8, 0x78, 0x3F, 0x9F, 0xE1, 0xE0, 0xFE, 0x7F, 0x87, 0x80,
  0x01, 0xFE, 0x1E, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x0F, 0xF1, 0xE0, 0x00,
  0x3F, 0xE7, 0x80, 0x00, 0xFF, 0xDE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xE7, 0xFE, 0x00, 0x07, 0x8F,
  0xFC, 0x00, 0x1E, 0x1F, 0xF0, 0x00, 0x78, 0x3F, 0xC0, 0x01, 0xE0, 0xFF,
  0x00, 0x07, 0x83, 0xFF, 0xFC, 0x1E, 0x0F, 0xF7, 0xF0, 0x78, 0x3F, 0xDF,
  0xE1, 0xE0, 0xFF, 0x7F, 0x87, 0x87, 0xFD, 0xFF, 0x1E, 0x1F, 0xE3, 0xFF,
  0x79, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x0F, 0x87, 0xFF, 0xC0, 0x00,
  0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x07,
  0xE0, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x3F, 0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x3E,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0xF8,
  0x00, 0x3F, 0xFF, 0xCF, 0x80, 0x01, 0xFF, 0xFC, 0xFC, 0x00, 0x07, 0xFF,
  0xC7, 0xC0, 0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00,
  0x01, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0x9F, 0xFF, 0x80, 0x01, 0xF9, 0xFF,
  0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0xF0, 0x00, 0xFC, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x7E, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x1F,
  0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0xFF,
  0xFF, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x3F, 0xC1, 0xFC,
  0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0xFE, 0x07, 0xF7, 0xF8,
  0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0,
  0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xE1, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x07, 0xE0, 0x0E, 0x1F,
  0x01, 0xF0, 0x3F, 0x1F, 0xE0, 0xF8, 0x7F, 0x8F, 0xFC, 0x78, 0x7F, 0xEF,
  0xFF, 0x3C, 0xFF, 0xF7, 0xFF, 0xEE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1E, 0x0F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD,
  0xFF, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xF8, 0x7F, 0xFE,
  0x1F, 0xC7, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x06, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xFC,
  0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFC, 0x00, 0xFF,
  0xCF, 0xE0, 0x07, 0xFC, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x0F, 0x80, 0xFE, 0x00, 0x70, 0x07, 0xF0, 0x03, 0x00, 0x3F, 0x80,
  0x10, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x7F,
  0xE0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xF1, 0xFF,
  0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF9,
  0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x07, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0D, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0x80,
  0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xCF, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFD, 0xFE, 0x00, 0x1F, 0x8F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x07, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0x9F, 0xFE,
  0x01, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0xFF,
  0xF8, 0x1F, 0x80, 0x7F, 0xFC, 0x0F, 0xC0, 0x1F, 0xFE, 0x07, 0xE0, 0x0F,
  0xFF, 0x03, 0xF0, 0x07, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0xC0, 0xFC, 0x01,
  0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F, 0x80,
  0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0x03, 0xF8,
  0x0F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0xFE, 0xFE, 0x00, 0x3F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE,
  0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0xFC, 0xFE, 0x00, 0x7F,
  0xEF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x3F, 0xEF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x00,
  0xFF, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x83,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x01, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80,
  0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xF3,
  0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0xBF, 0x80, 0x01, 0xFE, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xF7, 0xFF, 0x7C, 0x07, 0xDF, 0xFD, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0, 0xFB,
  0xFF, 0xDF, 0x83, 0xEF, 0xFF, 0x3E, 0x0F, 0xBF, 0xFE, 0xF8, 0x3E, 0xFF,
  0xFB, 0xE1, 0xF3, 0xFF, 0xE7, 0xC7, 0xCF, 0xFF, 0x9F, 0x1F, 0x3F, 0xFE,
  0x7C, 0xFC, 0xFF, 0xF9, 0xFB, 0xE3, 0xFF, 0xE3, 0xEF, 0x8F, 0xFF, 0x8F,
  0xBE, 0x7F, 0xFE, 0x3E, 0xF1, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xE1, 0xFF,
  0x1F, 0xFF, 0x87, 0xFC, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0x87,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFC, 0x07, 0xFF, 0xEF, 0xC0,
  0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xE7, 0xE0, 0x7F, 0xFE, 0x7E, 0x07, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFE, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0x7F, 0xFE, 0x1F,
  0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE0, 0xFC, 0x7F,
  0xFE, 0x0F, 0xC7, 0xFF, 0xE0, 0xFC, 0x7F, 0xFE, 0x07, 0xE7, 0xFF, 0xE0,
  0x7E, 0x7F, 0xFE, 0x07, 0xE7, 0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x03, 0xF3,
  0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xBF, 0xFE,
  0x01, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xFC, 0x01, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x68, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFE,
  0xFE, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xE0, 0x03, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F,
  0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xFC, 0xFE, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFD, 0xFC,
  0x00, 0x7F, 0xCF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x1F,
  0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x03, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0x7F, 0x01, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x80,
  0xFD, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0x81, 0xFE, 0x03, 0xF3, 0xF0, 0x3D,
  0xC0, 0xFE, 0x7E, 0x07, 0xB8, 0x1F, 0xCF, 0xC0, 0xF7, 0x83, 0xF9, 0xF8,
  0x1E, 0xF0, 0x7F, 0x3F, 0x83, 0xDE, 0x0F, 0xC7, 0xF0, 0x7B, 0xC1, 0xF8,
  0xFE, 0x0F, 0x78, 0x3F, 0x1F, 0xC1, 0xEF, 0x07, 0xE1, 0xF8, 0x79, 0xE0,
  0xFC, 0x3F, 0x0F, 0x3C, 0x1F, 0x87, 0xE1, 0xE7, 0x83, 0xF0, 0xFC, 0x3C,
  0x78, 0x7E, 0x1F, 0x87, 0x8F, 0x1F, 0xC3, 0xF0, 0xF1, 0xE3, 0xF0, 0x7E,
  0x1E, 0x3C, 0x7E, 0x0F, 0xC3, 0xC7, 0x8F, 0xC1, 0xFC, 0xF8, 0xF1, 0xF8,
  0x3F, 0x9E, 0x1E, 0x3F, 0x03, 0xF3, 0xC3, 0xC7, 0xE0, 0x7E, 0x78, 0x78,
  0xFC, 0x0F, 0xCF, 0x07, 0x9F, 0x81, 0xF9, 0xE0, 0xF3, 0xF0, 0x3F, 0x3C,
  0x1E, 0x7E, 0x07, 0xE7, 0x83, 0xCF, 0x80, 0xFC, 0xF0, 0x7B, 0xF0, 0x1F,
  0xBC, 0x0F, 0x7E, 0x03, 0xF7, 0x81, 0xEF, 0xC0, 0x7E, 0xF0, 0x3D, 0xF8,
  0x07, 0xFE, 0x07, 0xBF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0x9F, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x81, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x07,
  0xBF, 0x9F, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0xEF, 0xE3, 0xFF, 0xFE, 0x7F,
  0x0F, 0xFF, 0xE3, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x0F, 0xE3, 0xFF, 0xC1, 0xFC, 0xFF, 0xFC, 0x3F, 0xBF,
  0xFF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFB,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFF, 0xFF, 0x9F, 0xDF, 0xFF, 0xF3, 0xF9, 0xFF, 0xFC,
  0x7F, 0x1F, 0xFF, 0x0F, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x07,
  0xFC, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x07, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xEF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xC0, 0x3F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF,
  0xF0, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x01,
  0xFE, 0x3F, 0xFD, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0x0F, 0xFF,
  0xCF, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFC, 0xFF,
  0x03, 0xFF, 0x8F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xE3, 0xFF,
  0xC1, 0xFC, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x3E, 0x07, 0xE3, 0xF3, 0xFC, 0x3F,
  0xCF, 0xDF, 0xF9, 0xFF, 0xBF, 0x7F, 0xEF, 0xFE, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xCF, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE,
  0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x81,
  0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xE0, 0x7C,
  0x0F, 0xFF, 0x81, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x03,
  0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x81, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0xFF,
  0xF8, 0x1F, 0x03, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x81, 0xF0, 0x3F, 0xFE,
  0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x81,
  0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xE0, 0x7C,
  0x0F, 0xFF, 0x81, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x03,
  0xF0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC7, 0xFF, 0x83, 0xF9, 0xFF, 0xF8, 0x7F,
  0x7F, 0xFF, 0x8F, 0xEF, 0xFF, 0xF9, 0xFD, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x03, 0xFE,
  0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC7, 0xFF, 0x83, 0xF9, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF,
  0x8F, 0xEF, 0xFF, 0xF9, 0xFD, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF7, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFD, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xE7, 0xF3, 0xFF, 0xF8, 0xFE,
  0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0x06, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F,
  0xF8, 0xFF, 0x0F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xCF, 0xF0, 0x3F, 0xF0, 0xFF, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xF8,
  0x0F, 0xE3, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF8, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xCF, 0xF0, 0x01,
  0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xF0,
  0x7F, 0xE7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0, 0x3F, 0x7E,
  0x03, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x81, 0xF9,
  0xFC, 0x1F, 0xE0, 0x7E, 0x7F, 0x07, 0xB8, 0x1F, 0x8F, 0xC1, 0xEF, 0x07,
  0xE3, 0xF0, 0x7B, 0xC1, 0xF8, 0xFC, 0x1E, 0xF0, 0x7E, 0x3F, 0x07, 0x3C,
  0x1F, 0x8F, 0xC3, 0xCF, 0x0F, 0xC3, 0xF0, 0xF1, 0xC3, 0xF0, 0x7E, 0x3C,
  0x78, 0xFC, 0x1F, 0x8F, 0x1E, 0x3F, 0x07, 0xE3, 0xC7, 0x8F, 0xC1, 0xF8,
  0xF1, 0xE3, 0xF0, 0x7E, 0x78, 0x78, 0xF8, 0x1F, 0x9E, 0x1E, 0x7E, 0x07,
  0xE7, 0x87, 0x9F, 0x80, 0xFD, 0xE0, 0xF7, 0xE0, 0x3F, 0x78, 0x3D, 0xF8,
  0x0F, 0xDE, 0x0F, 0x7E, 0x03, 0xF7, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0xF7,
  0xC0, 0x3F, 0xF0, 0x3D, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xF9,
  0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xDF, 0xF0, 0x3F, 0xFF, 0x0F, 0xF0, 0x7E, 0xFE, 0x0F, 0xFB, 0xFD, 0xFC,
  0x0F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph JetBrainsMono_Bold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 45, 37, 13, -45 },
  { 58, 21, 19, 37, 8, -45 },
  { 108, 33, 45, 37, 2, -45 },
  { 294, 30, 62, 37, 3, -53 },
  { 527, 37, 45, 37, 0, -45 },
  { 736, 32, 46, 37, 3, -45 },
  { 920, 8, 19, 37, 14, -45 },
  { 939, 20, 58, 37, 10, -51 },
  { 1084, 19, 58, 37, 7, -51 },
  { 1222, 33, 32, 37, 2, -37 },
  { 1354, 29, 29, 37, 4, -35 },
  { 1460, 15, 19, 37, 9, -9 },
  { 1496, 19, 7, 37, 9, -24 },
  { 1513, 11, 12, 37, 13, -11 },
  { 1530, 29, 58, 37, 4, -51 },
  { 1741, 28, 46, 37, 4, -45 },
  { 1902, 29, 45, 37, 5, -45 },
  { 2066, 29, 45, 37, 4, -45 },
  { 2230, 28, 46, 37, 4, -45 },
  { 2391, 27, 45, 37, 4, -45 },
  { 2543, 28, 46, 37, 4, -45 },
  { 2704, 30, 46, 37, 3, -45 },
  { 2877, 29, 45, 37, 4, -45 },
  { 3041, 29, 46, 37, 4, -45 },
  { 3208, 30, 45, 37, 3, -45 },
  { 3377, 11, 35, 37, 13, -34 },
  { 3426, 15, 44, 37, 9, -34 },
  { 3509, 27, 34, 37, 5, -37 },
  { 3624, 27, 22, 37, 5, -31 },
  { 3699, 27, 34, 37, 5, -37 },
  { 3814, 24, 45, 37, 7, -45 },
  { 3949, 33, 56, 37, 2, -45 },
  { 4180, 32, 45, 37, 2, -45 },
  { 4360, 28, 45, 37, 5, -45 },
  { 4518, 29, 46, 37, 4, -45 },
  { 4685, 28, 45, 37, 5, -45 },
  { 4843, 27, 45, 37, 5, -45 },
  { 4995, 28, 45, 37, 5, -45 },
  { 5153, 29, 46, 37, 4, -45 },
  { 5320, 27, 45, 37, 5, -45 },
  { 5472, 26, 45, 37, 5, -45 },
  { 5619, 29, 46, 37, 2, -45 },
  { 5786, 30, 45, 37, 5, -45 },
  { 5955, 27, 45, 37, 6, -45 },
  { 6107, 30, 45, 37, 3, -45 },
  { 6276, 28, 45, 37, 4, -45 },
  { 6434, 28, 46, 37, 4, -45 },
  { 6595, 29, 45, 37, 5, -45 },
  { 6759, 29, 56, 37, 4, -45 },
  { 6962, 29, 45, 37, 5, -45 },
  { 7126, 30, 46, 37, 3, -45 },
  { 7299, 31, 45, 37, 3, -45 },
  { 7474, 28, 46, 37, 4, -45 },
  { 7635, 32, 45, 37, 2, -45 },
  { 7815, 35, 45, 37, 1, -45 },
  { 8012, 33, 45, 37, 2, -45 },
  { 8198, 34, 45, 37, 1, -45 },
  { 8390, 27, 45, 37, 5, -45 },
  { 8542, 17, 58, 37, 11, -51 },
  { 8666, 29, 58, 37, 4, -51 },
  { 8877, 17, 58, 37, 8, -51 },
  { 9001, 28, 24, 37, 4, -45 },
  { 9085, 29, 6, 37, 4, 2 },
  { 9107, 15, 9, 37, 10, -48 },
  { 9124, 29, 35, 37, 3, -34 },
  { 9251, 27, 46, 37, 5, -45 },
  { 9407, 29, 35, 37, 4, -34 },
  { 9534, 28, 46, 37, 4, -45 },
  { 9695, 28, 35, 37, 4, -34 },
  { 9818, 30, 45, 37, 3, -45 },
  { 9987, 28, 45, 37, 4, -34 },
  { 10145, 27, 45, 37, 5, -45 },
  { 10297, 29, 48, 37, 5, -48 },
  { 10471, 24, 59, 37, 5, -48 },
  { 10648, 30, 45, 37, 5, -45 },
  { 10817, 32, 45, 37, 2, -45 },
  { 10997, 30, 34, 37, 3, -34 },
  { 11125, 27, 34, 37, 5, -34 },
  { 11240, 28, 35, 37, 4, -34 },
  { 11363, 27, 45, 37, 5, -34 },
  { 11515, 28, 45, 37, 4, -34 },
  { 11673, 28, 34, 37, 6, -34 },
  { 11792, 29, 35, 37, 4, -34 },
  { 11919, 29, 43, 37, 3, -43 },
  { 12075, 27, 35, 37, 5, -34 },
  { 12194, 32, 34, 37, 2, -34 },
  { 12330, 34, 34, 37, 1, -34 },
  { 12475, 32, 34, 37, 2, -34 },
  { 12611, 32, 45, 37, 2, -34 },
  { 12791, 27, 34, 37, 5, -34 },
  { 12906, 27, 58, 37, 5, -51 },
  { 13102, 8, 58, 37, 14, -51 },
  { 13160, 27, 58, 37, 5, -51 },
  { 13356, 31, 15, 37, 3, -29 },
};

const GFXfont JetBrainsMono_Bold61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_BOLD61PT7B_H_
