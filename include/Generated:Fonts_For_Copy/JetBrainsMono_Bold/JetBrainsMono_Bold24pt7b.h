#ifndef _JETBRAINSMONO_BOLD24PT7B_H_
#define _JETBRAINSMONO_BOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x00, 0x07, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE3, 0xE3, 0x0C, 0x70, 0x63, 0x03, 0x18, 0x38,
  0xC1, 0x86, 0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x38, 0xC1, 0x86, 0x0C, 0x30,
  0x63, 0x8F, 0xFF, 0x7F, 0xF9, 0xC6, 0x0C, 0x30, 0x61, 0x83, 0x1C, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x3F, 0xC7, 0xFE, 0x76, 0xF7, 0x67,
  0x76, 0x07, 0x60, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0x7E, 0x06, 0xF0, 0x67,
  0xE6, 0x77, 0x67, 0x7F, 0xF3, 0xFE, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x60,
  0x18, 0x0D, 0xF8, 0x3E, 0x61, 0xB1, 0x8C, 0xC6, 0x73, 0x19, 0x87, 0xEC,
  0x1F, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x67, 0x01, 0xBF, 0x0D, 0x8C, 0x66,
  0x33, 0x98, 0xCC, 0x63, 0x61, 0xFF, 0x03, 0xE0, 0x0F, 0x01, 0xFC, 0x0F,
  0xF0, 0xE1, 0xC7, 0x0E, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x07, 0xF1,
  0xFB, 0x9D, 0xCE, 0xEE, 0x3E, 0x70, 0xE3, 0x87, 0x1E, 0x7C, 0x7F, 0xF1,
  0xF3, 0xC0, 0xFF, 0xFF, 0xF6, 0x03, 0x0F, 0x1F, 0x3C, 0x78, 0x70, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x78,
  0x3E, 0x1F, 0x0F, 0x03, 0xC1, 0xC3, 0xE3, 0xE1, 0xC3, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0xF3, 0xCF, 0x1C, 0x20,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x0C, 0x2E, 0x67, 0x7D, 0x7D, 0xFF,
  0x80, 0xC0, 0x0F, 0x80, 0xEE, 0x0E, 0x70, 0xF1, 0xC1, 0x08, 0x00, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x7B, 0xDC, 0xEF, 0x73, 0x98, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x00, 0x1E, 0x0F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xCE, 0xF9, 0xDF, 0x33, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x9E, 0x7F,
  0xC7, 0xE0, 0x0F, 0x03, 0xE1, 0xFC, 0x7B, 0x8E, 0x71, 0x0E, 0x21, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xFE, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x7E, 0x07, 0x70, 0xF7, 0x9E, 0x3F, 0xC1, 0xF8, 0x03, 0xC0, 0xE0,
  0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x71, 0xF8, 0x7E, 0x1F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xDF, 0xFB, 0xFF,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x87, 0xFC, 0xFF, 0xDE, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xF8, 0x7F, 0xDE, 0x7F, 0xC7, 0xE0, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xB8, 0x7F, 0xE7, 0xFE,
  0x70, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x9E, 0x3F, 0xE1, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1E, 0x0F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8,
  0x73, 0x9E, 0x3F, 0x07, 0xF1, 0xCF, 0x70, 0xEE, 0x0F, 0x81, 0xF8, 0x3F,
  0x9E, 0x7F, 0xC7, 0xE0, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0F, 0xF0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0x78, 0xF7, 0xFE, 0x3E, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0xFF, 0xF2, 0x00, 0x00, 0x06,
  0xFF, 0xF0, 0x7B, 0xDE, 0x60, 0x00, 0x00, 0x01, 0xDE, 0xF7, 0x3B, 0x9C,
  0xE0, 0x00, 0x60, 0x7C, 0x3F, 0x1F, 0x8F, 0xC1, 0xE0, 0x38, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xC0, 0x78, 0x3F, 0x1F, 0x8F, 0xC3, 0xC0, 0x60, 0x08, 0x00, 0xE0,
  0x7F, 0x3F, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x0F, 0x3F, 0x1F, 0x0F, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0x7C, 0xE0, 0xEE, 0x03, 0xE0, 0x1F, 0x0E, 0xF8, 0xFB, 0xC6, 0x3E, 0x71,
  0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x1C, 0xF8, 0xFB, 0xC1, 0xA7,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xC6,
  0x0E, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xC1, 0xDC, 0x0E, 0xE0, 0x77,
  0x03, 0xC0, 0xF8, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x77,
  0x1E, 0xFF, 0x9F, 0xF3, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF,
  0xFF, 0xDF, 0xE0, 0x1E, 0x0F, 0xF1, 0xFF, 0x70, 0xFE, 0x0F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC1, 0xF8, 0x7F,
  0xDE, 0x7F, 0xC7, 0xE0, 0xFC, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7F, 0xFE, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x0F, 0xF1, 0xFF, 0x70,
  0xFE, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0x9F, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7F, 0xDE, 0x7F, 0xC7, 0xE0, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFC, 0x3F,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0xC1, 0xF8, 0x3F, 0xDF, 0x7F, 0xC7, 0xF0, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x8E, 0x70, 0xFF, 0x0F, 0xF0,
  0xE7, 0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0xFF, 0x0F, 0xD8, 0xFF, 0x8F, 0xF9, 0xBF, 0x9B, 0xED, 0xBE,
  0xF7, 0xEF, 0x7E, 0x77, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xB1,
  0xF6, 0x3E, 0xE7, 0xCC, 0xF9, 0x9F, 0x3B, 0xE3, 0x7C, 0x7F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3C, 0x1E, 0x0F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7F, 0xDE, 0x7F, 0xC7, 0xE0, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE3, 0xFF, 0xFB, 0xFE, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x0F, 0xF3, 0xFF, 0x70,
  0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7F, 0xDE, 0x7F, 0xC7, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xFF, 0xDF, 0xFB, 0xFC, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0xF7, 0x0E,
  0xE1, 0xFC, 0x1C, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0F, 0x70, 0x77, 0x00,
  0x70, 0x07, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x07,
  0xF0, 0x77, 0xDF, 0x3F, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x9E, 0x7F, 0xC7, 0xE0, 0xE0, 0x3F,
  0x03, 0xB8, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38,
  0xE1, 0xCE, 0x0E, 0x70, 0x33, 0x81, 0xDC, 0x0E, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x00, 0xE3, 0x9F, 0x8E, 0x76, 0x39, 0xD8, 0xE7, 0x67,
  0x9D, 0x9E, 0x66, 0x69, 0x9D, 0xA6, 0x76, 0x99, 0xDA, 0x67, 0x4D, 0x8D,
  0x36, 0x34, 0xF8, 0xF3, 0xE3, 0xCF, 0x8F, 0x1C, 0x3C, 0x70, 0xF1, 0xC0,
  0xE0, 0x77, 0x83, 0x9C, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE3,
  0x8E, 0x1C, 0xF0, 0x77, 0x03, 0xC0, 0xE0, 0x3F, 0x03, 0xBC, 0x1C, 0xE1,
  0xC7, 0x8E, 0x1C, 0x70, 0xE7, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xFF, 0xDF, 0xFB, 0xFF, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0x80, 0xF0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0xFF, 0xFF, 0xF8,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x80, 0x0E, 0x03, 0xC0, 0x7C, 0x1F, 0x83,
  0xB0, 0x67, 0x1C, 0x63, 0x0E, 0xE1, 0xDC, 0x1C, 0xFF, 0xFF, 0xFF, 0xE1,
  0xC3, 0x87, 0x1F, 0xC3, 0xFE, 0x78, 0xE7, 0x07, 0x00, 0x71, 0xFF, 0x7F,
  0xF7, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xF7, 0xF7, 0x3E, 0x70, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0x8E, 0xE1, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x9E, 0xFF, 0xDD, 0xF0, 0x3F,
  0x8F, 0xFB, 0xC7, 0x70, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFC,
  0x1F, 0xCF, 0x3F, 0xE3, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0xFD, 0xFF, 0xBF, 0x9F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7F, 0x9F, 0x7E, 0xE7, 0x9C, 0x3F, 0x8F, 0xFB, 0x87, 0x70, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x1F, 0xC7, 0x3F, 0xE3, 0xF0,
  0x00, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x7E, 0xFF, 0xDF, 0xCF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFE, 0x7D, 0xFB, 0x9F, 0x70, 0x0E, 0x03, 0xC0, 0x71,
  0xFE, 0x3F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F,
  0xF7, 0x9E, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1C, 0x06, 0x01, 0xE0, 0x3C, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x03, 0xC0, 0xE0, 0x20,
  0x00, 0x01, 0xFE, 0xFF, 0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xFF, 0xFB, 0xF8, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x78,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0F,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0x07, 0xF0, 0x3F, 0xFE, 0xEF, 0xFF, 0xE6, 0x7E, 0x63, 0xE6, 0x3E, 0x63,
  0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x30, 0xEF,
  0x9F, 0xFB, 0xCF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x3F, 0x8F, 0xFB, 0xCF, 0x70, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xEF, 0x3F, 0xE3, 0xF0, 0xEF,
  0x9F, 0xFB, 0xC7, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0xCF, 0x7F, 0xEE, 0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x7E,
  0xFF, 0xDF, 0xCF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0xCF, 0xBF, 0x73, 0xCE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xEF,
  0xDF, 0xFF, 0xC7, 0xF0, 0x7E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0x9F, 0xFB, 0x87, 0xF0, 0x0E, 0x01,
  0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x3B, 0xCF, 0x3F, 0xC3, 0xF0, 0xE0, 0x7F, 0x07, 0x70, 0x77,
  0x0E, 0x70, 0xE3, 0x8E, 0x39, 0xC3, 0x9C, 0x1D, 0xC1, 0xD8, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0xE3, 0x1D, 0x8E, 0x76, 0x39, 0xD9, 0xE6, 0x76, 0x99,
  0xDA, 0x63, 0x69, 0x8D, 0x3E, 0x34, 0xF8, 0xD3, 0xC3, 0xCF, 0x0F, 0x1C,
  0x3C, 0x70, 0xF0, 0xF3, 0xC7, 0x0E, 0x70, 0x3B, 0x81, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x1F, 0xC1, 0xEE, 0x0E, 0x38, 0xE1, 0xEF, 0x07, 0x80,
  0xE0, 0x77, 0x07, 0x70, 0xF7, 0x8E, 0x38, 0xE3, 0x9C, 0x1D, 0xC1, 0xDC,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xFC, 0x1F,
  0x87, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE3, 0xF8, 0x7E,
  0x0F, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0x7E, 0x07, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x1F, 0x03, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x7F, 0x83, 0xF1, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x0F, 0xC1, 0xF0, 0x38, 0x00, 0x7C, 0x3F, 0xE3,
  0xE7, 0x3E, 0x7F, 0xE3, 0xE0,
};

const GFXglyph JetBrainsMono_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 18, 14, 5, -18 },
  { 10, 8, 8, 14, 3, -18 },
  { 18, 13, 18, 14, 1, -18 },
  { 48, 12, 24, 14, 1, -21 },
  { 84, 14, 18, 14, 0, -18 },
  { 116, 13, 18, 14, 1, -18 },
  { 146, 3, 8, 14, 6, -18 },
  { 149, 8, 23, 14, 4, -20 },
  { 172, 7, 23, 14, 3, -20 },
  { 193, 13, 13, 14, 1, -15 },
  { 215, 12, 12, 14, 1, -14 },
  { 233, 5, 8, 14, 4, -4 },
  { 238, 8, 2, 14, 3, -9 },
  { 240, 4, 4, 14, 5, -4 },
  { 242, 12, 23, 14, 1, -20 },
  { 277, 11, 18, 14, 2, -18 },
  { 302, 11, 18, 14, 2, -18 },
  { 327, 12, 18, 14, 1, -18 },
  { 354, 12, 18, 14, 1, -18 },
  { 381, 10, 18, 14, 2, -18 },
  { 404, 11, 18, 14, 2, -18 },
  { 429, 12, 18, 14, 1, -18 },
  { 456, 12, 18, 14, 1, -18 },
  { 483, 11, 18, 14, 2, -18 },
  { 508, 12, 18, 14, 1, -18 },
  { 535, 4, 13, 14, 5, -13 },
  { 542, 5, 17, 14, 4, -13 },
  { 553, 11, 13, 14, 2, -14 },
  { 571, 10, 8, 14, 2, -12 },
  { 581, 11, 13, 14, 2, -14 },
  { 599, 9, 18, 14, 3, -18 },
  { 620, 13, 22, 14, 1, -18 },
  { 656, 13, 18, 14, 1, -18 },
  { 686, 11, 18, 14, 2, -18 },
  { 711, 11, 18, 14, 2, -18 },
  { 736, 11, 18, 14, 2, -18 },
  { 761, 11, 18, 14, 2, -18 },
  { 786, 11, 18, 14, 2, -18 },
  { 811, 11, 18, 14, 2, -18 },
  { 836, 11, 18, 14, 2, -18 },
  { 861, 10, 18, 14, 2, -18 },
  { 884, 11, 18, 14, 1, -18 },
  { 909, 12, 18, 14, 2, -18 },
  { 936, 11, 18, 14, 2, -18 },
  { 961, 12, 18, 14, 1, -18 },
  { 988, 11, 18, 14, 2, -18 },
  { 1013, 11, 18, 14, 2, -18 },
  { 1038, 11, 18, 14, 2, -18 },
  { 1063, 11, 22, 14, 2, -18 },
  { 1094, 11, 18, 14, 2, -18 },
  { 1119, 12, 18, 14, 1, -18 },
  { 1146, 12, 18, 14, 1, -18 },
  { 1173, 11, 18, 14, 2, -18 },
  { 1198, 13, 18, 14, 1, -18 },
  { 1228, 14, 18, 14, 0, -18 },
  { 1260, 13, 18, 14, 1, -18 },
  { 1290, 13, 18, 14, 1, -18 },
  { 1320, 11, 18, 14, 2, -18 },
  { 1345, 7, 23, 14, 4, -20 },
  { 1366, 12, 23, 14, 1, -20 },
  { 1401, 7, 23, 14, 3, -20 },
  { 1422, 11, 10, 14, 2, -18 },
  { 1436, 12, 2, 14, 1, 1 },
  { 1439, 6, 4, 14, 4, -19 },
  { 1442, 12, 13, 14, 1, -13 },
  { 1462, 11, 18, 14, 2, -18 },
  { 1487, 11, 13, 14, 2, -13 },
  { 1505, 11, 18, 14, 2, -18 },
  { 1530, 11, 13, 14, 2, -13 },
  { 1548, 12, 18, 14, 1, -18 },
  { 1575, 11, 17, 14, 2, -13 },
  { 1599, 11, 18, 14, 2, -18 },
  { 1624, 11, 19, 14, 2, -19 },
  { 1651, 9, 23, 14, 2, -19 },
  { 1677, 12, 18, 14, 2, -18 },
  { 1704, 12, 18, 14, 1, -18 },
  { 1731, 12, 13, 14, 1, -13 },
  { 1751, 11, 13, 14, 2, -13 },
  { 1769, 11, 13, 14, 2, -13 },
  { 1787, 11, 17, 14, 2, -13 },
  { 1811, 11, 17, 14, 2, -13 },
  { 1835, 11, 13, 14, 2, -13 },
  { 1853, 11, 13, 14, 2, -13 },
  { 1871, 12, 17, 14, 1, -17 },
  { 1897, 11, 13, 14, 2, -13 },
  { 1915, 12, 13, 14, 1, -13 },
  { 1935, 14, 13, 14, 0, -13 },
  { 1958, 13, 13, 14, 1, -13 },
  { 1980, 12, 17, 14, 1, -13 },
  { 2006, 11, 13, 14, 2, -13 },
  { 2024, 11, 23, 14, 2, -20 },
  { 2056, 3, 23, 14, 6, -20 },
  { 2065, 11, 23, 14, 2, -20 },
  { 2097, 12, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_Bold24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_BOLD24PT7B_H_
