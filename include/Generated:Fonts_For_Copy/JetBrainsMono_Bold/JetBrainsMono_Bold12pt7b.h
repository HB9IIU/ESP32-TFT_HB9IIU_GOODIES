#ifndef _JETBRAINSMONO_BOLD12PT7B_H_
#define _JETBRAINSMONO_BOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0xC0, 0xBB, 0xBB, 0x34, 0x49, 0xF9, 0x22, 0xC5, 0x3F,
  0xA4, 0x48, 0x21, 0xCF, 0xAA, 0xE1, 0xC3, 0x8B, 0xE9, 0xE2, 0x08, 0x63,
  0x2A, 0x57, 0x41, 0x07, 0xCA, 0xA5, 0x8E, 0x73, 0x6C, 0x10, 0xE2, 0xB9,
  0xA6, 0xFC, 0xF0, 0x36, 0xCC, 0xCC, 0xCC, 0xC6, 0x30, 0xC6, 0x31, 0x11,
  0x11, 0x36, 0xC0, 0x10, 0xA7, 0xF8, 0xC2, 0xCC, 0x80, 0x21, 0x3F, 0xF2,
  0x10, 0x7B, 0x40, 0xFF, 0x7C, 0x08, 0xC6, 0x23, 0x10, 0x8C, 0x46, 0x30,
  0x76, 0xE3, 0x1A, 0xC6, 0x39, 0x78, 0x33, 0xCB, 0x0C, 0x30, 0xC3, 0x0C,
  0xFC, 0x76, 0xE2, 0x11, 0x99, 0x98, 0xF8, 0xFF, 0xCC, 0x43, 0x84, 0x3B,
  0x70, 0x19, 0x88, 0xCC, 0xC7, 0xE1, 0x08, 0xFF, 0xF1, 0xED, 0x84, 0x39,
  0x78, 0x30, 0x86, 0x10, 0xFA, 0x28, 0xF2, 0x78, 0xFF, 0xF8, 0x86, 0x10,
  0xC3, 0x08, 0x60, 0x76, 0xE3, 0xB7, 0x6E, 0x39, 0x78, 0x73, 0x68, 0xE3,
  0xF9, 0xE1, 0x0C, 0x60, 0x5C, 0x00, 0xF8, 0x5C, 0x00, 0xF6, 0x80, 0x09,
  0xF1, 0x87, 0x04, 0xF8, 0x01, 0xF0, 0x83, 0x86, 0x37, 0x60, 0xF7, 0xC2,
  0x37, 0x30, 0x08, 0x60, 0x38, 0xC9, 0x0E, 0xDD, 0x7A, 0x74, 0xEF, 0xC0,
  0x80, 0xE0, 0x18, 0x70, 0xA1, 0x42, 0xCD, 0x9F, 0x22, 0xC6, 0xF2, 0x68,
  0xA2, 0xF2, 0x28, 0xE2, 0xF8, 0x76, 0xE3, 0x08, 0x42, 0x19, 0x78, 0xF7,
  0xE3, 0x18, 0xC6, 0x33, 0xF0, 0xFF, 0xF1, 0x8F, 0xE3, 0x18, 0xF8, 0xFF,
  0xE1, 0x0F, 0xC2, 0x10, 0x80, 0x76, 0xE3, 0x0B, 0xDE, 0x39, 0x78, 0x8C,
  0x63, 0x1F, 0xC6, 0x31, 0x88, 0xFF, 0xC8, 0x42, 0x10, 0x84, 0xF8, 0x1C,
  0x70, 0x41, 0x04, 0x1C, 0x53, 0x78, 0x8E, 0x29, 0xA4, 0xF2, 0x49, 0xA6,
  0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8, 0xCF, 0x7D, 0xF7, 0xBE, 0x38,
  0xE3, 0x8C, 0xCE, 0x73, 0x5A, 0xDE, 0x73, 0x98, 0x76, 0xE3, 0x18, 0xC6,
  0x3B, 0x78, 0xF3, 0xE8, 0xE3, 0xFB, 0xC8, 0x20, 0x80, 0x73, 0x68, 0xA2,
  0x8A, 0x28, 0xB2, 0x78, 0x60, 0xC0, 0xF3, 0xE8, 0xE2, 0xFB, 0xC9, 0xA6,
  0x8C, 0x73, 0x68, 0xB0, 0x70, 0x60, 0xF2, 0x78, 0xFF, 0xF2, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0x78, 0xC6, 0x89, 0x93,
  0x26, 0xC5, 0x0A, 0x1C, 0x38, 0xD3, 0xA7, 0x4B, 0x76, 0xED, 0x9B, 0x36,
  0x6C, 0xC6, 0xD8, 0xA1, 0xC1, 0x07, 0x0B, 0x36, 0xC6, 0xC6, 0x89, 0xB1,
  0x43, 0x83, 0x04, 0x08, 0x10, 0xFF, 0xC6, 0x62, 0x31, 0x18, 0xF8, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x86, 0x10, 0xC6, 0x10, 0xC6, 0x10, 0xC2,
  0xED, 0xB6, 0xDB, 0x6F, 0x80, 0x23, 0x95, 0xB8, 0x80, 0xFF, 0xC0, 0xE0,
  0x77, 0xC3, 0xF8, 0xC7, 0xE0, 0x84, 0x2D, 0xF8, 0xC6, 0x39, 0xB8, 0x77,
  0xE3, 0x08, 0x65, 0xE0, 0x08, 0x5B, 0xF8, 0xC6, 0x3B, 0x68, 0x76, 0xE3,
  0xF8, 0x65, 0xE0, 0x39, 0xD9, 0xF6, 0x31, 0x8C, 0x60, 0x6F, 0xE3, 0x18,
  0xFD, 0xA1, 0x78, 0x84, 0x2D, 0xF8, 0xC6, 0x31, 0x88, 0x30, 0x0F, 0x3C,
  0x30, 0xC3, 0x0C, 0xFC, 0x18, 0x3F, 0xF1, 0x8C, 0x63, 0x18, 0xBC, 0x82,
  0x08, 0xE6, 0x93, 0xC9, 0x26, 0x8C, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x08, 0x1E, 0xFA, 0xBA, 0xEB, 0xAE, 0xBA, 0xC0, 0xB7, 0xE3, 0x18, 0xC6,
  0x20, 0x77, 0xE3, 0x18, 0xED, 0xC0, 0xB7, 0xE3, 0x18, 0xE6, 0xF0, 0x80,
  0x6F, 0xE3, 0x18, 0xED, 0xA1, 0x08, 0xF3, 0xEC, 0xF0, 0xC3, 0x0C, 0x00,
  0x77, 0xE1, 0xF0, 0xC7, 0xE0, 0x67, 0xFE, 0xC6, 0x31, 0x87, 0x8C, 0x63,
  0x18, 0xED, 0xC0, 0xC6, 0x89, 0x93, 0x62, 0x87, 0x0E, 0x00, 0x93, 0xA5,
  0x7B, 0x66, 0xCD, 0x9B, 0x00, 0x46, 0xD8, 0xE0, 0xC3, 0x8D, 0xB1, 0x80,
  0xC6, 0x89, 0xB1, 0x63, 0x87, 0x06, 0x08, 0x30, 0xFF, 0xC4, 0x66, 0x63,
  0xE0, 0x19, 0x8C, 0x63, 0x70, 0xC6, 0x31, 0x86, 0xFF, 0xE0, 0xC3, 0x18,
  0xC6, 0x1D, 0x8C, 0x63, 0x38, 0x43, 0xBB, 0x80,
};

const GFXglyph JetBrainsMono_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 4, 4, 7, 2, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 12, 7, 1, -10 },
  { 23, 7, 9, 7, 0, -9 },
  { 31, 6, 9, 7, 1, -9 },
  { 38, 1, 4, 7, 3, -9 },
  { 39, 4, 11, 7, 2, -10 },
  { 45, 4, 11, 7, 1, -10 },
  { 51, 7, 6, 7, 0, -7 },
  { 57, 5, 6, 7, 1, -7 },
  { 61, 3, 4, 7, 2, -2 },
  { 63, 4, 2, 7, 2, -5 },
  { 64, 3, 2, 7, 2, -2 },
  { 65, 5, 11, 7, 1, -10 },
  { 72, 5, 9, 7, 1, -9 },
  { 78, 6, 9, 7, 1, -9 },
  { 85, 5, 9, 7, 1, -9 },
  { 91, 5, 9, 7, 1, -9 },
  { 97, 5, 9, 7, 1, -9 },
  { 103, 5, 9, 7, 1, -9 },
  { 109, 6, 9, 7, 1, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 6, 9, 7, 1, -9 },
  { 136, 3, 7, 7, 2, -7 },
  { 139, 3, 9, 7, 2, -7 },
  { 143, 5, 6, 7, 1, -7 },
  { 147, 5, 4, 7, 1, -6 },
  { 150, 5, 6, 7, 1, -7 },
  { 154, 5, 9, 7, 1, -9 },
  { 160, 7, 11, 7, 0, -9 },
  { 170, 7, 9, 7, 0, -9 },
  { 178, 6, 9, 7, 1, -9 },
  { 185, 5, 9, 7, 1, -9 },
  { 191, 5, 9, 7, 1, -9 },
  { 197, 5, 9, 7, 1, -9 },
  { 203, 5, 9, 7, 1, -9 },
  { 209, 5, 9, 7, 1, -9 },
  { 215, 5, 9, 7, 1, -9 },
  { 221, 5, 9, 7, 1, -9 },
  { 227, 6, 9, 7, 0, -9 },
  { 234, 6, 9, 7, 1, -9 },
  { 241, 5, 9, 7, 1, -9 },
  { 247, 6, 9, 7, 1, -9 },
  { 254, 5, 9, 7, 1, -9 },
  { 260, 5, 9, 7, 1, -9 },
  { 266, 6, 9, 7, 1, -9 },
  { 273, 6, 11, 7, 1, -9 },
  { 282, 6, 9, 7, 1, -9 },
  { 289, 6, 9, 7, 1, -9 },
  { 296, 6, 9, 7, 1, -9 },
  { 303, 5, 9, 7, 1, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 7, 9, 7, 0, -9 },
  { 333, 7, 9, 7, 0, -9 },
  { 341, 5, 9, 7, 1, -9 },
  { 347, 4, 11, 7, 2, -10 },
  { 353, 5, 11, 7, 1, -10 },
  { 360, 3, 11, 7, 2, -10 },
  { 365, 5, 5, 7, 1, -9 },
  { 369, 5, 2, 7, 1, 0 },
  { 371, 3, 1, 7, 2, -9 },
  { 372, 5, 7, 7, 1, -7 },
  { 377, 5, 9, 7, 1, -9 },
  { 383, 5, 7, 7, 1, -7 },
  { 388, 5, 9, 7, 1, -9 },
  { 394, 5, 7, 7, 1, -7 },
  { 399, 5, 9, 7, 1, -9 },
  { 405, 5, 9, 7, 1, -7 },
  { 411, 5, 9, 7, 1, -9 },
  { 417, 6, 9, 7, 1, -9 },
  { 424, 5, 11, 7, 1, -9 },
  { 431, 6, 9, 7, 1, -9 },
  { 438, 7, 9, 7, 0, -9 },
  { 446, 6, 7, 7, 1, -7 },
  { 452, 5, 7, 7, 1, -7 },
  { 457, 5, 7, 7, 1, -7 },
  { 462, 5, 9, 7, 1, -7 },
  { 468, 5, 9, 7, 1, -7 },
  { 474, 6, 7, 7, 1, -7 },
  { 480, 5, 7, 7, 1, -7 },
  { 485, 5, 8, 7, 1, -8 },
  { 490, 5, 7, 7, 1, -7 },
  { 495, 7, 7, 7, 0, -7 },
  { 502, 7, 7, 7, 0, -7 },
  { 509, 7, 7, 7, 0, -7 },
  { 516, 7, 9, 7, 0, -7 },
  { 524, 5, 7, 7, 1, -7 },
  { 529, 5, 11, 7, 1, -10 },
  { 536, 1, 11, 7, 3, -10 },
  { 538, 5, 11, 7, 1, -10 },
  { 545, 6, 3, 7, 1, -6 },
};

const GFXfont JetBrainsMono_Bold12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_BOLD12PT7B_H_
