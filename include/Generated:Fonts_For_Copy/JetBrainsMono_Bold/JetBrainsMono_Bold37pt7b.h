#ifndef _JETBRAINSMONO_BOLD37PT7B_H_
#define _JETBRAINSMONO_BOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0xC0, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0xBC, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x07, 0x83, 0x87, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x07, 0x80, 0x70, 0x70, 0x0F, 0x07,
  0x00, 0xF0, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1C, 0x1E, 0x01, 0xC1, 0xE0, 0x1C,
  0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x33, 0xE7, 0xCC,
  0x7D, 0xE3, 0x1F, 0x78, 0xC0, 0x1F, 0x30, 0x07, 0xCC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x37, 0xF0, 0x0C, 0x7C, 0x03, 0x1F, 0x00, 0xC7, 0xFE, 0x31, 0xFF, 0x8C,
  0x7D, 0xF3, 0x3F, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0x80, 0x1C, 0xFF, 0x00, 0xE7, 0xFE, 0x07, 0x9C, 0x38, 0x3C, 0xF0,
  0xE0, 0xE3, 0xC3, 0x87, 0x0F, 0x0E, 0x3C, 0x3C, 0x38, 0xE0, 0x70, 0xE7,
  0x01, 0xFF, 0xBC, 0x03, 0xFC, 0xE0, 0x07, 0xE7, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xF8, 0x01, 0xEF, 0xF8, 0x07,
  0x7F, 0xE0, 0x39, 0xE3, 0xC1, 0xE7, 0x0F, 0x0F, 0x1C, 0x3C, 0x38, 0x70,
  0xF1, 0xC1, 0xC3, 0xCF, 0x07, 0x8F, 0x38, 0x1F, 0xF9, 0xC0, 0x3F, 0xEF,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0xF0, 0xFF, 0x9F, 0x1E, 0xF1, 0xF7, 0xDE, 0x1F, 0xF3, 0xC1, 0xFE,
  0x78, 0x3F, 0x8F, 0x03, 0xE1, 0xE0, 0x7C, 0x3E, 0x0F, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xFE, 0x78, 0x7F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xF8, 0x3F,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0xC0, 0x0F, 0x00, 0xFC, 0x0F,
  0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x7E, 0x07, 0xC1, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x0F, 0x80, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x04, 0x0F, 0x02, 0x78, 0x71, 0xE7, 0xE6, 0x3E, 0xFF, 0x6F, 0xF7, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07,
  0x9E, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0E, 0x07, 0x00,
  0x40, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E,
  0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x31, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF,
  0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x79, 0xFF, 0x3C, 0xFF, 0x9F, 0x7F, 0xCF, 0x3F, 0xE3,
  0x9F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0xE0, 0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xCF, 0x83, 0xC7, 0xC1, 0xC3, 0xE0, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x1F, 0xBE, 0x03,
  0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xBE,
  0x03, 0xE7, 0xC0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE1, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x78, 0x3E, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x7D,
  0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE3, 0x00, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xE1, 0xFB, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7B, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0x9F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE1, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C,
  0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF7, 0xC0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xBE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0x7E, 0x1F, 0xDF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x03, 0x9F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x39, 0xFB, 0xF7, 0xFF, 0xDF, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xFD, 0xFB, 0xFF, 0xE7, 0xC0, 0x0E, 0x1F, 0x8F, 0xC7,
  0xF3, 0xF1, 0xF8, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x3C, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xE1,
  0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xF0, 0x7E, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xEF, 0xF0, 0x7F, 0x7F, 0x0F, 0xFF, 0xF0, 0xF0,
  0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xFF, 0xFF, 0x07, 0xF7, 0xF0, 0x3C, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xDE, 0x00, 0x79,
  0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x01,
  0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01, 0xF7,
  0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x0F,
  0xDF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xE0, 0x3E, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7C,
  0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x07, 0xF7, 0x80, 0xFB, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC1, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7C,
  0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x0F,
  0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F,
  0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xC3, 0xE0, 0xF0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C, 0x0F, 0xCF,
  0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0x7C, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xB8, 0x3F, 0xFE, 0x1D, 0xFF, 0x87, 0x7F, 0xF1, 0xFF, 0xDC, 0xFF, 0xF7,
  0x3B, 0xFD, 0xCE, 0xFF, 0x3B, 0xBF, 0xCF, 0xCF, 0xF3, 0xF3, 0xFC, 0xFC,
  0xFF, 0x1F, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0x70, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xF7,
  0x0F, 0xFB, 0xC7, 0xFD, 0xE3, 0xFE, 0x71, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F,
  0xC7, 0x3F, 0xE3, 0xDF, 0xF1, 0xEF, 0xF8, 0x77, 0xFC, 0x3D, 0xFE, 0x1E,
  0xFF, 0x07, 0x7F, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xF7, 0xC0, 0xFB, 0xF0, 0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0,
  0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF,
  0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7B, 0xE0, 0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xF0, 0x3F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x07,
  0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC1,
  0xF0, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x1F,
  0x3C, 0x03, 0xEF, 0x00, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7C, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xFD, 0xFF, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xFB, 0xF0, 0x7C,
  0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x01, 0xF7,
  0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E,
  0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF8,
  0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x07,
  0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xBC, 0x3C,
  0x3D, 0xE1, 0xE1, 0xEF, 0x0F, 0x8F, 0x78, 0x7C, 0x7B, 0xC7, 0xE3, 0xDE,
  0x3B, 0x1E, 0xF1, 0xD8, 0xF3, 0x8E, 0xC7, 0x9E, 0x66, 0x38, 0xF3, 0x31,
  0xC7, 0x99, 0x8E, 0x3C, 0xCE, 0x71, 0xE6, 0x77, 0x8F, 0x73, 0xBC, 0x7B,
  0x9D, 0xE3, 0xDC, 0x6F, 0x1E, 0xE3, 0x78, 0x76, 0x1B, 0xC3, 0xB0, 0xDC,
  0x1D, 0x86, 0xE0, 0xEC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0x79, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0xF9,
  0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x1E, 0x07,
  0x8F, 0x03, 0xCF, 0x80, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xE0,
  0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xDF, 0xFF, 0xE7, 0xFE, 0xF1, 0xFE, 0x78, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xC1, 0xE7, 0xF8,
  0xF7, 0xFE, 0x7B, 0xFF, 0xBF, 0x8F, 0xDF, 0x03, 0xEF, 0x80, 0xF7, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xF0, 0x7D, 0xFF, 0xFE, 0xF7, 0xFE,
  0x7B, 0xFF, 0x3C, 0x7E, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xE3, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x07, 0x0F, 0x3F, 0xCF, 0x7F, 0xEF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x03, 0xC0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x3F, 0x1F, 0x9F, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3F, 0xCF, 0x7F, 0xEF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x0F, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE, 0xFE, 0x7F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xE0,
  0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFC, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0x07, 0x3D, 0xF7, 0xEF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF,
  0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xC0, 0x00, 0xF0, 0xF3, 0xFC, 0xF7,
  0xFE, 0xF7, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xE7, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1E, 0xFC,
  0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xF0,
  0x79, 0xFE, 0x3D, 0xFF, 0x9E, 0xFF, 0xEF, 0xE3, 0xF7, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0xFC, 0x1F, 0x7F, 0xFF,
  0xBD, 0xFF, 0x9E, 0xFF, 0xCF, 0x1F, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x3F, 0xCF, 0x7F, 0xEF, 0x7F, 0xEF, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0xEF,
  0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x3E, 0x7F, 0x8F, 0xBF,
  0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0xC7, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC,
  0x1F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C,
  0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F,
  0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xDE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xF0,
  0xF0, 0x7F, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF8, 0xF7,
  0x1F, 0x8F, 0x79, 0xD8, 0xE7, 0x99, 0x8E, 0x79, 0x99, 0xE7, 0x99, 0x9E,
  0x79, 0x9D, 0xE3, 0xB9, 0xDE, 0x3B, 0x9D, 0xC3, 0xB8, 0xDC, 0x3F, 0x0D,
  0xC3, 0xF0, 0xDC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0,
  0xF8, 0x7E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x0F,
  0x9F, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF0,
  0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x03,
  0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xF0, 0x07, 0xDE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xDF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xEF, 0x8F, 0xF1, 0xF7, 0xFC, 0x3F, 0xFF, 0x07, 0xFB, 0xC0, 0xFC,
};

const GFXglyph JetBrainsMono_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 13, 11, 22, 5, -27 },
  { 40, 20, 27, 22, 1, -27 },
  { 108, 18, 37, 22, 2, -32 },
  { 192, 22, 27, 22, 0, -27 },
  { 267, 19, 27, 22, 2, -27 },
  { 332, 4, 11, 22, 9, -27 },
  { 338, 12, 35, 22, 6, -31 },
  { 391, 12, 35, 22, 4, -31 },
  { 444, 20, 20, 22, 1, -23 },
  { 494, 18, 18, 22, 2, -21 },
  { 535, 8, 12, 22, 6, -6 },
  { 547, 12, 4, 22, 5, -14 },
  { 553, 7, 7, 22, 8, -7 },
  { 560, 18, 35, 22, 2, -31 },
  { 639, 17, 27, 22, 3, -27 },
  { 697, 17, 27, 22, 3, -27 },
  { 755, 18, 27, 22, 2, -27 },
  { 816, 18, 27, 22, 2, -27 },
  { 877, 17, 27, 22, 2, -27 },
  { 935, 17, 27, 22, 3, -27 },
  { 993, 18, 27, 22, 2, -27 },
  { 1054, 18, 27, 22, 2, -27 },
  { 1115, 18, 27, 22, 2, -27 },
  { 1176, 18, 27, 22, 2, -27 },
  { 1237, 7, 21, 22, 8, -21 },
  { 1256, 9, 27, 22, 6, -21 },
  { 1287, 16, 20, 22, 3, -22 },
  { 1327, 16, 13, 22, 3, -19 },
  { 1353, 16, 20, 22, 3, -22 },
  { 1393, 15, 27, 22, 4, -27 },
  { 1444, 20, 34, 22, 1, -27 },
  { 1529, 20, 27, 22, 1, -27 },
  { 1597, 17, 27, 22, 3, -27 },
  { 1655, 17, 27, 22, 3, -27 },
  { 1713, 17, 27, 22, 3, -27 },
  { 1771, 16, 27, 22, 3, -27 },
  { 1825, 17, 27, 22, 3, -27 },
  { 1883, 17, 27, 22, 3, -27 },
  { 1941, 16, 27, 22, 3, -27 },
  { 1995, 16, 27, 22, 3, -27 },
  { 2049, 18, 27, 22, 1, -27 },
  { 2110, 18, 27, 22, 3, -27 },
  { 2171, 16, 27, 22, 4, -27 },
  { 2225, 18, 27, 22, 2, -27 },
  { 2286, 17, 27, 22, 3, -27 },
  { 2344, 17, 27, 22, 3, -27 },
  { 2402, 18, 27, 22, 3, -27 },
  { 2463, 17, 34, 22, 3, -27 },
  { 2536, 18, 27, 22, 3, -27 },
  { 2597, 18, 27, 22, 2, -27 },
  { 2658, 19, 27, 22, 2, -27 },
  { 2723, 17, 27, 22, 3, -27 },
  { 2781, 20, 27, 22, 1, -27 },
  { 2849, 21, 27, 22, 1, -27 },
  { 2920, 20, 27, 22, 1, -27 },
  { 2988, 20, 27, 22, 1, -27 },
  { 3056, 16, 27, 22, 3, -27 },
  { 3110, 10, 35, 22, 7, -31 },
  { 3154, 18, 35, 22, 2, -31 },
  { 3233, 10, 35, 22, 5, -31 },
  { 3277, 17, 14, 22, 3, -27 },
  { 3307, 18, 4, 22, 2, 1 },
  { 3316, 9, 5, 22, 6, -29 },
  { 3322, 17, 21, 22, 2, -21 },
  { 3367, 17, 27, 22, 3, -27 },
  { 3425, 17, 21, 22, 3, -21 },
  { 3470, 16, 27, 22, 3, -27 },
  { 3524, 17, 21, 22, 3, -21 },
  { 3569, 18, 27, 22, 2, -27 },
  { 3630, 16, 28, 22, 3, -21 },
  { 3686, 16, 27, 22, 3, -27 },
  { 3740, 18, 29, 22, 3, -29 },
  { 3806, 15, 36, 22, 3, -29 },
  { 3874, 18, 27, 22, 3, -27 },
  { 3935, 20, 27, 22, 1, -27 },
  { 4003, 18, 21, 22, 2, -21 },
  { 4051, 16, 21, 22, 3, -21 },
  { 4093, 17, 21, 22, 3, -21 },
  { 4138, 17, 28, 22, 3, -21 },
  { 4198, 16, 28, 22, 3, -21 },
  { 4254, 18, 21, 22, 3, -21 },
  { 4302, 18, 21, 22, 2, -21 },
  { 4350, 18, 26, 22, 2, -26 },
  { 4409, 16, 20, 22, 3, -20 },
  { 4449, 20, 20, 22, 1, -20 },
  { 4499, 20, 20, 22, 1, -20 },
  { 4549, 20, 20, 22, 1, -20 },
  { 4599, 20, 27, 22, 1, -20 },
  { 4667, 16, 20, 22, 3, -20 },
  { 4707, 16, 35, 22, 3, -31 },
  { 4777, 4, 35, 22, 9, -31 },
  { 4795, 16, 35, 22, 3, -31 },
  { 4865, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_Bold37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_BOLD37PT7B_H_
