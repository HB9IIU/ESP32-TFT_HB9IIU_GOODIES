#ifndef _JETBRAINSMONO_BOLD15PT7B_H_
#define _JETBRAINSMONO_BOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x24, 0x92, 0x1F, 0x80, 0xDE, 0xF7, 0xBD, 0x80, 0x13, 0x09,
  0x84, 0x8F, 0xF3, 0x21, 0x10, 0x99, 0xFE, 0x24, 0x32, 0x19, 0x00, 0x10,
  0x21, 0xF7, 0xFD, 0x7A, 0x3C, 0x3E, 0x1E, 0x2F, 0x5F, 0xF7, 0xC2, 0x04,
  0x00, 0x71, 0xE8, 0xB6, 0x9A, 0xC7, 0x40, 0x40, 0x5C, 0x6B, 0x2D, 0xA6,
  0xF1, 0xC0, 0x78, 0x6C, 0xC4, 0x40, 0x60, 0xF1, 0x96, 0x9E, 0x8C, 0xDE,
  0xFF, 0xF8, 0x08, 0xCE, 0xC6, 0x23, 0x18, 0xC2, 0x18, 0xC3, 0x0C, 0x20,
  0x86, 0x38, 0x63, 0x08, 0x63, 0x18, 0x8C, 0x66, 0x62, 0x00, 0x08, 0x04,
  0x1A, 0xDF, 0xF1, 0xC1, 0xB1, 0xDC, 0x44, 0x10, 0x20, 0x47, 0xFF, 0xE2,
  0x04, 0x08, 0x76, 0x6C, 0xFF, 0xC0, 0x5F, 0x80, 0x06, 0x18, 0x30, 0x61,
  0x83, 0x06, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x00, 0x7D, 0xFF, 0x1E,
  0x3D, 0x7A, 0xF5, 0xE3, 0xC7, 0xDD, 0xF0, 0x38, 0xF3, 0x64, 0xC1, 0x83,
  0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x7D, 0xFF, 0x18, 0x30, 0x61, 0x86, 0x18,
  0x61, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0xC7, 0xC1, 0x83, 0xC7, 0xDD,
  0xF0, 0x0C, 0x30, 0xE1, 0x86, 0x1C, 0xF1, 0xFF, 0xFE, 0x0C, 0x18, 0xFF,
  0xFF, 0x06, 0x0F, 0xDD, 0xC1, 0x83, 0xC7, 0xDD, 0xF0, 0x18, 0x70, 0xC3,
  0x07, 0x9F, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xFF, 0xFF, 0x18, 0x20, 0xC1,
  0x86, 0x0C, 0x30, 0x61, 0xC0, 0x7D, 0xDF, 0x1E, 0x36, 0xC7, 0x3B, 0xE3,
  0xC7, 0xDD, 0xF0, 0x7D, 0xDF, 0x1E, 0x3C, 0x7F, 0xDF, 0x06, 0x18, 0x70,
  0xC0, 0xFC, 0x00, 0x3F, 0x77, 0x00, 0x00, 0x76, 0x6C, 0x02, 0x1D, 0xE7,
  0x0E, 0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC0,
  0xF0, 0x70, 0xE7, 0xBC, 0x60, 0xF3, 0xE0, 0x83, 0x19, 0xE6, 0x18, 0x01,
  0x8E, 0x00, 0x3E, 0x31, 0x90, 0x48, 0x3C, 0xFE, 0xCF, 0x67, 0xB3, 0xD9,
  0xA7, 0xD0, 0x0C, 0x03, 0xC0, 0xE0, 0x38, 0x70, 0xA3, 0x66, 0xCD, 0x91,
  0x7F, 0xC7, 0x8F, 0x18, 0xFD, 0xFF, 0x1E, 0x3C, 0xDF, 0xB1, 0xE3, 0xC7,
  0xFF, 0xF0, 0x7D, 0xFF, 0x1E, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0xFD, 0xF0,
  0xF9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFB, 0xE0, 0xFF, 0xFF,
  0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0C,
  0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x00, 0x7D, 0xFF, 0x1E, 0x0C, 0x1B, 0xF7,
  0xE3, 0xC7, 0xDD, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFF, 0xF8,
  0x1F, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0x7E, 0x3C, 0xC6,
  0xC6, 0xCC, 0xCC, 0xF8, 0xF8, 0xDC, 0xCC, 0xCC, 0xC6, 0xC7, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xC0, 0xC7, 0xCE, 0xAD, 0x5A, 0xBF,
  0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xE7, 0xCF, 0x9F, 0xBF, 0x7A, 0xF7, 0xEF,
  0xCF, 0x9F, 0x38, 0x7D, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD,
  0xF0, 0xFD, 0xFF, 0x1E, 0x1C, 0x7F, 0xFE, 0x60, 0xC1, 0x83, 0x00, 0x7D,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0x60, 0xC0, 0xC0,
  0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xBE, 0x66, 0xCD, 0x8F, 0x18, 0x7D, 0xFF,
  0x1E, 0x0F, 0x0F, 0x83, 0x83, 0xC7, 0xFD, 0xF0, 0xFF, 0xFC, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0xDD, 0xF0, 0xC7, 0x8F, 0x1E, 0x36, 0x4D, 0x9B, 0x36, 0x28,
  0x70, 0xE0, 0xC9, 0xE4, 0xF5, 0x4A, 0xA5, 0x52, 0xA9, 0x54, 0xAA, 0x77,
  0x3B, 0x9D, 0xC0, 0x63, 0x31, 0x8D, 0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x6C,
  0x36, 0x31, 0xB8, 0xE0, 0xE1, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70,
  0x10, 0x08, 0x04, 0x02, 0x00, 0xFF, 0xFC, 0x30, 0x61, 0x86, 0x0C, 0x30,
  0x61, 0xFF, 0xF8, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0xC1,
  0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x38, 0x70, 0xA3, 0x64, 0x58, 0xC0,
  0xFF, 0xFC, 0xE3, 0x7D, 0x8C, 0x1B, 0xFC, 0x78, 0xF3, 0xBF, 0xC1, 0x83,
  0x07, 0xEE, 0x78, 0xF1, 0xE3, 0xC7, 0xDF, 0x70, 0x7D, 0xCF, 0x1E, 0x0C,
  0x18, 0xFB, 0xBE, 0x06, 0x0C, 0x1B, 0xFC, 0xF8, 0xF1, 0xE3, 0xC7, 0xDD,
  0xD8, 0x7D, 0x8F, 0x1F, 0xFC, 0x18, 0x3B, 0xBE, 0x1E, 0x7C, 0xC1, 0x8F,
  0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x7F, 0x9F, 0x1E, 0x3C, 0x78, 0xDF,
  0x93, 0x06, 0xF9, 0xE0, 0xC1, 0x83, 0x07, 0xEE, 0xF8, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0x18, 0x30, 0x00, 0x07, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF,
  0xF0, 0x0C, 0x30, 0x00, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xEF,
  0x00, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xCC, 0xF8, 0xF8, 0xCC, 0xC6, 0xC7,
  0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0xFF,
  0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFD, 0xDF, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0x7D, 0xDF, 0x1E, 0x3C, 0x78, 0xFF, 0xBE, 0xFD, 0xCF, 0x1E, 0x3C,
  0x78, 0xFB, 0xEE, 0xC1, 0x83, 0x00, 0x7F, 0x9F, 0x1E, 0x3C, 0x78, 0xFB,
  0xBB, 0x06, 0x0C, 0x18, 0xDF, 0xCF, 0x1E, 0x0C, 0x18, 0x30, 0x60, 0x7D,
  0x8F, 0x03, 0xE1, 0xE0, 0xF1, 0xBE, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C,
  0x18, 0x30, 0x7C, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBE, 0xC7,
  0x8F, 0x1B, 0x66, 0xCD, 0x8E, 0x1C, 0xC9, 0xAA, 0x95, 0x4A, 0xA7, 0x53,
  0xB9, 0xDC, 0xEC, 0xC6, 0xD8, 0xA1, 0xC3, 0x8D, 0x9B, 0x63, 0xC7, 0x8D,
  0x93, 0x66, 0xC7, 0x0E, 0x0C, 0x30, 0x61, 0xC0, 0xFE, 0x1C, 0x30, 0xC3,
  0x0C, 0x3F, 0xFF, 0x0E, 0x30, 0x60, 0xC1, 0x83, 0x3C, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0xE0, 0xC0, 0xFF, 0xFC, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x07,
  0x9C, 0x30, 0x60, 0xC1, 0x8F, 0x18, 0x00, 0xE3, 0xE6, 0x78,
};

const GFXglyph JetBrainsMono_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 15, 9, 1, -13 },
  { 37, 9, 11, 9, 0, -11 },
  { 50, 8, 11, 9, 1, -11 },
  { 61, 1, 5, 9, 4, -11 },
  { 62, 5, 15, 9, 2, -13 },
  { 72, 5, 15, 9, 2, -13 },
  { 82, 9, 8, 9, 0, -9 },
  { 91, 7, 8, 9, 1, -9 },
  { 98, 4, 4, 9, 2, -2 },
  { 100, 5, 2, 9, 2, -6 },
  { 102, 3, 3, 9, 3, -3 },
  { 104, 7, 14, 9, 1, -12 },
  { 117, 7, 11, 9, 1, -11 },
  { 127, 7, 11, 9, 1, -11 },
  { 137, 7, 11, 9, 1, -11 },
  { 147, 7, 11, 9, 1, -11 },
  { 157, 7, 11, 9, 1, -11 },
  { 167, 7, 11, 9, 1, -11 },
  { 177, 7, 11, 9, 1, -11 },
  { 187, 7, 11, 9, 1, -11 },
  { 197, 7, 11, 9, 1, -11 },
  { 207, 7, 11, 9, 1, -11 },
  { 217, 3, 8, 9, 3, -8 },
  { 220, 4, 10, 9, 2, -8 },
  { 225, 7, 8, 9, 1, -9 },
  { 232, 7, 6, 9, 1, -8 },
  { 238, 7, 8, 9, 1, -9 },
  { 245, 6, 11, 9, 2, -11 },
  { 254, 9, 14, 9, 0, -11 },
  { 270, 7, 11, 9, 1, -11 },
  { 280, 7, 11, 9, 1, -11 },
  { 290, 7, 11, 9, 1, -11 },
  { 300, 7, 11, 9, 1, -11 },
  { 310, 7, 11, 9, 1, -11 },
  { 320, 7, 11, 9, 1, -11 },
  { 330, 7, 11, 9, 1, -11 },
  { 340, 7, 11, 9, 1, -11 },
  { 350, 7, 11, 9, 1, -11 },
  { 360, 8, 11, 9, 0, -11 },
  { 371, 8, 11, 9, 1, -11 },
  { 382, 6, 11, 9, 2, -11 },
  { 391, 7, 11, 9, 1, -11 },
  { 401, 7, 11, 9, 1, -11 },
  { 411, 7, 11, 9, 1, -11 },
  { 421, 7, 11, 9, 1, -11 },
  { 431, 7, 14, 9, 1, -11 },
  { 444, 7, 11, 9, 1, -11 },
  { 454, 7, 11, 9, 1, -11 },
  { 464, 7, 11, 9, 1, -11 },
  { 474, 7, 11, 9, 1, -11 },
  { 484, 7, 11, 9, 1, -11 },
  { 494, 9, 11, 9, 0, -11 },
  { 507, 9, 11, 9, 0, -11 },
  { 520, 9, 11, 9, 0, -11 },
  { 533, 7, 11, 9, 1, -11 },
  { 543, 4, 14, 9, 3, -12 },
  { 550, 7, 14, 9, 1, -12 },
  { 563, 4, 14, 9, 2, -12 },
  { 570, 7, 6, 9, 1, -11 },
  { 576, 7, 2, 9, 1, 0 },
  { 578, 4, 2, 9, 2, -12 },
  { 579, 7, 8, 9, 1, -8 },
  { 586, 7, 11, 9, 1, -11 },
  { 596, 7, 8, 9, 1, -8 },
  { 603, 7, 11, 9, 1, -11 },
  { 613, 7, 8, 9, 1, -8 },
  { 620, 7, 11, 9, 1, -11 },
  { 630, 7, 11, 9, 1, -8 },
  { 640, 7, 11, 9, 1, -11 },
  { 650, 7, 12, 9, 1, -12 },
  { 661, 6, 15, 9, 1, -12 },
  { 673, 8, 11, 9, 1, -11 },
  { 684, 8, 11, 9, 0, -11 },
  { 695, 7, 8, 9, 1, -8 },
  { 702, 7, 8, 9, 1, -8 },
  { 709, 7, 8, 9, 1, -8 },
  { 716, 7, 11, 9, 1, -8 },
  { 726, 7, 11, 9, 1, -8 },
  { 736, 7, 8, 9, 1, -8 },
  { 743, 7, 8, 9, 1, -8 },
  { 750, 7, 11, 9, 1, -11 },
  { 760, 7, 8, 9, 1, -8 },
  { 767, 7, 8, 9, 1, -8 },
  { 774, 9, 8, 9, 0, -8 },
  { 783, 7, 8, 9, 1, -8 },
  { 790, 7, 11, 9, 1, -8 },
  { 800, 7, 8, 9, 1, -8 },
  { 807, 7, 14, 9, 1, -12 },
  { 820, 1, 14, 9, 4, -12 },
  { 822, 7, 14, 9, 1, -12 },
  { 835, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_Bold15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_BOLD15PT7B_H_
