#ifndef _JETBRAINSMONO_BOLD19PT7B_H_
#define _JETBRAINSMONO_BOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6C, 0x0F, 0xC0, 0xE7, 0xCF, 0x9F, 0x36, 0x6C,
  0xC0, 0x0C, 0xC1, 0x18, 0x63, 0x0C, 0x47, 0xFE, 0x33, 0x04, 0x60, 0x8C,
  0x31, 0x1F, 0xFB, 0xFF, 0x19, 0x82, 0x30, 0xC6, 0x00, 0x08, 0x04, 0x02,
  0x07, 0xC7, 0xF3, 0x5F, 0xA7, 0xD0, 0x78, 0x3F, 0x07, 0xC1, 0x70, 0x9E,
  0x4F, 0xAE, 0xFF, 0x3F, 0x04, 0x02, 0x01, 0x00, 0x78, 0x7F, 0x8B, 0x33,
  0x66, 0xCC, 0xD0, 0xF6, 0x01, 0x80, 0x20, 0x0F, 0xC3, 0x6C, 0xC9, 0x91,
  0x36, 0x37, 0x83, 0x80, 0x3E, 0x1F, 0xC6, 0x31, 0x80, 0x60, 0x0C, 0x07,
  0x83, 0xE7, 0xCD, 0xB3, 0xEC, 0x73, 0x1C, 0xFF, 0x9F, 0x70, 0xFF, 0xF6,
  0xC0, 0x04, 0x73, 0xDC, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87,
  0x0E, 0x1C, 0x30, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x71, 0x9E, 0xF3, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x36, 0xFB, 0xDF,
  0xC1, 0xC0, 0xD8, 0x73, 0x18, 0xE0, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF,
  0xFC, 0x30, 0x18, 0x0C, 0x00, 0x77, 0x66, 0xEC, 0xFF, 0xF0, 0xFF, 0x80,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x00, 0x3E, 0x3F, 0x98,
  0xFC, 0x3E, 0x1F, 0x0F, 0xB7, 0xFB, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1,
  0xF0, 0x3C, 0x7C, 0xFC, 0xDC, 0x9C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0xFF, 0xFF, 0x3E, 0x3F, 0xB8, 0xFC, 0x30, 0x18, 0x1C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0xFF, 0xFC, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xF0, 0x7C, 0x07, 0x01, 0x80, 0xF8, 0x7C, 0x77, 0xF1, 0xF0, 0x07,
  0x03, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xCF, 0xC7, 0xE3, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x1C, 0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0x79, 0xFE, 0xC7,
  0x01, 0x80, 0xC0, 0x7C, 0x77, 0xF1, 0xF0, 0x0E, 0x06, 0x07, 0x07, 0x03,
  0x03, 0xA1, 0xFD, 0xE7, 0xE1, 0xE0, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7C, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0x3E, 0x3F, 0x98, 0xFC, 0x36, 0x3B, 0x98, 0xF8, 0x7E,
  0x63, 0xF0, 0xF8, 0x7C, 0x77, 0xF9, 0xF8, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C,
  0x1F, 0x0F, 0x8E, 0xFF, 0x1B, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0x7F,
  0xA0, 0x00, 0xFF, 0x80, 0x33, 0x9C, 0x40, 0x00, 0x00, 0x7B, 0x9C, 0xCE,
  0x60, 0x01, 0x83, 0xC7, 0x8F, 0x0E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x38, 0x3C, 0x7C, 0xF8, 0xE0, 0x40, 0x00, 0xF8, 0xFE, 0x0E, 0x07,
  0x07, 0x06, 0x3E, 0x3C, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70, 0x3F, 0x1F,
  0xEE, 0x1B, 0x03, 0xC0, 0xF3, 0xFD, 0xCF, 0x63, 0xD8, 0xF6, 0x3D, 0x8F,
  0x37, 0xCE, 0xF0, 0x0C, 0x01, 0xC0, 0x3E, 0x00, 0x1C, 0x07, 0x81, 0xE0,
  0xD8, 0x36, 0x0D, 0xC3, 0x31, 0xCC, 0x63, 0x1F, 0xE7, 0xFB, 0x86, 0xC1,
  0xB0, 0x70, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x1F, 0xF9, 0xFE, 0xE1,
  0xF0, 0xF8, 0x7C, 0x7F, 0xFF, 0xF0, 0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x6C, 0x77, 0xF1, 0xF0, 0xFE, 0x7F,
  0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F,
  0xF7, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x07,
  0x03, 0x81, 0xDF, 0xEF, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0C, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0xFF, 0xFF, 0x1F, 0x8F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xF0, 0xFC, 0x6F, 0xF3, 0xF0, 0xE1, 0xF8, 0xEE, 0x3B,
  0x8C, 0xE7, 0x39, 0x8F, 0xE3, 0xF8, 0xE6, 0x39, 0xCE, 0x33, 0x8E, 0xE3,
  0xB8, 0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE3, 0xF1, 0xFC, 0xBE, 0x7D, 0x7E, 0xFF, 0x77,
  0xBB, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xE1, 0xF8, 0xFC, 0x7A,
  0x3D, 0x9E, 0xCF, 0xA7, 0xDB, 0xED, 0xF2, 0xF9, 0xFC, 0xFE, 0x3F, 0x1C,
  0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x6C, 0x77, 0xF1, 0xF0, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x7B, 0xFC, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3E, 0x3F,
  0x98, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77,
  0xF1, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xFE, 0x3F, 0xCE, 0x3B, 0x86, 0xE1,
  0xB8, 0x6F, 0xFB, 0xFC, 0xE6, 0x39, 0x8E, 0x73, 0x8C, 0xE3, 0xB8, 0x70,
  0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x03, 0x81, 0xF8, 0x3E, 0x03, 0x80, 0xF0,
  0x7C, 0x77, 0xF9, 0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77,
  0xF1, 0xF0, 0xC1, 0xF0, 0x6E, 0x19, 0x86, 0x63, 0x98, 0xC7, 0x30, 0xCC,
  0x37, 0x0D, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xC6, 0x78, 0xCD, 0xB9,
  0xB7, 0x36, 0xA6, 0xD4, 0xDA, 0x93, 0x5E, 0x6B, 0xCD, 0x79, 0xA7, 0x3C,
  0xE3, 0x9C, 0x63, 0x80, 0xE1, 0xF8, 0xE7, 0x30, 0xDC, 0x3E, 0x07, 0x81,
  0xC0, 0x70, 0x1E, 0x0D, 0x87, 0x71, 0x8E, 0xE3, 0xB0, 0x70, 0xE0, 0xEE,
  0x18, 0xC7, 0x18, 0xC3, 0x98, 0x36, 0x07, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xBF, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0xFF, 0xF1,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE0, 0x30,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x1C, 0x0E, 0x07, 0x86, 0xC3,
  0x33, 0x19, 0x8F, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3, 0x8E, 0x1C, 0x1F,
  0x9C, 0xEC, 0x30, 0x1B, 0xFF, 0x87, 0x83, 0xE3, 0xFF, 0xDF, 0x60, 0xE0,
  0x70, 0x38, 0x1C, 0xCF, 0xF7, 0xBF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7F, 0xFF, 0x78, 0x1C, 0x1F, 0x9D, 0xFC, 0x3E, 0x07, 0x03, 0x81, 0xC3,
  0x63, 0xBF, 0xCF, 0x80, 0x01, 0x80, 0xC0, 0x63, 0x37, 0xDB, 0xBF, 0x8F,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x77, 0xD9, 0xEC, 0x1C, 0x1F, 0x9C, 0xFC,
  0x3E, 0x1F, 0xFF, 0x81, 0xC0, 0x61, 0xBF, 0x8F, 0x80, 0x0F, 0x8F, 0xC7,
  0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x18, 0x3E, 0xDD, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC7, 0x7F, 0xBE,
  0xC0, 0x60, 0x33, 0xF9, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0xCF, 0xF7, 0xBF,
  0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0x0C, 0x07, 0x80,
  0xC0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xFF, 0xFC, 0x0E, 0x1C, 0x30, 0x00, 0x1F, 0xFF, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFD, 0xF0, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x36, 0x3B, 0x39, 0x98, 0xFC, 0x7E, 0x33, 0x98, 0xCC, 0x76, 0x1C,
  0xF8, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x1F, 0xC3, 0xF0, 0x11, 0x7D, 0xF3, 0x79, 0xBC, 0xDE,
  0x6F, 0x37, 0x9B, 0xCD, 0xE6, 0xF3, 0x60, 0x06, 0x7F, 0xBD, 0xFC, 0x7E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x60, 0x1C, 0x1F, 0x9D, 0xFC,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0x06, 0x7F, 0xBD,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xFF, 0xFB, 0xDC, 0x0E, 0x07,
  0x00, 0x18, 0x3E, 0xDD, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0x63, 0xBE,
  0xCF, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x7F, 0xB9, 0xD8, 0x6C, 0x3E, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x1C, 0x3F, 0x98, 0xEC, 0x07, 0x03,
  0xF8, 0x3E, 0x03, 0xE1, 0xBF, 0xCF, 0xC0, 0x18, 0x0C, 0x06, 0x1F, 0xFF,
  0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x86, 0xC7, 0x7F, 0x1F, 0x00, 0xC1, 0xF8,
  0x66, 0x39, 0x8C, 0x73, 0x0D, 0xC3, 0x60, 0xF8, 0x1E, 0x07, 0x00, 0xC6,
  0x6D, 0xCD, 0xB9, 0xB5, 0x26, 0xAC, 0xD7, 0x9A, 0xF1, 0x4E, 0x39, 0xC6,
  0x30, 0xE3, 0x9C, 0xC3, 0x70, 0x78, 0x1C, 0x07, 0x83, 0xE1, 0xDC, 0x63,
  0xB8, 0x70, 0xE1, 0xF8, 0x66, 0x39, 0xCC, 0x37, 0x0D, 0xC3, 0xE0, 0x78,
  0x1C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x7F, 0xBF, 0xC1, 0xC1, 0xC1,
  0xC0, 0xC0, 0xC0, 0xE0, 0xFF, 0xFF, 0xC0, 0x03, 0x83, 0xC3, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0xFC, 0x7E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x7C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0x87, 0xC7, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0xF8, 0x78, 0x00, 0x71, 0xFC, 0xF3, 0x79,
  0xF0, 0x20,
};

const GFXglyph JetBrainsMono_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 7, 6, 11, 2, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 9, 20, 11, 1, -17 },
  { 56, 11, 14, 11, 0, -14 },
  { 76, 10, 14, 11, 1, -14 },
  { 94, 3, 6, 11, 4, -14 },
  { 97, 6, 18, 11, 3, -16 },
  { 111, 6, 18, 11, 2, -16 },
  { 125, 10, 10, 11, 1, -12 },
  { 138, 9, 9, 11, 1, -11 },
  { 149, 4, 6, 11, 3, -3 },
  { 152, 6, 2, 11, 3, -7 },
  { 154, 3, 3, 11, 4, -3 },
  { 156, 9, 18, 11, 1, -16 },
  { 177, 9, 14, 11, 1, -14 },
  { 193, 8, 14, 11, 2, -14 },
  { 207, 9, 14, 11, 1, -14 },
  { 223, 9, 14, 11, 1, -14 },
  { 239, 9, 14, 11, 1, -14 },
  { 255, 9, 14, 11, 1, -14 },
  { 271, 9, 14, 11, 1, -14 },
  { 287, 9, 14, 11, 1, -14 },
  { 303, 9, 14, 11, 1, -14 },
  { 319, 9, 14, 11, 1, -14 },
  { 335, 3, 11, 11, 4, -11 },
  { 340, 5, 14, 11, 3, -11 },
  { 349, 9, 10, 11, 1, -11 },
  { 361, 8, 7, 11, 2, -10 },
  { 368, 9, 10, 11, 1, -11 },
  { 380, 8, 14, 11, 2, -14 },
  { 394, 10, 17, 11, 1, -14 },
  { 416, 10, 14, 11, 1, -14 },
  { 434, 9, 14, 11, 1, -14 },
  { 450, 9, 14, 11, 1, -14 },
  { 466, 9, 14, 11, 1, -14 },
  { 482, 8, 14, 11, 2, -14 },
  { 496, 8, 14, 11, 2, -14 },
  { 510, 9, 14, 11, 1, -14 },
  { 526, 9, 14, 11, 1, -14 },
  { 542, 8, 14, 11, 2, -14 },
  { 556, 9, 14, 11, 1, -14 },
  { 572, 10, 14, 11, 1, -14 },
  { 590, 8, 14, 11, 2, -14 },
  { 604, 9, 14, 11, 1, -14 },
  { 620, 9, 14, 11, 1, -14 },
  { 636, 9, 14, 11, 1, -14 },
  { 652, 10, 14, 11, 1, -14 },
  { 670, 9, 17, 11, 1, -14 },
  { 690, 10, 14, 11, 1, -14 },
  { 708, 9, 14, 11, 1, -14 },
  { 724, 10, 14, 11, 1, -14 },
  { 742, 9, 14, 11, 1, -14 },
  { 758, 10, 14, 11, 1, -14 },
  { 776, 11, 14, 11, 0, -14 },
  { 796, 10, 14, 11, 1, -14 },
  { 814, 11, 14, 11, 0, -14 },
  { 834, 9, 14, 11, 1, -14 },
  { 850, 5, 18, 11, 4, -16 },
  { 862, 9, 18, 11, 1, -16 },
  { 883, 5, 18, 11, 3, -16 },
  { 895, 9, 8, 11, 1, -14 },
  { 904, 9, 3, 11, 1, 0 },
  { 908, 5, 3, 11, 3, -15 },
  { 910, 9, 11, 11, 1, -11 },
  { 923, 9, 14, 11, 1, -14 },
  { 939, 9, 11, 11, 1, -11 },
  { 952, 9, 14, 11, 1, -14 },
  { 968, 9, 11, 11, 1, -11 },
  { 981, 9, 14, 11, 1, -14 },
  { 997, 9, 14, 11, 1, -11 },
  { 1013, 9, 14, 11, 1, -14 },
  { 1029, 10, 15, 11, 1, -15 },
  { 1048, 7, 18, 11, 2, -15 },
  { 1064, 9, 14, 11, 2, -14 },
  { 1080, 10, 14, 11, 1, -14 },
  { 1098, 9, 11, 11, 1, -11 },
  { 1111, 9, 11, 11, 1, -11 },
  { 1124, 9, 11, 11, 1, -11 },
  { 1137, 9, 14, 11, 1, -11 },
  { 1153, 9, 14, 11, 1, -11 },
  { 1169, 9, 11, 11, 2, -11 },
  { 1182, 9, 11, 11, 1, -11 },
  { 1195, 9, 13, 11, 1, -13 },
  { 1210, 9, 10, 11, 1, -10 },
  { 1222, 10, 10, 11, 1, -10 },
  { 1235, 11, 10, 11, 0, -10 },
  { 1249, 10, 10, 11, 1, -10 },
  { 1262, 10, 13, 11, 1, -10 },
  { 1279, 9, 10, 11, 1, -10 },
  { 1291, 9, 18, 11, 1, -16 },
  { 1312, 3, 18, 11, 4, -16 },
  { 1319, 9, 18, 11, 1, -16 },
  { 1340, 9, 5, 11, 1, -9 },
};

const GFXfont JetBrainsMono_Bold19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_BOLD19PT7B_H_
