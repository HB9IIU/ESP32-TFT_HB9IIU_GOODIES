#ifndef _JETBRAINSMONO_BOLD27PT7B_H_
#define _JETBRAINSMONO_BOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x76, 0x66, 0x00, 0x0F, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xDC, 0x77, 0x1D, 0xC7, 0x0E, 0x18, 0x1C,
  0x70, 0x38, 0xE0, 0x61, 0xC0, 0xC3, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x1C, 0x70, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x03, 0x86, 0x1F, 0xFF, 0xBF,
  0xFF, 0x18, 0x60, 0x30, 0xC0, 0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x3F, 0x03, 0xFE, 0x3F, 0xFB, 0xDB, 0xDC, 0xCE,
  0xE6, 0x07, 0xB0, 0x3D, 0x80, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0xDE, 0x06, 0x78, 0x33, 0xF9, 0x9F, 0xEC, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3C, 0x03, 0x7E, 0x06, 0x67,
  0x0E, 0xE3, 0x0C, 0xE3, 0x18, 0xE3, 0x38, 0xE7, 0x70, 0x7F, 0x60, 0x3E,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x06, 0xE7, 0x0C,
  0xC7, 0x1C, 0xC7, 0x38, 0xC7, 0x30, 0xE7, 0x60, 0x7E, 0xE0, 0x3C, 0x0F,
  0x80, 0x3F, 0xC0, 0xFF, 0x81, 0xC7, 0x83, 0x87, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xFC, 0x77, 0xB9, 0xEE, 0x3B, 0x9C,
  0x7F, 0x38, 0x7C, 0x70, 0x78, 0xF0, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0xF8,
  0xF0, 0xFF, 0xFF, 0xFF, 0x77, 0x01, 0x07, 0x0F, 0x3F, 0x3C, 0x78, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x78, 0x3E, 0x1F, 0x0F, 0x03, 0x80, 0x70, 0x3E, 0x1F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0xF1, 0xF1, 0xF0, 0xF0, 0x60,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x10, 0xC3, 0xF3, 0x3F, 0xFF, 0xF3,
  0xFF, 0x80, 0xC0, 0x07, 0xC0, 0x73, 0x81, 0xCF, 0x0F, 0x1E, 0x38, 0x70,
  0x20, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0x3E, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x70, 0xFF, 0xFF, 0xFF, 0x67, 0xBF,
  0xFF, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xEF,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE6, 0x7E, 0xF7, 0xEF, 0x7E,
  0x67, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0x78, 0x63, 0xC2, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83,
  0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0x7F, 0xE3, 0xF8, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x87, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x3B, 0xE1, 0xFF, 0xC7, 0xFF, 0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0xF7, 0x03,
  0xDC, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F,
  0xF0, 0x7E, 0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xE1, 0xF8, 0x3F, 0xC7, 0x9E,
  0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0x7F, 0xE1, 0xFC,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xFF, 0x03,
  0xDC, 0x0F, 0x70, 0x3D, 0xF1, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0xF7,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xC0, 0x3C, 0x7C, 0xF9,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xC7, 0x9E, 0x3C, 0x70,
  0xE3, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xC0, 0xF0,
  0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF0, 0x07, 0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xC0, 0xF0, 0x0C, 0x00, 0xFC,
  0x1F, 0xE3, 0xFE, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC7,
  0xF8, 0xFE, 0x1F, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xEF, 0x9C, 0x0F, 0xF0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0xFB, 0xE3, 0xFF, 0x9C, 0x7E, 0x70, 0xF9, 0xC3,
  0xE7, 0x0F, 0x9C, 0x3E, 0x70, 0xF9, 0xC7, 0xE3, 0xFF, 0x8F, 0xBE, 0x08,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3B, 0x81, 0xCE, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xC7, 0x0E, 0x1C, 0x3F, 0xF0, 0xFF, 0xE7,
  0xFF, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xFF,
  0xE7, 0xFC, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1,
  0xFC, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE,
  0x3F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1,
  0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x73, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xE0, 0x7F,
  0x03, 0xF8, 0x3D, 0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x78, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xC7, 0x8E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C,
  0xE0, 0xF7, 0x07, 0xB8, 0x1F, 0xC0, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFD, 0x9F, 0xEC, 0xDF, 0x66,
  0xFB, 0xB7, 0xCF, 0xBF, 0x79, 0xFB, 0xCF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEC, 0x7E, 0xE7, 0xEE, 0x7E,
  0x67, 0xE7, 0x7E, 0x77, 0xE3, 0x7E, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1, 0xF8, 0xFF, 0x87,
  0xFF, 0x3F, 0xFD, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0xFF, 0xBF, 0xFD, 0xFF, 0x8E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xF9,
  0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8,
  0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xF0, 0xF3, 0xFF,
  0x9F, 0xF8, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0xFF, 0x07, 0xFE, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8E, 0x3C, 0x71, 0xE3, 0x87,
  0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D, 0xC0, 0xF0, 0x1F, 0x81, 0xFF,
  0x1F, 0xFD, 0xE1, 0xEE, 0x07, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x7E, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xFC, 0x0F, 0xF0,
  0x77, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xE1, 0xF8, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xDC, 0x0E, 0x70, 0x39, 0xE0, 0xE7, 0x87, 0x8E,
  0x1C, 0x38, 0x70, 0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x7B, 0x80,
  0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0xE1, 0xC7,
  0x61, 0xC7, 0x73, 0xC7, 0x73, 0xC6, 0x73, 0xC6, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0x4E, 0x73, 0x4E, 0x72, 0x6E, 0x72, 0x6E, 0x36, 0x6E, 0x36, 0x6C,
  0x36, 0x6C, 0x3E, 0x6C, 0x3E, 0x6C, 0x3E, 0x2C, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0x73,
  0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x81, 0xCE, 0x0F, 0x3C, 0x38, 0x79, 0xE1, 0xE7, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xC3, 0x87, 0x87, 0x8E,
  0x0F, 0x3C, 0x0E, 0x70, 0x1E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xFF,
  0xFE, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0xC3, 0x9C, 0x39, 0xC7,
  0x0E, 0x70, 0xEF, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x70, 0x70, 0xF0, 0x1F, 0x83, 0xFE, 0x7F, 0xFF, 0x0F, 0x00, 0x70, 0x07,
  0x1F, 0xF7, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xFF, 0xF7,
  0x7E, 0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C, 0xEF,
  0xEE, 0xFF, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xEF, 0xEE, 0x7C, 0x1F, 0x83, 0xFE, 0x7F,
  0xFF, 0x0F, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x7F, 0x0F, 0x7F, 0xF7, 0xFE, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x73, 0xE7, 0x7F, 0x77, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0x7F, 0x73,
  0xE7, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x07, 0x7D, 0xF7, 0xFE, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x3E,
  0x77, 0xF7, 0x7F, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0x73, 0xE7, 0x00, 0x70, 0x07, 0x00,
  0xF3, 0xFE, 0x3F, 0xE3, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x7C, 0xEF, 0xEE, 0xFF, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x07,
  0x00, 0x7C, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0,
  0x7C, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x7F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x81, 0xF7, 0xFC, 0xFF, 0x9F, 0xC0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xC1, 0xDE, 0x1E, 0xF1,
  0xE7, 0x8F, 0x3C, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xCF, 0x1E, 0x3C,
  0xF1, 0xE7, 0x87, 0xBC, 0x1D, 0xE0, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xEE, 0x7B, 0xFF, 0xEF, 0x7B, 0xF8,
  0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E,
  0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xC0, 0xE7, 0xCE, 0xFE,
  0xEF, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x1F, 0x83, 0xFE, 0x7F,
  0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x0F, 0x7F, 0xF7, 0xFE, 0x1F, 0x80, 0xE7, 0xCE, 0xFE, 0xEF, 0xFF,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x0F, 0xFF, 0xFE, 0xFE, 0xE7, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x3E, 0x77, 0xF7, 0x7F, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xFF, 0xF7, 0xF7, 0x3E, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xEF, 0xCF, 0xFE, 0xFF, 0xEF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xC3, 0xFF, 0x3F, 0xFD, 0xE0,
  0xEF, 0x00, 0x78, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0x80, 0x1F,
  0xC0, 0xEF, 0x9F, 0x3F, 0xF8, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xE7, 0xFE, 0x1F,
  0x80, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x78, 0x78, 0xE1, 0xC3,
  0xC7, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x78, 0x00, 0xC3, 0x0F, 0xC7, 0x1B, 0x9E, 0x37, 0x3C, 0xEE,
  0x79, 0xDC, 0xD3, 0x99, 0xA7, 0x32, 0x6E, 0x64, 0xD8, 0xF9, 0xB1, 0xF3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x87, 0x8F, 0x0E, 0x1C, 0x00, 0xF0, 0x3D, 0xE1,
  0xE3, 0xC7, 0x07, 0x3C, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0xC0, 0x3F, 0x81, 0xEE, 0x0F, 0x3C, 0x38, 0x79, 0xE1, 0xEF, 0x03, 0xC0,
  0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x78, 0xF1, 0xC1, 0xCF,
  0x07, 0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x78, 0x07, 0x8F, 0xF0, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xF0, 0x3F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xF0, 0xFF, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x00, 0x18, 0x01, 0xF8, 0x77, 0xF1, 0xF9, 0xE7, 0xE3, 0xFF,
  0x87, 0xE0, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 10, 8, 16, 3, -20 },
  { 21, 15, 20, 16, 1, -20 },
  { 59, 13, 27, 16, 2, -23 },
  { 103, 16, 20, 16, 0, -20 },
  { 143, 15, 20, 16, 1, -20 },
  { 181, 4, 8, 16, 6, -20 },
  { 185, 8, 26, 16, 5, -23 },
  { 211, 9, 26, 16, 3, -23 },
  { 241, 14, 14, 16, 1, -16 },
  { 266, 13, 13, 16, 2, -15 },
  { 288, 7, 8, 16, 4, -4 },
  { 295, 8, 3, 16, 4, -10 },
  { 298, 5, 5, 16, 6, -5 },
  { 302, 13, 25, 16, 2, -22 },
  { 343, 12, 20, 16, 2, -20 },
  { 373, 13, 20, 16, 2, -20 },
  { 406, 12, 20, 16, 2, -20 },
  { 436, 12, 20, 16, 2, -20 },
  { 466, 12, 20, 16, 2, -20 },
  { 496, 12, 20, 16, 2, -20 },
  { 526, 14, 20, 16, 1, -20 },
  { 561, 13, 20, 16, 2, -20 },
  { 594, 12, 20, 16, 2, -20 },
  { 624, 14, 20, 16, 1, -20 },
  { 659, 5, 15, 16, 6, -15 },
  { 669, 7, 19, 16, 4, -15 },
  { 686, 12, 14, 16, 2, -16 },
  { 707, 12, 10, 16, 2, -14 },
  { 722, 12, 14, 16, 2, -16 },
  { 743, 11, 20, 16, 3, -20 },
  { 771, 14, 25, 16, 1, -20 },
  { 815, 14, 20, 16, 1, -20 },
  { 850, 13, 20, 16, 2, -20 },
  { 883, 12, 20, 16, 2, -20 },
  { 913, 12, 20, 16, 2, -20 },
  { 943, 12, 20, 16, 2, -20 },
  { 973, 12, 20, 16, 2, -20 },
  { 1003, 12, 20, 16, 2, -20 },
  { 1033, 12, 20, 16, 2, -20 },
  { 1063, 12, 20, 16, 2, -20 },
  { 1093, 13, 20, 16, 1, -20 },
  { 1126, 13, 20, 16, 2, -20 },
  { 1159, 12, 20, 16, 3, -20 },
  { 1189, 13, 20, 16, 2, -20 },
  { 1222, 12, 20, 16, 2, -20 },
  { 1252, 12, 20, 16, 2, -20 },
  { 1282, 13, 20, 16, 2, -20 },
  { 1315, 13, 25, 16, 2, -20 },
  { 1356, 13, 20, 16, 2, -20 },
  { 1389, 13, 20, 16, 2, -20 },
  { 1422, 14, 20, 16, 1, -20 },
  { 1457, 12, 20, 16, 2, -20 },
  { 1487, 14, 20, 16, 1, -20 },
  { 1522, 16, 20, 16, 0, -20 },
  { 1562, 14, 20, 16, 1, -20 },
  { 1597, 15, 20, 16, 1, -20 },
  { 1635, 12, 20, 16, 2, -20 },
  { 1665, 8, 25, 16, 5, -22 },
  { 1690, 13, 25, 16, 2, -22 },
  { 1731, 7, 25, 16, 4, -22 },
  { 1753, 12, 11, 16, 2, -20 },
  { 1770, 13, 3, 16, 2, 1 },
  { 1775, 7, 4, 16, 4, -21 },
  { 1779, 12, 15, 16, 2, -15 },
  { 1802, 12, 20, 16, 2, -20 },
  { 1832, 12, 15, 16, 2, -15 },
  { 1855, 12, 20, 16, 2, -20 },
  { 1885, 12, 15, 16, 2, -15 },
  { 1908, 14, 20, 16, 1, -20 },
  { 1943, 12, 20, 16, 2, -15 },
  { 1973, 12, 20, 16, 2, -20 },
  { 2003, 13, 21, 16, 2, -21 },
  { 2038, 11, 26, 16, 2, -21 },
  { 2074, 13, 20, 16, 2, -20 },
  { 2107, 14, 20, 16, 1, -20 },
  { 2142, 14, 15, 16, 1, -15 },
  { 2169, 12, 15, 16, 2, -15 },
  { 2192, 12, 15, 16, 2, -15 },
  { 2215, 12, 20, 16, 2, -15 },
  { 2245, 12, 20, 16, 2, -15 },
  { 2275, 12, 15, 16, 3, -15 },
  { 2298, 13, 15, 16, 2, -15 },
  { 2323, 13, 19, 16, 1, -19 },
  { 2354, 12, 15, 16, 2, -15 },
  { 2377, 14, 15, 16, 1, -15 },
  { 2404, 15, 15, 16, 1, -15 },
  { 2433, 14, 15, 16, 1, -15 },
  { 2460, 14, 20, 16, 1, -15 },
  { 2495, 12, 15, 16, 2, -15 },
  { 2518, 12, 25, 16, 2, -22 },
  { 2556, 4, 25, 16, 6, -22 },
  { 2569, 12, 25, 16, 2, -22 },
  { 2607, 14, 7, 16, 1, -13 },
};

const GFXfont JetBrainsMono_Bold27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Bold27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Bold27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_BOLD27PT7B_H_
