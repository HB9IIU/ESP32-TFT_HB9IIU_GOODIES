#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x1C, 0x70, 0x00, 0x38, 0xE3, 0x80,
  0x7F, 0xDF, 0xBF, 0x6C, 0xC0, 0x06, 0xC1, 0x98, 0x36, 0x06, 0xD3, 0xFC,
  0xFF, 0x86, 0xC1, 0x98, 0xFF, 0x9F, 0xF1, 0x98, 0x33, 0x06, 0xC1, 0xD8,
  0x00, 0x02, 0x03, 0x87, 0xE7, 0xF3, 0x51, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0xA3, 0xC9, 0xEF, 0xE7, 0xE0, 0x40, 0x20, 0x3C, 0x73, 0xE3, 0x1B, 0x31,
  0x9B, 0x8C, 0xD8, 0x6F, 0xDB, 0x6D, 0xFE, 0xDB, 0x06, 0xD8, 0x66, 0xC3,
  0x76, 0x33, 0x31, 0x8F, 0x18, 0x70, 0x0F, 0x83, 0xF0, 0x66, 0x0D, 0xC1,
  0xB0, 0x3E, 0x07, 0xBB, 0xF7, 0x7F, 0xDC, 0xFB, 0x9E, 0x73, 0xCF, 0xF8,
  0xFF, 0x80, 0x7E, 0xEE, 0xC0, 0x0E, 0x38, 0x61, 0xC3, 0x86, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0x0E, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x1C, 0x71, 0xC0,
  0x0C, 0x4C, 0x7F, 0xFF, 0x1F, 0x3C, 0x7E, 0x26, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x3B, 0x9C, 0xCE, 0x60, 0x7D, 0xEF,
  0x80, 0xFF, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x00, 0x0F, 0x0F, 0xCE,
  0xE7, 0x77, 0x3B, 0x9D, 0xCE, 0xE7, 0x67, 0x33, 0xB9, 0xCD, 0xC7, 0xC3,
  0xC0, 0x1E, 0x79, 0xF7, 0xED, 0xCB, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x00, 0x0F, 0x87, 0xF1, 0x9C, 0x47, 0x01, 0xC0, 0xE0, 0x78, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xFC, 0x7F, 0x3F, 0xC0, 0x1F, 0x9F, 0xC4, 0xE0,
  0x70, 0x38, 0xF8, 0x70, 0x7E, 0x07, 0x03, 0x81, 0xD9, 0xCF, 0xE7, 0xE0,
  0x03, 0x83, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0xDC, 0xCE, 0x66, 0x7F, 0xFF,
  0xC1, 0xC0, 0xE0, 0xE0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x81, 0xF1, 0xFC,
  0x4E, 0x07, 0x03, 0x81, 0xD9, 0xCF, 0xE7, 0xE0, 0x02, 0x07, 0xC7, 0xC7,
  0x07, 0x03, 0x83, 0xF9, 0xFC, 0xEF, 0x73, 0x33, 0x99, 0xCF, 0xE7, 0xE1,
  0xE0, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x1F, 0x9F, 0xCE, 0xE7, 0x73, 0xB9, 0xF8,
  0x78, 0x7C, 0x77, 0x73, 0xB9, 0xDC, 0xEF, 0xE3, 0xE0, 0x04, 0x0F, 0x8F,
  0xE7, 0x77, 0x3B, 0x9D, 0xCE, 0xEF, 0x7F, 0x1F, 0x81, 0xC1, 0xC9, 0xE7,
  0xE3, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x38, 0x1C, 0x71, 0xC0,
  0x00, 0x00, 0x00, 0x39, 0xC7, 0x18, 0xE3, 0x00, 0x01, 0x07, 0x1F, 0x7C,
  0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x1F, 0x7C, 0xF0, 0xC0, 0x80, 0x7C, 0xFD,
  0x38, 0x70, 0xC3, 0x8E, 0x38, 0x60, 0x00, 0x07, 0x0E, 0x18, 0x00, 0x07,
  0xF0, 0x71, 0xC6, 0x06, 0x73, 0xF3, 0x7C, 0xB3, 0x65, 0xB3, 0x6D, 0x9B,
  0x4D, 0x9E, 0x6D, 0xB3, 0xFC, 0x8D, 0x86, 0x00, 0x38, 0x40, 0xFE, 0x00,
  0x80, 0x03, 0xC1, 0xF0, 0x7C, 0x3F, 0x0D, 0xC7, 0x71, 0xDC, 0x67, 0x3F,
  0xCF, 0xF7, 0xFD, 0xC7, 0xF1, 0xF8, 0x70, 0x1F, 0x87, 0xF3, 0x9C, 0xE7,
  0x39, 0xCF, 0xE3, 0xF1, 0xFE, 0x73, 0x9C, 0xE7, 0x3B, 0x9C, 0xFF, 0x3F,
  0x00, 0x1F, 0x9F, 0xCE, 0x4E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1E, 0xCF, 0xE3, 0xF0, 0x1F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x1D, 0xC7, 0x71, 0xDC, 0xE7, 0x3B, 0xFC, 0xFE, 0x3F, 0x00, 0x1F,
  0x8F, 0xCE, 0x07, 0x03, 0x81, 0xF8, 0xF8, 0xFC, 0x70, 0x38, 0x1C, 0x1F,
  0xCF, 0xC7, 0xE0, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xFC, 0xFC,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x00, 0x0F, 0xCF, 0xF3, 0x89, 0xC0,
  0x70, 0x38, 0x0E, 0x7B, 0x9E, 0xEB, 0xB8, 0xEE, 0x73, 0xDC, 0xFF, 0x1F,
  0x80, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFC, 0x3F, 0xC7,
  0xFC, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x1F, 0x87,
  0x83, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x07,
  0xE7, 0xE0, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x71, 0x70, 0xF8, 0x78, 0x00, 0x1C,
  0xF1, 0x9C, 0x39, 0xC3, 0xB8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7F,
  0x07, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x78, 0x1C, 0x38, 0xE1, 0xC3,
  0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7, 0xFF, 0xFF, 0x80, 0x1E, 0x1E, 0x3C,
  0x7C, 0xF8, 0xF1, 0xF3, 0xE3, 0xE7, 0xC6, 0xCF, 0x8D, 0xB7, 0x3B, 0x6C,
  0x77, 0xF8, 0xEF, 0x71, 0x9E, 0xE7, 0x39, 0xCE, 0x73, 0x1C, 0xCE, 0x00,
  0x1C, 0x71, 0xE7, 0x3E, 0x73, 0xE7, 0x3E, 0x63, 0x6E, 0x36, 0xE7, 0x7E,
  0x77, 0xC7, 0x7C, 0x67, 0xCE, 0x3C, 0xE3, 0xCE, 0x38, 0x02, 0x07, 0xE3,
  0xFC, 0xE7, 0x71, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x3B, 0x9E,
  0xFF, 0x3F, 0x87, 0xC0, 0x1F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0xF9, 0xFE, 0x7E, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x02, 0x07,
  0xE3, 0xFC, 0xE7, 0x71, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x3B,
  0x9E, 0xFF, 0x3F, 0x87, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x1F, 0x87, 0xF3,
  0x9C, 0xE7, 0x39, 0xCE, 0xE3, 0xF9, 0xFC, 0x7E, 0x1D, 0xC7, 0x73, 0x9C,
  0xE7, 0x39, 0xE0, 0x1F, 0x9F, 0xCE, 0x47, 0x03, 0x81, 0xE0, 0xF8, 0x3C,
  0x0F, 0x03, 0xA3, 0xDF, 0xCF, 0xE7, 0xE0, 0x7F, 0xBF, 0x87, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x80, 0x39,
  0xCC, 0x77, 0x1D, 0xC7, 0x73, 0x9C, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xCE,
  0x73, 0xBC, 0xFE, 0x1F, 0x00, 0xE3, 0xF8, 0xEE, 0x73, 0x9C, 0xE7, 0x3B,
  0x8E, 0xE3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x73,
  0x8E, 0xE7, 0x1D, 0x8E, 0x73, 0x3C, 0xE6, 0x7B, 0x8D, 0xF7, 0x1B, 0x6E,
  0x36, 0xF8, 0x7D, 0xF1, 0xF3, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0x3C, 0x1E,
  0x78, 0x00, 0x1C, 0xF1, 0xCE, 0x0D, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3B, 0x07, 0x38, 0x73, 0x8E, 0x38, 0xE7,
  0xF3, 0xBB, 0x9D, 0xCF, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1C,
  0x0E, 0x07, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x3F, 0x87, 0xF1, 0xFE, 0x00, 0x0F,
  0x1F, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x78, 0xF8, 0xEE, 0xEE, 0x66, 0x67, 0x77, 0x73, 0x33, 0x0F,
  0x87, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0xF0, 0xF8, 0x00, 0x06, 0x07, 0x03, 0xC3, 0xE3,
  0xB1, 0x99, 0xCE, 0xC7, 0xC1, 0x80, 0xFF, 0xE7, 0x70, 0x1D, 0xCF, 0xE7,
  0xB9, 0xCE, 0x73, 0x9C, 0xEE, 0x73, 0x9C, 0xEF, 0x1F, 0xC7, 0x60, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0xF1, 0xFC, 0xEE, 0xE7, 0x73, 0xB9, 0xDC, 0xEE,
  0xEF, 0x77, 0xF3, 0x70, 0x1F, 0x3F, 0x3A, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xF4, 0x7C, 0x7C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE1, 0xDC, 0x7F, 0x0E,
  0xE3, 0x9C, 0x73, 0x8C, 0x63, 0x8C, 0x73, 0x8E, 0x70, 0xFE, 0x1D, 0x80,
  0x1F, 0x1F, 0x8C, 0xEE, 0x77, 0xF3, 0xF3, 0x81, 0xC0, 0xE2, 0x3F, 0x0F,
  0x80, 0x03, 0xC1, 0xF0, 0x70, 0x18, 0x0F, 0x87, 0xE0, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x3C, 0x0F,
  0x03, 0x80, 0x0E, 0xE3, 0xF8, 0x77, 0x1C, 0xE3, 0x9C, 0x73, 0x9C, 0xE3,
  0x9C, 0x77, 0x8F, 0xF0, 0xEC, 0x03, 0x80, 0x71, 0xFE, 0x3F, 0x83, 0xC0,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0xF1, 0xFC, 0xEE, 0xE7, 0x73, 0xB9, 0xDC,
  0xCC, 0xEE, 0x77, 0x3B, 0x98, 0x1C, 0x71, 0x80, 0x38, 0xE3, 0x1C, 0x71,
  0xC7, 0x18, 0xE3, 0x8E, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38,
  0x7C, 0x3E, 0x1C, 0x00, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x39, 0xCE, 0xE3,
  0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x39, 0xCE, 0x70, 0x1C,
  0x73, 0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x00, 0x37,
  0xB8, 0xFF, 0xE3, 0xBF, 0xDC, 0xE6, 0x73, 0xB9, 0xCC, 0xE7, 0x73, 0x99,
  0xCE, 0xE7, 0x33, 0x9D, 0xCE, 0xE7, 0x00, 0x37, 0x1F, 0xCE, 0xEE, 0x77,
  0x3B, 0x9D, 0xCC, 0xCE, 0xE7, 0x73, 0xB9, 0x80, 0x1F, 0x1F, 0x8E, 0xEE,
  0x77, 0x3B, 0x1F, 0x8D, 0xCE, 0xE7, 0x3F, 0x0F, 0x00, 0x1B, 0x87, 0xF1,
  0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xEE, 0x7B, 0x9F, 0xC7, 0xF1, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1D, 0xCF, 0xE3, 0xB9, 0xCE, 0x73, 0x98,
  0xCE, 0x33, 0x9C, 0xE7, 0x3F, 0xC7, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x37, 0x3E, 0x3E, 0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0x3F, 0x3E, 0x72, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x9C, 0xFC, 0xF8, 0x38,
  0xC7, 0xFF, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0xBC, 0xF0, 0x39, 0xCE, 0x63,
  0x39, 0xCE, 0x73, 0x9C, 0xC7, 0x71, 0x9C, 0xEF, 0x3F, 0xC7, 0x60, 0xE7,
  0xF3, 0xB9, 0x9D, 0xCE, 0xE7, 0xE3, 0xF1, 0xF0, 0x78, 0x38, 0x1C, 0x00,
  0xE7, 0x3F, 0x79, 0xBB, 0xDD, 0xDE, 0xEF, 0xBE, 0x7D, 0xF3, 0xEF, 0x1E,
  0x78, 0xF7, 0xC7, 0xBC, 0x39, 0xE0, 0x39, 0xE3, 0xB8, 0x7E, 0x0F, 0x81,
  0xF0, 0x1C, 0x07, 0x81, 0xF8, 0x37, 0x0E, 0xE3, 0x9C, 0x00, 0x38, 0xE7,
  0x38, 0xE6, 0x1D, 0xC1, 0xB8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x1F, 0x9F, 0xC1, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x3F, 0x3F, 0x80, 0x07, 0x0F, 0x1E,
  0x1C, 0x1C, 0x1C, 0x38, 0x78, 0xE0, 0xF0, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x0F, 0x06, 0x1E, 0x38, 0x38, 0x38, 0x38,
  0x70, 0xF0, 0xE0, 0x71, 0xFF, 0xFF, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 11, 14, 10, 0, -14 },
  { 37, 9, 16, 9, 0, -15 },
  { 55, 13, 14, 15, 1, -14 },
  { 78, 11, 14, 11, 0, -14 },
  { 98, 4, 5, 5, 2, -14 },
  { 101, 7, 17, 6, 0, -14 },
  { 116, 7, 18, 6, -2, -15 },
  { 132, 8, 8, 9, 1, -15 },
  { 140, 8, 10, 10, 1, -12 },
  { 150, 5, 6, 5, -1, -3 },
  { 154, 6, 3, 6, 0, -7 },
  { 157, 3, 3, 5, 0, -3 },
  { 159, 10, 14, 8, -1, -14 },
  { 177, 9, 14, 9, 0, -14 },
  { 193, 7, 14, 9, 2, -14 },
  { 206, 10, 14, 9, -1, -14 },
  { 224, 9, 14, 9, 0, -14 },
  { 240, 9, 14, 9, 0, -14 },
  { 256, 9, 14, 9, 0, -14 },
  { 272, 9, 15, 9, 1, -15 },
  { 289, 9, 14, 9, 1, -14 },
  { 305, 9, 14, 9, 0, -14 },
  { 321, 9, 15, 9, 0, -15 },
  { 338, 5, 11, 5, 0, -11 },
  { 345, 6, 14, 5, -1, -11 },
  { 356, 8, 10, 10, 1, -12 },
  { 366, 8, 6, 10, 1, -10 },
  { 372, 8, 10, 10, 1, -12 },
  { 382, 7, 14, 7, 1, -14 },
  { 395, 13, 16, 14, 0, -14 },
  { 421, 10, 14, 10, -1, -14 },
  { 439, 10, 14, 10, 0, -14 },
  { 457, 9, 14, 9, 1, -14 },
  { 473, 10, 14, 11, 0, -14 },
  { 491, 9, 14, 8, 0, -14 },
  { 507, 9, 14, 8, 0, -14 },
  { 523, 10, 14, 11, 1, -14 },
  { 541, 12, 14, 11, 0, -14 },
  { 562, 9, 14, 7, -1, -14 },
  { 578, 9, 18, 5, -3, -14 },
  { 599, 12, 14, 10, 0, -14 },
  { 620, 7, 14, 8, 0, -14 },
  { 633, 15, 14, 14, 0, -14 },
  { 660, 12, 14, 12, 0, -14 },
  { 681, 10, 15, 11, 1, -15 },
  { 700, 10, 14, 9, 0, -14 },
  { 718, 10, 18, 11, 1, -15 },
  { 741, 10, 14, 10, 0, -14 },
  { 759, 9, 14, 8, 0, -14 },
  { 775, 9, 14, 8, 1, -14 },
  { 791, 10, 14, 11, 1, -14 },
  { 809, 10, 14, 10, 2, -14 },
  { 827, 15, 14, 14, 1, -14 },
  { 854, 12, 14, 9, -1, -14 },
  { 875, 9, 14, 9, 2, -14 },
  { 891, 11, 14, 8, -1, -14 },
  { 911, 8, 17, 6, -1, -14 },
  { 928, 4, 14, 8, 2, -14 },
  { 935, 9, 17, 6, -2, -14 },
  { 955, 9, 9, 9, 0, -14 },
  { 966, 8, 1, 7, -2, 2 },
  { 967, 4, 3, 6, 3, -15 },
  { 969, 10, 11, 9, 0, -11 },
  { 983, 9, 15, 9, 0, -15 },
  { 1000, 8, 11, 8, 0, -11 },
  { 1011, 11, 15, 9, 0, -15 },
  { 1032, 9, 11, 9, 0, -11 },
  { 1045, 10, 20, 6, -2, -15 },
  { 1070, 11, 16, 9, -1, -11 },
  { 1092, 9, 15, 9, 0, -15 },
  { 1109, 6, 15, 5, 0, -15 },
  { 1121, 9, 20, 5, -3, -15 },
  { 1144, 10, 15, 9, 0, -15 },
  { 1163, 6, 15, 5, 0, -15 },
  { 1175, 14, 11, 14, 0, -11 },
  { 1195, 9, 11, 9, 0, -11 },
  { 1208, 9, 11, 9, 0, -11 },
  { 1221, 10, 16, 9, -1, -11 },
  { 1241, 10, 16, 9, 0, -11 },
  { 1261, 8, 11, 7, 0, -11 },
  { 1272, 8, 11, 7, 0, -11 },
  { 1283, 6, 13, 6, 1, -13 },
  { 1293, 10, 11, 9, 0, -11 },
  { 1307, 9, 11, 9, 1, -11 },
  { 1320, 13, 11, 13, 1, -11 },
  { 1338, 11, 11, 9, -1, -11 },
  { 1354, 11, 16, 9, -1, -11 },
  { 1376, 9, 11, 7, -1, -11 },
  { 1389, 8, 17, 7, 0, -14 },
  { 1406, 3, 20, 8, 2, -15 },
  { 1414, 8, 17, 7, -1, -14 },
  { 1431, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC20PT7B_H_
