#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB5, 0xE0, 0x14, 0x52, 0xDF,
  0x2B, 0xFF, 0x94, 0xF0, 0x10, 0xF7, 0x98, 0x30, 0x6B, 0xBC, 0x61, 0x00,
  0x66, 0xE4, 0xAC, 0xA8, 0xF6, 0xDF, 0x2B, 0x6A, 0x4E, 0x18, 0x78, 0xA1,
  0xC3, 0x6F, 0xB7, 0x6C, 0xFC, 0x7F, 0x13, 0x66, 0x4C, 0xCC, 0xCC, 0xC0,
  0x31, 0x11, 0x13, 0x32, 0x64, 0xC0, 0x27, 0x9F, 0xE7, 0x00, 0x30, 0xCF,
  0xCC, 0x30, 0xC0, 0x6D, 0x60, 0xFC, 0xF0, 0x06, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0xC0, 0x19, 0xDA, 0xD4, 0xEF, 0x7E, 0x70, 0x13, 0x7B, 0x22,
  0x66, 0x60, 0x13, 0xD2, 0x31, 0x99, 0x9E, 0xF0, 0x39, 0xF0, 0x86, 0x31,
  0x61, 0xAC, 0xF0, 0x0C, 0x63, 0x8E, 0x5B, 0x4F, 0x8C, 0x30, 0x3C, 0xE6,
  0x18, 0x78, 0x61, 0xAC, 0xF0, 0x0C, 0xF6, 0x1C, 0x7B, 0x6D, 0xB6, 0x70,
  0x3D, 0xF0, 0x86, 0x10, 0xC2, 0x18, 0xC0, 0x19, 0xF6, 0xDE, 0x31, 0xED,
  0xB6, 0xF0, 0x13, 0xDA, 0x97, 0xBC, 0x76, 0xE0, 0x2C, 0x01, 0xB0, 0x13,
  0x00, 0x06, 0x64, 0xC0, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xFC, 0x0F, 0xFF,
  0xC1, 0xC1, 0xCE, 0xE2, 0x00, 0x33, 0xC6, 0x22, 0x30, 0x08, 0xC0, 0x0C,
  0x33, 0x21, 0x5D, 0x55, 0xE5, 0xBE, 0x94, 0x44, 0x38, 0x0C, 0x71, 0xC5,
  0x34, 0xD7, 0xDB, 0xCC, 0x38, 0xF6, 0xDB, 0x79, 0x6C, 0xB6, 0xF0, 0x1C,
  0xF6, 0x18, 0x63, 0x0C, 0x1E, 0x78, 0x30, 0xF6, 0xDB, 0x6D, 0x3C, 0xFE,
  0xF0, 0x39, 0xD8, 0xC7, 0xA3, 0x1E, 0xF0, 0x39, 0xD8, 0xC7, 0xBB, 0x18,
  0xC0, 0x0C, 0x7D, 0x83, 0x07, 0xDB, 0xB3, 0x36, 0x78, 0x36, 0x4D, 0x9B,
  0x27, 0xC9, 0xB3, 0x64, 0xD8, 0x79, 0x8C, 0x46, 0x31, 0x8C, 0xE0, 0x0C,
  0x21, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xCE, 0x30, 0x36, 0x59, 0xB3, 0xC7,
  0x0E, 0x36, 0x6C, 0xD8, 0x32, 0x66, 0x64, 0xCF, 0xF0, 0x31, 0x99, 0xDC,
  0xEE, 0xE7, 0x72, 0xFB, 0x6D, 0xB6, 0xDA, 0x00, 0x32, 0x65, 0xDB, 0xB7,
  0x6B, 0xB7, 0x6E, 0xCC, 0x18, 0x79, 0x9B, 0x36, 0x79, 0xB3, 0x3C, 0x78,
  0x38, 0xF6, 0xDB, 0x7D, 0xEC, 0x30, 0xC0, 0x18, 0x79, 0x9B, 0x36, 0x79,
  0xB3, 0x3C, 0x78, 0x20, 0x60, 0x30, 0xF6, 0xDB, 0x79, 0xCD, 0xB6, 0xD8,
  0x19, 0xF6, 0x98, 0x70, 0xE1, 0xBC, 0xF0, 0xFF, 0xD8, 0xC6, 0x23, 0x18,
  0xC0, 0x36, 0x4D, 0x93, 0x66, 0xC9, 0xB3, 0x7C, 0x70, 0xCF, 0x2D, 0xB6,
  0xF3, 0xCE, 0x38, 0xC0, 0xC9, 0xEC, 0xB6, 0xDF, 0x6E, 0xE7, 0x73, 0xB1,
  0xB8, 0xDC, 0x00, 0x32, 0x6C, 0x50, 0xE1, 0x87, 0x0E, 0x36, 0xCC, 0xCF,
  0x6D, 0x1C, 0x61, 0x84, 0x30, 0xC0, 0x7D, 0xF1, 0x8C, 0x31, 0x84, 0x3C,
  0xF0, 0x19, 0xCC, 0x62, 0x11, 0x8C, 0x62, 0x38, 0xDB, 0x24, 0x93, 0x60,
  0x39, 0xC6, 0x21, 0x18, 0xC4, 0x23, 0x38, 0x10, 0x8E, 0xF4, 0xE4, 0xF0,
  0xD0, 0x3D, 0xF4, 0xB6, 0xDB, 0x6F, 0x80, 0x31, 0x87, 0x9E, 0x6D, 0x2D,
  0xB6, 0xB0, 0x33, 0xD1, 0x8C, 0x69, 0xC0, 0x04, 0x33, 0xDF, 0x4B, 0x6D,
  0xB6, 0x70, 0x33, 0xD3, 0xFC, 0x65, 0xC0, 0x1C, 0x43, 0x9E, 0x30, 0xC2,
  0x18, 0x61, 0x8C, 0x30, 0x3D, 0xF4, 0xB6, 0xDB, 0x6F, 0x84, 0xF3, 0x80,
  0x33, 0x1E, 0xF6, 0xAF, 0x7B, 0xD8, 0x25, 0xB6, 0xB6, 0xC0, 0x08, 0x46,
  0x31, 0x88, 0xC6, 0x31, 0x39, 0xC0, 0x21, 0x86, 0xDE, 0x51, 0xCF, 0x34,
  0xD8, 0x36, 0x66, 0x64, 0xCC, 0xC0, 0x7B, 0x7F, 0x6B, 0x5B, 0xDB, 0xDA,
  0xD6, 0x7B, 0xDA, 0xBD, 0xEF, 0x60, 0x33, 0xD3, 0x9D, 0xED, 0xC0, 0x3C,
  0xF3, 0x49, 0x6D, 0xB7, 0x90, 0x43, 0x00, 0x3D, 0xF4, 0xB6, 0xDB, 0x6F,
  0x04, 0x30, 0xC0, 0x7B, 0x98, 0x8C, 0x63, 0x00, 0x3B, 0x90, 0xC3, 0x5B,
  0x80, 0x23, 0x76, 0x44, 0xD6, 0x6D, 0xB4, 0x96, 0xDB, 0x6F, 0x00, 0x9C,
  0xAD, 0x4E, 0x63, 0x00, 0x93, 0x6E, 0xDF, 0xAD, 0xDB, 0x36, 0x00, 0x36,
  0x78, 0xE0, 0xC3, 0x8F, 0x32, 0x00, 0x26, 0x48, 0xB1, 0x43, 0x86, 0x0C,
  0x18, 0xE1, 0x80, 0x7B, 0xCC, 0xC6, 0x63, 0xC0, 0x09, 0xCC, 0x46, 0x61,
  0x8C, 0x43, 0x18, 0xFF, 0xFF, 0xFF, 0x21, 0x84, 0x23, 0x0C, 0xC4, 0x67,
  0x30, 0xFE, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 6, 9, 6, 0, -9 },
  { 16, 6, 10, 5, 0, -9 },
  { 24, 8, 9, 9, 1, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 4, 3, 1, -9 },
  { 42, 4, 11, 3, 0, -9 },
  { 48, 4, 11, 3, -1, -9 },
  { 54, 5, 5, 5, 1, -9 },
  { 58, 6, 6, 6, 0, -7 },
  { 63, 3, 4, 3, -1, -2 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 2, 2, 3, 0, -2 },
  { 67, 7, 9, 5, -1, -9 },
  { 75, 5, 9, 5, 0, -9 },
  { 81, 4, 9, 5, 1, -9 },
  { 86, 5, 9, 5, 0, -9 },
  { 92, 6, 9, 5, 0, -9 },
  { 99, 6, 9, 5, 0, -9 },
  { 106, 6, 9, 5, 0, -9 },
  { 113, 6, 9, 5, 0, -9 },
  { 120, 6, 9, 5, 0, -9 },
  { 127, 6, 9, 5, 0, -9 },
  { 134, 5, 9, 5, 0, -9 },
  { 140, 3, 7, 3, 0, -7 },
  { 143, 4, 9, 3, -1, -7 },
  { 148, 6, 6, 6, 0, -7 },
  { 153, 6, 4, 6, 0, -6 },
  { 156, 6, 6, 6, 0, -7 },
  { 161, 5, 9, 4, 0, -9 },
  { 167, 8, 10, 8, 0, -9 },
  { 177, 6, 9, 6, -1, -9 },
  { 184, 6, 9, 6, 0, -9 },
  { 191, 6, 9, 5, 0, -9 },
  { 198, 6, 9, 6, 0, -9 },
  { 205, 5, 9, 5, 0, -9 },
  { 211, 5, 9, 5, 0, -9 },
  { 217, 7, 9, 6, 0, -9 },
  { 225, 7, 9, 7, 0, -9 },
  { 233, 5, 9, 4, 0, -9 },
  { 239, 6, 12, 3, -2, -9 },
  { 248, 7, 9, 6, 0, -9 },
  { 256, 4, 9, 5, 0, -9 },
  { 261, 9, 9, 9, 0, -9 },
  { 272, 7, 9, 7, 0, -9 },
  { 280, 7, 9, 7, 0, -9 },
  { 288, 6, 9, 6, 0, -9 },
  { 295, 7, 11, 7, 0, -9 },
  { 305, 6, 9, 6, 0, -9 },
  { 312, 6, 9, 5, 0, -9 },
  { 319, 5, 9, 5, 1, -9 },
  { 325, 7, 9, 6, 0, -9 },
  { 333, 6, 9, 6, 1, -9 },
  { 340, 9, 9, 9, 1, -9 },
  { 351, 7, 9, 6, -1, -9 },
  { 359, 6, 9, 5, 1, -9 },
  { 366, 6, 9, 5, 0, -9 },
  { 373, 5, 11, 3, -1, -9 },
  { 380, 3, 9, 5, 1, -9 },
  { 384, 5, 11, 3, -1, -9 },
  { 391, 5, 6, 5, 0, -9 },
  { 395, 4, 1, 4, -1, 1 },
  { 396, 2, 2, 4, 2, -9 },
  { 397, 6, 7, 6, 0, -7 },
  { 403, 6, 9, 6, 0, -9 },
  { 410, 5, 7, 5, 0, -7 },
  { 415, 6, 9, 6, 0, -9 },
  { 422, 5, 7, 5, 0, -7 },
  { 427, 6, 12, 4, -1, -9 },
  { 436, 6, 10, 6, 0, -7 },
  { 444, 5, 9, 6, 0, -9 },
  { 450, 3, 9, 3, 0, -9 },
  { 454, 5, 12, 3, -2, -9 },
  { 462, 6, 9, 5, 0, -9 },
  { 469, 4, 9, 3, 0, -9 },
  { 474, 8, 7, 8, 0, -7 },
  { 481, 5, 7, 6, 0, -7 },
  { 486, 5, 7, 6, 0, -7 },
  { 491, 6, 10, 6, -1, -7 },
  { 499, 6, 10, 6, 0, -7 },
  { 507, 5, 7, 4, 0, -7 },
  { 512, 5, 7, 4, 0, -7 },
  { 517, 4, 8, 4, 0, -8 },
  { 521, 6, 7, 6, 0, -7 },
  { 527, 5, 7, 5, 1, -7 },
  { 532, 7, 7, 8, 1, -7 },
  { 539, 7, 7, 5, -1, -7 },
  { 546, 7, 10, 5, -1, -7 },
  { 555, 5, 7, 4, 0, -7 },
  { 560, 5, 11, 4, 0, -9 },
  { 567, 2, 12, 5, 1, -9 },
  { 570, 5, 11, 4, -1, -9 },
  { 577, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC12PT7B_H_
