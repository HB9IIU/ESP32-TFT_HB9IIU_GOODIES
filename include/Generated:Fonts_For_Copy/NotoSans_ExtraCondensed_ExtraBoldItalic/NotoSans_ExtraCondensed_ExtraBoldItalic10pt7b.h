#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x25, 0x30, 0xFA, 0x29, 0x5E, 0xAF, 0xB2, 0x80, 0x11, 0xD4,
  0xC3, 0x1B, 0xCC, 0x40, 0xCB, 0xCD, 0x3B, 0x35, 0x5D, 0x80, 0x39, 0xE7,
  0x1B, 0xFA, 0x4F, 0x80, 0xE0, 0x36, 0x44, 0xC8, 0x88, 0xC0, 0x33, 0x33,
  0x22, 0x64, 0x80, 0x6D, 0xFE, 0xA0, 0x21, 0x3E, 0x42, 0x00, 0x78, 0xE0,
  0xB0, 0x0C, 0x61, 0x0C, 0x21, 0x8C, 0x00, 0x32, 0xD5, 0xAD, 0x79, 0x80,
  0x7F, 0xB4, 0xB0, 0x72, 0xC4, 0x66, 0x63, 0xC0, 0x72, 0xC4, 0xC3, 0x5B,
  0x80, 0x19, 0x94, 0xEF, 0x78, 0x80, 0x7B, 0x18, 0xE1, 0x5B, 0x80, 0x3B,
  0x1D, 0xED, 0x79, 0x80, 0x78, 0xC4, 0x62, 0x33, 0x00, 0x7A, 0xDC, 0xED,
  0x4B, 0x80, 0x72, 0xD4, 0xE5, 0x1B, 0x80, 0x4C, 0x09, 0x80, 0x23, 0x00,
  0x06, 0xC0, 0x0B, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0x83, 0x86, 0xC8, 0x00,
  0x71, 0x36, 0x44, 0xC0, 0x3C, 0x85, 0x6D, 0x5A, 0xD7, 0xB2, 0x38, 0x18,
  0xCE, 0x57, 0xB7, 0x20, 0x7B, 0x56, 0xED, 0x6B, 0xC0, 0x3B, 0x11, 0x8C,
  0x69, 0xC0, 0x7B, 0x52, 0x9D, 0xFB, 0x80, 0x7B, 0x10, 0xEC, 0x63, 0x80,
  0x7B, 0x10, 0xEC, 0x63, 0x00, 0x3D, 0x84, 0x36, 0xDB, 0x67, 0x00, 0x6D,
  0xA4, 0x9E, 0xDB, 0x6D, 0x00, 0x72, 0x66, 0x44, 0xE0, 0x18, 0xC4, 0x21,
  0x18, 0xC4, 0xE0, 0x6D, 0xE5, 0x1C, 0xF3, 0xCD, 0x00, 0x6D, 0x2D, 0xB8,
  0x67, 0x66, 0x6E, 0x6E, 0xFE, 0xF4, 0xB4, 0x65, 0xB7, 0xDE, 0xDB, 0x69,
  0x80, 0x39, 0xB4, 0xF2, 0xCB, 0x67, 0x00, 0x7B, 0xD6, 0xEE, 0x63, 0x00,
  0x39, 0xB4, 0xF2, 0xCB, 0x67, 0x0C, 0x30, 0x7B, 0xD6, 0xEF, 0x7B, 0x40,
  0x7A, 0x58, 0xE3, 0x5B, 0x80, 0xF4, 0x4C, 0xCC, 0x80, 0x6D, 0xA4, 0x96,
  0xDB, 0x47, 0x00, 0x9C, 0xAD, 0x4E, 0x63, 0x00, 0x97, 0x6A, 0xD7, 0xED,
  0x9B, 0x26, 0x00, 0x34, 0xE1, 0x84, 0x39, 0xED, 0x80, 0x9F, 0xEC, 0xCC,
  0xC0, 0x78, 0x8C, 0xC4, 0x63, 0xC0, 0x74, 0x44, 0xC8, 0x88, 0xC0, 0xAF,
  0x54, 0x31, 0x33, 0x22, 0x26, 0xC0, 0x31, 0x95, 0xB0, 0xF0, 0xD0, 0x23,
  0xF5, 0xAF, 0x78, 0x63, 0x14, 0xF5, 0xEB, 0x5C, 0x37, 0xCC, 0xDE, 0x08,
  0x4E, 0xFD, 0x6B, 0xDA, 0x27, 0xDE, 0xC7, 0x19, 0xCC, 0xE2, 0x11, 0x8C,
  0x46, 0x00, 0x23, 0xF5, 0xAF, 0x78, 0xDC, 0x63, 0x14, 0xF5, 0x6B, 0x56,
  0x2C, 0x25, 0xB4, 0x13, 0x02, 0x26, 0x64, 0x4C, 0x63, 0x12, 0xA7, 0x73,
  0xD6, 0x6D, 0x25, 0xB4, 0x14, 0xFD, 0x5E, 0xAD, 0x56, 0x80, 0x13, 0xD5,
  0xAD, 0x58, 0x27, 0xDD, 0xF6, 0x08, 0xF2, 0xDA, 0x69, 0xE4, 0x30, 0x23,
  0xD5, 0xAF, 0x78, 0xC4, 0x17, 0x4C, 0xC8, 0x27, 0x46, 0xAE, 0x2F, 0xA5,
  0xB8, 0x5A, 0xB5, 0xED, 0x00, 0xBA, 0xCC, 0xC0, 0xBF, 0xAF, 0xBC, 0xB0,
  0x2C, 0xC3, 0x1C, 0xD8, 0x2C, 0xA3, 0x0C, 0x30, 0x8E, 0x00, 0x72, 0x4C,
  0xE0, 0x32, 0x66, 0xC4, 0x44, 0x20, 0xFF, 0xC0, 0x33, 0x33, 0x32, 0x6E,
  0x80, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 4, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 4, 0, -8 },
  { 16, 6, 7, 7, 1, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 2, 2, 1, -7 },
  { 29, 4, 9, 3, 0, -7 },
  { 34, 4, 9, 3, -1, -7 },
  { 39, 4, 5, 4, 1, -8 },
  { 42, 5, 5, 5, 0, -6 },
  { 46, 3, 2, 2, -1, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 2, 2, 2, 0, -2 },
  { 49, 6, 7, 4, -1, -7 },
  { 55, 5, 7, 4, 0, -7 },
  { 60, 3, 7, 5, 1, -7 },
  { 63, 5, 7, 4, 0, -7 },
  { 68, 5, 7, 4, 0, -7 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 5, 7, 4, 0, -7 },
  { 83, 5, 7, 4, 0, -7 },
  { 88, 5, 7, 4, 0, -7 },
  { 93, 5, 7, 4, 0, -7 },
  { 98, 5, 7, 4, 0, -7 },
  { 103, 3, 6, 3, 0, -6 },
  { 106, 4, 7, 3, -1, -6 },
  { 110, 5, 5, 5, 0, -6 },
  { 114, 5, 3, 5, 0, -5 },
  { 116, 5, 5, 5, 0, -6 },
  { 120, 4, 7, 4, 0, -7 },
  { 124, 7, 8, 7, 0, -7 },
  { 131, 5, 7, 5, -1, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 5, 7, 5, 0, -7 },
  { 146, 5, 7, 5, 0, -7 },
  { 151, 5, 7, 4, 0, -7 },
  { 156, 5, 7, 4, 0, -7 },
  { 161, 6, 7, 5, 0, -7 },
  { 167, 6, 7, 5, 0, -7 },
  { 173, 4, 7, 3, 0, -7 },
  { 177, 5, 9, 3, -2, -7 },
  { 183, 6, 7, 5, 0, -7 },
  { 189, 3, 7, 4, 0, -7 },
  { 192, 8, 7, 7, 0, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 6, 7, 6, 0, -7 },
  { 211, 5, 7, 5, 0, -7 },
  { 216, 6, 9, 6, 0, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 5, 7, 4, 0, -7 },
  { 233, 4, 7, 4, 1, -7 },
  { 237, 6, 7, 5, 0, -7 },
  { 243, 5, 7, 5, 1, -7 },
  { 248, 7, 7, 7, 1, -7 },
  { 255, 6, 7, 5, -1, -7 },
  { 261, 4, 7, 5, 1, -7 },
  { 265, 5, 7, 4, 0, -7 },
  { 270, 4, 9, 3, 0, -7 },
  { 275, 2, 7, 4, 1, -7 },
  { 277, 4, 9, 3, -1, -7 },
  { 282, 5, 4, 4, 0, -7 },
  { 285, 4, 1, 4, -1, 1 },
  { 286, 2, 2, 3, 1, -8 },
  { 287, 5, 6, 5, 0, -6 },
  { 291, 5, 8, 5, 0, -8 },
  { 296, 4, 6, 4, 0, -6 },
  { 299, 5, 8, 5, 0, -8 },
  { 304, 4, 6, 4, 0, -6 },
  { 307, 5, 10, 3, -1, -8 },
  { 314, 5, 8, 5, 0, -6 },
  { 319, 5, 8, 5, 0, -8 },
  { 324, 3, 8, 2, 0, -8 },
  { 327, 4, 10, 2, -1, -8 },
  { 332, 5, 8, 5, 0, -8 },
  { 337, 3, 8, 2, 0, -8 },
  { 340, 7, 6, 7, 0, -6 },
  { 346, 5, 6, 5, 0, -6 },
  { 350, 4, 6, 5, 0, -6 },
  { 353, 6, 8, 5, -1, -6 },
  { 359, 5, 8, 5, 0, -6 },
  { 364, 4, 6, 3, 0, -6 },
  { 367, 4, 6, 4, 0, -6 },
  { 370, 3, 7, 3, 0, -7 },
  { 373, 5, 5, 5, 0, -5 },
  { 377, 4, 5, 4, 1, -5 },
  { 380, 6, 5, 6, 1, -5 },
  { 384, 6, 5, 4, -1, -5 },
  { 388, 6, 7, 4, -1, -5 },
  { 394, 4, 5, 4, 0, -5 },
  { 397, 4, 9, 3, 0, -7 },
  { 402, 1, 10, 4, 1, -8 },
  { 404, 4, 9, 3, -1, -7 },
  { 409, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC10PT7B_H_
