#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x00, 0x7E, 0xFD, 0xF3, 0xF7, 0xCF, 0xBF, 0x3E, 0xF8, 0xFB,
  0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xF3, 0xC7, 0x80, 0x00, 0x79, 0xF0,
  0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x1E, 0x00, 0xF1,
  0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xE3, 0x80, 0x1E,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F,
  0xB3, 0x03, 0xC8, 0x01, 0xF6, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x02, 0xF8, 0x41, 0xBE, 0x18, 0x6F, 0x87, 0x9F, 0xE1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x1E, 0x07, 0xF8, 0x1E,
  0x07, 0xFC, 0x0F, 0x03, 0xDE, 0x0F, 0x03, 0xC7, 0x0F, 0x81, 0xE7, 0x87,
  0x80, 0xF3, 0xC7, 0xC0, 0xF1, 0xE3, 0xC0, 0x78, 0xF3, 0xC0, 0x3C, 0x79,
  0xE0, 0x1E, 0x79, 0xE1, 0x8F, 0x3C, 0xF3, 0xF7, 0xBE, 0xF3, 0xFF, 0xFE,
  0x7B, 0xFE, 0xFE, 0x79, 0xEF, 0x7E, 0x7D, 0xE7, 0x84, 0x3C, 0xF3, 0xC0,
  0x3C, 0x79, 0xE0, 0x1E, 0x78, 0xF0, 0x1E, 0x3C, 0x78, 0x0F, 0x1E, 0x3C,
  0x0F, 0x0F, 0x3C, 0x07, 0x87, 0x9E, 0x07, 0x83, 0xDE, 0x07, 0xC1, 0xFF,
  0x03, 0xC0, 0x7F, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x8F, 0x87, 0xFC, 0xFC, 0x7F, 0xE7, 0xC7, 0xFF,
  0xFE, 0x7E, 0xFF, 0xE3, 0xE7, 0xFF, 0x3F, 0x1F, 0xF1, 0xF8, 0xFF, 0x8F,
  0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xFB, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xF3, 0xF8, 0x7E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E,
  0x7C, 0xF1, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x03, 0x1E, 0x07, 0xBC, 0x5F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFF, 0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0x83, 0xFF, 0x0F, 0xDF, 0x07,
  0x9F, 0x06, 0x3C, 0x08, 0x60, 0x00, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x8F, 0x87,
  0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x7F, 0xEF, 0xFD,
  0xFF, 0x3F, 0xEF, 0xFC, 0x3D, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8,
  0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3,
  0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0xEF, 0xC3, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x78, 0xFC, 0x08, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xEF, 0xF0, 0x40, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x09, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x88, 0x0F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E,
  0x07, 0x9F, 0x83, 0xC7, 0xC0, 0xF1, 0xF0, 0x78, 0x7C, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xCF, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x30, 0x3F, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0x88, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x9E, 0x07, 0xDF, 0x87, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0xFE, 0x3E, 0x7E, 0x3F, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xF3, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x0F, 0x9F, 0x87, 0xE3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE3, 0xF1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7E, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0xC7,
  0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF9, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xDF, 0x0F, 0xDF, 0x81, 0x8F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE1, 0xCF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F,
  0xFC, 0x73, 0xF1, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7E, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x1C, 0x3C, 0x3F, 0xCF, 0x1E, 0x3F, 0xE7, 0x9E, 0x3F, 0xF3,
  0xCF, 0x3C, 0x71, 0xEF, 0x1E, 0x78, 0xE7, 0x9E, 0x3C, 0x73, 0x8F, 0x1E,
  0x3B, 0xC7, 0x0F, 0x3D, 0xE7, 0x8F, 0x1E, 0xF3, 0xC7, 0x8E, 0x79, 0xE3,
  0xCF, 0x3C, 0xF3, 0xE7, 0x1C, 0x7F, 0xFF, 0x8E, 0x3F, 0xBF, 0x87, 0x8F,
  0x9F, 0x83, 0xC3, 0x87, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x40, 0x0F, 0xC7, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFF,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x7E, 0x7F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F,
  0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xEF, 0x03, 0xF0, 0x40, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x82, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0x87, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xBE, 0x0F, 0xE0, 0x41, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0xE7, 0xE3, 0xFE, 0x7E,
  0x3F, 0xC7, 0xE3, 0xFC, 0x7C, 0x7F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F,
  0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x07, 0xDE, 0x3F, 0xF0, 0x3E, 0xF1, 0xFF, 0x81,
  0xF7, 0x9F, 0x7C, 0x0F, 0xBC, 0xFF, 0xE0, 0x7D, 0xE7, 0xBF, 0x07, 0xCF,
  0x7D, 0xF0, 0x3E, 0x7B, 0xCF, 0x81, 0xF3, 0xFE, 0xFC, 0x0F, 0x9F, 0xE7,
  0xE0, 0xFC, 0xFF, 0x3E, 0x07, 0xC7, 0xF9, 0xF0, 0x3E, 0x3F, 0x8F, 0x81,
  0xF1, 0xFC, 0xFC, 0x0F, 0x8F, 0xC7, 0xE0, 0xFC, 0x7E, 0x3E, 0x07, 0xC3,
  0xE1, 0xF0, 0x3E, 0x1F, 0x1F, 0x80, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x7C,
  0x1F, 0xC0, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x87, 0xE1, 0xFF, 0x0F, 0x83,
  0xFE, 0x1F, 0x07, 0xFC, 0x3E, 0x0F, 0xF8, 0xFC, 0x1E, 0xF1, 0xF0, 0x7D,
  0xF3, 0xE0, 0xFB, 0xE7, 0xC1, 0xF7, 0xCF, 0x83, 0xEF, 0xBF, 0x07, 0xDF,
  0x7C, 0x1F, 0x1E, 0xF8, 0x3E, 0x3F, 0xF0, 0x7C, 0x7F, 0xE0, 0xF8, 0xFF,
  0xC3, 0xF1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8,
  0x3E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0x3F, 0x83, 0xE0, 0x7F, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x7E, 0x3F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x83, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF8, 0x60, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x80,
  0xFC, 0x1C, 0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE1,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x07, 0xFF,
  0x81, 0xFB, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F,
  0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E,
  0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0x03, 0xFF, 0xC1, 0xF0, 0x3E, 0xFC, 0x1F, 0x07,
  0xEF, 0xC3, 0xF0, 0x7C, 0xFC, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0xFC, 0xF8,
  0x7F, 0x0F, 0x8F, 0x87, 0xF1, 0xF8, 0xF8, 0xFF, 0x1F, 0x0F, 0x8F, 0xF1,
  0xF0, 0xF8, 0xFF, 0x3F, 0x0F, 0x9F, 0xF3, 0xE0, 0xF9, 0xEF, 0x7E, 0x0F,
  0xBF, 0xF7, 0xE0, 0xFB, 0xFF, 0x7C, 0x0F, 0xBD, 0xFF, 0xC0, 0xFF, 0xDF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x0F, 0xF9, 0xFF, 0x00,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xDF, 0x07, 0xE7,
  0xC1, 0xF1, 0xF0, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xEF, 0xC0, 0xFB,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x1F, 0x1F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x07, 0xCF, 0x03, 0xC7, 0xC3, 0xE3,
  0xE3, 0xE1, 0xF1, 0xF0, 0x79, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F,
  0x07, 0xC7, 0x87, 0xF7, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xF1,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFD, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xDF, 0x07, 0xC7, 0x80, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x9E, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFD,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x87, 0xE7, 0xC3, 0xF7, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C,
  0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFB, 0x87, 0xE1, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x10, 0xFC, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xCF,
  0x81, 0xFD, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7C, 0x7E,
  0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC7, 0xE0,
  0xFD, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xBC, 0x07, 0xE7, 0x80,
  0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xF3, 0xE7, 0xC3, 0xDF,
  0x8F, 0xBE, 0x1F, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x11, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF9, 0xE0, 0x7F, 0x7C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC,
  0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF1,
  0xF8, 0x3F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFB,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x80, 0xFC, 0x1F, 0x7F,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87,
  0xC0, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x3E, 0x0F,
  0xCF, 0xC1, 0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xDF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xBF, 0x03, 0xE7, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x0F, 0x3F,
  0x1F, 0x03, 0xDF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3E,
  0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0xFC,
  0x7C, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0x1F, 0x07, 0xBF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F,
  0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xE3, 0xF3, 0xF1,
  0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F,
  0x0F, 0x8F, 0x87, 0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFF, 0x3E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC,
  0xFD, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x03, 0xC7,
  0x80, 0x7B, 0xF8, 0x0F, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x87, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C,
  0x1F, 0x9F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x7F, 0x03, 0xE7, 0xC0,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE7,
  0x87, 0xF7, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xF1, 0xF9, 0xF8,
  0xFC, 0xF8, 0x7E, 0x7C, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFD, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x3E, 0x1E, 0xF8, 0x3D, 0xF0, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xE3, 0xF1, 0x87, 0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x41, 0xF8,
  0xE7, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0xF3, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE3,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x8F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80,
  0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xCF, 0xC7, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFD, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xEF, 0x07, 0xE7, 0x80, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3E, 0xFC, 0x7E, 0xFC, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7D, 0xF0, 0x79, 0xF0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0xF8, 0xFE, 0x3F,
  0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x3E, 0xF9, 0xFE, 0x7C, 0xF9, 0xFE, 0x7C,
  0xF9, 0xFE, 0xFC, 0xFB, 0xDE, 0xF8, 0xFB, 0xDE, 0xF8, 0xFB, 0xDF, 0xF0,
  0xFF, 0x9F, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xE0,
  0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x3E,
  0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3C,
  0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xBF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFA, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 14, 10, 16, 4, -27 },
  { 57, 20, 27, 19, 0, -27 },
  { 125, 18, 31, 17, 0, -29 },
  { 195, 25, 28, 28, 2, -28 },
  { 283, 21, 27, 21, 0, -27 },
  { 354, 7, 10, 9, 4, -27 },
  { 363, 14, 34, 10, 0, -28 },
  { 423, 13, 34, 11, -3, -28 },
  { 479, 15, 17, 16, 3, -29 },
  { 511, 16, 19, 18, 2, -23 },
  { 549, 9, 10, 9, -2, -5 },
  { 561, 11, 5, 11, 0, -13 },
  { 568, 6, 6, 9, 0, -6 },
  { 573, 20, 27, 15, -2, -27 },
  { 641, 16, 28, 17, 1, -28 },
  { 697, 14, 27, 17, 3, -27 },
  { 745, 18, 28, 17, -1, -28 },
  { 808, 18, 28, 17, 0, -28 },
  { 871, 18, 27, 17, 0, -27 },
  { 932, 18, 27, 17, 0, -27 },
  { 993, 17, 28, 17, 1, -28 },
  { 1053, 18, 27, 17, 1, -27 },
  { 1114, 18, 28, 17, 0, -28 },
  { 1177, 17, 28, 17, 0, -28 },
  { 1237, 10, 21, 10, 0, -21 },
  { 1264, 12, 26, 10, -2, -21 },
  { 1303, 17, 19, 18, 1, -23 },
  { 1344, 16, 13, 18, 2, -20 },
  { 1370, 16, 19, 18, 2, -23 },
  { 1408, 14, 28, 13, 1, -28 },
  { 1457, 25, 30, 26, 1, -27 },
  { 1551, 19, 27, 19, -2, -27 },
  { 1616, 19, 27, 19, 0, -27 },
  { 1681, 19, 28, 17, 1, -28 },
  { 1748, 20, 27, 20, 0, -27 },
  { 1816, 17, 27, 16, 0, -27 },
  { 1874, 17, 27, 15, 0, -27 },
  { 1932, 20, 28, 20, 1, -28 },
  { 2002, 22, 27, 21, 0, -27 },
  { 2077, 18, 27, 13, -2, -27 },
  { 2138, 17, 35, 10, -6, -27 },
  { 2213, 22, 27, 18, 0, -27 },
  { 2288, 13, 27, 15, 0, -27 },
  { 2332, 29, 27, 27, 0, -27 },
  { 2430, 23, 27, 22, 0, -27 },
  { 2508, 20, 28, 21, 1, -28 },
  { 2578, 19, 27, 18, 0, -27 },
  { 2643, 20, 34, 21, 1, -28 },
  { 2728, 19, 27, 18, 0, -27 },
  { 2793, 19, 28, 16, -1, -28 },
  { 2860, 16, 27, 16, 3, -27 },
  { 2914, 21, 27, 20, 1, -27 },
  { 2985, 19, 27, 19, 3, -27 },
  { 3050, 28, 27, 27, 3, -27 },
  { 3145, 23, 27, 18, -2, -27 },
  { 3223, 18, 27, 17, 3, -27 },
  { 3284, 20, 27, 16, -2, -27 },
  { 3352, 16, 34, 11, -2, -28 },
  { 3420, 8, 27, 15, 4, -27 },
  { 3447, 16, 34, 11, -3, -28 },
  { 3515, 17, 17, 17, 0, -27 },
  { 3552, 14, 3, 13, -4, 3 },
  { 3558, 8, 6, 12, 5, -29 },
  { 3564, 17, 21, 18, 1, -21 },
  { 3609, 17, 29, 18, 0, -29 },
  { 3671, 15, 21, 14, 1, -21 },
  { 3711, 19, 29, 18, 1, -29 },
  { 3780, 15, 21, 17, 1, -21 },
  { 3820, 19, 38, 11, -4, -29 },
  { 3911, 19, 30, 18, -1, -21 },
  { 3983, 17, 29, 18, 0, -29 },
  { 4045, 11, 29, 9, 0, -29 },
  { 4085, 16, 38, 9, -5, -29 },
  { 4161, 19, 29, 17, 0, -29 },
  { 4230, 11, 29, 9, 0, -29 },
  { 4270, 26, 21, 26, 0, -21 },
  { 4339, 17, 21, 18, 0, -21 },
  { 4384, 16, 21, 18, 1, -21 },
  { 4426, 19, 30, 18, -2, -21 },
  { 4498, 17, 30, 18, 1, -21 },
  { 4562, 15, 21, 13, 0, -21 },
  { 4602, 15, 21, 14, 0, -21 },
  { 4642, 12, 25, 12, 1, -25 },
  { 4680, 17, 21, 18, 1, -21 },
  { 4725, 16, 21, 16, 2, -21 },
  { 4767, 24, 21, 24, 2, -21 },
  { 4830, 20, 21, 16, -2, -21 },
  { 4883, 21, 30, 16, -3, -21 },
  { 4962, 17, 21, 14, -2, -21 },
  { 5007, 16, 33, 13, 0, -27 },
  { 5073, 4, 38, 15, 5, -29 },
  { 5092, 15, 33, 13, -2, -27 },
  { 5154, 17, 7, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC38PT7B_H_
