#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x03, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x9F, 0xC7, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x78,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7E, 0xC7, 0x03, 0xF3, 0x08, 0x0F, 0xCC, 0x00, 0x3F, 0xB0, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x67, 0xE1, 0x01, 0x9F, 0x86, 0x06, 0x7E, 0x1E, 0x1B,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x03, 0xE0, 0x0F, 0xFC, 0x07, 0xC0,
  0x1F, 0xFE, 0x07, 0xC0, 0x1F, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x1F, 0x80,
  0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0xF8, 0x00,
  0xF8, 0xF8, 0xF8, 0x20, 0xF8, 0xF9, 0xF1, 0xFC, 0x78, 0xFB, 0xF3, 0xFE,
  0x7F, 0xF3, 0xE7, 0xFE, 0x7F, 0xF7, 0xEF, 0xFF, 0x7F, 0xE7, 0xCF, 0x9F,
  0x3F, 0xCF, 0x9F, 0x1F, 0x1F, 0x0F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x3E,
  0x00, 0x7C, 0x3E, 0x3E, 0x00, 0xFC, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x7C,
  0x01, 0xF0, 0x3E, 0x7C, 0x01, 0xF0, 0x3E, 0xFC, 0x03, 0xE0, 0x3F, 0xF8,
  0x03, 0xE0, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xC1, 0xFF, 0xC7, 0xE0, 0xFF,
  0xF3, 0xF8, 0x7F, 0xFE, 0xFE, 0x3F, 0xBF, 0xFF, 0x1F, 0xCF, 0xFF, 0xC7,
  0xF3, 0xFF, 0xE1, 0xF8, 0x7F, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0x83, 0xFE,
  0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFE, 0x07,
  0xFC, 0x7F, 0x80, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x03,
  0x0F, 0x80, 0x79, 0xF0, 0x5F, 0xFE, 0x73, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFD, 0xF8, 0x3F, 0x3F, 0x03, 0xC7, 0xF0, 0x38, 0x78, 0x02,
  0x0C, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0x3F, 0xF9, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xFB, 0xFF, 0xC0, 0x0C, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0xFE, 0x3F,
  0x0F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x3F, 0x87,
  0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7E, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x8F, 0xDF, 0xC3, 0xCF, 0xC0, 0x8F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7E, 0x7F, 0x80, 0xF0, 0x7F, 0x00, 0xC0, 0xFE, 0x01, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3C, 0x3F, 0xC0, 0x40, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x08, 0x01, 0xFC, 0x30, 0x0F,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0xFE, 0x00, 0x79,
  0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F,
  0x80, 0xF8, 0x7F, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC4,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xEC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xE3, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x08, 0x03, 0xFC, 0x38, 0x1F,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0xFE, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F,
  0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFF,
  0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xDF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0x7E, 0x03,
  0xF7, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0x3F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07,
  0xC0, 0x10, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xC1, 0xFC, 0x20, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x07, 0xFC, 0x7C, 0x3E,
  0x1F, 0xFC, 0xF8, 0xF8, 0x7F, 0xF9, 0xF1, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7,
  0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x8F, 0x1E, 0x3E, 0x1F, 0x1E, 0x7C, 0x7C,
  0x3C, 0x3C, 0xF8, 0xF0, 0xF8, 0x79, 0xE3, 0xE1, 0xF1, 0xF3, 0xC7, 0xC3,
  0xE3, 0xCF, 0x8F, 0x87, 0x87, 0x9F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3C, 0x3E,
  0x3C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xFB, 0xFB, 0xE1, 0xF1, 0xFF, 0xFF,
  0xC3, 0xE3, 0xFD, 0xFF, 0x07, 0xC3, 0xF1, 0xFC, 0x0F, 0x80, 0xC0, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x18, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xCF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF8,
  0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x87, 0x03, 0xFC, 0x08, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F,
  0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFE, 0x0F, 0xE3,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x70, 0x1F, 0xF0, 0x08, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xF8, 0xFF,
  0x0F, 0xFC, 0x7F, 0x8F, 0xFE, 0x3F, 0x87, 0xFF, 0x1F, 0xC3, 0xFF, 0x0F,
  0xE1, 0xFF, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x87, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0,
  0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xF7,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xBE, 0x1F,
  0xFF, 0x03, 0xF7, 0xC3, 0xFF, 0xC0, 0x7E, 0xF8, 0xFD, 0xF8, 0x0F, 0xDF,
  0x1F, 0xFF, 0x03, 0xFB, 0xE7, 0xEF, 0xE0, 0x7F, 0x7C, 0xFD, 0xFC, 0x0F,
  0xCF, 0x9F, 0x3F, 0x01, 0xF9, 0xF7, 0xEF, 0xE0, 0x7F, 0x3E, 0xF9, 0xFC,
  0x0F, 0xE7, 0xFF, 0x3F, 0x81, 0xF8, 0xFF, 0xE7, 0xE0, 0x3F, 0x1F, 0xF8,
  0xFC, 0x07, 0xE3, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xF8, 0xFE, 0x07, 0xE1, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0xC3, 0xF0, 0x1F,
  0x87, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x01,
  0xFF, 0x01, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0, 0xFF, 0xE0, 0xFE, 0x07, 0xFF,
  0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0x01, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE, 0x1F,
  0xC0, 0xFD, 0xF8, 0xFC, 0x07, 0xEF, 0xC7, 0xE0, 0x3F, 0x7E, 0x3F, 0x01,
  0xFB, 0xF3, 0xF8, 0x0F, 0xDF, 0x9F, 0xC0, 0xFE, 0xFE, 0xFC, 0x07, 0xE3,
  0xF7, 0xE0, 0x3F, 0x1F, 0xBF, 0x01, 0xF8, 0xFD, 0xF8, 0x1F, 0xC7, 0xFF,
  0xC0, 0xFE, 0x3F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0x01,
  0xF8, 0x3F, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0xFE, 0x0F, 0xFC, 0x07, 0xE0,
  0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFB, 0xFF,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x0F, 0xE3, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF3,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0xFE,
  0x0F, 0xF1, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xBE, 0x03, 0xFC, 0x0C, 0x07, 0xF0, 0x08, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x80, 0x1F, 0xC1, 0x80, 0x7F, 0x83, 0xC1,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF9,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0x01, 0xFD, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0xC1, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F,
  0x0F, 0xC1, 0xFF, 0x0F, 0xE1, 0xF8, 0x7F, 0xE3, 0xF8, 0x3F, 0x0F, 0xFC,
  0x7F, 0x07, 0xE3, 0xFF, 0x8F, 0xC0, 0xFC, 0x7F, 0xF3, 0xF8, 0x1F, 0x8F,
  0xFC, 0x7F, 0x03, 0xF3, 0xFF, 0x8F, 0xC0, 0x7E, 0x7D, 0xF3, 0xF8, 0x0F,
  0xDF, 0xBE, 0x7F, 0x01, 0xFB, 0xF7, 0xDF, 0xC0, 0x3F, 0x7C, 0xFB, 0xF8,
  0x07, 0xFF, 0x9F, 0x7E, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F,
  0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xC7, 0xC0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x7F, 0x9F, 0xCF, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0xF7, 0xE0, 0x7F, 0xDF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x7F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xE0, 0x7F, 0x9F, 0x80, 0xFC, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x7E, 0x01, 0xFB, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF9, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xDF,
  0xF0, 0x3E, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFC, 0x10, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x30, 0xFF, 0x3C, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF9, 0xFC,
  0x03, 0xFD, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xDF, 0x80,
  0x3F, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0x8F, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07,
  0xEF, 0xE1, 0xFD, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x8F, 0xE0, 0x61, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x7E, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x3F,
  0x8F, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x80, 0x3F, 0x80, 0xF8,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x0F, 0xDF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0x8F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8,
  0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1,
  0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0xFF, 0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F,
  0xFF, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0xFC,
  0x07, 0xCF, 0xF3, 0xFE, 0x07, 0xDF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F,
  0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E,
  0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE,
  0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x87, 0xF0, 0x07, 0xC7, 0xE0, 0x3E, 0x7F, 0x81, 0xF7, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xE3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F,
  0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE3, 0xFC, 0xFF, 0x7F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xFE,
  0x00, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xBF, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x0F, 0xF3, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xBF, 0x80, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x3F, 0x7E,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF1, 0xC1, 0xFC, 0x10, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE2, 0x03, 0xF8, 0xF3,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0xF3,
  0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF9, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x3F,
  0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0,
  0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x8F, 0xE0, 0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xDF, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x07, 0xFF, 0xC0,
  0xFE, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x7F, 0x87,
  0xF3, 0xF0, 0xFF, 0x0F, 0xC7, 0xE3, 0xFE, 0x1F, 0x8F, 0xC7, 0xFC, 0x7F,
  0x1F, 0x8F, 0xF8, 0xFC, 0x3F, 0x3F, 0xF1, 0xF8, 0x7E, 0x7F, 0xE7, 0xE0,
  0xFC, 0xFF, 0xCF, 0xC1, 0xFB, 0xEF, 0xBF, 0x83, 0xF7, 0xDF, 0x7E, 0x07,
  0xFF, 0xBE, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3E,
  0xFB, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0xFF,
  0x03, 0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xF8,
  0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0x8F, 0xC0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x80, 0x07,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 35, 12, 0, -34 },
  { 63, 18, 13, 20, 4, -34 },
  { 93, 25, 34, 24, 0, -34 },
  { 200, 22, 39, 21, 0, -36 },
  { 308, 32, 34, 35, 2, -34 },
  { 444, 26, 34, 26, 0, -34 },
  { 555, 9, 13, 11, 4, -34 },
  { 570, 16, 41, 13, 1, -34 },
  { 652, 16, 41, 13, -4, -34 },
  { 734, 19, 21, 20, 3, -36 },
  { 784, 20, 23, 23, 2, -28 },
  { 842, 11, 13, 12, -3, -7 },
  { 860, 13, 7, 14, 0, -16 },
  { 872, 8, 9, 12, 0, -8 },
  { 881, 25, 34, 18, -3, -34 },
  { 988, 20, 34, 21, 1, -34 },
  { 1073, 17, 34, 21, 4, -34 },
  { 1146, 23, 34, 21, -2, -34 },
  { 1244, 22, 34, 21, 0, -34 },
  { 1338, 23, 34, 21, -1, -34 },
  { 1436, 22, 34, 21, 0, -34 },
  { 1530, 22, 34, 21, 1, -34 },
  { 1624, 23, 34, 21, 1, -34 },
  { 1722, 22, 34, 21, 0, -34 },
  { 1816, 21, 34, 21, 0, -34 },
  { 1906, 12, 27, 12, 0, -26 },
  { 1947, 15, 32, 12, -3, -26 },
  { 2007, 20, 23, 23, 2, -28 },
  { 2065, 20, 15, 23, 2, -24 },
  { 2103, 20, 23, 23, 2, -28 },
  { 2161, 18, 35, 17, 1, -34 },
  { 2240, 31, 38, 32, 1, -34 },
  { 2388, 24, 34, 23, -3, -34 },
  { 2490, 24, 34, 23, 0, -34 },
  { 2592, 22, 34, 21, 2, -34 },
  { 2686, 25, 34, 25, 0, -34 },
  { 2793, 21, 34, 19, 0, -34 },
  { 2883, 21, 34, 19, 0, -34 },
  { 2973, 25, 34, 25, 2, -34 },
  { 3080, 27, 34, 26, 0, -34 },
  { 3195, 22, 34, 16, -2, -34 },
  { 3289, 21, 44, 12, -7, -34 },
  { 3405, 27, 34, 23, 0, -34 },
  { 3520, 16, 34, 18, 0, -34 },
  { 3588, 35, 34, 34, 0, -34 },
  { 3737, 29, 34, 27, 0, -34 },
  { 3861, 24, 34, 26, 2, -34 },
  { 3963, 24, 34, 22, 0, -34 },
  { 4065, 24, 42, 26, 2, -34 },
  { 4191, 23, 34, 23, 0, -34 },
  { 4289, 23, 34, 20, -1, -34 },
  { 4387, 20, 34, 19, 3, -34 },
  { 4472, 25, 34, 25, 2, -34 },
  { 4579, 23, 34, 23, 4, -34 },
  { 4677, 35, 34, 34, 3, -34 },
  { 4826, 28, 34, 22, -3, -34 },
  { 4945, 22, 34, 21, 4, -34 },
  { 5039, 25, 34, 19, -2, -34 },
  { 5146, 19, 42, 13, -2, -34 },
  { 5246, 10, 34, 18, 5, -34 },
  { 5289, 20, 42, 13, -4, -34 },
  { 5394, 22, 22, 21, -1, -34 },
  { 5455, 18, 4, 17, -5, 4 },
  { 5464, 9, 8, 15, 7, -36 },
  { 5473, 22, 26, 22, 1, -26 },
  { 5545, 22, 36, 22, 0, -36 },
  { 5644, 18, 26, 18, 1, -26 },
  { 5703, 24, 36, 22, 1, -36 },
  { 5811, 19, 26, 21, 1, -26 },
  { 5873, 24, 47, 14, -5, -36 },
  { 6014, 24, 37, 22, -1, -26 },
  { 6125, 21, 36, 22, 0, -36 },
  { 6220, 14, 36, 11, 0, -36 },
  { 6283, 20, 47, 11, -6, -36 },
  { 6401, 24, 36, 21, 0, -36 },
  { 6509, 14, 36, 11, 0, -36 },
  { 6572, 32, 26, 33, 0, -26 },
  { 6676, 21, 26, 22, 0, -26 },
  { 6745, 20, 26, 22, 1, -26 },
  { 6810, 24, 37, 22, -3, -26 },
  { 6921, 22, 37, 22, 1, -26 },
  { 7023, 18, 26, 16, 0, -26 },
  { 7082, 18, 26, 17, 0, -26 },
  { 7141, 14, 31, 15, 2, -31 },
  { 7196, 22, 26, 22, 1, -26 },
  { 7268, 20, 26, 20, 3, -26 },
  { 7333, 31, 26, 30, 2, -26 },
  { 7434, 24, 26, 20, -2, -26 },
  { 7512, 26, 37, 20, -3, -26 },
  { 7633, 21, 26, 17, -2, -26 },
  { 7702, 19, 41, 16, 0, -34 },
  { 7800, 6, 47, 18, 6, -36 },
  { 7836, 19, 41, 16, -3, -34 },
  { 7934, 20, 9, 23, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC47PT7B_H_
