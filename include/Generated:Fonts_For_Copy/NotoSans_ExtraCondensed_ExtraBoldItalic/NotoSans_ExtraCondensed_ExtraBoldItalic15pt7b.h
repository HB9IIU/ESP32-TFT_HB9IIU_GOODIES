#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x66, 0x31, 0x80, 0x06, 0x30, 0x6D, 0xB6, 0xB6, 0x0B,
  0x1A, 0x16, 0x7F, 0x7F, 0x34, 0x2C, 0xFE, 0x68, 0x58, 0xD8, 0x08, 0x7C,
  0xF3, 0x47, 0x07, 0x87, 0x0E, 0xDD, 0xF0, 0x81, 0x00, 0x31, 0x9C, 0xCD,
  0x23, 0x58, 0xB4, 0xBB, 0xFF, 0xAC, 0x7B, 0x36, 0x89, 0xE6, 0x30, 0x1C,
  0x3E, 0x36, 0x36, 0x3C, 0x3B, 0x7B, 0xDE, 0xCE, 0xFE, 0x76, 0x6D, 0xE0,
  0x18, 0x8C, 0x66, 0x31, 0x98, 0xC6, 0x31, 0x8E, 0x00, 0x18, 0xC6, 0x31,
  0x8C, 0x66, 0x31, 0x98, 0xCC, 0x00, 0x20, 0xCF, 0x7F, 0x73, 0xE5, 0x80,
  0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x00, 0x76, 0x6C, 0xFF, 0xF8, 0x03, 0x06,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1C, 0x7C, 0xDB,
  0x36, 0x6D, 0xDB, 0x66, 0xCD, 0xF1, 0xC0, 0x0C, 0xE7, 0xBE, 0x58, 0xE3,
  0x0C, 0x30, 0xC6, 0x00, 0x0E, 0x3F, 0x17, 0x07, 0x06, 0x0E, 0x1C, 0x18,
  0x30, 0x7C, 0xFC, 0x1C, 0x7C, 0x98, 0x31, 0xC7, 0x07, 0x06, 0x1D, 0xF3,
  0xC0, 0x06, 0x1C, 0x70, 0xE3, 0xCD, 0x93, 0x7E, 0xFC, 0x30, 0x60, 0x3E,
  0x7C, 0xC1, 0x87, 0x8F, 0x83, 0x06, 0x9D, 0xF3, 0xC0, 0x0E, 0x3C, 0xC3,
  0x87, 0xCF, 0x9B, 0x76, 0xEC, 0xF9, 0xE0, 0x3F, 0x3E, 0x46, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1C, 0x7C, 0xDB, 0xB3, 0xC7, 0x1F,
  0x66, 0xCD, 0xF9, 0xE0, 0x1C, 0x7D, 0xDB, 0x36, 0xEF, 0xDF, 0x06, 0x19,
  0xF3, 0xC0, 0x77, 0x00, 0x00, 0xEC, 0x39, 0xC0, 0x00, 0x01, 0xCC, 0x66,
  0x00, 0x04, 0x77, 0xB0, 0xF0, 0xF0, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83,
  0x87, 0x87, 0x7B, 0x88, 0x00, 0x39, 0xF4, 0xC3, 0x18, 0xC6, 0x00, 0x01,
  0x8E, 0x00, 0x07, 0x07, 0x63, 0x0C, 0xBD, 0x6B, 0x56, 0x95, 0x2F, 0x5A,
  0xDF, 0xB0, 0x06, 0x20, 0xF8, 0x06, 0x0E, 0x0E, 0x1A, 0x1A, 0x3F, 0x37,
  0x3F, 0x7F, 0x67, 0xE7, 0x3C, 0x3E, 0x37, 0x36, 0x6E, 0x7C, 0x6E, 0x6E,
  0xEE, 0xFC, 0xF8, 0x1E, 0x79, 0xD7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xF3,
  0xE0, 0x3C, 0x3E, 0x37, 0x37, 0x77, 0x67, 0x66, 0x66, 0xEE, 0xFC, 0xF8,
  0x3E, 0x7C, 0xC1, 0x87, 0xCF, 0x98, 0x30, 0xE1, 0xF3, 0xE0, 0x3E, 0x7C,
  0xC1, 0x87, 0x0F, 0x9E, 0x30, 0xE1, 0x83, 0x00, 0x1E, 0x7D, 0xCF, 0x0C,
  0x1B, 0xF7, 0x66, 0xCD, 0xF9, 0xF0, 0x33, 0x99, 0x8C, 0xC6, 0x67, 0xF3,
  0xF9, 0x98, 0xCC, 0xE6, 0x63, 0x33, 0x80, 0x1E, 0x7C, 0x70, 0xC1, 0x83,
  0x06, 0x1C, 0x30, 0x63, 0xE0, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18,
  0xE3, 0x0C, 0xF3, 0x80, 0x33, 0x99, 0x8D, 0x87, 0xC6, 0xC3, 0xC1, 0xF0,
  0xD8, 0xEC, 0x66, 0x33, 0x00, 0x31, 0x8C, 0x67, 0x31, 0x8C, 0xE7, 0xFE,
  0x38, 0xE7, 0x1C, 0xE7, 0x9C, 0xF7, 0xBC, 0xF7, 0x9E, 0xB3, 0xF6, 0xFD,
  0xD9, 0xB3, 0x36, 0x00, 0x39, 0x9C, 0xCE, 0x67, 0x37, 0xB3, 0x79, 0xBC,
  0xDE, 0xEF, 0x67, 0x33, 0x80, 0x1C, 0x7D, 0x9F, 0x3C, 0x78, 0xF1, 0xE7,
  0xCD, 0xFB, 0xE0, 0x3C, 0x3E, 0x37, 0x37, 0x76, 0x7E, 0x7C, 0x60, 0xE0,
  0xC0, 0xC0, 0x1C, 0x7D, 0x9F, 0x3C, 0x78, 0xF1, 0xE7, 0xCD, 0xFB, 0xE1,
  0xC3, 0x83, 0x00, 0x3C, 0x7C, 0xD9, 0xB6, 0x6F, 0xDE, 0x3E, 0xED, 0x9B,
  0x30, 0x1C, 0x7D, 0xD3, 0x87, 0x07, 0x07, 0x0E, 0x9D, 0xF3, 0xC0, 0x7F,
  0xF3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x8C, 0x00, 0x67, 0x66, 0x66, 0xE6,
  0xEE, 0xCC, 0xCC, 0xCC, 0xDC, 0xF8, 0xF0, 0xE7, 0xE6, 0xEE, 0xEC, 0xEC,
  0xD8, 0xD8, 0xD8, 0x70, 0x70, 0x60, 0xC6, 0x79, 0xDF, 0x3B, 0x67, 0x6D,
  0xDD, 0xBB, 0x3D, 0x67, 0xB8, 0xE7, 0x1C, 0xE3, 0x98, 0x00, 0x19, 0x8D,
  0x86, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3E, 0x33, 0x39, 0x80, 0xE6,
  0xD9, 0xB3, 0xC7, 0x8E, 0x1C, 0x30, 0x60, 0xC3, 0x80, 0x1F, 0x3F, 0x06,
  0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x7C, 0xFC, 0x1C, 0x71, 0x8C, 0x30,
  0xC3, 0x0C, 0x61, 0x86, 0x18, 0xF0, 0xC6, 0x66, 0x66, 0x66, 0x23, 0x30,
  0x1C, 0xF0, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0xE0, 0x08, 0x38,
  0x71, 0xE6, 0xCC, 0xB1, 0x80, 0xFF, 0xC0, 0xEC, 0x3E, 0xFD, 0xBB, 0x6E,
  0xD9, 0xBF, 0x36, 0x30, 0x60, 0xC3, 0xF7, 0xEC, 0xD9, 0xB7, 0xED, 0xFB,
  0xE0, 0x3D, 0xD6, 0x18, 0xE3, 0x8F, 0x9E, 0x03, 0x07, 0x06, 0x3E, 0x7E,
  0x6E, 0x6C, 0xEC, 0xCC, 0xFC, 0x6C, 0x3D, 0xB6, 0xFF, 0xF3, 0x0F, 0x9E,
  0x07, 0x0D, 0x0C, 0x1E, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x30, 0xE0, 0xC0, 0x3E, 0xFD, 0xBB, 0x6E, 0xD9, 0xBF, 0x36, 0x19, 0x33,
  0xE3, 0x00, 0x30, 0x60, 0xC3, 0x77, 0xEC, 0xDB, 0x36, 0xED, 0x9B, 0x70,
  0x13, 0x30, 0x76, 0x66, 0x6E, 0xCC, 0x04, 0x30, 0xC0, 0x1C, 0x61, 0x86,
  0x18, 0xE3, 0x0C, 0x31, 0xCE, 0x30, 0x30, 0x30, 0x31, 0x76, 0x6C, 0x78,
  0x78, 0x78, 0xF8, 0xDC, 0xCC, 0x33, 0x37, 0x66, 0x66, 0xEC, 0xC0, 0x7F,
  0xDF, 0xB6, 0xED, 0xB3, 0x6C, 0xF3, 0x6C, 0xDB, 0x76, 0x6E, 0xFD, 0x9B,
  0x66, 0xD9, 0xB3, 0x6E, 0x3C, 0xFD, 0x9B, 0x7C, 0xD9, 0xBF, 0x3C, 0x37,
  0x3F, 0x33, 0x33, 0x37, 0x76, 0x7E, 0x7C, 0x60, 0x60, 0xC0, 0xC0, 0x3E,
  0xFD, 0xBB, 0x6C, 0xD9, 0xBF, 0x36, 0x18, 0x30, 0x60, 0xC0, 0x6D, 0xE6,
  0x18, 0x63, 0x8C, 0x30, 0x7D, 0xA6, 0x1C, 0x38, 0x6F, 0xBC, 0x26, 0xFF,
  0xCC, 0xCC, 0xEE, 0x76, 0xCD, 0x9B, 0x66, 0xD9, 0xBF, 0x36, 0xCF, 0x6D,
  0xBC, 0xF3, 0xCE, 0x38, 0xDD, 0xEE, 0xFF, 0xDF, 0xEE, 0xF7, 0x73, 0xB9,
  0x98, 0x37, 0x3E, 0x1C, 0x1C, 0x3C, 0x3C, 0x6C, 0xEC, 0x33, 0x36, 0x36,
  0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0x30, 0xE0, 0xC0, 0x3E, 0x78, 0x30,
  0xC3, 0x0E, 0x1F, 0x7C, 0x0C, 0x71, 0x8E, 0x30, 0xCE, 0x38, 0x61, 0x86,
  0x18, 0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xE1, 0x86, 0x18, 0x61, 0xCF,
  0x30, 0xC3, 0x18, 0xE0, 0x47, 0xFB, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 6, 4, 6, 1, -11 },
  { 11, 8, 11, 8, 0, -11 },
  { 22, 7, 12, 7, 0, -11 },
  { 33, 10, 11, 11, 1, -11 },
  { 47, 8, 11, 8, 0, -11 },
  { 58, 3, 4, 4, 1, -11 },
  { 60, 5, 13, 4, 0, -11 },
  { 69, 5, 13, 4, -1, -11 },
  { 78, 6, 7, 6, 1, -12 },
  { 84, 6, 7, 7, 1, -9 },
  { 90, 4, 4, 4, -1, -2 },
  { 92, 4, 2, 4, 0, -5 },
  { 93, 3, 2, 4, 0, -2 },
  { 94, 8, 11, 6, -1, -11 },
  { 105, 7, 11, 7, 0, -11 },
  { 115, 6, 11, 7, 1, -11 },
  { 124, 8, 11, 7, -1, -11 },
  { 135, 7, 11, 7, 0, -11 },
  { 145, 7, 11, 7, 0, -11 },
  { 155, 7, 11, 7, 0, -11 },
  { 165, 7, 11, 7, 0, -11 },
  { 175, 8, 11, 7, 0, -11 },
  { 186, 7, 11, 7, 0, -11 },
  { 196, 7, 11, 7, 0, -11 },
  { 206, 4, 8, 4, 0, -8 },
  { 210, 5, 10, 4, -1, -8 },
  { 217, 6, 7, 7, 1, -9 },
  { 223, 6, 5, 7, 1, -8 },
  { 227, 6, 7, 7, 1, -9 },
  { 233, 6, 11, 5, 0, -11 },
  { 242, 10, 12, 10, 0, -11 },
  { 257, 8, 11, 7, -1, -11 },
  { 268, 8, 11, 7, 0, -11 },
  { 279, 7, 11, 7, 1, -11 },
  { 289, 8, 11, 8, 0, -11 },
  { 300, 7, 11, 6, 0, -11 },
  { 310, 7, 11, 6, 0, -11 },
  { 320, 7, 11, 8, 1, -11 },
  { 330, 9, 11, 8, 0, -11 },
  { 343, 7, 11, 5, -1, -11 },
  { 353, 6, 14, 4, -2, -11 },
  { 364, 9, 11, 7, 0, -11 },
  { 377, 5, 11, 6, 0, -11 },
  { 384, 11, 11, 11, 0, -11 },
  { 400, 9, 11, 9, 0, -11 },
  { 413, 7, 11, 8, 1, -11 },
  { 423, 8, 11, 7, 0, -11 },
  { 434, 7, 14, 8, 1, -11 },
  { 447, 7, 11, 7, 0, -11 },
  { 457, 7, 11, 6, 0, -11 },
  { 467, 6, 11, 6, 1, -11 },
  { 476, 8, 11, 8, 1, -11 },
  { 487, 8, 11, 7, 1, -11 },
  { 498, 11, 11, 11, 1, -11 },
  { 514, 9, 11, 7, -1, -11 },
  { 527, 7, 11, 7, 1, -11 },
  { 537, 8, 11, 6, -1, -11 },
  { 548, 6, 13, 4, -1, -11 },
  { 558, 4, 11, 6, 1, -11 },
  { 564, 6, 13, 4, -1, -11 },
  { 574, 7, 7, 7, 0, -11 },
  { 581, 5, 2, 5, -1, 1 },
  { 583, 3, 2, 5, 2, -11 },
  { 584, 7, 8, 7, 0, -8 },
  { 591, 7, 11, 7, 0, -11 },
  { 601, 6, 8, 6, 0, -8 },
  { 607, 8, 11, 7, 0, -11 },
  { 618, 6, 8, 7, 0, -8 },
  { 624, 8, 15, 4, -2, -11 },
  { 639, 7, 12, 7, 0, -8 },
  { 650, 7, 11, 7, 0, -11 },
  { 660, 4, 12, 4, 0, -12 },
  { 666, 6, 16, 4, -2, -12 },
  { 678, 8, 11, 7, 0, -11 },
  { 689, 4, 11, 4, 0, -11 },
  { 695, 10, 8, 10, 0, -8 },
  { 705, 7, 8, 7, 0, -8 },
  { 712, 7, 8, 7, 0, -8 },
  { 719, 8, 12, 7, -1, -8 },
  { 731, 7, 12, 7, 0, -8 },
  { 742, 6, 8, 5, 0, -8 },
  { 748, 6, 8, 6, 0, -8 },
  { 754, 4, 10, 5, 1, -10 },
  { 759, 7, 8, 7, 0, -8 },
  { 766, 6, 8, 6, 1, -8 },
  { 772, 9, 8, 10, 1, -8 },
  { 781, 8, 8, 6, -1, -8 },
  { 789, 8, 12, 6, -1, -8 },
  { 801, 7, 8, 5, -1, -8 },
  { 808, 6, 13, 5, 0, -11 },
  { 818, 2, 15, 6, 2, -12 },
  { 822, 6, 13, 5, -1, -11 },
  { 832, 6, 3, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC15PT7B_H_
