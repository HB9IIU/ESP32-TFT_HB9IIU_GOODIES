#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC0, 0x00, 0xE3, 0x8E,
  0x00, 0x77, 0x67, 0xEE, 0xEE, 0xEE, 0x06, 0xE0, 0xD8, 0x33, 0x06, 0x63,
  0xFE, 0xFF, 0xC6, 0x60, 0xD8, 0x3B, 0x1F, 0xFB, 0xFE, 0x3B, 0x06, 0x60,
  0xDC, 0x3B, 0x00, 0x02, 0x00, 0x81, 0xFC, 0x7E, 0x3D, 0x8F, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0xB2, 0x2C, 0xEF, 0x3F, 0xC7, 0xE0, 0x40, 0x10,
  0x00, 0x3C, 0x31, 0xF1, 0xC6, 0xC6, 0x1B, 0x30, 0xEC, 0xC3, 0x36, 0x0D,
  0xDB, 0xFE, 0xDF, 0x77, 0x6C, 0x1B, 0x30, 0xEC, 0xC3, 0x37, 0x18, 0xD8,
  0x63, 0xE3, 0x0F, 0x00, 0x0F, 0x81, 0xFC, 0x1D, 0xC1, 0xDC, 0x1F, 0x81,
  0xF8, 0x1F, 0x03, 0xEF, 0x7E, 0xE7, 0x7E, 0xE7, 0xCE, 0x78, 0xF7, 0x8F,
  0xFC, 0x7D, 0xC0, 0x77, 0xEE, 0xE0, 0x0F, 0x0C, 0x1C, 0x18, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x18, 0x38, 0x30, 0xF0, 0x1C, 0x98, 0xD9, 0xFF, 0x7F, 0x78,
  0xEC, 0x6E, 0x48, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x3B, 0x9C, 0xEE, 0x70, 0x7F, 0xFF, 0x80, 0xFE,
  0xE0, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x1F, 0x3F,
  0x3F, 0x73, 0x73, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xCE, 0xCE, 0xFC, 0xFC,
  0x78, 0x0E, 0x3C, 0xFB, 0xFF, 0xCB, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3,
  0x8E, 0x1C, 0x00, 0x07, 0x87, 0xF1, 0xFC, 0x27, 0x01, 0xC0, 0x70, 0x38,
  0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0x9F, 0xCF, 0xF0, 0x1F, 0x8F,
  0xE1, 0xFC, 0x0F, 0x03, 0x80, 0xE1, 0xF0, 0x78, 0x3F, 0x01, 0xC0, 0x70,
  0x1C, 0xFF, 0x3F, 0x8F, 0xC0, 0x03, 0xC0, 0xE0, 0x78, 0x3E, 0x0F, 0x86,
  0xE3, 0xF0, 0xDC, 0x67, 0x3F, 0xEF, 0xFB, 0xFE, 0x0E, 0x03, 0x80, 0xE0,
  0x1F, 0xC7, 0xE1, 0xF8, 0x60, 0x38, 0x0F, 0x83, 0xF1, 0xFC, 0x07, 0x81,
  0xE0, 0x72, 0x1C, 0xFF, 0x3F, 0x8F, 0xC0, 0x0F, 0x8F, 0xCF, 0x27, 0x07,
  0x03, 0xF3, 0xFD, 0xFE, 0xE7, 0x73, 0xB9, 0xDD, 0xCF, 0xE7, 0xE1, 0xE0,
  0x3F, 0xDF, 0xE7, 0xF8, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xE7,
  0x39, 0x8E, 0xE1, 0xF0, 0x78, 0x7F, 0x1D, 0xCE, 0x3B, 0x9C, 0xE7, 0x3F,
  0x87, 0xC0, 0x0F, 0x07, 0xE3, 0xF8, 0xE6, 0x73, 0xDC, 0xE7, 0x39, 0xFE,
  0x7F, 0x8E, 0xE0, 0x70, 0x3C, 0x9E, 0x3F, 0x0F, 0x80, 0x19, 0xCE, 0x60,
  0x00, 0x00, 0x07, 0xB9, 0xC0, 0x0C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0xE7, 0x1C, 0x63, 0x8C, 0x00, 0x00, 0x81, 0xC3, 0xE7, 0xEF, 0x87, 0x03,
  0xF0, 0x7E, 0x0F, 0x80, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x80, 0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x7C, 0xF8, 0xF0,
  0x60, 0x20, 0x00, 0x3E, 0xFD, 0xB8, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xC0,
  0x00, 0x0E, 0x1C, 0x38, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xC1, 0xC6, 0x03,
  0x33, 0xEC, 0xDD, 0xB6, 0x66, 0xDB, 0x33, 0x6C, 0xCD, 0xB3, 0x64, 0xDD,
  0xB3, 0xFC, 0x66, 0x61, 0x80, 0x07, 0x0C, 0x0F, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF1, 0xDC, 0x77, 0x1D, 0xCF, 0xF3,
  0xFD, 0xFF, 0x71, 0xFC, 0x7E, 0x1C, 0x1F, 0x83, 0xF8, 0x7F, 0x9C, 0xF3,
  0x9C, 0x73, 0x8F, 0xE1, 0xF8, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0xF9,
  0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE3, 0xF9, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFE, 0x3F, 0x87, 0xE0, 0x1F, 0x83,
  0xF8, 0x7F, 0x9C, 0xF3, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x71, 0xEE, 0x39,
  0xCF, 0x39, 0xCF, 0xF9, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xE0,
  0x38, 0x0E, 0x03, 0xF0, 0xFC, 0x7F, 0x1C, 0x07, 0x01, 0xC0, 0xFE, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xE1, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0xF0, 0xFC,
  0x7F, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0x0F, 0xC3, 0xFC,
  0xFF, 0x3C, 0x07, 0x00, 0xE0, 0x3D, 0xF7, 0x3E, 0xE7, 0x9C, 0x73, 0x8E,
  0x71, 0xCF, 0xF8, 0xFE, 0x1F, 0xC0, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8F,
  0x38, 0xE3, 0x8E, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xF3, 0xCE, 0x38, 0xE3, 0x80, 0x1F, 0xC7, 0xE0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x3F, 0x8F, 0xE0,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x7C, 0x3C, 0x08, 0x00, 0x1C,
  0x71, 0xCE, 0x1D, 0xE3, 0x9C, 0x3B, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7F,
  0x07, 0x70, 0x77, 0x07, 0x70, 0xE7, 0x8E, 0x38, 0xE3, 0x80, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8F, 0xFF, 0xFF, 0x80,
  0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E,
  0x3E, 0x6C, 0x36, 0xFC, 0x76, 0xDC, 0x77, 0xDC, 0x77, 0xDC, 0x77, 0xB8,
  0xE7, 0xB8, 0xE7, 0x38, 0xE7, 0x38, 0x1E, 0x38, 0xF1, 0xC7, 0x8C, 0x7C,
  0xE3, 0xE7, 0x1F, 0x38, 0xFD, 0xC6, 0xEC, 0x77, 0xE3, 0xBF, 0x1C, 0xF8,
  0xE7, 0xCE, 0x3C, 0x71, 0xE3, 0x8F, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x3C,
  0xF7, 0x1E, 0xE3, 0xFC, 0x7F, 0x0E, 0xE1, 0xDC, 0x3B, 0x8F, 0x71, 0xCF,
  0xF1, 0xFE, 0x1F, 0x00, 0x1F, 0x83, 0xF8, 0x7F, 0x1C, 0xF3, 0x9E, 0x73,
  0x8E, 0x71, 0xFC, 0x7F, 0x8F, 0xC1, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x1E, 0xE3, 0xFC, 0x7F, 0x0E,
  0xE1, 0xDC, 0x3B, 0x8F, 0x71, 0xCF, 0xF1, 0xFE, 0x1F, 0x00, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x00, 0x1F, 0x87, 0xF1, 0xFC, 0xE7, 0x39, 0xCE, 0x73,
  0xBC, 0xFE, 0x7F, 0x1D, 0xC7, 0x71, 0xDC, 0xE7, 0x39, 0xEE, 0x38, 0x0F,
  0x87, 0xF3, 0xF8, 0xE2, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x72, 0x1C, 0xFF, 0x3F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x38, 0xE7, 0x3C,
  0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0xF7, 0x9C, 0xE3, 0x9C, 0x73, 0x8E,
  0x73, 0x8F, 0xF1, 0xFC, 0x1F, 0x00, 0xE1, 0xF8, 0xFE, 0x3B, 0x8E, 0xE7,
  0x39, 0xCE, 0xE3, 0xB8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F,
  0x00, 0x71, 0xC7, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x77, 0xDC, 0x77,
  0xDC, 0x77, 0x9C, 0x7F, 0xB8, 0x6D, 0xB8, 0x7D, 0xF0, 0x7D, 0xF0, 0x79,
  0xF0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0, 0x1C, 0x71, 0xEE, 0x0E, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x83,
  0xB8, 0x73, 0x87, 0x38, 0xE3, 0xC0, 0xE3, 0xF3, 0xF9, 0xDD, 0xC6, 0xE3,
  0xE1, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x1F,
  0xE3, 0xFC, 0x7F, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0xF9, 0xFE, 0x3F, 0xC0, 0x0F, 0x87, 0x87, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xF8, 0x7C, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0xCE, 0x73, 0x9C,
  0x63, 0x18, 0xE0, 0x0F, 0x87, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x78, 0x7C, 0x00,
  0x06, 0x03, 0x83, 0xC3, 0xE1, 0xF1, 0xDC, 0xCE, 0xE7, 0xE1, 0x80, 0xFF,
  0xFE, 0xF7, 0x70, 0x0C, 0xC7, 0xF3, 0xFD, 0xEF, 0x73, 0x9C, 0xE7, 0x3B,
  0x8E, 0xE7, 0x3D, 0xC7, 0xF1, 0xDC, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3B,
  0x0F, 0xE3, 0xFC, 0xEF, 0x71, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xBD, 0xCF,
  0xF3, 0x78, 0x0F, 0x0F, 0xCF, 0xCF, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x7B, 0x1F, 0x87, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0xDC, 0x3F,
  0x8F, 0xF3, 0xDE, 0x73, 0x8E, 0x71, 0xCE, 0x71, 0xCE, 0x71, 0xEE, 0x1F,
  0xC3, 0xF8, 0x06, 0x0F, 0xCF, 0xEE, 0x77, 0x3B, 0xF9, 0xF9, 0xC0, 0xE0,
  0x39, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x1D, 0x03, 0x80, 0x78, 0x3F,
  0x07, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x06, 0x61, 0xFC,
  0x7F, 0x9E, 0xF3, 0x9C, 0x73, 0x8E, 0x73, 0x8E, 0x73, 0x8F, 0xF0, 0xFE,
  0x1D, 0xC0, 0x38, 0x0E, 0x3B, 0xC7, 0xF0, 0x7C, 0x00, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x3B, 0x0F, 0xE3, 0xFC, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x63, 0x39, 0xCE, 0x73, 0x9C, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x8E, 0x71,
  0xC7, 0x1C, 0x73, 0x8E, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x1C, 0x3E, 0x1F, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x9E,
  0x73, 0x8E, 0xE1, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xCE,
  0x39, 0xC7, 0x38, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C,
  0x73, 0x8E, 0x38, 0x3B, 0x18, 0xDE, 0xF3, 0xFF, 0xCE, 0xF7, 0x73, 0x9D,
  0xCE, 0x77, 0x39, 0xDC, 0xEE, 0x67, 0x3B, 0x9C, 0xEE, 0x73, 0xB9, 0xDE,
  0x3B, 0x0D, 0xE3, 0xFC, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x39,
  0xCE, 0x73, 0x9C, 0x0E, 0x0F, 0xCF, 0xEF, 0x77, 0x3B, 0x9D, 0xCF, 0xC7,
  0xE7, 0xBB, 0x9F, 0x87, 0x80, 0x1D, 0x83, 0xF8, 0x7F, 0x8E, 0x73, 0x8E,
  0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x71, 0xFE, 0x3F, 0x87, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0xC7, 0xF3, 0xFD, 0xEE, 0x73, 0x9C,
  0xE7, 0x3B, 0x8E, 0xE7, 0x3D, 0xC7, 0xF1, 0xDC, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x00, 0x3B, 0x3F, 0x3F, 0x3E, 0x78, 0x70, 0x70, 0x70, 0x70,
  0xE0, 0xE0, 0xE0, 0x1E, 0x3F, 0x7E, 0x70, 0x78, 0x7C, 0x3C, 0x1E, 0x0E,
  0xDE, 0xFC, 0xF8, 0x18, 0xE3, 0xFF, 0xFD, 0xC7, 0x38, 0xE3, 0x8E, 0x3A,
  0xF3, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x67, 0x3F, 0xC7, 0xF1, 0xFC, 0xE3, 0xF1, 0xF9, 0xDC, 0xEE, 0xE7, 0x73,
  0xB0, 0xF8, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0xE7, 0x9F, 0x9E, 0xEE, 0x73,
  0xBB, 0xCC, 0xEF, 0x73, 0xFD, 0xCF, 0xB6, 0x3E, 0xF8, 0xFB, 0xC3, 0xCF,
  0x0F, 0x3C, 0x38, 0xE0, 0x3C, 0xE3, 0xB8, 0x77, 0x0F, 0xC1, 0xF0, 0x1E,
  0x07, 0x80, 0xF8, 0x3F, 0x07, 0xE1, 0xDC, 0x73, 0xC0, 0x38, 0xE7, 0x1C,
  0xE7, 0x1C, 0xE1, 0xB8, 0x37, 0x06, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x70, 0x3E, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x8F, 0xCF,
  0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0xBF, 0x9F, 0xC0, 0x07,
  0x87, 0x83, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x78, 0x78, 0x1E, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1E, 0x0F, 0x0F,
  0x1E, 0x38, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0xF8, 0xFF, 0xE7, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 8, 5, 9, 2, -15 },
  { 18, 11, 15, 11, 0, -15 },
  { 39, 10, 17, 9, 0, -16 },
  { 61, 14, 15, 16, 1, -15 },
  { 88, 12, 15, 12, 0, -15 },
  { 111, 4, 5, 5, 2, -15 },
  { 114, 8, 18, 6, 0, -15 },
  { 132, 8, 18, 6, -2, -15 },
  { 150, 8, 9, 9, 2, -16 },
  { 159, 9, 11, 10, 1, -13 },
  { 172, 5, 6, 5, -1, -3 },
  { 176, 6, 3, 6, 0, -7 },
  { 179, 4, 3, 5, 0, -3 },
  { 181, 11, 15, 8, -1, -15 },
  { 202, 8, 15, 9, 1, -15 },
  { 217, 7, 15, 9, 2, -15 },
  { 231, 10, 15, 9, -1, -15 },
  { 250, 10, 15, 9, 0, -15 },
  { 269, 10, 15, 9, 0, -15 },
  { 288, 10, 15, 9, 0, -15 },
  { 307, 9, 15, 9, 1, -15 },
  { 324, 10, 15, 9, 1, -15 },
  { 343, 10, 15, 9, 0, -15 },
  { 362, 10, 15, 9, 0, -15 },
  { 381, 5, 12, 5, 0, -12 },
  { 389, 6, 15, 5, -1, -12 },
  { 401, 9, 11, 10, 1, -13 },
  { 414, 9, 7, 10, 1, -11 },
  { 422, 9, 11, 10, 1, -13 },
  { 435, 7, 15, 7, 1, -15 },
  { 449, 14, 17, 14, 0, -15 },
  { 479, 10, 15, 10, -1, -15 },
  { 498, 11, 15, 10, 0, -15 },
  { 519, 10, 15, 10, 1, -15 },
  { 538, 11, 15, 11, 0, -15 },
  { 559, 10, 15, 9, 0, -15 },
  { 578, 10, 15, 8, 0, -15 },
  { 597, 11, 15, 11, 1, -15 },
  { 618, 12, 15, 11, 0, -15 },
  { 641, 10, 15, 7, -1, -15 },
  { 660, 9, 20, 5, -3, -15 },
  { 683, 12, 15, 10, 0, -15 },
  { 706, 7, 15, 8, 0, -15 },
  { 720, 16, 15, 15, 0, -15 },
  { 750, 13, 15, 12, 0, -15 },
  { 775, 11, 15, 12, 1, -15 },
  { 796, 11, 15, 10, 0, -15 },
  { 817, 11, 19, 12, 1, -15 },
  { 844, 10, 15, 10, 0, -15 },
  { 863, 10, 15, 9, 0, -15 },
  { 882, 8, 15, 9, 2, -15 },
  { 897, 11, 15, 11, 1, -15 },
  { 918, 10, 15, 10, 2, -15 },
  { 937, 16, 15, 15, 1, -15 },
  { 967, 12, 15, 10, -1, -15 },
  { 990, 9, 15, 10, 2, -15 },
  { 1007, 11, 15, 9, -1, -15 },
  { 1028, 9, 18, 6, -1, -15 },
  { 1049, 5, 15, 8, 2, -15 },
  { 1059, 9, 18, 6, -2, -15 },
  { 1080, 9, 9, 9, 0, -15 },
  { 1091, 8, 2, 7, -2, 2 },
  { 1093, 4, 3, 7, 3, -16 },
  { 1095, 10, 12, 10, 0, -12 },
  { 1110, 10, 16, 10, 0, -16 },
  { 1130, 9, 12, 8, 0, -12 },
  { 1144, 11, 16, 10, 0, -16 },
  { 1166, 9, 12, 9, 0, -12 },
  { 1180, 11, 21, 6, -2, -16 },
  { 1209, 11, 17, 10, -1, -12 },
  { 1233, 10, 16, 10, 0, -16 },
  { 1253, 6, 16, 5, 0, -16 },
  { 1265, 9, 21, 5, -3, -16 },
  { 1289, 11, 16, 9, 0, -16 },
  { 1311, 6, 16, 5, 0, -16 },
  { 1323, 14, 12, 15, 0, -12 },
  { 1344, 10, 12, 10, 0, -12 },
  { 1359, 9, 12, 10, 0, -12 },
  { 1373, 11, 17, 10, -1, -12 },
  { 1397, 10, 17, 10, 0, -12 },
  { 1419, 8, 12, 7, 0, -12 },
  { 1431, 8, 12, 8, 0, -12 },
  { 1443, 6, 14, 7, 1, -14 },
  { 1454, 10, 12, 10, 0, -12 },
  { 1469, 9, 12, 9, 1, -12 },
  { 1483, 14, 12, 14, 1, -12 },
  { 1504, 11, 12, 9, -1, -12 },
  { 1521, 11, 17, 9, -1, -12 },
  { 1545, 9, 12, 8, -1, -12 },
  { 1559, 9, 18, 7, 0, -15 },
  { 1580, 2, 21, 8, 3, -16 },
  { 1586, 8, 18, 7, -1, -15 },
  { 1604, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC21PT7B_H_
