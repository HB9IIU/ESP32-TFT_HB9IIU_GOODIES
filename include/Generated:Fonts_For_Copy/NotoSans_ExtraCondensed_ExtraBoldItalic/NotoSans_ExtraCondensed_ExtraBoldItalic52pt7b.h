#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x30, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x8F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE3,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF3, 0x3C,
  0x07, 0xF7, 0x08, 0x07, 0xE7, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xF6, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1B, 0xF8, 0x00, 0x3B, 0xF8,
  0x20, 0x33, 0xF8, 0x30, 0x33, 0xF8, 0x78, 0x37, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x3F, 0xF8,
  0x07, 0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xF3,
  0xE0, 0x7E, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x7E, 0x3E, 0x0F, 0xC0, 0x1F,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x7C, 0x00,
  0xFC, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC7, 0xE0,
  0x03, 0xE1, 0xF3, 0xF0, 0x70, 0xF8, 0xFC, 0xFC, 0x7F, 0x3E, 0x3E, 0x7E,
  0x3F, 0xEF, 0xDF, 0x9F, 0x1F, 0xFF, 0xFF, 0xCF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xE7, 0xE7, 0xDF, 0xF1, 0xF9, 0xF1, 0xF3, 0xF8, 0x7C, 0xFC, 0x7C, 0x10,
  0x3F, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x87, 0xC0, 0x07, 0xE7, 0xE1, 0xF0,
  0x03, 0xF1, 0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x0F,
  0xC0, 0x1F, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0xF8, 0x03, 0xE0, 0x7C,
  0x7E, 0x01, 0xF8, 0x1F, 0x1F, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x01,
  0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE1, 0xFE,
  0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F,
  0xFF, 0xBF, 0x87, 0xFB, 0xFF, 0xF8, 0x7F, 0x9F, 0xFF, 0xC3, 0xF8, 0x7F,
  0xFC, 0x1F, 0xC3, 0xFF, 0xE1, 0xFE, 0x1F, 0xFE, 0x0F, 0xF0, 0x7F, 0xF0,
  0x7F, 0x83, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xEF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x04, 0x00, 0x00,
  0x00, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x20, 0xFC, 0x03, 0x8F,
  0xC0, 0x7C, 0xF8, 0x37, 0xFF, 0x9F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xBF, 0x07, 0xFB, 0xF8, 0x3F, 0x3F, 0x81, 0xE1, 0xFC,
  0x0E, 0x1F, 0x00, 0x41, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7E,
  0x0F, 0xE0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC,
  0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC,
  0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF3, 0xFB, 0xFC, 0x7C,
  0xFE, 0x0E, 0x3F, 0x81, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xF1, 0xFE, 0x00, 0xF0,
  0x7F, 0xC0, 0x38, 0x0F, 0xE0, 0x04, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xE1, 0xFF,
  0x01, 0x80, 0xFF, 0x01, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0x80, 0x1F, 0xF0, 0xF0, 0x7F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xDF, 0xC0, 0x03, 0xEF, 0xE0, 0x03, 0xE7, 0xF0, 0x03, 0xF7, 0xF8, 0x01,
  0xF3, 0xFC, 0x01, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xF8, 0x7F, 0x00,
  0xF8, 0x7F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x04, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0xC0, 0x1F, 0xF0, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xE7, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFB,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF9,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xE7, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFB,
  0xF8, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x80, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFE, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x0C, 0x00, 0x00,
  0x1E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0xFF,
  0x0C, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0x9F, 0x0F, 0x83, 0xFF,
  0xC7, 0xC3, 0xE1, 0xFF, 0xF1, 0xF1, 0xF0, 0xFE, 0xFC, 0x7C, 0x7C, 0x7E,
  0x3F, 0x1F, 0x3E, 0x1F, 0x0F, 0x87, 0xCF, 0x8F, 0xC3, 0xE1, 0xF3, 0xE3,
  0xE0, 0xF8, 0x7D, 0xF0, 0xF8, 0x7E, 0x1E, 0x7C, 0x7E, 0x1F, 0x0F, 0x9F,
  0x1F, 0x07, 0xC3, 0xE7, 0xC7, 0xC1, 0xF0, 0xF1, 0xE1, 0xF0, 0xFC, 0x7C,
  0xF8, 0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x87, 0x8F, 0x87, 0xC7, 0xE3,
  0xE3, 0xE1, 0xFB, 0xF9, 0xF0, 0xF8, 0x7F, 0xFF, 0xF8, 0x3E, 0x1F, 0xF7,
  0xFE, 0x0F, 0x83, 0xF8, 0xFF, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x08, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07,
  0xF8, 0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF9, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x38, 0x0F, 0xFC, 0x04, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0x01, 0xFF, 0x8F, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF,
  0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0xFF,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7C, 0x07,
  0xFC, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xF1, 0xFE, 0x1F, 0xFE,
  0x3F, 0xC3, 0xFF, 0x8F, 0xF0, 0x7F, 0xF1, 0xFE, 0x0F, 0xFE, 0x3F, 0xC3,
  0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03,
  0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x6F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFB, 0xF0,
  0xFF, 0xFC, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x0F, 0xEF, 0xC7, 0xFF, 0xF0,
  0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0xBF, 0x1F, 0xBF, 0x80, 0x7F, 0x7E,
  0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0xFD, 0xFE, 0x03, 0xF9, 0xFB, 0xFB, 0xFC,
  0x07, 0xF3, 0xF7, 0xE7, 0xF0, 0x0F, 0xE7, 0xFF, 0xCF, 0xE0, 0x3F, 0xCF,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0xC3, 0xF8, 0x0F, 0xF1,
  0xFF, 0x87, 0xF0, 0x1F, 0xC3, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x80, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x81, 0xFE, 0x03, 0xFF,
  0xC1, 0xFC, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF,
  0xC1, 0xFC, 0x07, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xC3, 0xF8, 0x07, 0xEF,
  0xE3, 0xF8, 0x0F, 0xEF, 0xE3, 0xF8, 0x0F, 0xEF, 0xE7, 0xF8, 0x0F, 0xEF,
  0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xF7, 0xF0, 0x1F, 0xC7,
  0xF7, 0xF0, 0x1F, 0xC7, 0xF7, 0xF0, 0x1F, 0xC7, 0xFF, 0xE0, 0x1F, 0xC3,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x83,
  0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0xC0, 0x7F, 0x01,
  0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0x80, 0x7F, 0x01,
  0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xE7,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC,
  0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xCF, 0xFC, 0x0F, 0xF1, 0xFF,
  0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF3, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC,
  0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFC, 0x0E, 0x01, 0xFF, 0x00, 0x80, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x40, 0x07, 0xF8, 0x18, 0x03, 0xFC,
  0x07, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03,
  0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE,
  0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x7F, 0x00,
  0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F,
  0xE3, 0xF8, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xF8, 0x3F, 0x83, 0xFC,
  0x3F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xE1, 0xFC, 0x0F, 0xE1, 0xFF, 0xC7,
  0xF8, 0x1F, 0xC7, 0xFF, 0x8F, 0xF0, 0x3F, 0x8F, 0xFF, 0x1F, 0xC0, 0x7F,
  0x1F, 0xFE, 0x7F, 0x80, 0xFE, 0x7E, 0xFC, 0xFE, 0x01, 0xFC, 0xFD, 0xFB,
  0xFC, 0x03, 0xFB, 0xFB, 0xF7, 0xF8, 0x07, 0xF7, 0xE7, 0xEF, 0xE0, 0x0F,
  0xEF, 0xCF, 0xFF, 0xC0, 0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFB,
  0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x8F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x81, 0xFC,
  0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFE, 0x7F, 0x03,
  0xFF, 0x7F, 0x07, 0xFF, 0x7F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF7, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xEF, 0xE0, 0x3F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x9F,
  0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xDF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3,
  0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF9, 0xFF,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xF9, 0xC1, 0xFE, 0x04, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x20, 0xFF, 0x06, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x03,
  0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFE, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFE, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x87, 0xE3, 0xF8, 0x3F, 0x3F, 0xC1,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x02, 0x1F, 0xF1, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F,
  0xFD, 0xFC, 0x07, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xDF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC,
  0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xC0, 0x0F,
  0xE7, 0xF0, 0x00, 0x41, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x20, 0x07, 0xF8, 0x0E, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F,
  0xDF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x02, 0x1F,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0xFC, 0x0F, 0x80, 0x3F, 0x3F,
  0xE3, 0xFE, 0x03, 0xF7, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0x8F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0xFF, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xE3, 0xFC, 0x07, 0xE7,
  0xFE, 0x07, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF7, 0xF8,
  0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0xBF,
  0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x8F,
  0xF0, 0x03, 0xF3, 0xFE, 0x00, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x7F,
  0xE0, 0x0F, 0xEF, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x82, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x01, 0xFE, 0x7F, 0x03, 0xFF, 0x7F, 0x07, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFE, 0x1F, 0xE3,
  0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF,
  0xC0, 0x3F, 0x9F, 0xC0, 0x04, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xE0,
  0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xE1, 0xC1, 0xFE,
  0x04, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x88, 0x07, 0xF8,
  0xE0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x9F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x10, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0C, 0x00, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xEF, 0xC0, 0x3F, 0x8F, 0xC0, 0x06, 0x00, 0x00,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE,
  0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F, 0x01,
  0xF9, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x3F,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x1F, 0xDF, 0xC3, 0xFF, 0x0F,
  0xEF, 0xE1, 0xFF, 0x8F, 0xF7, 0xF0, 0xFF, 0xC7, 0xF3, 0xF8, 0xFF, 0xC3,
  0xF9, 0xFC, 0x7F, 0xE3, 0xF8, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0x3F, 0xF8,
  0xFE, 0x3F, 0x9F, 0x7C, 0xFE, 0x1F, 0xDF, 0xBE, 0x7F, 0x0F, 0xEF, 0xFF,
  0x3F, 0x07, 0xF7, 0xDF, 0xBF, 0x83, 0xFF, 0xEF, 0xDF, 0xC1, 0xFB, 0xF7,
  0xEF, 0xC0, 0xFD, 0xF3, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x83,
  0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE,
  0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 16, 38, 13, 0, -37 },
  { 77, 20, 13, 22, 5, -37 },
  { 110, 28, 37, 26, 0, -37 },
  { 240, 24, 43, 23, 0, -40 },
  { 369, 34, 38, 39, 3, -38 },
  { 531, 29, 39, 29, 0, -38 },
  { 673, 10, 13, 13, 5, -37 },
  { 690, 18, 46, 14, 1, -38 },
  { 794, 18, 46, 14, -4, -38 },
  { 898, 20, 23, 22, 4, -40 },
  { 956, 22, 25, 25, 2, -31 },
  { 1025, 12, 14, 13, -3, -7 },
  { 1046, 14, 7, 15, 1, -17 },
  { 1059, 9, 9, 13, 0, -8 },
  { 1070, 28, 38, 20, -3, -38 },
  { 1203, 23, 39, 23, 1, -38 },
  { 1316, 18, 37, 24, 5, -37 },
  { 1400, 26, 38, 23, -2, -38 },
  { 1524, 24, 39, 23, 0, -38 },
  { 1641, 25, 37, 24, -1, -37 },
  { 1757, 24, 38, 23, 0, -37 },
  { 1871, 24, 39, 23, 1, -38 },
  { 1988, 25, 37, 23, 1, -37 },
  { 2104, 24, 39, 23, 0, -38 },
  { 2221, 24, 39, 23, 0, -38 },
  { 2338, 13, 30, 13, 0, -29 },
  { 2387, 16, 36, 13, -3, -29 },
  { 2459, 22, 25, 25, 2, -31 },
  { 2528, 22, 17, 25, 2, -27 },
  { 2575, 22, 25, 25, 2, -31 },
  { 2644, 20, 39, 18, 1, -38 },
  { 2742, 34, 42, 35, 1, -38 },
  { 2921, 26, 37, 26, -3, -37 },
  { 3042, 26, 37, 26, 0, -37 },
  { 3163, 25, 39, 24, 2, -38 },
  { 3285, 27, 37, 27, 0, -37 },
  { 3410, 24, 37, 21, 0, -37 },
  { 3521, 24, 37, 20, 0, -37 },
  { 3632, 27, 39, 28, 2, -38 },
  { 3764, 30, 37, 28, 0, -37 },
  { 3903, 24, 37, 18, -2, -37 },
  { 4014, 24, 48, 14, -8, -37 },
  { 4158, 30, 37, 25, 0, -37 },
  { 4297, 18, 37, 20, 0, -37 },
  { 4381, 39, 37, 37, 0, -37 },
  { 4562, 32, 37, 30, 0, -37 },
  { 4710, 27, 39, 29, 2, -38 },
  { 4842, 26, 37, 24, 0, -37 },
  { 4963, 27, 47, 29, 2, -38 },
  { 5122, 26, 37, 25, 0, -37 },
  { 5243, 26, 39, 22, -1, -38 },
  { 5370, 21, 37, 21, 4, -37 },
  { 5468, 28, 38, 28, 2, -37 },
  { 5601, 25, 37, 25, 5, -37 },
  { 5717, 39, 37, 37, 3, -37 },
  { 5898, 31, 37, 24, -3, -37 },
  { 6042, 23, 37, 24, 5, -37 },
  { 6149, 27, 37, 21, -2, -37 },
  { 6274, 21, 46, 15, -2, -38 },
  { 6395, 12, 38, 20, 5, -38 },
  { 6452, 21, 46, 15, -4, -38 },
  { 6573, 24, 23, 23, -1, -37 },
  { 6642, 19, 5, 18, -5, 4 },
  { 6654, 11, 8, 16, 7, -40 },
  { 6665, 24, 30, 25, 1, -29 },
  { 6755, 25, 41, 25, -1, -40 },
  { 6884, 20, 30, 20, 1, -29 },
  { 6959, 26, 41, 25, 1, -40 },
  { 7093, 21, 30, 23, 1, -29 },
  { 7172, 27, 52, 15, -6, -40 },
  { 7348, 26, 41, 25, -1, -29 },
  { 7482, 25, 40, 25, -1, -40 },
  { 7607, 16, 40, 12, -1, -40 },
  { 7687, 22, 52, 12, -7, -40 },
  { 7830, 27, 40, 24, -1, -40 },
  { 7965, 16, 40, 12, -1, -40 },
  { 8045, 36, 29, 36, -1, -29 },
  { 8176, 24, 29, 25, 0, -29 },
  { 8263, 22, 30, 24, 1, -29 },
  { 8346, 27, 41, 25, -3, -29 },
  { 8485, 24, 41, 25, 1, -29 },
  { 8608, 20, 29, 17, 0, -29 },
  { 8681, 20, 30, 19, 0, -29 },
  { 8756, 16, 35, 16, 2, -34 },
  { 8826, 24, 30, 24, 1, -29 },
  { 8916, 22, 29, 22, 3, -29 },
  { 8996, 33, 29, 33, 3, -29 },
  { 9116, 28, 29, 22, -3, -29 },
  { 9218, 29, 41, 22, -4, -29 },
  { 9367, 23, 29, 19, -2, -29 },
  { 9451, 22, 45, 18, 0, -37 },
  { 9575, 7, 52, 20, 6, -40 },
  { 9621, 20, 45, 18, -3, -37 },
  { 9734, 22, 9, 25, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC52PT7B_H_
