#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xF7, 0x9E,
  0x79, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0x00, 0xE7, 0x80, 0xF3, 0x80, 0x73,
  0xC0, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0x83, 0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x83, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x1E, 0x70, 0x0E, 0x78, 0x07, 0x38,
  0x07, 0x9C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xF6, 0x0F, 0x60, 0x1E, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0x78, 0x86, 0xF1, 0xCB, 0xC3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x07, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x0F, 0x01, 0xC1, 0xFC,
  0x1E, 0x0F, 0xE0, 0xE0, 0xF7, 0x0F, 0x07, 0x38, 0xF0, 0x79, 0xC7, 0x03,
  0x8E, 0x78, 0x1C, 0x73, 0x80, 0xE7, 0xBC, 0x07, 0x39, 0xCF, 0x3B, 0xDE,
  0xFD, 0xFC, 0xEF, 0xFF, 0xEF, 0x73, 0xBE, 0x77, 0x9C, 0x07, 0x38, 0xE0,
  0x79, 0xC7, 0x03, 0x8E, 0x78, 0x3C, 0xF3, 0x81, 0xC7, 0x9C, 0x1E, 0x3D,
  0xE0, 0xE0, 0xFE, 0x0F, 0x07, 0xE0, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF3,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x9F,
  0x3F, 0xEF, 0x8F, 0xFB, 0xE7, 0xDF, 0xF3, 0xE7, 0xFC, 0xF8, 0xFE, 0x3E,
  0x3F, 0x0F, 0x8F, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xF3,
  0xF0, 0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0x3C, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x7C,
  0x00, 0x04, 0x00, 0x3E, 0x01, 0xE0, 0x4F, 0x07, 0xF9, 0xBF, 0xFF, 0xFF,
  0xE3, 0xFF, 0x0F, 0x80, 0xFE, 0x1F, 0xF0, 0xFB, 0xC3, 0x9E, 0x08, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F,
  0xBF, 0xDF, 0xEF, 0xEF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x3F, 0xC3, 0xFE, 0x3F, 0xF1, 0xE7, 0x9F, 0x3C, 0xF1, 0xEF, 0x8F, 0x7C,
  0x7B, 0xC3, 0xDE, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xDE, 0x3E,
  0xF1, 0xF7, 0x8F, 0x3C, 0xF9, 0xFF, 0x8F, 0xF8, 0x3F, 0xC0, 0xF8, 0x00,
  0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF3, 0xFC, 0xFF, 0xBF, 0xF7, 0xBE, 0x67,
  0x84, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF0, 0x73, 0xE0, 0xC3, 0xC1, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE2, 0x07, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0x78, 0x1D, 0xF0, 0x7B, 0xE0, 0xE7, 0x83, 0x8F,
  0x0F, 0x3E, 0x1C, 0x7C, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xC1, 0x9F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE3, 0x07, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7D, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F,
  0xFC, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF1, 0xF3, 0xC7, 0xCF,
  0x9F, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x9E, 0x1F, 0x7C, 0x1F, 0xF0,
  0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xF3, 0xC3, 0xC7,
  0x8F, 0x8F, 0x9F, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x06, 0x1F, 0x1F,
  0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8,
  0xF8, 0xF8, 0xF0, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x3E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F,
  0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xC3, 0xFE, 0x3F, 0xF3,
  0xFF, 0x31, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x0F, 0x00, 0x38, 0x71, 0xFD,
  0xC7, 0x1F, 0xE7, 0x39, 0xEF, 0x3B, 0x9E, 0x73, 0x9C, 0xE3, 0x9D, 0xE7,
  0x1C, 0xEE, 0x79, 0xE7, 0x73, 0x8E, 0x3B, 0x9C, 0x73, 0x9C, 0xE7, 0x9C,
  0xE7, 0xFD, 0xC7, 0x3F, 0xFC, 0x38, 0xF3, 0xC1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x02, 0x01, 0xF0, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xEF, 0x01, 0xEF, 0x01, 0xEF, 0x03, 0xEF, 0x03, 0xCF, 0x07,
  0xCF, 0x07, 0x8F, 0x07, 0x8F, 0x0F, 0x9F, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8,
  0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x1F, 0x0F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x8C, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x20, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFB, 0xF0, 0x78, 0xFC, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xE7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F,
  0x7F, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8,
  0x20, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x3F, 0xCF, 0x9F, 0xCF, 0x8F, 0xE7, 0xC7, 0xF3, 0xE0, 0xF9, 0xF0, 0x78,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x9F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF1, 0xF0,
  0x1E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xDE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF0, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE3, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xBC, 0x1F, 0xE7, 0xFC,
  0x3F, 0xE7, 0xFC, 0x3D, 0xEF, 0x78, 0x3D, 0xEF, 0x78, 0x3D, 0xFE, 0x78,
  0x7D, 0xFE, 0xF8, 0x7D, 0xFC, 0xF8, 0x79, 0xFC, 0xF0, 0x79, 0xF8, 0xF0,
  0x79, 0xF9, 0xF0, 0xF9, 0xF9, 0xF0, 0xF8, 0xF1, 0xF0, 0xF0, 0xF1, 0xE0,
  0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F, 0xE3,
  0xE0, 0xFE, 0x3E, 0x1F, 0xE3, 0xC1, 0xFE, 0x3C, 0x1F, 0xE3, 0xC1, 0xFF,
  0x7C, 0x1E, 0xF7, 0xC3, 0xEF, 0x78, 0x3C, 0xF7, 0x83, 0xCF, 0x78, 0x3C,
  0xF7, 0x87, 0xCF, 0xF8, 0x7C, 0x7F, 0x07, 0x87, 0xF0, 0x78, 0x7F, 0x07,
  0x87, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF0, 0x3E, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xEF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3E,
  0x3F, 0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xBF, 0x0F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x1E, 0x3E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xEF, 0x81,
  0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3E, 0x3F,
  0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x3F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3E, 0x1E, 0x3E, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xE0, 0x3D, 0xF0, 0x7D, 0xF0, 0x7D, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0x78,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0x00, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xCE, 0x0F, 0x84, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x40, 0xF8, 0x71, 0xF8, 0x7F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x8F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x0F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xE1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF3, 0xE0, 0xF3, 0xE0, 0xF3,
  0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x3C, 0x1F,
  0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x3E, 0x78, 0x7C, 0x3E, 0x78, 0x7C, 0x3C,
  0x78, 0xFC, 0x7C, 0x78, 0xFC, 0x7C, 0x78, 0xFC, 0xF8, 0x79, 0xFC, 0xF8,
  0x79, 0xFC, 0xF0, 0x7B, 0xFD, 0xF0, 0x7B, 0xFD, 0xF0, 0xFB, 0xBD, 0xE0,
  0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x0F,
  0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xEF,
  0x80, 0x7D, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x7C, 0x3E, 0x0F,
  0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xBE, 0x3E, 0xF9, 0xF1, 0xE7, 0x87,
  0xBE, 0x1E, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x00, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xDE, 0x1F,
  0x78, 0x79, 0xE3, 0xC3, 0xDF, 0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFB, 0xE7, 0x9E, 0x3C, 0xF0, 0x07, 0x3C,
  0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7E, 0xFD, 0xF3, 0xE7, 0x8F, 0xBE, 0x3E,
  0xF8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0xCF, 0xFF,
  0x3F, 0xF8, 0xFD, 0xE1, 0xE7, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xE7, 0xCF, 0xFF, 0x1F, 0xFE, 0x3F,
  0xF8, 0x7B, 0xE0, 0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xFE, 0x7E, 0x27, 0xC0,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x88,
  0xFF, 0x8F, 0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0x3C, 0x1F, 0xBC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xE0, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7F,
  0xF7, 0xC7, 0xBC, 0x3D, 0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE3, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xA0, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x13, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xCF, 0x07, 0xEF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x3F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0x78, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0xC3, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xDE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF9, 0xF1, 0xE3, 0xE3,
  0xC7, 0x8F, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xE3, 0xE3,
  0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0x02, 0x03, 0xC3,
  0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1,
  0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0x20, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x0B,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x70, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x3E, 0xF0, 0x3D, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xF0, 0x79, 0xF0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x1E,
  0x78, 0x70, 0x7B, 0xF7, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0x7E,
  0x7C, 0xF8, 0xF1, 0xF3, 0xE7, 0xC7, 0x8F, 0x1F, 0x1E, 0x3C, 0x7C, 0xF9,
  0xF1, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x3E, 0x3C, 0x78, 0xF8, 0xF1, 0xE3,
  0xC7, 0xCF, 0x8F, 0x1F, 0x3E, 0x3C, 0x78, 0xF1, 0xF1, 0xE3, 0xC7, 0xCF,
  0x80, 0x1E, 0x78, 0x3D, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF3, 0xE7, 0xC7,
  0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF9, 0xF1, 0xE3, 0xE3, 0xC7,
  0x8F, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xE3, 0xE0, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x3D, 0xE1, 0xFF, 0x0F,
  0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x1F, 0x78, 0xFB, 0xFF, 0x9F,
  0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x07, 0x9E, 0x03, 0xDF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3D, 0xF8, 0x1E, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x8E, 0x0F, 0xBC, 0x3F, 0xF8, 0xFF, 0xF3, 0xE7, 0xE7, 0xC7,
  0x8F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xCF,
  0x8F, 0x9F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF8, 0x7E, 0xF0, 0x7F, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x71, 0xEF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x07, 0xC1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3E,
  0x23, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x03,
  0xC8, 0x7C, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x07, 0x03, 0xC0, 0xF0,
  0x7F, 0x3F, 0xDF, 0xF7, 0xFE, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x7E, 0x00, 0x3E,
  0x3C, 0xF8, 0xF3, 0xC7, 0xCF, 0x1F, 0x7C, 0x7D, 0xF1, 0xE7, 0xC7, 0x9E,
  0x3E, 0x78, 0xFB, 0xE3, 0xCF, 0x8F, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE1, 0xF7, 0x80, 0xF0, 0x7F, 0x87, 0xFC, 0x3D,
  0xE3, 0xEF, 0x1F, 0x78, 0xF3, 0xCF, 0x9E, 0x78, 0xF7, 0xC7, 0xBC, 0x3D,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x00, 0xF0, 0xF8, 0xFF, 0x1F, 0x9F, 0xF1, 0xF9, 0xEF, 0x3F, 0x1E, 0xF3,
  0xF3, 0xEF, 0x3F, 0x3C, 0xF7, 0xF3, 0xCF, 0x77, 0x78, 0xF7, 0x77, 0x8F,
  0xF7, 0x78, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE0,
  0xFC, 0xFE, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x87, 0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x7C, 0xF0, 0x7C, 0x78, 0x7E, 0x3E,
  0x00, 0x0F, 0x87, 0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xDE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x05, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xFE, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFA, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 23, 8, 0, -23 },
  { 30, 12, 8, 13, 3, -23 },
  { 42, 17, 23, 16, 0, -23 },
  { 91, 15, 26, 14, 0, -24 },
  { 140, 21, 23, 24, 2, -23 },
  { 201, 18, 23, 18, 0, -23 },
  { 253, 6, 8, 8, 3, -23 },
  { 259, 11, 28, 9, 0, -23 },
  { 298, 11, 28, 9, -3, -23 },
  { 337, 13, 14, 14, 2, -25 },
  { 360, 14, 15, 15, 1, -19 },
  { 387, 8, 8, 8, -2, -4 },
  { 395, 9, 5, 10, 0, -11 },
  { 401, 5, 5, 8, 0, -5 },
  { 405, 17, 23, 12, -2, -23 },
  { 454, 13, 23, 14, 1, -23 },
  { 492, 11, 23, 14, 3, -23 },
  { 524, 15, 23, 14, -1, -23 },
  { 568, 15, 23, 14, 0, -23 },
  { 612, 15, 23, 14, 0, -23 },
  { 656, 15, 23, 14, 0, -23 },
  { 700, 14, 23, 14, 1, -23 },
  { 741, 15, 23, 14, 1, -23 },
  { 785, 15, 23, 14, 0, -23 },
  { 829, 15, 23, 14, 0, -23 },
  { 873, 8, 18, 8, 0, -18 },
  { 891, 10, 22, 8, -2, -18 },
  { 919, 14, 15, 15, 1, -19 },
  { 946, 14, 10, 15, 1, -16 },
  { 964, 14, 15, 15, 1, -19 },
  { 991, 12, 23, 11, 1, -23 },
  { 1026, 21, 26, 22, 1, -23 },
  { 1095, 16, 23, 16, -2, -23 },
  { 1141, 16, 23, 16, 0, -23 },
  { 1187, 16, 23, 15, 1, -23 },
  { 1233, 17, 23, 17, 0, -23 },
  { 1282, 15, 23, 13, 0, -23 },
  { 1326, 15, 23, 13, 0, -23 },
  { 1370, 17, 23, 17, 1, -23 },
  { 1419, 19, 23, 17, 0, -23 },
  { 1474, 14, 23, 11, -1, -23 },
  { 1515, 15, 30, 8, -5, -23 },
  { 1572, 19, 23, 16, 0, -23 },
  { 1627, 11, 23, 13, 0, -23 },
  { 1659, 24, 23, 23, 0, -23 },
  { 1728, 20, 23, 19, 0, -23 },
  { 1786, 17, 23, 18, 1, -23 },
  { 1835, 16, 23, 15, 0, -23 },
  { 1881, 17, 28, 18, 1, -23 },
  { 1941, 16, 23, 15, 0, -23 },
  { 1987, 16, 23, 14, -1, -23 },
  { 2033, 14, 23, 13, 2, -23 },
  { 2074, 17, 23, 17, 1, -23 },
  { 2123, 16, 23, 16, 3, -23 },
  { 2169, 24, 23, 23, 2, -23 },
  { 2238, 19, 23, 15, -2, -23 },
  { 2293, 14, 23, 15, 3, -23 },
  { 2334, 16, 23, 13, -1, -23 },
  { 2380, 13, 28, 9, -1, -23 },
  { 2426, 7, 23, 12, 3, -23 },
  { 2447, 13, 28, 9, -2, -23 },
  { 2493, 14, 15, 14, 0, -23 },
  { 2520, 12, 3, 11, -3, 2 },
  { 2525, 6, 6, 10, 5, -25 },
  { 2530, 14, 18, 15, 1, -18 },
  { 2562, 15, 24, 15, 0, -24 },
  { 2607, 12, 18, 12, 1, -18 },
  { 2634, 16, 24, 15, 1, -24 },
  { 2682, 13, 18, 14, 1, -18 },
  { 2712, 17, 32, 9, -4, -24 },
  { 2780, 16, 26, 15, -1, -18 },
  { 2832, 15, 24, 15, 0, -24 },
  { 2877, 9, 25, 8, 0, -25 },
  { 2906, 13, 33, 8, -4, -25 },
  { 2960, 16, 24, 14, 0, -24 },
  { 3008, 9, 24, 8, 0, -24 },
  { 3035, 22, 18, 22, 0, -18 },
  { 3085, 15, 18, 15, 0, -18 },
  { 3119, 13, 18, 15, 1, -18 },
  { 3149, 17, 26, 15, -2, -18 },
  { 3205, 15, 26, 15, 0, -18 },
  { 3254, 12, 18, 11, 0, -18 },
  { 3281, 12, 18, 12, 0, -18 },
  { 3308, 10, 21, 10, 1, -21 },
  { 3335, 14, 18, 15, 1, -18 },
  { 3367, 13, 18, 14, 2, -18 },
  { 3397, 20, 18, 21, 2, -18 },
  { 3442, 17, 18, 14, -2, -18 },
  { 3481, 17, 26, 14, -2, -18 },
  { 3537, 14, 18, 12, -1, -18 },
  { 3569, 13, 28, 11, 0, -23 },
  { 3615, 4, 32, 12, 4, -25 },
  { 3631, 13, 28, 11, -2, -23 },
  { 3677, 14, 6, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC32PT7B_H_
