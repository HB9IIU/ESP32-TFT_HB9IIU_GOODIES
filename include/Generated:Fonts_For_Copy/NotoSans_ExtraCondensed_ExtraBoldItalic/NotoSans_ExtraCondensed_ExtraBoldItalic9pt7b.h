#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x61, 0x80, 0xF4, 0x3B, 0xD5, 0xE6, 0x50, 0x27, 0x66, 0x3A,
  0x44, 0x25, 0xA6, 0xAD, 0x5C, 0xB4, 0xC0, 0x23, 0x94, 0xCF, 0xDB, 0xC0,
  0xE0, 0x2D, 0x29, 0x26, 0x24, 0x92, 0x5E, 0x5F, 0x50, 0x2F, 0x22, 0x78,
  0xE0, 0xC0, 0x08, 0x44, 0x62, 0x33, 0x00, 0x27, 0x5D, 0xFA, 0xE0, 0x7D,
  0x25, 0x80, 0x27, 0x13, 0x6C, 0xE0, 0x27, 0x16, 0x32, 0xE0, 0x33, 0x7A,
  0xF2, 0x74, 0x63, 0xAE, 0x13, 0x4F, 0xFF, 0x60, 0x78, 0x88, 0x44, 0x60,
  0x27, 0x56, 0xFB, 0xE0, 0x27, 0x5F, 0x72, 0xE0, 0x50, 0xC0, 0x24, 0x15,
  0x80, 0x3C, 0x71, 0xF0, 0xF0, 0xC3, 0x68, 0x27, 0x26, 0x40, 0xC0, 0x18,
  0x95, 0xEB, 0xB6, 0xE8, 0x1C, 0x19, 0xCA, 0x77, 0xE4, 0x7A, 0x9D, 0xAD,
  0x70, 0x13, 0xD1, 0x8C, 0x61, 0x80, 0x72, 0xD7, 0xAF, 0x70, 0x74, 0x6C,
  0xCE, 0x74, 0x6C, 0xC8, 0x13, 0xD1, 0xBF, 0x69, 0xC0, 0x6A, 0xDF, 0xAD,
  0x48, 0x76, 0x44, 0x4E, 0x32, 0x22, 0x64, 0x4C, 0x7A, 0x99, 0xCF, 0x58,
  0x69, 0x6D, 0xC0, 0x66, 0xD9, 0xB7, 0xAF, 0xD5, 0x80, 0x6D, 0xA6, 0xBA,
  0xFA, 0x40, 0x13, 0xD3, 0x9D, 0xE9, 0xC0, 0x72, 0xD5, 0xCC, 0x40, 0x13,
  0xD3, 0x9D, 0xE9, 0xC4, 0x30, 0x75, 0x7E, 0xFB, 0x27, 0x46, 0x2A, 0xE0,
  0xEB, 0x69, 0x00, 0x6A, 0xD5, 0xAD, 0x30, 0xBA, 0xAE, 0xCC, 0xB6, 0xFE,
  0xBA, 0xF2, 0xC0, 0x2C, 0xE3, 0x0C, 0x73, 0x60, 0xBA, 0xCC, 0x88, 0x72,
  0x64, 0xCE, 0x69, 0x2D, 0x26, 0xAA, 0xD4, 0x31, 0x32, 0x22, 0x2C, 0x27,
  0x59, 0xE0, 0xD0, 0x75, 0xDB, 0xE0, 0x64, 0x75, 0xDF, 0xE0, 0x74, 0xCC,
  0xE0, 0x18, 0x9C, 0xAD, 0x5B, 0x80, 0x75, 0xE8, 0xE0, 0x19, 0x9C, 0x42,
  0x31, 0x08, 0xC0, 0x75, 0xDB, 0xE2, 0xE0, 0x64, 0x75, 0xDF, 0xA0, 0x69,
  0x2D, 0xA0, 0x32, 0x22, 0x66, 0x44, 0xC0, 0x62, 0x16, 0xCE, 0x72, 0xC0,
  0x69, 0x2D, 0xA0, 0x7D, 0x5D, 0x6F, 0xA8, 0x75, 0xDB, 0xA0, 0x75, 0xDB,
  0xE0, 0x39, 0x5A, 0xF7, 0x23, 0x00, 0x75, 0xDB, 0xE2, 0x20, 0x6B, 0x68,
  0x79, 0x9E, 0x7D, 0x2D, 0x80, 0x55, 0xDF, 0xE0, 0xBF, 0x68, 0x55, 0xF7,
  0xB6, 0xD0, 0x56, 0x66, 0xA0, 0x29, 0xCC, 0x62, 0x13, 0x00, 0x72, 0x4C,
  0xE0, 0x36, 0x48, 0x44, 0xC0, 0xFF, 0x80, 0x32, 0x21, 0x26, 0xC0, 0xF9,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 6, 7, 7, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 2, 2, 2, 1, -6 },
  { 25, 3, 8, 2, 0, -7 },
  { 28, 3, 8, 3, -1, -7 },
  { 31, 3, 4, 4, 1, -7 },
  { 33, 4, 4, 4, 0, -5 },
  { 35, 3, 2, 2, -1, -1 },
  { 36, 3, 1, 3, 0, -3 },
  { 37, 2, 1, 2, 0, -1 },
  { 38, 5, 7, 3, -1, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 3, 6, 4, 1, -6 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 5, 6, 4, 0, -6 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 2, 5, 2, 0, -5 },
  { 82, 3, 6, 2, -1, -5 },
  { 85, 4, 4, 4, 0, -5 },
  { 87, 4, 3, 4, 0, -5 },
  { 89, 4, 4, 4, 0, -5 },
  { 91, 4, 7, 3, 0, -7 },
  { 95, 6, 8, 6, 0, -7 },
  { 101, 5, 6, 4, -1, -6 },
  { 105, 5, 6, 4, 0, -6 },
  { 109, 5, 7, 4, 0, -7 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 4, 6, 4, 0, -6 },
  { 121, 4, 6, 4, 0, -6 },
  { 124, 5, 7, 5, 0, -7 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 4, 6, 3, 0, -6 },
  { 136, 4, 8, 2, -1, -6 },
  { 140, 5, 6, 4, 0, -6 },
  { 144, 3, 6, 4, 0, -6 },
  { 147, 7, 6, 6, 0, -6 },
  { 153, 6, 6, 5, 0, -6 },
  { 158, 5, 7, 5, 0, -7 },
  { 163, 5, 6, 4, 0, -6 },
  { 167, 5, 9, 5, 0, -7 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 4, 7, 4, 0, -7 },
  { 180, 3, 6, 4, 1, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 4, 6, 4, 1, -6 },
  { 190, 6, 6, 6, 1, -6 },
  { 195, 6, 6, 4, -1, -6 },
  { 200, 4, 6, 4, 1, -6 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 3, 8, 3, 0, -7 },
  { 209, 2, 7, 3, 1, -7 },
  { 211, 4, 8, 3, -1, -7 },
  { 215, 4, 4, 4, 0, -6 },
  { 217, 3, 1, 3, -1, 1 },
  { 218, 2, 2, 3, 1, -7 },
  { 219, 4, 5, 4, 0, -5 },
  { 222, 4, 7, 4, 0, -7 },
  { 226, 4, 5, 3, 0, -5 },
  { 229, 5, 7, 4, 0, -7 },
  { 234, 4, 5, 4, 0, -5 },
  { 237, 5, 9, 3, -1, -7 },
  { 243, 4, 7, 4, 0, -5 },
  { 247, 4, 7, 4, 0, -7 },
  { 251, 3, 7, 2, 0, -7 },
  { 254, 4, 9, 2, -1, -7 },
  { 259, 5, 7, 4, 0, -7 },
  { 264, 3, 7, 2, 0, -7 },
  { 267, 6, 5, 6, 0, -5 },
  { 271, 4, 5, 4, 0, -5 },
  { 274, 4, 5, 4, 0, -5 },
  { 277, 5, 7, 4, -1, -5 },
  { 282, 4, 7, 4, 0, -5 },
  { 286, 3, 5, 3, 0, -5 },
  { 288, 3, 5, 3, 0, -5 },
  { 290, 3, 6, 3, 0, -6 },
  { 293, 4, 5, 4, 0, -5 },
  { 296, 3, 5, 4, 1, -5 },
  { 298, 6, 5, 6, 0, -5 },
  { 302, 4, 5, 4, 0, -5 },
  { 305, 5, 7, 4, -1, -5 },
  { 310, 4, 5, 3, 0, -5 },
  { 313, 4, 7, 3, 0, -6 },
  { 317, 1, 9, 3, 1, -7 },
  { 319, 4, 7, 3, -1, -6 },
  { 323, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC9PT7B_H_
