#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x36, 0xDF, 0xB0, 0x1C, 0xA7, 0xCE, 0x53, 0xE5, 0x28,
  0x13, 0xD4, 0xC3, 0x5B, 0xCC, 0x40, 0x65, 0x52, 0xA7, 0xBF, 0xA5, 0x53,
  0xE6, 0x38, 0xA7, 0x8C, 0x7F, 0x6D, 0xBE, 0xF8, 0x32, 0x64, 0x4C, 0xCC,
  0xCC, 0x33, 0x33, 0x33, 0x26, 0x4C, 0xAF, 0x6F, 0x21, 0x3F, 0xF2, 0x10,
  0x6D, 0x60, 0xFC, 0xF0, 0x04, 0x21, 0x84, 0x30, 0x86, 0x30, 0x3B, 0xD6,
  0xBD, 0xEB, 0xCC, 0x37, 0xE2, 0x66, 0x64, 0x3B, 0xC6, 0x23, 0x33, 0x1E,
  0x3B, 0xC6, 0x67, 0x0A, 0xDC, 0x18, 0xCE, 0xA5, 0x7C, 0xC6, 0x3B, 0xD8,
  0xE5, 0x0A, 0xDC, 0x19, 0xD8, 0xED, 0xEF, 0x4E, 0x7D, 0xE1, 0x84, 0x30,
  0x86, 0x30, 0x3B, 0xDE, 0xE7, 0x6B, 0x5E, 0x33, 0xD6, 0xB7, 0x88, 0xDC,
  0x68, 0x0D, 0x80, 0x32, 0x00, 0x66, 0x4C, 0x08, 0xDD, 0xC1, 0x84, 0xFF,
  0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0x75, 0x13, 0x60, 0x4C, 0x1C, 0x45,
  0x7A, 0xFA, 0xB5, 0x6F, 0x22, 0x78, 0x0C, 0x71, 0xCF, 0x2D, 0xF6, 0xF3,
  0x39, 0xB6, 0x9E, 0x7B, 0x6D, 0xBC, 0x3C, 0xE6, 0x10, 0xC3, 0x0D, 0x1C,
  0x39, 0xF6, 0xDB, 0x4F, 0x6F, 0xBC, 0x3B, 0xD8, 0xE7, 0x63, 0x5C, 0x3B,
  0xD8, 0xE7, 0x63, 0x18, 0x1C, 0xD6, 0x17, 0xDB, 0x2D, 0x9E, 0x25, 0xB6,
  0xDF, 0x7B, 0x2D, 0xB6, 0x79, 0x08, 0xC6, 0x31, 0x1C, 0x08, 0xC6, 0x31,
  0x08, 0xC6, 0x27, 0x00, 0x2D, 0xA7, 0x9C, 0x73, 0x4D, 0x36, 0x26, 0x66,
  0x4C, 0xCF, 0x33, 0x77, 0x77, 0x77, 0x5A, 0xDA, 0xDE, 0xD6, 0x26, 0xED,
  0xD2, 0xA5, 0xDB, 0xB6, 0x6C, 0x38, 0xF6, 0xD3, 0xCF, 0x3D, 0x9C, 0x39,
  0xF6, 0xDA, 0x7B, 0x0C, 0x30, 0x38, 0xF6, 0xD3, 0xCF, 0x3D, 0x9C, 0x30,
  0x60, 0x3B, 0xDA, 0xF7, 0x6B, 0x5B, 0x3B, 0xD8, 0xC3, 0x1A, 0xDC, 0xFF,
  0x64, 0x4C, 0xCC, 0x25, 0xB6, 0xDB, 0x4B, 0x6D, 0x9C, 0xCE, 0xF5, 0xEE,
  0x53, 0x98, 0xDB, 0x9A, 0xBE, 0xB6, 0xB4, 0xDC, 0xD8, 0xD8, 0x36, 0x68,
  0x70, 0xC1, 0x87, 0x1A, 0x64, 0xDE, 0xBD, 0xC6, 0x23, 0x18, 0x7B, 0xC4,
  0x66, 0x23, 0x1E, 0x76, 0x44, 0x4C, 0xC8, 0x8C, 0xDB, 0x24, 0x93, 0x38,
  0x84, 0x63, 0x10, 0x84, 0x67, 0x00, 0x11, 0x9C, 0xBD, 0x80, 0xF0, 0xC0,
  0x7A, 0xF7, 0xBD, 0x78, 0x63, 0x1E, 0xF5, 0xEF, 0x56, 0x7B, 0xB1, 0x8D,
  0x30, 0x0C, 0x27, 0x96, 0xDB, 0x6D, 0x3C, 0x3A, 0xFD, 0x8D, 0x38, 0x19,
  0x8E, 0xE2, 0x11, 0x8C, 0x46, 0x20, 0x7A, 0xF7, 0xBD, 0x78, 0xDE, 0xC0,
  0x63, 0x1E, 0xF5, 0xEF, 0x5A, 0x61, 0xA5, 0xB6, 0x30, 0x32, 0x26, 0x66,
  0x4C, 0x80, 0x61, 0x87, 0xD4, 0x73, 0xCF, 0x34, 0x6D, 0xA5, 0xB6, 0x5E,
  0xF5, 0x6E, 0x9D, 0x7E, 0xC0, 0x5B, 0xD7, 0xBD, 0x68, 0x72, 0xF7, 0xBD,
  0x38, 0x2C, 0xF2, 0xDB, 0x69, 0xE4, 0x10, 0xC0, 0x7A, 0xF7, 0xBD, 0x78,
  0xC6, 0x20, 0x57, 0x4C, 0xCC, 0x75, 0x63, 0xBE, 0x27, 0x64, 0x4C, 0x60,
  0x6A, 0xD7, 0xBD, 0x78, 0xBB, 0xAE, 0xCC, 0xB7, 0x6B, 0xF6, 0xCD, 0x96,
  0x00, 0x2C, 0xE3, 0x8C, 0x7B, 0x60, 0x2C, 0xB2, 0x8E, 0x30, 0xC2, 0x38,
  0xC0, 0x73, 0x64, 0xCE, 0x19, 0x88, 0xCE, 0x61, 0x08, 0x63, 0x00, 0xFF,
  0xFF, 0xFC, 0x31, 0x8C, 0x61, 0x98, 0x8C, 0xE6, 0x00, 0x6D, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 8, 1, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 2, 3, 3, 1, -8 },
  { 32, 4, 10, 3, 0, -8 },
  { 37, 4, 10, 3, -1, -8 },
  { 42, 4, 4, 5, 1, -8 },
  { 44, 5, 6, 5, 0, -7 },
  { 48, 3, 4, 3, -1, -2 },
  { 50, 3, 2, 3, 0, -4 },
  { 51, 2, 2, 3, 0, -2 },
  { 52, 6, 8, 4, -1, -8 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 4, 8, 5, 1, -8 },
  { 67, 5, 8, 5, 0, -8 },
  { 72, 5, 8, 5, 0, -8 },
  { 77, 5, 8, 5, 0, -8 },
  { 82, 5, 8, 5, 0, -8 },
  { 87, 5, 8, 5, 0, -8 },
  { 92, 6, 8, 5, 0, -8 },
  { 98, 5, 8, 5, 0, -8 },
  { 103, 5, 8, 5, 0, -8 },
  { 108, 3, 6, 3, 0, -6 },
  { 111, 4, 8, 3, -1, -6 },
  { 115, 5, 6, 5, 0, -7 },
  { 119, 5, 4, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -7 },
  { 126, 4, 8, 4, 0, -8 },
  { 130, 7, 9, 7, 0, -8 },
  { 138, 6, 8, 5, -1, -8 },
  { 144, 6, 8, 5, 0, -8 },
  { 150, 6, 8, 5, 0, -8 },
  { 156, 6, 8, 6, 0, -8 },
  { 162, 5, 8, 4, 0, -8 },
  { 167, 5, 8, 4, 0, -8 },
  { 172, 6, 8, 6, 0, -8 },
  { 178, 6, 8, 6, 0, -8 },
  { 184, 5, 8, 4, 0, -8 },
  { 189, 5, 10, 3, -2, -8 },
  { 196, 6, 8, 5, 0, -8 },
  { 202, 4, 8, 4, 0, -8 },
  { 206, 8, 8, 8, 0, -8 },
  { 214, 7, 8, 6, 0, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 6, 8, 5, 0, -8 },
  { 233, 6, 10, 6, 0, -8 },
  { 241, 5, 8, 5, 0, -8 },
  { 246, 5, 8, 5, 0, -8 },
  { 251, 4, 8, 5, 1, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 5, 8, 5, 1, -8 },
  { 266, 8, 8, 8, 1, -8 },
  { 274, 7, 8, 5, -1, -8 },
  { 281, 5, 8, 5, 1, -8 },
  { 286, 5, 8, 5, 0, -8 },
  { 291, 4, 10, 3, 0, -8 },
  { 296, 3, 8, 4, 1, -8 },
  { 299, 5, 10, 3, -1, -8 },
  { 306, 5, 5, 5, 0, -8 },
  { 310, 4, 1, 4, -1, 1 },
  { 311, 2, 1, 3, 2, -8 },
  { 312, 5, 6, 5, 0, -6 },
  { 316, 5, 8, 5, 0, -8 },
  { 321, 5, 6, 4, 0, -6 },
  { 325, 6, 8, 5, 0, -8 },
  { 331, 5, 6, 5, 0, -6 },
  { 335, 5, 11, 3, -1, -8 },
  { 342, 5, 9, 5, 0, -6 },
  { 348, 5, 8, 5, 0, -8 },
  { 353, 3, 8, 3, 0, -8 },
  { 356, 4, 11, 3, -1, -8 },
  { 362, 6, 8, 5, 0, -8 },
  { 368, 3, 8, 3, 0, -8 },
  { 371, 7, 6, 8, 0, -6 },
  { 377, 5, 6, 5, 0, -6 },
  { 381, 5, 6, 5, 0, -6 },
  { 385, 6, 9, 5, -1, -6 },
  { 392, 5, 9, 5, 0, -6 },
  { 398, 4, 6, 4, 0, -6 },
  { 401, 4, 6, 4, 0, -6 },
  { 404, 4, 7, 3, 0, -7 },
  { 408, 5, 6, 5, 0, -6 },
  { 412, 4, 6, 5, 1, -6 },
  { 415, 7, 6, 7, 1, -6 },
  { 421, 6, 6, 5, -1, -6 },
  { 426, 6, 9, 5, -1, -6 },
  { 433, 4, 6, 4, 0, -6 },
  { 436, 5, 10, 4, 0, -8 },
  { 443, 2, 11, 4, 1, -8 },
  { 446, 5, 10, 4, -1, -8 },
  { 453, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC11PT7B_H_
