#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x60, 0x19, 0xCE, 0x00, 0xEF, 0xDB,
  0x36, 0xED, 0x80, 0x0D, 0x83, 0x60, 0x98, 0x6D, 0x7F, 0x86, 0xC3, 0x60,
  0xD8, 0xFF, 0x1B, 0x06, 0xC1, 0xB0, 0xD8, 0x00, 0x04, 0x04, 0x1F, 0x3F,
  0x35, 0x38, 0x38, 0x3E, 0x0E, 0x16, 0x56, 0xFE, 0xFC, 0x10, 0x20, 0x38,
  0xC7, 0x8C, 0x49, 0x8D, 0x98, 0xDB, 0x0D, 0xB6, 0xF6, 0xF6, 0xDB, 0x0D,
  0xB1, 0x9B, 0x19, 0x23, 0x1E, 0x71, 0xC0, 0x0F, 0x07, 0xC1, 0xB0, 0xEC,
  0x3F, 0x07, 0x83, 0xDD, 0xF6, 0xEF, 0xBB, 0xCE, 0xF3, 0xFC, 0x7B, 0x80,
  0xFF, 0x6C, 0x0C, 0x61, 0x8C, 0x31, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xE3,
  0x8E, 0x18, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x71,
  0x8E, 0x30, 0x1C, 0x31, 0xEF, 0xF3, 0xEF, 0x9B, 0x94, 0x38, 0x70, 0xE1,
  0xCF, 0xFF, 0xCE, 0x1C, 0x38, 0x37, 0x76, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x1F, 0x3B, 0x33, 0x73, 0x77, 0x67,
  0x67, 0x66, 0xEE, 0xEE, 0x7C, 0x78, 0x1C, 0xF7, 0xBE, 0xDA, 0xE3, 0x8C,
  0x31, 0xC7, 0x1C, 0x60, 0x0F, 0x0F, 0xC6, 0xE2, 0x70, 0x38, 0x18, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x4F, 0xCF, 0xE0, 0x1E, 0x3F, 0x37, 0x03, 0x07,
  0x3E, 0x3C, 0x3E, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x03, 0x07, 0x0F, 0x0F,
  0x1E, 0x36, 0x2E, 0x6E, 0xFF, 0xFE, 0x0C, 0x1C, 0x1C, 0x1F, 0x1F, 0x3F,
  0x30, 0x30, 0x3E, 0x7E, 0x0E, 0x06, 0x0E, 0x8E, 0xFC, 0xF8, 0x07, 0x8F,
  0x87, 0x07, 0x03, 0x03, 0xF1, 0xFC, 0xEE, 0x67, 0x73, 0x1B, 0x8F, 0x87,
  0xC0, 0x3F, 0x9F, 0xCF, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x0E, 0x00, 0x1E, 0x3F, 0x33, 0x33, 0x37, 0x3E, 0x3C, 0x7E,
  0xE6, 0xE6, 0xEE, 0xFE, 0x7C, 0x1E, 0x3F, 0x3F, 0x73, 0x77, 0x77, 0x7F,
  0x7F, 0x36, 0x0E, 0x1C, 0xFC, 0xF0, 0x31, 0xCC, 0x00, 0x00, 0x0C, 0xE7,
  0x00, 0x18, 0x71, 0x80, 0x00, 0x00, 0x0C, 0x71, 0xC6, 0x38, 0x02, 0x0C,
  0xFF, 0xCE, 0x1F, 0x0F, 0x87, 0x02, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x81, 0xC3, 0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x3C, 0xFC, 0x98, 0x30,
  0xE3, 0x8E, 0x18, 0x70, 0x01, 0x83, 0x0E, 0x00, 0x07, 0xC0, 0xFE, 0x18,
  0x33, 0x3F, 0x27, 0xB6, 0xDB, 0x6D, 0xB5, 0x9B, 0xDB, 0x2D, 0xFE, 0xCD,
  0xC4, 0x00, 0x61, 0x03, 0xF0, 0x07, 0x83, 0xC3, 0x61, 0xF0, 0xF8, 0xFC,
  0x6E, 0x77, 0x3F, 0xBF, 0xDC, 0xEC, 0x7E, 0x38, 0x1F, 0x1F, 0xCE, 0xE7,
  0x73, 0x39, 0xF9, 0xF8, 0xEE, 0x67, 0x33, 0xB9, 0xDF, 0xCF, 0xC0, 0x1F,
  0x3F, 0x7A, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE4, 0xFC, 0x7C,
  0x1E, 0x1F, 0xCF, 0xE7, 0x73, 0x19, 0x8D, 0xCE, 0xE7, 0x73, 0xB3, 0xBB,
  0xDF, 0xCF, 0x80, 0x1F, 0x3F, 0x38, 0x38, 0x30, 0x3E, 0x7E, 0x7C, 0x70,
  0x60, 0xE0, 0xFC, 0xFC, 0x1F, 0x3F, 0x38, 0x38, 0x30, 0x30, 0x7E, 0x7C,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x0F, 0x9F, 0xCE, 0x4E, 0x0E, 0x07, 0x03,
  0xBD, 0xDE, 0xC7, 0x73, 0xB9, 0x9F, 0xC7, 0xE0, 0x18, 0xE7, 0x18, 0xE7,
  0x1C, 0xE3, 0x1C, 0x7F, 0x1F, 0xE3, 0x9C, 0x73, 0x8C, 0x73, 0x8C, 0x73,
  0x8E, 0x70, 0x1F, 0x8F, 0x83, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x1C, 0x0E, 0x0F, 0x8F, 0xC0, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0xB8, 0xF8, 0xF0, 0x19, 0xCE,
  0x73, 0xB8, 0xFC, 0x37, 0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x1B, 0x8E, 0x63,
  0x98, 0xE7, 0x00, 0x18, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x71, 0x8E, 0x3F,
  0xFC, 0x1C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF8, 0xF3, 0xC7,
  0xDB, 0x1F, 0x7C, 0x6F, 0x71, 0xBD, 0xCE, 0xF6, 0x3B, 0x98, 0xCE, 0xE0,
  0x1C, 0x67, 0x9C, 0xF3, 0x9E, 0x63, 0xCC, 0x7D, 0x9F, 0xF3, 0xBE, 0x67,
  0x8C, 0xF3, 0x9E, 0x73, 0xCC, 0x70, 0x1F, 0x1F, 0x9E, 0xEE, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xC7, 0x63, 0xBB, 0x9F, 0xC7, 0x80, 0x1F, 0x1F, 0xCE,
  0xE7, 0x73, 0x39, 0x9D, 0xFC, 0xFC, 0x78, 0x30, 0x38, 0x1C, 0x0E, 0x00,
  0x1F, 0x1F, 0x9E, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC7, 0x63, 0xBB,
  0x9F, 0xC7, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x1F, 0xCE, 0xE7, 0x73, 0x39,
  0xB9, 0xFC, 0xF8, 0x6E, 0x37, 0x3B, 0x9C, 0xCE, 0x70, 0x1F, 0x9F, 0x8E,
  0xCE, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x37, 0x9F, 0x8F, 0x80,
  0x7F, 0x7F, 0xFE, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0x33, 0xB9, 0xDC, 0xEE, 0x76, 0x37, 0x3B, 0x9D, 0xCE, 0xE6, 0x63,
  0x3B, 0x9F, 0x87, 0x80, 0xC7, 0xC7, 0xC6, 0xCE, 0xCE, 0xDC, 0xDC, 0xD8,
  0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x63, 0x1D, 0x9C, 0xE6, 0x73, 0x99, 0xCC,
  0xEF, 0x73, 0xBD, 0xCF, 0xF6, 0x3E, 0xF8, 0xFB, 0xC3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xE0, 0xE3, 0x80, 0x1C, 0xE3, 0xB8, 0x76, 0x0F, 0xC0, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x07, 0xE0, 0xDC, 0x3B, 0x8E, 0x70, 0xC7, 0xCE,
  0xEC, 0xFC, 0xF8, 0xF8, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0x1F,
  0xC7, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0x11, 0xF8, 0xFE, 0x00, 0x1F, 0x1E, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x78, 0xF0, 0xCC, 0xCC, 0xEE, 0x66,
  0x66, 0x67, 0x70, 0x1E, 0x3C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x06, 0x3C, 0x78, 0x04, 0x0E, 0x1E, 0x1E, 0x36, 0x77, 0x67,
  0xE3, 0x7F, 0xFC, 0xFD, 0x80, 0x1F, 0x9F, 0x9D, 0xCE, 0xE6, 0x77, 0x3B,
  0x99, 0xDC, 0xFE, 0x3B, 0x00, 0x18, 0x38, 0x38, 0x38, 0x37, 0x3F, 0x73,
  0x73, 0x67, 0x67, 0x67, 0xE6, 0xFE, 0xDC, 0x1E, 0x7D, 0xCB, 0x86, 0x1C,
  0x38, 0x72, 0x7C, 0xF0, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x1F, 0x8F, 0xC7,
  0x71, 0xDC, 0x67, 0x39, 0xCE, 0x63, 0xB8, 0xFE, 0x1D, 0x80, 0x1E, 0x3F,
  0x77, 0x67, 0x7E, 0xFC, 0xE0, 0xE2, 0x7C, 0x7C, 0x03, 0x83, 0xC1, 0xA1,
  0xC0, 0xF0, 0xF8, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0xF0, 0x70, 0x00, 0x1F, 0x9F, 0x9D, 0xCE, 0xE6, 0x77, 0x3B,
  0x99, 0xDC, 0xFE, 0x3F, 0x03, 0x91, 0x8F, 0xC7, 0xC0, 0x18, 0x38, 0x38,
  0x38, 0x37, 0x3F, 0x77, 0x77, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xCE, 0x19,
  0xCE, 0x03, 0x19, 0xCE, 0x73, 0x19, 0xCE, 0x60, 0x06, 0x1C, 0x38, 0x00,
  0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x38, 0xF1, 0xC0,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x39, 0xB9, 0xD8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x1D, 0xCE, 0xE6, 0x70, 0x19, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x19, 0xCE,
  0x60, 0x37, 0x73, 0xFF, 0x77, 0x77, 0x73, 0x77, 0x76, 0x67, 0x66, 0x6E,
  0x66, 0xEE, 0xEC, 0xEE, 0x37, 0x3F, 0x77, 0x77, 0x77, 0x67, 0x66, 0xE6,
  0xEE, 0xCE, 0x1E, 0x3F, 0x77, 0x77, 0x67, 0xE7, 0xE6, 0xEE, 0x7C, 0x78,
  0x1B, 0x8F, 0xCE, 0x67, 0x33, 0x39, 0x9C, 0xCE, 0xEE, 0x7F, 0x37, 0x18,
  0x0C, 0x0E, 0x07, 0x00, 0x1F, 0x9F, 0x9D, 0xCE, 0xE6, 0x77, 0x3B, 0x99,
  0xDC, 0xFE, 0x3F, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x36, 0x7D, 0xF3, 0x87,
  0x0C, 0x18, 0x70, 0xE1, 0x80, 0x3E, 0xFD, 0xD3, 0x87, 0x87, 0x87, 0x4E,
  0xF9, 0xF0, 0x31, 0x9F, 0xF6, 0x73, 0x9C, 0xC6, 0x3D, 0xE0, 0x33, 0x99,
  0x9C, 0xCE, 0xE6, 0x73, 0x39, 0x99, 0xDC, 0xFE, 0x3B, 0x00, 0xE7, 0xEE,
  0xEE, 0xEC, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0xEE, 0x7E, 0xE6, 0xDE,
  0xED, 0xEC, 0xDF, 0xCF, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0x39,
  0xC6, 0xE1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xD8, 0x76, 0x39, 0xC0,
  0x39, 0xCE, 0xE3, 0xB8, 0xEC, 0x3F, 0x0F, 0x83, 0xE0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xC0, 0xF0, 0x38, 0x00, 0x3F, 0x3F, 0x06, 0x0E, 0x1C, 0x18,
  0x38, 0x70, 0x7E, 0xFC, 0x06, 0x1C, 0x70, 0xE1, 0x87, 0x0E, 0x78, 0xE0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x38, 0x70, 0x61, 0xC3, 0x87, 0x07, 0x1E, 0x70, 0xE1, 0x83, 0x0E, 0x3C,
  0x60, 0xF3, 0xFE, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 7, 5, 8, 2, -13 },
  { 15, 10, 13, 9, 0, -13 },
  { 32, 8, 15, 8, 0, -14 },
  { 47, 12, 13, 13, 1, -13 },
  { 67, 10, 13, 10, 0, -13 },
  { 84, 3, 5, 4, 2, -13 },
  { 86, 6, 16, 5, 0, -13 },
  { 98, 6, 16, 5, -1, -13 },
  { 110, 7, 8, 8, 1, -14 },
  { 117, 7, 9, 9, 1, -11 },
  { 125, 4, 5, 4, -1, -3 },
  { 128, 5, 2, 5, 0, -6 },
  { 130, 3, 3, 4, 0, -3 },
  { 132, 10, 13, 7, -1, -13 },
  { 149, 8, 13, 8, 0, -13 },
  { 162, 6, 13, 8, 2, -13 },
  { 172, 9, 13, 8, -1, -13 },
  { 187, 8, 13, 8, 0, -13 },
  { 200, 8, 13, 8, 0, -13 },
  { 213, 8, 13, 8, 0, -13 },
  { 226, 9, 13, 8, 0, -13 },
  { 241, 9, 13, 8, 0, -13 },
  { 256, 8, 13, 8, 0, -13 },
  { 269, 8, 13, 8, 0, -13 },
  { 282, 5, 10, 5, 0, -10 },
  { 289, 6, 12, 5, -1, -10 },
  { 298, 7, 9, 9, 1, -11 },
  { 306, 7, 6, 9, 1, -9 },
  { 312, 7, 9, 9, 1, -11 },
  { 320, 7, 13, 6, 0, -13 },
  { 332, 12, 14, 12, 0, -13 },
  { 353, 9, 13, 9, -1, -13 },
  { 368, 9, 13, 9, 0, -13 },
  { 383, 8, 13, 8, 1, -13 },
  { 396, 9, 13, 9, 0, -13 },
  { 411, 8, 13, 7, 0, -13 },
  { 424, 8, 13, 7, 0, -13 },
  { 437, 9, 13, 10, 1, -13 },
  { 452, 11, 13, 10, 0, -13 },
  { 470, 9, 13, 6, -1, -13 },
  { 485, 8, 17, 5, -3, -13 },
  { 502, 10, 13, 9, 0, -13 },
  { 519, 6, 13, 7, 0, -13 },
  { 529, 14, 13, 13, 0, -13 },
  { 552, 11, 13, 10, 0, -13 },
  { 570, 9, 13, 10, 1, -13 },
  { 585, 9, 13, 8, 0, -13 },
  { 600, 9, 16, 10, 1, -13 },
  { 618, 9, 13, 9, 0, -13 },
  { 633, 9, 13, 8, 0, -13 },
  { 648, 8, 13, 7, 1, -13 },
  { 661, 9, 13, 10, 1, -13 },
  { 676, 8, 13, 9, 2, -13 },
  { 689, 14, 13, 13, 1, -13 },
  { 712, 11, 13, 8, -1, -13 },
  { 730, 8, 13, 8, 2, -13 },
  { 743, 10, 13, 7, -1, -13 },
  { 760, 8, 16, 5, -1, -13 },
  { 776, 4, 13, 7, 2, -13 },
  { 783, 7, 16, 5, -1, -13 },
  { 797, 8, 8, 8, 0, -13 },
  { 805, 7, 2, 6, -2, 1 },
  { 807, 3, 3, 6, 3, -14 },
  { 809, 9, 10, 9, 0, -10 },
  { 821, 8, 14, 9, 0, -14 },
  { 835, 7, 10, 7, 0, -10 },
  { 844, 10, 14, 9, 0, -14 },
  { 862, 8, 10, 8, 0, -10 },
  { 872, 9, 18, 5, -2, -14 },
  { 893, 9, 14, 9, 0, -10 },
  { 909, 8, 14, 9, 0, -14 },
  { 923, 5, 14, 4, 0, -14 },
  { 932, 7, 18, 4, -2, -14 },
  { 948, 9, 14, 8, 0, -14 },
  { 964, 5, 14, 4, 0, -14 },
  { 973, 12, 10, 13, 0, -10 },
  { 988, 8, 10, 9, 0, -10 },
  { 998, 8, 10, 8, 0, -10 },
  { 1008, 9, 14, 9, -1, -10 },
  { 1024, 9, 14, 9, 0, -10 },
  { 1040, 7, 10, 6, 0, -10 },
  { 1049, 7, 10, 7, 0, -10 },
  { 1058, 5, 12, 6, 1, -12 },
  { 1066, 9, 10, 8, 0, -10 },
  { 1078, 8, 10, 8, 1, -10 },
  { 1088, 12, 10, 12, 1, -10 },
  { 1103, 10, 10, 8, -1, -10 },
  { 1116, 10, 14, 8, -1, -10 },
  { 1134, 8, 10, 7, -1, -10 },
  { 1144, 7, 16, 6, 0, -13 },
  { 1158, 2, 18, 7, 2, -14 },
  { 1163, 7, 16, 6, -1, -13 },
  { 1177, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC18PT7B_H_
