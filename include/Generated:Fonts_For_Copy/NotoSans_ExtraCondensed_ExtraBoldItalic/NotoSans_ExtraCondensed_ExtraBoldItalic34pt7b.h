#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x01,
  0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xC0, 0x7C, 0xFB, 0xE7, 0xDF, 0x3C,
  0xF1, 0xE7, 0x9F, 0x3C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1, 0xE0, 0x00, 0xF3,
  0xC0, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x9C, 0x01, 0xCF, 0x00, 0xF3, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0x8E, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x07, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07,
  0x9C, 0x01, 0xCF, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x01, 0xFE,
  0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x4C, 0x1E, 0x40, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x01, 0x7C, 0x41, 0x7C, 0x63, 0x78, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x10, 0x7E, 0x03, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0xF0, 0x7B,
  0xC3, 0xC1, 0xCF, 0x1E, 0x0F, 0x3C, 0x70, 0x3C, 0xF3, 0xC0, 0xF3, 0xCE,
  0x03, 0x8E, 0x78, 0x0E, 0x79, 0xC7, 0xB9, 0xEF, 0x7F, 0xFF, 0x79, 0xFF,
  0xFD, 0xEF, 0xF7, 0xEF, 0x79, 0xCC, 0x3D, 0xE7, 0x01, 0xE7, 0x1C, 0x07,
  0x1C, 0x70, 0x3C, 0xF3, 0xC0, 0xE3, 0xCF, 0x07, 0x8F, 0x38, 0x3C, 0x3D,
  0xE0, 0xF0, 0xFF, 0x07, 0x81, 0xFC, 0x1E, 0x03, 0xE0, 0x00, 0x20, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x3E, 0x3F, 0xEF, 0x8F, 0xFD, 0xF3, 0xEF, 0xBC, 0x7C,
  0xFF, 0x9F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x3F, 0x0F, 0x8F, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0x9F, 0x80, 0x7E, 0xF9, 0xF3,
  0xE7, 0x8F, 0x1E, 0x78, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x07,
  0x80, 0x3C, 0x21, 0xE0, 0xCF, 0x0F, 0x73, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0x1F, 0x81, 0xFC, 0x1F, 0xF1, 0xF7, 0xC7, 0x1E, 0x18, 0xE0, 0x04, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xE7, 0xFB, 0xFE, 0x11, 0xEF, 0xFF,
  0xFB, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0x7C, 0xF3, 0xE3, 0xCF,
  0x8F, 0x3C, 0x3D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x7F, 0xE1, 0xFF,
  0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x1F, 0x3C, 0x7C, 0xFB, 0xE3,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFE, 0xFF, 0xE7, 0xBC, 0x77, 0xC2, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x30, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0x1F, 0x06, 0x1F, 0x04, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x70, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x04, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x80,
  0xF8, 0xC1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0x7C, 0x0F, 0x7C, 0x0E, 0x78, 0x1E, 0xF8, 0x3C,
  0xF8, 0x38, 0xF8, 0x78, 0xF8, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x80,
  0xF8, 0xC1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x1E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x79, 0xE1, 0xF7, 0xE3, 0xFF, 0xC7, 0xFF, 0x9F,
  0xDF, 0x3F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF,
  0xCF, 0x9F, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x30,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xBF, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3E, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x00, 0x70, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE7, 0xC7,
  0xCF, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFE, 0x0E, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x07,
  0x07, 0xC7, 0xE3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x81, 0xE1, 0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x01, 0xC0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x98, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFC, 0x7C, 0x07, 0xC0, 0x78,
  0x3C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x0F, 0xE7, 0x3C, 0x7F, 0x9C, 0xE3,
  0xFE, 0x77, 0x9E, 0x71, 0xDC, 0x71, 0xC7, 0x73, 0xCF, 0x3F, 0xCE, 0x3C,
  0xEE, 0x38, 0xE3, 0xB9, 0xE3, 0x8E, 0xE7, 0x9E, 0x73, 0x9E, 0x79, 0xCE,
  0x7F, 0xFE, 0x38, 0xFF, 0xF0, 0xE1, 0xC7, 0x83, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x80, 0x7E, 0x1E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xF7,
  0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7C, 0x7C, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0x83, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0x9F,
  0x87, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x30, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC3, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0x9F, 0x83, 0xE3, 0xF0, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7,
  0xC3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x41, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF1, 0xFE,
  0x7C, 0x7F, 0x1F, 0x1F, 0xCF, 0xCF, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F,
  0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0x7E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8,
  0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xE0, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0x7F, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x07, 0xE0, 0x3F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xBC, 0xFF, 0xC1, 0xEF,
  0x3D, 0xE0, 0x7B, 0xCF, 0xF8, 0x3E, 0xF7, 0xBE, 0x0F, 0xBD, 0xEF, 0x83,
  0xEF, 0xF3, 0xC0, 0xF3, 0xFD, 0xF0, 0x7C, 0xFF, 0x7C, 0x1F, 0x3F, 0x9F,
  0x07, 0xCF, 0xE7, 0xC1, 0xE3, 0xF1, 0xE0, 0x78, 0xFC, 0xF8, 0x3E, 0x3E,
  0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xC3, 0xF8, 0x3C, 0x1F, 0xC1, 0xE0, 0xFE, 0x1F, 0x07, 0xF8, 0xF8,
  0x3F, 0xC7, 0xC3, 0xFE, 0x3C, 0x1F, 0xF3, 0xE0, 0xF7, 0x9F, 0x07, 0xBC,
  0xF8, 0x3D, 0xF7, 0xC3, 0xEF, 0xBC, 0x1F, 0x3D, 0xE0, 0xF9, 0xFF, 0x07,
  0x8F, 0xF8, 0x7C, 0x7F, 0x83, 0xE3, 0xFC, 0x1F, 0x1F, 0xE0, 0xF0, 0x7F,
  0x07, 0x83, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xE3,
  0xF1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0xFD,
  0xF0, 0x3F, 0x7C, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0x3F, 0x07, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xE3,
  0xF1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0xFD,
  0xF0, 0x3F, 0x7C, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0x3F, 0x07, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xDF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xFC,
  0x00, 0x30, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E,
  0x30, 0x3E, 0x08, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x0C, 0x1F, 0x87, 0x9F, 0x83, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xF3, 0xF0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xF8, 0x1F, 0xFC,
  0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x7C, 0x1E, 0x0F, 0xDF, 0x07, 0x83, 0xE7, 0xC3, 0xE0, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x7E, 0x1F, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF3,
  0xF8, 0xF8, 0x78, 0xFE, 0x7C, 0x1E, 0x7F, 0x9F, 0x07, 0x9F, 0xE7, 0x81,
  0xE7, 0xFB, 0xE0, 0x7B, 0xDE, 0xF8, 0x1E, 0xF7, 0xFC, 0x07, 0xF9, 0xFF,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFB, 0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C,
  0x78, 0xF8, 0x7C, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xFE, 0x07, 0xFE, 0x0F, 0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xF7, 0xC1,
  0xEF, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF9,
  0xF1, 0xE3, 0xE0, 0x07, 0x9E, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7,
  0xEF, 0x8F, 0x9F, 0x1F, 0x7E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3E, 0x7C, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE1, 0xF3, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x38, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xF7, 0xF0, 0xF3, 0xE0, 0x03, 0xE0, 0x7F, 0xC7, 0xFC,
  0x7F, 0xE3, 0xE2, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE3, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x3C, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x87, 0xCF, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x0F, 0x87, 0xCF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFE, 0xF0, 0x3E, 0x78, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xBE, 0x7E,
  0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x82,
  0x3F, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x17, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE7, 0x81, 0xFB, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFB, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x07, 0xDF, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC3,
  0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x9E, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFD, 0xF1, 0xF3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x0F, 0xBE, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF0,
  0x03, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x38, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xCF, 0x81, 0xEF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x00, 0x0E, 0x3C, 0x78, 0x3D, 0xFD, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFB, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F, 0x1F,
  0x1F, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3,
  0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x0F, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C,
  0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xE3, 0xE3, 0xC7, 0xC0, 0x0E, 0x3C, 0x3D,
  0xFC, 0x7B, 0xF8, 0xFF, 0xF1, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3E, 0x3E, 0x78, 0x7D, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1F, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE0, 0x03, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0xF0, 0xFB, 0xC3, 0xEF, 0x9F, 0x3F,
  0xFC, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0x8F, 0x01, 0xEF, 0xE0,
  0x7B, 0xF8, 0x1F, 0xFE, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F,
  0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xEF, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x9E, 0x1F, 0xBC,
  0x7F, 0x79, 0xFF, 0xF3, 0xE7, 0xEF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0xF8,
  0x7D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1F, 0x3E, 0x7C,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xF7, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0E,
  0x38, 0xF7, 0xC7, 0xBE, 0x3F, 0xE1, 0xFF, 0x0F, 0xC8, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x7F, 0xC7, 0xFE, 0x7F,
  0xE3, 0xE3, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF2, 0x0F, 0x9F, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F,
  0xC0, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xFE, 0x7F, 0xDF, 0xF3, 0xFE,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC0, 0x1E, 0x1E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3E,
  0x7C, 0x7F, 0xF8, 0xFF, 0xF1, 0xFD, 0xE1, 0xF3, 0xC0, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0xF8, 0xFB,
  0xE3, 0xEF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0xFC, 0x7F, 0xE3, 0xE1,
  0xEF, 0x9F, 0x8F, 0xBE, 0x7E, 0x3C, 0xF9, 0xF9, 0xF3, 0xEF, 0xE7, 0xCF,
  0xBF, 0x9E, 0x3D, 0xFE, 0xF8, 0xF7, 0xFB, 0xC3, 0xDD, 0xEF, 0x0F, 0xF7,
  0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x00,
  0x0F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xF0,
  0x3E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x1E,
  0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x80,
  0xFC, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x02, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0x1F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 13, 9, 14, 3, -24 },
  { 46, 18, 24, 17, 0, -24 },
  { 100, 16, 28, 15, 0, -26 },
  { 156, 22, 25, 25, 2, -25 },
  { 225, 19, 25, 19, 0, -25 },
  { 285, 7, 9, 8, 3, -24 },
  { 293, 12, 30, 9, 0, -25 },
  { 338, 12, 30, 9, -3, -25 },
  { 383, 13, 15, 14, 3, -26 },
  { 408, 15, 16, 16, 1, -20 },
  { 438, 8, 10, 8, -2, -5 },
  { 448, 10, 4, 10, 0, -11 },
  { 453, 6, 6, 8, 0, -6 },
  { 458, 18, 25, 13, -2, -25 },
  { 515, 14, 25, 15, 1, -25 },
  { 559, 12, 24, 15, 3, -24 },
  { 595, 16, 25, 15, -1, -25 },
  { 645, 16, 25, 15, 0, -25 },
  { 695, 16, 24, 15, 0, -24 },
  { 743, 16, 24, 15, 0, -24 },
  { 791, 15, 25, 15, 1, -25 },
  { 838, 16, 24, 15, 1, -24 },
  { 886, 16, 25, 15, 0, -25 },
  { 936, 15, 25, 15, 0, -25 },
  { 983, 9, 19, 9, 0, -19 },
  { 1005, 11, 24, 9, -2, -19 },
  { 1038, 15, 16, 16, 1, -20 },
  { 1068, 15, 12, 16, 1, -18 },
  { 1091, 15, 16, 16, 1, -20 },
  { 1121, 13, 25, 12, 1, -25 },
  { 1162, 22, 28, 23, 1, -25 },
  { 1239, 17, 24, 17, -2, -24 },
  { 1290, 17, 24, 17, 0, -24 },
  { 1341, 17, 25, 15, 1, -25 },
  { 1395, 18, 24, 18, 0, -24 },
  { 1449, 16, 24, 14, 0, -24 },
  { 1497, 16, 24, 13, 0, -24 },
  { 1545, 18, 25, 18, 1, -25 },
  { 1602, 20, 24, 19, 0, -24 },
  { 1662, 15, 24, 12, -1, -24 },
  { 1707, 15, 31, 9, -5, -24 },
  { 1766, 20, 24, 16, 0, -24 },
  { 1826, 12, 24, 13, 0, -24 },
  { 1862, 26, 24, 24, 0, -24 },
  { 1940, 21, 24, 20, 0, -24 },
  { 2003, 18, 25, 19, 1, -25 },
  { 2060, 17, 24, 16, 0, -24 },
  { 2111, 18, 31, 19, 1, -25 },
  { 2181, 17, 24, 16, 0, -24 },
  { 2232, 17, 25, 14, -1, -25 },
  { 2286, 15, 24, 14, 2, -24 },
  { 2331, 18, 24, 18, 1, -24 },
  { 2385, 17, 24, 17, 3, -24 },
  { 2436, 26, 24, 24, 2, -24 },
  { 2514, 20, 24, 16, -2, -24 },
  { 2574, 16, 24, 15, 3, -24 },
  { 2622, 17, 24, 14, -1, -24 },
  { 2673, 14, 31, 10, -2, -25 },
  { 2728, 8, 25, 13, 3, -25 },
  { 2753, 14, 31, 10, -3, -25 },
  { 2808, 15, 15, 15, 0, -24 },
  { 2837, 12, 3, 12, -3, 3 },
  { 2842, 7, 5, 11, 5, -26 },
  { 2847, 15, 19, 16, 1, -19 },
  { 2883, 16, 26, 16, 0, -26 },
  { 2935, 13, 19, 13, 1, -19 },
  { 2966, 17, 26, 16, 1, -26 },
  { 3022, 14, 19, 15, 1, -19 },
  { 3056, 18, 34, 10, -4, -26 },
  { 3133, 17, 27, 16, -1, -19 },
  { 3191, 15, 26, 16, 0, -26 },
  { 3240, 10, 26, 8, 0, -26 },
  { 3273, 14, 34, 8, -4, -26 },
  { 3333, 17, 26, 15, 0, -26 },
  { 3389, 10, 26, 8, 0, -26 },
  { 3422, 23, 19, 24, 0, -19 },
  { 3477, 15, 19, 16, 0, -19 },
  { 3513, 14, 19, 16, 1, -19 },
  { 3547, 18, 27, 16, -2, -19 },
  { 3608, 15, 27, 16, 1, -19 },
  { 3659, 13, 19, 11, 0, -19 },
  { 3690, 13, 19, 13, 0, -19 },
  { 3721, 11, 23, 11, 1, -23 },
  { 3753, 15, 19, 16, 1, -19 },
  { 3789, 14, 19, 14, 2, -19 },
  { 3823, 22, 19, 22, 2, -19 },
  { 3876, 18, 19, 15, -2, -19 },
  { 3919, 18, 27, 15, -2, -19 },
  { 3980, 14, 19, 12, -1, -19 },
  { 4014, 14, 29, 12, 0, -24 },
  { 4065, 4, 34, 13, 4, -26 },
  { 4082, 13, 29, 12, -2, -24 },
  { 4130, 15, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC34PT7B_H_
