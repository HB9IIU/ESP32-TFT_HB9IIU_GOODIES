#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xC0, 0x00,
  0x0E, 0x3C, 0x78, 0xE0, 0x7B, 0xB9, 0xDD, 0xEE, 0xEE, 0x77, 0x38, 0x03,
  0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xC3, 0xFF, 0x9F, 0xFC, 0xFF, 0xC3, 0xB8,
  0x1D, 0xC0, 0xCC, 0x3F, 0xF9, 0xFF, 0xC3, 0x30, 0x39, 0x81, 0xDC, 0x0C,
  0xC0, 0xE6, 0x00, 0x01, 0x00, 0x20, 0x3F, 0x8F, 0xF1, 0xFC, 0x74, 0x8E,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE8, 0x7C, 0x9F, 0x3F, 0xE7,
  0xF8, 0x7E, 0x01, 0x00, 0x60, 0x00, 0x1E, 0x1C, 0x3E, 0x18, 0x76, 0x38,
  0x67, 0x30, 0x66, 0x70, 0xE6, 0x60, 0xEE, 0xE4, 0xEF, 0xDF, 0xFD, 0xFF,
  0x7B, 0xBB, 0x03, 0x33, 0x07, 0x73, 0x06, 0x77, 0x0E, 0x77, 0x0C, 0x76,
  0x1C, 0x7E, 0x38, 0x3C, 0x07, 0xC0, 0x7F, 0x07, 0xB8, 0x39, 0xC1, 0xCE,
  0x0F, 0xE0, 0x7E, 0x01, 0xE0, 0x3F, 0x3B, 0xFB, 0xDD, 0xFD, 0xE7, 0xEF,
  0x3E, 0x79, 0xE3, 0xFF, 0x9F, 0xFC, 0x7C, 0xF0, 0x7B, 0x9C, 0xEF, 0x70,
  0x07, 0x87, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x00,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x0E, 0x46,
  0x3B, 0x3F, 0xFF, 0xF9, 0xFD, 0xF9, 0xFC, 0x67, 0x12, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0, 0x7F, 0xFE, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x0F,
  0x87, 0xE3, 0xFC, 0xEF, 0x79, 0xDC, 0xFF, 0x3F, 0xCF, 0xE3, 0xB8, 0xEE,
  0x7B, 0x9E, 0xE7, 0x3B, 0xCF, 0xE3, 0xF8, 0x78, 0x00, 0x07, 0x87, 0x87,
  0xC7, 0xEF, 0xF3, 0x71, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x00, 0x07, 0xE0, 0xFE, 0x1F, 0xF0, 0xCF, 0x08,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x7F, 0xC7, 0xF8, 0xFF, 0x80, 0x0F, 0xC3, 0xFC, 0x7F, 0x88,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0xF8, 0x1F, 0x03, 0xF0, 0x0F, 0x01, 0xE0,
  0x39, 0x0F, 0x3F, 0xE7, 0xF8, 0xFE, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x83,
  0xE0, 0x7C, 0x1B, 0x87, 0xF0, 0xDC, 0x33, 0x8E, 0x71, 0x9E, 0x7F, 0xEF,
  0xFD, 0xFF, 0x81, 0xC0, 0x78, 0x0F, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x8E,
  0x01, 0xC0, 0x78, 0x0F, 0xC1, 0xFC, 0x3F, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x39, 0x0F, 0x3F, 0xE7, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x7F, 0x1E,
  0x03, 0x80, 0xF0, 0x1D, 0xC7, 0xFC, 0xFF, 0x9E, 0x73, 0x8E, 0x73, 0xCE,
  0x79, 0xCE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x3F, 0xE7, 0xFD, 0xFF, 0x00,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xC3, 0xFC, 0x7F, 0x9E,
  0x73, 0xCE, 0x7B, 0xC7, 0xF0, 0xFC, 0x1F, 0x07, 0xF1, 0xEF, 0x79, 0xEF,
  0x3D, 0xE7, 0x3F, 0xE3, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF8, 0x7F, 0x9E,
  0xF3, 0x9E, 0x73, 0xDE, 0x7B, 0xCF, 0x7F, 0xC7, 0xF8, 0xFF, 0x01, 0xC0,
  0x78, 0x0E, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0xF3, 0xC6, 0x00, 0x00,
  0x00, 0x01, 0xCF, 0x3C, 0xE0, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0xC0, 0xF0, 0xFC, 0xFC,
  0xFC, 0x3C, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF0, 0xFD, 0xFC, 0xFC, 0x3C, 0x08, 0x00, 0x3F, 0x3F, 0x9F, 0xE8,
  0xF0, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x03,
  0xC1, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x78, 0x31, 0xC0, 0x73,
  0x1E, 0x6E, 0x7E, 0xD9, 0x99, 0xF7, 0x33, 0xCC, 0xE7, 0x99, 0xDF, 0x73,
  0x36, 0xEE, 0x6C, 0xFF, 0x99, 0xEE, 0x30, 0x00, 0x70, 0x00, 0x70, 0xC0,
  0xFF, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7,
  0x8E, 0x70, 0xEF, 0x0F, 0xF0, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xF1, 0xCF,
  0x1C, 0xF3, 0xCF, 0x3D, 0xE3, 0xFC, 0x3F, 0xC7, 0xFC, 0x79, 0xE7, 0x9E,
  0x71, 0xE7, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0xE3, 0xFC, 0x7F,
  0x1E, 0x27, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE2, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x07,
  0xFC, 0x39, 0xE1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x38, 0xF3, 0xC7,
  0x9E, 0x3C, 0xF3, 0xC7, 0x1E, 0x39, 0xE3, 0xFF, 0x1F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xFC, 0x3F,
  0x8F, 0xF1, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3F, 0xC7, 0xF8, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xFC, 0x3F,
  0x8F, 0xF1, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x78, 0x47, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x7C, 0xF3, 0xE7, 0x9F, 0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x78, 0xE3, 0xFF,
  0x0F, 0xF8, 0x3F, 0x80, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x1C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x8F, 0x1E,
  0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC0, 0x1F, 0xE3,
  0xFC, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x3F, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x3C, 0x79, 0xE1, 0xCF, 0x07, 0x3C,
  0x1D, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xB8,
  0x1E, 0xE0, 0x73, 0x81, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0x1E,
  0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C,
  0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x77,
  0x1F, 0xDD, 0xC7, 0xF7, 0xF1, 0xCF, 0xBC, 0x73, 0xEE, 0x1C, 0xF3, 0x8F,
  0x3C, 0xE3, 0xCE, 0x78, 0xE3, 0x9E, 0x00, 0x1F, 0x1E, 0x3E, 0x38, 0x7C,
  0x70, 0xF8, 0xE1, 0xF1, 0xC7, 0xE7, 0x8E, 0xEE, 0x1D, 0xDC, 0x3B, 0xB8,
  0xF7, 0x71, 0xEF, 0xE3, 0x9F, 0x87, 0x1F, 0x0E, 0x3E, 0x3C, 0x7C, 0x78,
  0xF8, 0xE1, 0xE0, 0x07, 0xE1, 0xFF, 0x1F, 0xF3, 0xCF, 0x78, 0x77, 0x87,
  0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C,
  0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C,
  0xF3, 0xCF, 0x3C, 0xF3, 0x9E, 0x3F, 0xE7, 0xFC, 0x7F, 0x87, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xE1, 0xFF, 0x1F, 0xF3,
  0xCF, 0x78, 0x77, 0x87, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF,
  0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C, 0xF3, 0xCF,
  0x3C, 0xE3, 0xBE, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x73, 0x87, 0x38,
  0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x0F, 0xE3, 0xFC, 0xFF, 0x9E, 0x23, 0xC0,
  0x78, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x79, 0x8F,
  0x3F, 0xC7, 0xF8, 0xFC, 0x00, 0xFF, 0xFF, 0xEF, 0xF8, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x00, 0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x71, 0xE7, 0x8F, 0x3C,
  0x71, 0xE3, 0x8E, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0x71, 0xE3, 0x8E, 0x3C,
  0x79, 0xE3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF,
  0x1C, 0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFE, 0x0E,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0xF1, 0xC3, 0xF0,
  0xE3, 0xF8, 0xF1, 0xDC, 0x78, 0xEE, 0x7C, 0xF7, 0x3E, 0x73, 0x9F, 0x79,
  0xDF, 0xBC, 0xEF, 0xDC, 0x76, 0xFE, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F,
  0x87, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x39, 0xE0, 0xE7, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xE7, 0x07, 0x9C,
  0x1C, 0x70, 0xF1, 0xE0, 0xF1, 0xFE, 0x39, 0xCF, 0x39, 0xC7, 0x70, 0xEE,
  0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xC3, 0xE0, 0xE0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0xE1,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C,
  0x07, 0xC3, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x07, 0xC3,
  0xF0, 0xFC, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x3B, 0x8E,
  0x71, 0xCE, 0x71, 0xDE, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0x80, 0xF3, 0xCE,
  0x1E, 0xF1, 0xFE, 0x3F, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x1C,
  0xF3, 0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x7B, 0x80, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x7F, 0x8F, 0xF9, 0xFF, 0x39, 0xE7, 0x3D, 0xE7, 0xB8,
  0xF7, 0x1C, 0xE3, 0xBC, 0xF7, 0xFC, 0xFF, 0x9D, 0xE0, 0x0F, 0xC7, 0xE3,
  0xF8, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x47, 0xF1, 0xFC,
  0x3E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x39, 0xE3, 0xCF, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x79,
  0xE3, 0xCF, 0x1F, 0xF0, 0x7F, 0x83, 0xDC, 0x00, 0x0F, 0x87, 0xF3, 0xDC,
  0xE7, 0x79, 0xDF, 0xF7, 0xF1, 0xC0, 0xF0, 0x3C, 0x07, 0xB1, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0x80, 0x38, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x7E,
  0x03, 0xE0, 0x1E, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x39, 0xE3, 0xCF,
  0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x79, 0xE3, 0xCF, 0x1F, 0xF0, 0x7F, 0x83,
  0xDC, 0x01, 0xE0, 0x0E, 0x18, 0xF0, 0xFF, 0x87, 0xF8, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x7F, 0x8F, 0xF9, 0xFF, 0x39, 0xE7,
  0x3D, 0xE7, 0x3C, 0xE7, 0x1C, 0xE7, 0xBC, 0xF7, 0x9C, 0xE3, 0x9C, 0xF0,
  0x1E, 0x3C, 0x70, 0x00, 0x07, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x0E,
  0x3C, 0x78, 0xF1, 0xC0, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x3E, 0x0F, 0x83, 0x80, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xCF, 0x3D, 0xE3, 0x9C, 0x3B, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xF7, 0x8F, 0x78, 0xE3, 0x8E,
  0x3C, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7,
  0x0E, 0x3C, 0x78, 0xF1, 0xC0, 0x3B, 0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x39,
  0xE7, 0x39, 0xE7, 0x79, 0xCF, 0x79, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0xF3,
  0x8E, 0xF3, 0x9E, 0xE3, 0x9E, 0xE7, 0x9C, 0x3B, 0xC7, 0xFC, 0xFF, 0x9C,
  0xF3, 0x9E, 0xF3, 0x9E, 0x73, 0x8E, 0x73, 0xCE, 0x7B, 0xCE, 0x71, 0xCE,
  0x78, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xF7, 0x9E, 0xE3, 0xDC, 0x73, 0x8E,
  0xF3, 0xDE, 0x79, 0xFE, 0x3F, 0x83, 0xE0, 0x1D, 0xE1, 0xFF, 0x1F, 0xF1,
  0xCF, 0x1C, 0xF3, 0xCF, 0x38, 0xF3, 0x8E, 0x38, 0xE7, 0x9E, 0x7F, 0xC7,
  0xFC, 0x77, 0x87, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x1C,
  0xF3, 0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x7B, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0x3B, 0x9F, 0xCF, 0xE7, 0x93, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x00, 0x1F, 0x9F, 0xDE, 0xCF,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x47, 0xBF, 0x9F, 0xCF, 0xC0, 0x1C,
  0x38, 0xE3, 0xFF, 0xFF, 0xDC, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1F, 0x3E,
  0x7C, 0x3C, 0xF3, 0xCE, 0x38, 0xE3, 0x9E, 0x39, 0xE7, 0x9C, 0x71, 0xC7,
  0x3C, 0x73, 0xC7, 0x38, 0xFF, 0x87, 0xF8, 0x7B, 0x80, 0xF1, 0xEE, 0x79,
  0xCE, 0x3B, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0x73, 0xCF, 0xF3, 0xCE, 0xF7, 0xDE, 0xF7, 0xDC, 0xFF,
  0xDC, 0xFF, 0xF8, 0xED, 0xF8, 0xFD, 0xF8, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9,
  0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1C, 0xF1, 0xCE, 0x1F, 0xE1, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xB8, 0x7B, 0x87, 0x38, 0xF3,
  0xC0, 0x0E, 0x3C, 0x39, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1F,
  0xC7, 0xF3, 0xFC, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07,
  0xF3, 0xFC, 0xFF, 0x00, 0x03, 0xC1, 0xF0, 0xF8, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0xC1, 0xE3, 0xE1, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x3E, 0x1E, 0x0C, 0x00, 0x20, 0x7F, 0x1F, 0xFF, 0x3F, 0x81, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 9, 6, 10, 2, -17 },
  { 23, 13, 17, 12, 0, -17 },
  { 51, 11, 19, 11, 0, -18 },
  { 78, 16, 17, 18, 1, -17 },
  { 112, 13, 17, 13, 0, -17 },
  { 140, 5, 6, 6, 2, -17 },
  { 144, 9, 21, 7, 0, -17 },
  { 168, 8, 22, 7, -2, -18 },
  { 190, 9, 10, 10, 2, -18 },
  { 202, 10, 11, 12, 1, -14 },
  { 216, 5, 6, 6, -1, -3 },
  { 220, 7, 3, 7, 0, -8 },
  { 223, 4, 4, 6, 0, -4 },
  { 225, 12, 17, 9, -1, -17 },
  { 251, 10, 17, 11, 1, -17 },
  { 273, 9, 17, 11, 2, -17 },
  { 293, 12, 17, 11, -1, -17 },
  { 319, 11, 17, 11, 0, -17 },
  { 343, 11, 17, 11, 0, -17 },
  { 367, 11, 17, 11, 0, -17 },
  { 391, 11, 17, 11, 1, -17 },
  { 415, 11, 17, 11, 1, -17 },
  { 439, 11, 17, 11, 0, -17 },
  { 463, 11, 17, 11, 0, -17 },
  { 487, 6, 13, 6, 0, -13 },
  { 497, 7, 16, 6, -1, -13 },
  { 511, 10, 11, 12, 1, -14 },
  { 525, 10, 7, 12, 1, -12 },
  { 534, 10, 11, 12, 1, -14 },
  { 548, 9, 17, 8, 1, -17 },
  { 568, 15, 19, 16, 1, -17 },
  { 604, 12, 17, 12, -1, -17 },
  { 630, 12, 17, 12, 0, -17 },
  { 656, 11, 17, 11, 1, -17 },
  { 680, 13, 17, 13, 0, -17 },
  { 708, 11, 17, 10, 0, -17 },
  { 732, 11, 17, 9, 0, -17 },
  { 756, 13, 17, 13, 1, -17 },
  { 784, 14, 17, 13, 0, -17 },
  { 814, 11, 17, 8, -1, -17 },
  { 838, 11, 22, 6, -4, -17 },
  { 869, 14, 17, 12, 0, -17 },
  { 899, 8, 17, 9, 0, -17 },
  { 916, 18, 17, 17, 0, -17 },
  { 955, 15, 17, 14, 0, -17 },
  { 987, 12, 17, 13, 1, -17 },
  { 1013, 12, 17, 11, 0, -17 },
  { 1039, 12, 21, 13, 1, -17 },
  { 1071, 12, 17, 12, 0, -17 },
  { 1097, 11, 17, 10, 0, -17 },
  { 1121, 10, 17, 10, 2, -17 },
  { 1143, 13, 17, 13, 1, -17 },
  { 1171, 12, 17, 12, 2, -17 },
  { 1197, 17, 17, 17, 2, -17 },
  { 1234, 14, 17, 11, -1, -17 },
  { 1264, 11, 17, 11, 2, -17 },
  { 1288, 13, 17, 10, -1, -17 },
  { 1316, 10, 21, 7, -1, -17 },
  { 1343, 6, 17, 9, 2, -17 },
  { 1356, 10, 21, 7, -2, -17 },
  { 1383, 11, 11, 11, 0, -17 },
  { 1399, 9, 2, 8, -2, 2 },
  { 1402, 5, 3, 8, 3, -18 },
  { 1404, 12, 13, 11, 0, -13 },
  { 1424, 11, 18, 11, 0, -18 },
  { 1449, 10, 13, 9, 0, -13 },
  { 1466, 13, 18, 11, 0, -18 },
  { 1496, 10, 13, 11, 0, -13 },
  { 1513, 13, 24, 7, -3, -18 },
  { 1552, 13, 19, 11, -1, -13 },
  { 1583, 11, 18, 11, 0, -18 },
  { 1608, 7, 18, 6, 0, -18 },
  { 1624, 10, 24, 6, -3, -18 },
  { 1654, 12, 18, 11, 0, -18 },
  { 1681, 7, 18, 6, 0, -18 },
  { 1697, 16, 13, 17, 0, -13 },
  { 1723, 11, 13, 11, 0, -13 },
  { 1741, 11, 13, 11, 0, -13 },
  { 1759, 12, 19, 11, -1, -13 },
  { 1788, 12, 19, 11, 0, -13 },
  { 1817, 9, 13, 8, 0, -13 },
  { 1832, 9, 13, 9, 0, -13 },
  { 1847, 7, 16, 8, 1, -16 },
  { 1861, 12, 13, 11, 0, -13 },
  { 1881, 11, 13, 10, 1, -13 },
  { 1899, 16, 13, 15, 1, -13 },
  { 1925, 12, 13, 10, -1, -13 },
  { 1945, 14, 19, 10, -2, -13 },
  { 1979, 10, 13, 9, -1, -13 },
  { 1996, 10, 21, 8, 0, -17 },
  { 2023, 3, 23, 9, 3, -18 },
  { 2032, 9, 21, 8, -1, -17 },
  { 2056, 10, 5, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC24PT7B_H_
