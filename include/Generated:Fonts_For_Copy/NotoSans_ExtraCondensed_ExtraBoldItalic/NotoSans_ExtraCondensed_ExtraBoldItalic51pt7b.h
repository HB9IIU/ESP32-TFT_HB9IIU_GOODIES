#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x3F,
  0x9F, 0xEF, 0xF3, 0xFD, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE,
  0x3F, 0x9F, 0x87, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3E,
  0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x0F, 0xC7, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F,
  0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0x7C, 0x07, 0xF7, 0x18, 0x07, 0xE6, 0x08, 0x07,
  0xE6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x33, 0xF8, 0x20, 0x33, 0xF0, 0x20, 0x33, 0xF0, 0x78,
  0x77, 0xF0, 0x7F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFF,
  0xC0, 0x1F, 0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0x1F, 0xFE, 0x03, 0xE0, 0x0F,
  0xDF, 0x81, 0xF8, 0x03, 0xE3, 0xE0, 0x7C, 0x01, 0xF8, 0xF8, 0x3F, 0x00,
  0x7C, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x87, 0xE0, 0x0F, 0xC7, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0xCF, 0xC0, 0x03, 0xE3, 0xF3, 0xE1, 0xF8, 0xF8, 0xF9,
  0xF9, 0xFF, 0x3E, 0x7E, 0x7C, 0xFF, 0xEF, 0xFF, 0x3F, 0x3F, 0xFB, 0xFF,
  0x9F, 0x9F, 0xFF, 0x7F, 0xE7, 0xE7, 0xCF, 0xDF, 0xF3, 0xF3, 0xE3, 0xF1,
  0xF0, 0xF8, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0xF8, 0x01, 0xF8, 0x7C,
  0x3E, 0x00, 0x7C, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC7, 0xC0, 0x1F, 0x83,
  0xF1, 0xF0, 0x07, 0xC0, 0xFC, 0xFC, 0x03, 0xF0, 0x1F, 0xFE, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0x03, 0xFF, 0x87, 0xF0, 0x7F,
  0xF8, 0xFE, 0x0F, 0xFF, 0xCF, 0xE1, 0xFF, 0xFD, 0xFE, 0x3F, 0xDF, 0xFF,
  0xC3, 0xF9, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0xFF,
  0x0F, 0xFF, 0x0F, 0xE0, 0x7F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xF8, 0x1F, 0xF8,
  0xFF, 0x80, 0x18, 0x00, 0x00, 0x3F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x20, 0xFC, 0x07, 0x8F, 0x80, 0x7E, 0xF8, 0x67, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xBF, 0x07, 0xF3, 0xF8, 0x3E,
  0x3F, 0x81, 0xE1, 0xF0, 0x0C, 0x1C, 0x00, 0x41, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0,
  0x3F, 0x3F, 0x9F, 0xFF, 0xFF, 0xF7, 0xFB, 0xF8, 0xFC, 0x10, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFE, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF,
  0x3F, 0x83, 0xFD, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x07, 0xF9, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F,
  0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xF7, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE1, 0xFB, 0xF8, 0x7C, 0xFE, 0x0C, 0x7F, 0x81, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0xFF, 0x00,
  0xF0, 0x7F, 0x80, 0x30, 0x3F, 0xC0, 0x10, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xC1, 0xFF, 0x01, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x80, 0x1F, 0xE0,
  0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xDF, 0xC0, 0x03, 0xEF, 0xE0, 0x03, 0xEF, 0xF0, 0x03,
  0xF7, 0xF0, 0x01, 0xF3, 0xF8, 0x01, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00,
  0xF8, 0xFF, 0x00, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7C, 0x1F, 0xC0,
  0x7C, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x06, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0xC0, 0x1F, 0xE0, 0xF0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xDC, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x7F,
  0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF1,
  0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x87,
  0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFC, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x8F,
  0xE0, 0xFF, 0x1F, 0xC3, 0xFE, 0x3F, 0xCF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFE, 0xFE, 0x03, 0xFB,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x20, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x60,
  0x7F, 0x08, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x3F, 0xE3, 0xE1, 0xF8,
  0x7F, 0xF9, 0xF0, 0xF8, 0x7F, 0xFC, 0x78, 0xF8, 0x7F, 0xFC, 0x3C, 0x7C,
  0x3E, 0x3E, 0x1E, 0x7C, 0x3E, 0x1F, 0x1F, 0x3E, 0x3F, 0x0F, 0x8F, 0x9F,
  0x1F, 0x0F, 0x87, 0xDF, 0x0F, 0x87, 0xC3, 0xEF, 0x8F, 0x83, 0xE1, 0xF7,
  0xC7, 0xC1, 0xF0, 0xF3, 0xE3, 0xE1, 0xF8, 0xF9, 0xE1, 0xF0, 0xF8, 0x7D,
  0xF1, 0xF8, 0x7C, 0x3C, 0xF8, 0xFC, 0x7E, 0x3E, 0x7C, 0x7E, 0x3F, 0x1E,
  0x3E, 0x1F, 0x3F, 0x9F, 0x1F, 0x0F, 0xFF, 0xFF, 0x0F, 0x87, 0xFD, 0xFF,
  0x07, 0xC1, 0xFC, 0xFF, 0x03, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x80, 0x07, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x01,
  0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xFF,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFC, 0x18, 0x0F, 0xF8, 0x08, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x80, 0xFF, 0xC7, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0x3F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFF,
  0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x38, 0x0F,
  0xF8, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1, 0xFE, 0x1F, 0xFC,
  0x7F, 0x83, 0xFF, 0x8F, 0xF0, 0xFF, 0xF1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3,
  0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x3F, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE,
  0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFE, 0x03, 0xFB, 0xF1, 0xFB, 0xF8, 0x0F, 0xEF, 0xC7, 0xEF,
  0xE0, 0x3F, 0xBF, 0x3F, 0xFF, 0x80, 0xFC, 0xFC, 0xFD, 0xFC, 0x07, 0xF3,
  0xF7, 0xF7, 0xF0, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0x7F, 0x3F, 0x7E, 0x7F,
  0x01, 0xFC, 0xFF, 0xF3, 0xFC, 0x0F, 0xE3, 0xFF, 0xCF, 0xE0, 0x3F, 0x8F,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0xE7, 0xF8,
  0x0F, 0xE3, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x7F, 0x01, 0xFC, 0x3F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x3F, 0xC0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x03,
  0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x83, 0xF8, 0x07,
  0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xC3, 0xF8, 0x07,
  0xEF, 0xC3, 0xF8, 0x0F, 0xEF, 0xC7, 0xF0, 0x0F, 0xEF, 0xE7, 0xF0, 0x0F,
  0xEF, 0xE7, 0xF0, 0x0F, 0xEF, 0xE7, 0xF0, 0x0F, 0xC7, 0xE7, 0xE0, 0x1F,
  0xC7, 0xEF, 0xE0, 0x1F, 0xC7, 0xEF, 0xE0, 0x1F, 0xC7, 0xFF, 0xE0, 0x1F,
  0xC7, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0xC0, 0x3F,
  0x83, 0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0xC0, 0x3F, 0x83, 0xFF, 0xC0, 0x7F,
  0x03, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x80, 0x7F,
  0x01, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC7, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFF, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x7C, 0x07, 0xFC, 0x0C, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x06, 0x00,
  0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0x0F,
  0xF3, 0xF8, 0x0F, 0xE0, 0x3F, 0x9F, 0xE0, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xE0, 0xFF,
  0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x7F, 0x07, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F,
  0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3, 0xFF, 0x8F, 0xF0,
  0x7F, 0x0F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF,
  0xC7, 0xF8, 0x1F, 0xCF, 0xDF, 0x1F, 0xC0, 0x7F, 0x3F, 0xFC, 0xFF, 0x01,
  0xFC, 0xFF, 0xF3, 0xF8, 0x07, 0xF7, 0xEF, 0xCF, 0xE0, 0x1F, 0xDF, 0xBF,
  0x7F, 0x80, 0x7F, 0x7E, 0xFD, 0xFC, 0x01, 0xFF, 0xF3, 0xF7, 0xF0, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF,
  0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8,
  0x3F, 0xCF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xF9, 0xFC, 0x03,
  0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0,
  0x3F, 0x00, 0x20, 0x00, 0x01, 0xFC, 0x7F, 0x03, 0xFE, 0x7E, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xC0, 0x7F, 0xCF,
  0xC0, 0x3F, 0x8F, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x20, 0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7E, 0xFF, 0xE0, 0x7E, 0x7F,
  0xC0, 0xFC, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFE, 0x08, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x20, 0xFF, 0x06, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x07, 0xF0, 0x07, 0xF3,
  0xFC, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xC0, 0x0F, 0xF3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF8, 0x3F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xC3,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x43, 0xFE, 0x1E, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE,
  0x40, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x08, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x0F, 0xF9, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x83, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xDF,
  0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0x43, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x20, 0x07, 0xF8, 0x0E, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x20, 0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x09, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F,
  0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x3F, 0x1F, 0xC1, 0xFC, 0x03, 0xF3, 0xFE, 0x7F, 0xC0, 0x3F, 0x7F, 0xEF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xC7, 0xF0,
  0x1F, 0x9F, 0xF0, 0x3F, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xF8, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFF, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF,
  0xC0, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xCF, 0xF8, 0x03, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xF0, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFE,
  0x7F, 0x03, 0xFE, 0x7E, 0x07, 0xFF, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xC0, 0x3F, 0x9F, 0xC0, 0x04, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x40, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0x40, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xE7, 0xC1, 0xFC, 0x08, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x88, 0x07, 0xF0, 0xE0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0C, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xDF, 0x81, 0xFF, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0x40, 0x00, 0x00,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x7F,
  0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xBF, 0x87,
  0xFC, 0x1F, 0xDF, 0xC3, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x0F, 0xE7, 0xF1,
  0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFC, 0xFF, 0xE3, 0xF8, 0xFE,
  0x7F, 0xF3, 0xF8, 0x7F, 0x3F, 0xF9, 0xFC, 0x3F, 0xBF, 0xFC, 0xFC, 0x1F,
  0xDF, 0x7E, 0xFE, 0x0F, 0xEF, 0xBF, 0x7F, 0x07, 0xEF, 0xDF, 0xFF, 0x03,
  0xF7, 0xCF, 0xBF, 0x81, 0xFB, 0xE7, 0xDF, 0x80, 0xFF, 0xF3, 0xEF, 0xC0,
  0x7F, 0xF1, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F,
  0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x02, 0x3F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x05, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xA0, 0x07, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 37, 13, 0, -36 },
  { 71, 19, 13, 21, 5, -36 },
  { 102, 27, 36, 26, 0, -36 },
  { 224, 24, 42, 23, 0, -39 },
  { 350, 34, 37, 38, 3, -37 },
  { 508, 28, 38, 28, 0, -37 },
  { 641, 9, 13, 12, 5, -36 },
  { 656, 17, 45, 14, 1, -37 },
  { 752, 18, 45, 14, -4, -37 },
  { 854, 20, 22, 22, 4, -39 },
  { 909, 22, 24, 25, 2, -30 },
  { 975, 12, 14, 13, -3, -7 },
  { 996, 13, 7, 15, 1, -17 },
  { 1008, 9, 9, 13, 0, -8 },
  { 1019, 27, 37, 20, -3, -37 },
  { 1144, 22, 38, 23, 1, -37 },
  { 1249, 18, 36, 23, 5, -36 },
  { 1330, 25, 37, 23, -2, -37 },
  { 1446, 24, 38, 23, 0, -37 },
  { 1560, 25, 37, 23, -1, -37 },
  { 1676, 24, 37, 23, 0, -36 },
  { 1787, 24, 38, 23, 1, -37 },
  { 1901, 25, 36, 23, 1, -36 },
  { 2014, 24, 38, 23, 0, -37 },
  { 2128, 23, 38, 23, 0, -37 },
  { 2238, 13, 29, 13, 0, -28 },
  { 2286, 16, 35, 13, -3, -28 },
  { 2356, 22, 25, 25, 2, -31 },
  { 2425, 22, 16, 25, 2, -26 },
  { 2469, 22, 25, 25, 2, -31 },
  { 2538, 19, 38, 18, 1, -37 },
  { 2629, 33, 41, 34, 1, -37 },
  { 2799, 25, 37, 25, -3, -37 },
  { 2915, 26, 36, 25, 0, -36 },
  { 3032, 24, 38, 23, 2, -37 },
  { 3146, 27, 36, 27, 0, -36 },
  { 3268, 23, 36, 21, 0, -36 },
  { 3372, 23, 36, 20, 0, -36 },
  { 3476, 27, 38, 27, 2, -37 },
  { 3605, 30, 36, 28, 0, -36 },
  { 3740, 23, 36, 18, -2, -36 },
  { 3844, 23, 47, 13, -8, -36 },
  { 3980, 30, 36, 25, 0, -36 },
  { 4115, 17, 36, 20, 0, -36 },
  { 4192, 38, 36, 37, 0, -36 },
  { 4363, 32, 36, 30, 0, -36 },
  { 4507, 26, 38, 28, 2, -37 },
  { 4631, 26, 36, 24, 0, -36 },
  { 4748, 26, 46, 28, 2, -37 },
  { 4898, 25, 36, 25, 0, -36 },
  { 5011, 25, 38, 22, -1, -37 },
  { 5130, 21, 36, 21, 4, -36 },
  { 5225, 27, 37, 27, 2, -36 },
  { 5350, 25, 36, 25, 5, -36 },
  { 5463, 38, 36, 37, 3, -36 },
  { 5634, 31, 36, 24, -3, -36 },
  { 5774, 23, 36, 23, 5, -36 },
  { 5878, 26, 36, 21, -2, -36 },
  { 5995, 21, 45, 15, -2, -37 },
  { 6114, 11, 37, 20, 5, -37 },
  { 6165, 21, 45, 15, -4, -37 },
  { 6284, 24, 22, 23, -1, -36 },
  { 6350, 19, 5, 18, -5, 4 },
  { 6362, 11, 8, 16, 7, -39 },
  { 6373, 24, 30, 24, 1, -29 },
  { 6463, 24, 40, 24, -1, -39 },
  { 6583, 20, 30, 19, 1, -29 },
  { 6658, 26, 40, 24, 1, -39 },
  { 6788, 21, 29, 22, 1, -28 },
  { 6865, 27, 51, 15, -6, -39 },
  { 7038, 26, 41, 24, -1, -29 },
  { 7172, 24, 39, 24, -1, -39 },
  { 7289, 16, 39, 12, -1, -39 },
  { 7367, 21, 51, 12, -6, -39 },
  { 7501, 27, 39, 23, -1, -39 },
  { 7633, 16, 39, 12, -1, -39 },
  { 7711, 36, 29, 36, -1, -29 },
  { 7842, 23, 29, 24, 0, -29 },
  { 7926, 22, 30, 24, 1, -29 },
  { 8009, 26, 41, 24, -3, -29 },
  { 8143, 24, 41, 24, 1, -29 },
  { 8266, 20, 29, 17, 0, -29 },
  { 8339, 20, 30, 19, 0, -29 },
  { 8414, 16, 35, 16, 2, -34 },
  { 8484, 23, 29, 24, 1, -28 },
  { 8568, 21, 28, 22, 3, -28 },
  { 8642, 33, 28, 33, 3, -28 },
  { 8758, 27, 28, 22, -3, -28 },
  { 8853, 29, 40, 22, -4, -28 },
  { 8998, 22, 28, 19, -2, -28 },
  { 9075, 21, 44, 17, 0, -36 },
  { 9191, 7, 51, 19, 6, -39 },
  { 9236, 20, 44, 17, -3, -36 },
  { 9346, 22, 9, 25, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLDITALIC51PT7B_H_
