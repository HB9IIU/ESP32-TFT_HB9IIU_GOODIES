#ifndef _ROBOTOMONO_SEMIBOLDITALIC18PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x39, 0x8C, 0x60, 0x01, 0xCE, 0x00, 0x4D, 0x34,
  0xF2, 0xD8, 0x06, 0xC0, 0x98, 0x32, 0x06, 0xC3, 0xFE, 0xB2, 0x06, 0xC0,
  0x98, 0xFF, 0x86, 0xC0, 0x90, 0x32, 0x04, 0xC0, 0x06, 0x03, 0x07, 0xC7,
  0xF3, 0x1B, 0x0D, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xD8, 0x6C, 0x37, 0xF9,
  0xF0, 0x20, 0x10, 0x00, 0x70, 0x6C, 0x36, 0x5B, 0x4F, 0x61, 0x20, 0x20,
  0x30, 0x37, 0x16, 0xD2, 0x61, 0xA0, 0xF0, 0x0F, 0x07, 0xC1, 0x98, 0x46,
  0x1B, 0x07, 0x81, 0xC1, 0xF3, 0x66, 0xF9, 0xEE, 0x39, 0xFE, 0x3D, 0xC0,
  0xFE, 0x80, 0x0C, 0x63, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x60, 0x80, 0x10, 0x30, 0x30, 0x60, 0x40, 0x81, 0x83, 0x0C,
  0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0xE0, 0x80, 0x04, 0x06, 0x03, 0x0D,
  0xBF, 0xF8, 0xE0, 0xD0, 0xCC, 0x22, 0x00, 0x0C, 0x06, 0x03, 0x03, 0x8F,
  0xFF, 0xF8, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x6D, 0xEC, 0x7F, 0xFE, 0x7F,
  0x80, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x36, 0x3B, 0x3F,
  0xFF, 0xE6, 0xE3, 0x61, 0xB1, 0xCF, 0xC7, 0xC0, 0x04, 0xFF, 0xF7, 0x18,
  0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0x0F, 0x0F, 0xE3, 0x19, 0xC6, 0x01,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0x07, 0xE3, 0x1C, 0xC3, 0x01, 0xC0, 0xE0, 0xE0, 0x0E, 0x01, 0xA0, 0x66,
  0x39, 0xFC, 0x3E, 0x00, 0x01, 0x81, 0xC1, 0xE1, 0xF0, 0xF8, 0xD8, 0xCC,
  0xC6, 0x7F, 0xFF, 0xC1, 0xC0, 0xC0, 0x60, 0x3F, 0x9F, 0xCC, 0x06, 0x06,
  0x03, 0xF1, 0xDC, 0x06, 0x03, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x07, 0x1E,
  0x38, 0x70, 0x64, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C, 0x7F,
  0xDF, 0xE0, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x36, 0x3B, 0xB8, 0xF8,
  0xCE, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x1E, 0x1F, 0x98, 0xCC, 0x6E,
  0x3F, 0x19, 0x8C, 0xFE, 0x3B, 0x03, 0x03, 0x8F, 0x87, 0x00, 0x33, 0xCC,
  0x00, 0x00, 0x0C, 0xE7, 0x00, 0x18, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0xC3, 0x18, 0xE0, 0x00, 0x81, 0x87, 0xCF, 0x8E, 0x03, 0xC0, 0x7C, 0x0C,
  0x01, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x40, 0x70, 0x7C, 0x0F,
  0x03, 0x1F, 0xF8, 0xE0, 0x80, 0x3E, 0x7F, 0xE3, 0x03, 0x07, 0x0E, 0x1C,
  0x38, 0x30, 0x00, 0x00, 0x70, 0x70, 0x07, 0x07, 0xE3, 0x04, 0x9D, 0x6D,
  0x56, 0x55, 0xB7, 0x49, 0xD2, 0xF7, 0xE4, 0x01, 0x88, 0x3E, 0x00, 0x01,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x83, 0x60, 0xDC, 0x63, 0x1F, 0xCF, 0xF3,
  0x0D, 0x83, 0xE0, 0xC0, 0x3F, 0x0F, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0xE7,
  0xF1, 0x86, 0x61, 0xD8, 0x76, 0x19, 0xFE, 0xFE, 0x00, 0x1E, 0x1F, 0xDC,
  0x6C, 0x3E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xB0, 0xDF, 0xC7, 0xC0,
  0x3E, 0x0F, 0xE3, 0x18, 0xC7, 0x30, 0xCC, 0x37, 0x0D, 0x87, 0x61, 0xD8,
  0x66, 0x33, 0xFC, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00,
  0x7F, 0x0F, 0xE3, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xCF, 0xF8, 0x1F,
  0xE7, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xE3, 0xFC, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x00, 0x1E, 0x1F, 0xDC, 0x6C, 0x3E, 0x06, 0x03,
  0x3F, 0x9F, 0xC3, 0xE1, 0xB0, 0xCF, 0xE7, 0xE0, 0x38, 0xE6, 0x18, 0xC3,
  0x18, 0x63, 0x0C, 0xFF, 0x9F, 0xF3, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x71,
  0xCC, 0x30, 0x3F, 0x9F, 0xC3, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x1F, 0xCF, 0xE0, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x30, 0xCC, 0x73, 0xF8, 0x7C, 0x00, 0x38, 0x73,
  0x8E, 0x31, 0xC3, 0x38, 0x37, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x06,
  0x30, 0x63, 0x86, 0x38, 0xE1, 0xC0, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xF8, 0x38, 0xE7, 0x3C,
  0xE7, 0x1D, 0xE3, 0xFC, 0xFD, 0x9B, 0xB3, 0x66, 0x6D, 0x8C, 0x31, 0x86,
  0x70, 0xCC, 0x18, 0x38, 0xE7, 0x18, 0xE3, 0x1C, 0x63, 0xCC, 0xFB, 0x9F,
  0x73, 0x3C, 0x67, 0x8C, 0xF1, 0x8E, 0x71, 0xCE, 0x30, 0x1E, 0x1F, 0x9C,
  0xEC, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xDF, 0xC7, 0xC0,
  0x1F, 0x07, 0xF8, 0xC3, 0x18, 0x73, 0x0C, 0x61, 0x8F, 0xF3, 0xF8, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xDF, 0xC7, 0xE0, 0x38, 0x0C, 0x3F,
  0x0F, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x77, 0xF9, 0xFC, 0x67, 0x18, 0xC6,
  0x31, 0x8E, 0xE1, 0x80, 0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0x61, 0xF0, 0xDF, 0xE7, 0xE0, 0x7F, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x00,
  0x71, 0xD8, 0x66, 0x19, 0x86, 0x61, 0x98, 0x6E, 0x3B, 0x0C, 0xC3, 0x30,
  0xCC, 0x73, 0xF8, 0x7C, 0x00, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x33,
  0xB0, 0xD8, 0x7C, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0xEC, 0xF3, 0x3C, 0xCF,
  0x36, 0xDD, 0xB7, 0x6D, 0x5B, 0xDC, 0xF7, 0x39, 0xCE, 0x63, 0x98, 0xC6,
  0x00, 0x18, 0x31, 0xC7, 0x0C, 0xE0, 0xCC, 0x0F, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x81, 0xD8, 0x39, 0x83, 0x1C, 0xF0, 0xC0, 0xC1, 0xF0, 0xEE,
  0x31, 0x9C, 0x66, 0x1B, 0x03, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x00, 0x3F, 0xE7, 0xFC, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x7F, 0xCF, 0xF8, 0x1E, 0x38, 0x61, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xF1, 0xE0,
  0xC3, 0x18, 0xC6, 0x31, 0x86, 0x31, 0x8C, 0x63, 0x0C, 0x1E, 0x38, 0x30,
  0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0xF1,
  0xE0, 0x08, 0x38, 0x71, 0xE6, 0x4C, 0xF1, 0x80, 0xFF, 0xFF, 0xCC, 0x1C,
  0x7F, 0x63, 0x03, 0x3F, 0xFF, 0xC7, 0xC7, 0xFE, 0x7E, 0x18, 0x0C, 0x0E,
  0x06, 0x03, 0x71, 0xFC, 0xE6, 0x63, 0x71, 0xB0, 0xD8, 0x6C, 0x77, 0xF7,
  0xF0, 0x1C, 0x3F, 0x63, 0xE3, 0xC0, 0xC0, 0xC0, 0xC7, 0x7E, 0x7C, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x19, 0x9F, 0xE6, 0x3B, 0x8C, 0xC3, 0x30, 0xCC,
  0x33, 0x1C, 0xFF, 0x1F, 0x80, 0x0C, 0x1F, 0x9C, 0xDC, 0x6F, 0xFF, 0xFB,
  0x01, 0x84, 0x7F, 0x1F, 0x00, 0x07, 0x8F, 0xC6, 0x07, 0x0F, 0xF7, 0xF8,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x0C, 0xC7, 0xF3,
  0x9D, 0xC6, 0x61, 0x98, 0x66, 0x19, 0x8E, 0x7F, 0x8F, 0xC0, 0x31, 0x1C,
  0xFE, 0x0E, 0x00, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x33, 0x0F, 0xE3, 0x99,
  0xC6, 0x71, 0x98, 0x66, 0x19, 0x86, 0x61, 0xB8, 0xE0, 0x06, 0x06, 0x00,
  0x3E, 0x7C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0xFF, 0xFF, 0x03, 0x81,
  0xC0, 0x03, 0xE1, 0xF0, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0xF0, 0xF0, 0x00, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0xCC, 0xE3, 0x70, 0xF8, 0x7C, 0x1F, 0x87, 0x61, 0x9C, 0x63, 0x38, 0xE0,
  0x3E, 0x3E, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0xFF, 0xFF, 0x6D, 0x9F, 0xF6, 0xED, 0xB3, 0x6C, 0xDB, 0x3C, 0xDB, 0x36,
  0xCD, 0xB6, 0x60, 0x33, 0x0F, 0xE3, 0x99, 0xC6, 0x71, 0x98, 0x66, 0x19,
  0x86, 0x63, 0xB8, 0xE0, 0x1C, 0x1F, 0x98, 0xDC, 0x6C, 0x3E, 0x1B, 0x0D,
  0x8E, 0xFE, 0x3E, 0x00, 0x36, 0x1F, 0xCC, 0x6E, 0x37, 0x1B, 0x0D, 0x86,
  0xC7, 0x7F, 0x7F, 0x38, 0x18, 0x0C, 0x06, 0x00, 0x19, 0xBF, 0xD8, 0xFC,
  0x6C, 0x36, 0x1B, 0x0D, 0x8E, 0xFF, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x67, 0x6F, 0x7F, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1C, 0x3F,
  0x98, 0xEC, 0x07, 0x81, 0xF0, 0x1D, 0x86, 0xFF, 0x3F, 0x00, 0x38, 0x30,
  0xFF, 0xFF, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x7C, 0x3E, 0x61, 0xB0,
  0xD8, 0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x8E, 0xFF, 0x3F, 0x00, 0xE1, 0xD8,
  0x66, 0x31, 0x8C, 0x66, 0x19, 0x83, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0xCC,
  0xF3, 0x6D, 0xDB, 0x76, 0xDD, 0x3F, 0xCE, 0xF3, 0xB8, 0xE6, 0x31, 0x80,
  0x30, 0xE6, 0x38, 0x6E, 0x0D, 0x80, 0xE0, 0x1C, 0x07, 0x81, 0xD8, 0x73,
  0x1C, 0x30, 0x70, 0x66, 0x1C, 0xC7, 0x18, 0xC3, 0x38, 0x36, 0x07, 0xC0,
  0xF0, 0x1C, 0x01, 0x80, 0x60, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xBF, 0xE0, 0x04,
  0x3C, 0x60, 0xC1, 0x86, 0x0C, 0x38, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x11, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0xC0, 0x30,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0E, 0x38, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0xC0, 0x78, 0xFF, 0x3C, 0x78, 0x0C,
};

const GFXglyph RobotoMono_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 3, -14 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 9, 17, 11, 1, -15 },
  { 52, 9, 13, 11, 1, -13 },
  { 67, 10, 13, 11, 0, -13 },
  { 84, 2, 5, 11, 5, -14 },
  { 86, 6, 18, 11, 3, -14 },
  { 100, 7, 18, 11, 1, -14 },
  { 116, 9, 9, 11, 1, -13 },
  { 127, 9, 10, 11, 1, -11 },
  { 139, 3, 5, 11, 2, -2 },
  { 141, 8, 2, 11, 2, -7 },
  { 143, 3, 3, 11, 3, -3 },
  { 145, 9, 14, 11, 1, -13 },
  { 161, 9, 13, 11, 1, -13 },
  { 176, 6, 13, 11, 2, -13 },
  { 186, 10, 13, 11, 0, -13 },
  { 203, 10, 13, 11, 0, -13 },
  { 220, 9, 13, 11, 0, -13 },
  { 235, 9, 13, 11, 1, -13 },
  { 250, 8, 13, 11, 1, -13 },
  { 263, 10, 13, 11, 1, -13 },
  { 280, 9, 13, 11, 1, -13 },
  { 295, 9, 13, 11, 1, -13 },
  { 310, 5, 10, 11, 3, -10 },
  { 317, 6, 13, 11, 2, -10 },
  { 327, 9, 9, 11, 1, -10 },
  { 338, 9, 5, 11, 1, -8 },
  { 344, 8, 9, 11, 1, -10 },
  { 353, 8, 13, 11, 2, -13 },
  { 366, 10, 13, 11, 0, -13 },
  { 383, 10, 13, 11, -1, -13 },
  { 400, 10, 13, 11, 0, -13 },
  { 417, 9, 13, 11, 1, -13 },
  { 432, 10, 13, 11, 0, -13 },
  { 449, 11, 13, 11, 0, -13 },
  { 467, 11, 13, 11, 0, -13 },
  { 485, 9, 13, 11, 1, -13 },
  { 500, 11, 13, 11, 0, -13 },
  { 518, 9, 13, 11, 1, -13 },
  { 533, 10, 13, 11, 1, -13 },
  { 550, 12, 13, 11, 0, -13 },
  { 570, 9, 13, 11, 0, -13 },
  { 585, 11, 13, 11, 0, -13 },
  { 603, 11, 13, 11, 0, -13 },
  { 621, 9, 13, 11, 1, -13 },
  { 636, 11, 13, 11, 0, -13 },
  { 654, 9, 15, 11, 1, -13 },
  { 671, 10, 13, 11, 0, -13 },
  { 688, 9, 13, 11, 1, -13 },
  { 703, 10, 13, 11, 1, -13 },
  { 720, 10, 13, 11, 1, -13 },
  { 737, 9, 13, 11, 2, -13 },
  { 752, 10, 13, 11, 1, -13 },
  { 769, 12, 13, 11, -1, -13 },
  { 789, 10, 13, 11, 2, -13 },
  { 806, 11, 13, 11, 0, -13 },
  { 824, 7, 18, 11, 2, -15 },
  { 840, 5, 14, 11, 3, -13 },
  { 849, 7, 18, 11, 2, -15 },
  { 865, 7, 7, 11, 2, -13 },
  { 872, 8, 2, 11, 0, 0 },
  { 874, 3, 2, 11, 5, -13 },
  { 875, 8, 10, 11, 1, -10 },
  { 885, 9, 14, 11, 0, -14 },
  { 901, 8, 10, 11, 1, -10 },
  { 911, 10, 14, 11, 1, -14 },
  { 929, 9, 10, 11, 1, -10 },
  { 941, 9, 14, 11, 2, -14 },
  { 957, 10, 14, 11, 0, -10 },
  { 975, 10, 14, 11, 0, -14 },
  { 993, 8, 13, 11, 1, -13 },
  { 1006, 9, 17, 11, 0, -13 },
  { 1026, 10, 14, 11, 0, -14 },
  { 1044, 8, 14, 11, 1, -14 },
  { 1058, 10, 10, 11, 0, -10 },
  { 1071, 10, 10, 11, 0, -10 },
  { 1084, 9, 10, 11, 1, -10 },
  { 1096, 9, 14, 11, 0, -10 },
  { 1112, 9, 14, 11, 1, -10 },
  { 1128, 8, 10, 11, 2, -10 },
  { 1138, 9, 10, 11, 1, -10 },
  { 1150, 8, 12, 11, 2, -12 },
  { 1162, 9, 10, 11, 1, -10 },
  { 1174, 10, 10, 11, 1, -10 },
  { 1187, 10, 10, 11, 1, -10 },
  { 1200, 11, 10, 11, 0, -10 },
  { 1214, 11, 14, 11, 0, -10 },
  { 1234, 10, 10, 11, 0, -10 },
  { 1247, 7, 17, 11, 3, -14 },
  { 1262, 4, 17, 11, 3, -13 },
  { 1271, 7, 17, 11, 2, -14 },
  { 1286, 10, 4, 11, 0, -7 },
};

const GFXfont RobotoMono_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC18PT7B_H_
