#ifndef _ROBOTOMONO_SEMIBOLDITALIC61PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x83,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F,
  0x80, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C,
  0x06, 0x1F, 0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x3E,
  0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x1F, 0x0F, 0x83, 0xF1, 0xF0, 0x7E,
  0x1F, 0x1F, 0x03, 0xFF, 0xF8, 0xF8, 0x0F, 0xFF, 0x8F, 0x80, 0x7F, 0xFC,
  0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x1F, 0xE0, 0x01, 0xF1, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x00, 0xF9, 0xFF,
  0xF8, 0x0F, 0x8F, 0xC7, 0xE0, 0x7C, 0xFC, 0x3F, 0x07, 0xC7, 0xC0, 0xF8,
  0x7C, 0x3E, 0x07, 0xC7, 0xE1, 0xF0, 0x3E, 0x3E, 0x1F, 0x81, 0xF3, 0xE0,
  0xFC, 0x0F, 0x82, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF9, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0x07, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0xFC, 0x07, 0xE1, 0xFF,
  0x7F, 0x83, 0xF8, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x9F,
  0xE0, 0x7F, 0x9F, 0xC7, 0xF8, 0x1F, 0xEF, 0xF1, 0xFC, 0x03, 0xFF, 0xF8,
  0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0x0F, 0xF0, 0x03, 0xFF,
  0xC3, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x3F, 0xE0, 0x0F,
  0xFF, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF1, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x07, 0xC0,
  0x31, 0xF0, 0x3E, 0x07, 0xDF, 0xE1, 0xF0, 0xFE, 0xFF, 0xCF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x60, 0x03,
  0x80, 0x01, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F,
  0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x1F, 0xF9, 0xFC, 0x01, 0xFF, 0xDF, 0xE0, 0x3F, 0xFE, 0xFF, 0x03, 0xFF,
  0xF7, 0xF8, 0x7F, 0xFF, 0x3F, 0x87, 0xFB, 0xF9, 0xFC, 0xFF, 0x1F, 0xCF,
  0xEF, 0xF1, 0xFE, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xE0, 0x7F, 0xBF, 0xFC,
  0x03, 0xF9, 0xFF, 0xC0, 0x1F, 0xCF, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F,
  0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0x7F, 0x1F, 0xC7,
  0xF8, 0xF0, 0x3F, 0xCC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0xCF, 0xFE, 0x03, 0xF9,
  0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xCF, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xF1,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xFB, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xC0, 0x7F,
  0xF3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0xFF, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xF1, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0xFC,
  0x3C, 0x1F, 0x0F, 0xFF, 0x8F, 0x0F, 0x87, 0xFF, 0xE3, 0xC3, 0xE1, 0xFC,
  0xF0, 0xF1, 0xF0, 0xFC, 0x3C, 0x3C, 0x7C, 0x7E, 0x0F, 0x0F, 0x3E, 0x1F,
  0x03, 0xC3, 0xCF, 0x8F, 0xC1, 0xF0, 0xF3, 0xC3, 0xE0, 0x78, 0x3D, 0xF0,
  0xF8, 0x1E, 0x0F, 0x7C, 0x3C, 0x0F, 0x87, 0xDF, 0x1F, 0x03, 0xE1, 0xE7,
  0x87, 0xC0, 0xF0, 0x79, 0xE1, 0xF0, 0x3C, 0x1E, 0x78, 0x7C, 0x1F, 0x07,
  0xBE, 0x1F, 0x07, 0xC3, 0xCF, 0x87, 0xC1, 0xE0, 0xF3, 0xE1, 0xF0, 0xF8,
  0x78, 0xF8, 0x7C, 0x7E, 0x1E, 0x3E, 0x1F, 0xFF, 0xCF, 0x07, 0x87, 0xFF,
  0xFF, 0xC1, 0xE0, 0xFF, 0x7F, 0xE0, 0x7C, 0x1F, 0x8F, 0xF0, 0x1F, 0x01,
  0xC0, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x30, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFE,
  0x01, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xF3,
  0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF,
  0xCF, 0xDF, 0x80, 0x7F, 0xFC, 0xFD, 0xF8, 0x07, 0xE7, 0xDF, 0xBF, 0x80,
  0xFE, 0x7D, 0xFB, 0xF8, 0x0F, 0xE7, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0xF3,
  0xF8, 0x0F, 0xE7, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0xE7, 0xF0, 0x0F, 0xC7,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xE0, 0xFE, 0x03, 0xF8, 0x3E, 0x0F, 0xE0, 0x3F, 0x83,
  0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x0F,
  0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0,
  0x07, 0xF0, 0x1F, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0,
  0x7F, 0xBF, 0x03, 0xF8, 0x0F, 0xF7, 0xE0, 0xFF, 0x01, 0xFE, 0xFC, 0x1F,
  0xE0, 0x3F, 0x8F, 0xC3, 0xFC, 0x07, 0xF1, 0xF8, 0x7F, 0x81, 0xFE, 0x3F,
  0x0F, 0xE0, 0x3F, 0xC7, 0xE3, 0xFC, 0x07, 0xF8, 0x7E, 0x7F, 0x80, 0xFF,
  0x0F, 0xCF, 0xF0, 0x1F, 0xC1, 0xF9, 0xFE, 0x03, 0xF8, 0x3F, 0x3F, 0x80,
  0xFF, 0x03, 0xF7, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x80,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xC0,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x43, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xC0, 0x7F,
  0x3F, 0x81, 0xF8, 0x0F, 0xE7, 0xF0, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F,
  0x0F, 0xF8, 0x7F, 0x07, 0xE1, 0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0xE1, 0xFC,
  0x1F, 0x8F, 0xFC, 0x3F, 0x83, 0xF1, 0xFF, 0x8F, 0xE0, 0x7E, 0x3F, 0xF1,
  0xFC, 0x0F, 0xCF, 0xFE, 0x3F, 0x81, 0xF9, 0xFF, 0xC7, 0xE0, 0x3F, 0x3E,
  0xF9, 0xFC, 0x07, 0xE7, 0xDF, 0x3F, 0x81, 0xFD, 0xFB, 0xE7, 0xE0, 0x3F,
  0xBE, 0x7C, 0xFC, 0x07, 0xF7, 0xCF, 0xBF, 0x80, 0xFF, 0xF9, 0xF7, 0xF0,
  0x1F, 0xFE, 0x3E, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8,
  0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xE7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x01, 0xF3,
  0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x01, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x7F, 0x03, 0xFF, 0xF3, 0xF8, 0x07, 0xFE, 0x1F, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0xFE, 0x7F, 0xF0, 0x01,
  0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFB, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xC7, 0xF0, 0x03, 0xFF,
  0xF3, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFB, 0xF0, 0x00, 0xFF, 0xFB,
  0xF8, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x01, 0xFE, 0x00, 0x1E, 0x07,
  0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x0C, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x0E, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xE0,
  0x00, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xF8,
  0x0F, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x04, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x06,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0xFF,
  0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x01, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x0F, 0xE7, 0xFE, 0x00, 0x03, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0x80,
  0x03, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x7E, 0x7F, 0x8F,
  0xF0, 0x1F, 0xDF, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x08, 0x1F, 0x80, 0x07, 0xE1, 0xFF,
  0xC0, 0x1F, 0xC7, 0xFF, 0xC0, 0x3F, 0x9F, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF9, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x3F,
  0xF8, 0x00, 0x3F, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF,
  0x80, 0x3F, 0x9F, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x1F, 0xE0, 0x38,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x02, 0x00, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0xE7, 0xF0, 0x1F,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0x9F, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xDF, 0xC0, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x07, 0xF3, 0xFF, 0xF0, 0x7F, 0x3F, 0xFF,
  0x83, 0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x10, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x10, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x80, 0xFF, 0xFC, 0xFE, 0x01, 0xFF,
  0xE3, 0xF8, 0x03, 0xFF, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xC0, 0xFC, 0xFE, 0x07, 0xF0, 0x7F, 0x3F,
  0x83, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x07, 0xE3, 0xF8, 0x3F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x07, 0xE1, 0xFF, 0x0F,
  0xC1, 0xF8, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0xF1, 0xF8, 0x1F, 0x9F, 0x7C,
  0x7E, 0x07, 0xE7, 0xDF, 0x3F, 0x81, 0xF9, 0xE7, 0xCF, 0xC0, 0x7E, 0xF9,
  0xF3, 0xF0, 0x1F, 0x3E, 0x7D, 0xFC, 0x07, 0xCF, 0x1F, 0x7E, 0x01, 0xF7,
  0xC7, 0xDF, 0x80, 0x7D, 0xF1, 0xFF, 0xC0, 0x1F, 0x78, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01,
  0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xE1, 0xFF,
  0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0xF0, 0x1F, 0x8F,
  0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xFC,
  0x7C, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0x83, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 15, 43, 36, 11, -43 },
  { 82, 20, 16, 36, 10, -46 },
  { 122, 36, 43, 36, 0, -43 },
  { 316, 32, 56, 36, 3, -50 },
  { 540, 29, 45, 36, 4, -44 },
  { 704, 34, 45, 36, 1, -44 },
  { 896, 9, 16, 36, 15, -46 },
  { 914, 21, 62, 36, 9, -48 },
  { 1077, 21, 62, 36, 5, -48 },
  { 1240, 29, 30, 36, 5, -43 },
  { 1349, 30, 32, 36, 3, -36 },
  { 1469, 12, 19, 36, 6, -7 },
  { 1498, 25, 6, 36, 7, -22 },
  { 1517, 11, 11, 36, 10, -10 },
  { 1533, 31, 47, 36, 3, -43 },
  { 1716, 29, 45, 36, 4, -44 },
  { 1880, 21, 43, 36, 7, -43 },
  { 1993, 32, 44, 36, 0, -44 },
  { 2169, 31, 45, 36, 2, -44 },
  { 2344, 31, 43, 36, 1, -43 },
  { 2511, 32, 44, 36, 3, -43 },
  { 2687, 28, 45, 36, 3, -44 },
  { 2845, 32, 43, 36, 4, -43 },
  { 3017, 31, 45, 36, 2, -44 },
  { 3192, 27, 44, 36, 5, -44 },
  { 3341, 15, 36, 36, 11, -35 },
  { 3409, 19, 47, 36, 8, -35 },
  { 3521, 29, 28, 36, 4, -33 },
  { 3623, 30, 19, 36, 3, -28 },
  { 3695, 29, 29, 36, 2, -33 },
  { 3801, 27, 44, 36, 7, -44 },
  { 3950, 34, 43, 36, 1, -43 },
  { 4133, 34, 43, 36, -2, -43 },
  { 4316, 34, 43, 36, 1, -43 },
  { 4499, 33, 45, 36, 2, -44 },
  { 4685, 33, 43, 36, 1, -43 },
  { 4863, 36, 43, 36, 1, -43 },
  { 5057, 36, 43, 36, 1, -43 },
  { 5251, 32, 45, 36, 3, -44 },
  { 5431, 35, 43, 36, 1, -43 },
  { 5620, 32, 43, 36, 2, -43 },
  { 5792, 34, 44, 36, 2, -43 },
  { 5979, 39, 43, 36, 1, -43 },
  { 6189, 28, 43, 36, 2, -43 },
  { 6340, 36, 43, 36, 1, -43 },
  { 6534, 35, 43, 36, 1, -43 },
  { 6723, 32, 45, 36, 2, -44 },
  { 6903, 35, 43, 36, 1, -43 },
  { 7092, 33, 52, 36, 2, -44 },
  { 7307, 34, 43, 36, 1, -43 },
  { 7490, 34, 45, 36, 2, -44 },
  { 7682, 35, 43, 36, 4, -43 },
  { 7871, 33, 44, 36, 3, -43 },
  { 8053, 33, 43, 36, 5, -43 },
  { 8231, 35, 43, 36, 4, -43 },
  { 8420, 41, 43, 36, -2, -43 },
  { 8641, 34, 43, 36, 6, -43 },
  { 8824, 36, 43, 36, 0, -43 },
  { 9018, 22, 60, 36, 7, -50 },
  { 9183, 15, 47, 36, 11, -43 },
  { 9272, 22, 60, 36, 7, -50 },
  { 9437, 23, 23, 36, 7, -43 },
  { 9504, 28, 6, 36, 0, 0 },
  { 9525, 12, 8, 36, 16, -44 },
  { 9537, 29, 34, 36, 2, -33 },
  { 9661, 31, 47, 36, 1, -46 },
  { 9844, 29, 34, 36, 3, -33 },
  { 9968, 33, 47, 36, 3, -46 },
  { 10162, 30, 34, 36, 3, -33 },
  { 10290, 33, 47, 36, 5, -47 },
  { 10484, 33, 46, 36, 1, -33 },
  { 10674, 31, 46, 36, 1, -46 },
  { 10853, 27, 45, 36, 3, -45 },
  { 11005, 28, 58, 36, 1, -45 },
  { 11208, 34, 46, 36, 1, -46 },
  { 11404, 27, 46, 36, 3, -46 },
  { 11560, 35, 33, 36, -1, -33 },
  { 11705, 31, 33, 36, 1, -33 },
  { 11833, 29, 34, 36, 3, -33 },
  { 11957, 33, 45, 36, -1, -33 },
  { 12143, 31, 45, 36, 3, -33 },
  { 12318, 29, 33, 36, 5, -33 },
  { 12438, 31, 34, 36, 2, -33 },
  { 12570, 28, 41, 36, 5, -40 },
  { 12714, 30, 33, 36, 4, -32 },
  { 12838, 31, 32, 36, 5, -32 },
  { 12962, 34, 32, 36, 3, -32 },
  { 13098, 36, 32, 36, 0, -32 },
  { 13242, 38, 45, 36, 0, -32 },
  { 13456, 33, 32, 36, 1, -32 },
  { 13588, 23, 59, 36, 9, -48 },
  { 13758, 13, 55, 36, 11, -43 },
  { 13848, 23, 59, 36, 6, -48 },
  { 14018, 34, 13, 36, 0, -24 },
};

const GFXfont RobotoMono_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC61PT7B_H_
