#ifndef _ROBOTOMONO_SEMIBOLDITALIC36PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x81, 0xE1, 0xF8, 0xF8, 0x3C, 0x00, 0x38, 0xF7, 0x8F, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xCE, 0x1C, 0xE1, 0xC0, 0x00, 0x3C, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1C,
  0x70, 0x01, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x87, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x3C, 0x03,
  0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xC7, 0x08,
  0xF1, 0xC3, 0xB8, 0x71, 0xCE, 0x1C, 0xE3, 0x8F, 0x70, 0x77, 0x9C, 0x1F,
  0xEE, 0x03, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x78, 0x07, 0x7F, 0x03, 0x9F, 0xE0, 0xEF, 0x38, 0x73, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x0E, 0x38, 0x03, 0xDE, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01,
  0xEF, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x3B, 0xFF, 0x8F, 0x7C, 0xF1, 0xFF, 0x1F, 0x7F, 0xE1, 0xFF, 0x78,
  0x3F, 0xEF, 0x03, 0xF9, 0xF0, 0x3E, 0x3F, 0x3F, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x83, 0xFC, 0xF8, 0x7B, 0xDE, 0xE7, 0x3B, 0xDC, 0xE0, 0x00, 0x20,
  0x06, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x60, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x02, 0x07, 0x05, 0xC3, 0x0F, 0xF9, 0xBF, 0xFF, 0xFF, 0x87, 0xFF, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x08, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF0, 0x20, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0x81,
  0xE3, 0xE0, 0x78, 0xF0, 0x1F, 0x3C, 0x07, 0xDF, 0x03, 0xF7, 0xC1, 0xF9,
  0xF1, 0xFE, 0x78, 0xF7, 0x9E, 0xFB, 0xE7, 0xF8, 0xFB, 0xFC, 0x3E, 0xFC,
  0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F,
  0x87, 0xC7, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x10,
  0x07, 0x03, 0xF1, 0xFF, 0x7F, 0xF7, 0xFF, 0x7D, 0xEE, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8,
  0x7E, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x20, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x78, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8,
  0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x9E, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x78, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x3F,
  0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0xF8, 0x7B, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xE0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E,
  0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x9F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7E, 0x1E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xDE, 0x07, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x03,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x07, 0x07, 0xC7,
  0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x7C, 0x3F, 0x3F, 0x8F, 0x87, 0xC0, 0x03, 0x80, 0xF8,
  0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x08, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x18, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xC3,
  0xC0, 0xF0, 0x0E, 0x0E, 0x00, 0x61, 0xC7, 0xC6, 0x38, 0xFE, 0x73, 0x9F,
  0x67, 0x73, 0xC6, 0x77, 0x38, 0xE7, 0x63, 0x8E, 0x7E, 0x70, 0xC6, 0xE7,
  0x1C, 0x6E, 0x71, 0xC6, 0xE7, 0x1C, 0xEE, 0x71, 0x8C, 0xE7, 0x39, 0xCE,
  0x7F, 0xF8, 0xE3, 0xDF, 0x0E, 0x10, 0x60, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFB, 0x80, 0x0F, 0x3C, 0x01, 0xF3, 0xC0,
  0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3C,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E, 0x01,
  0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0x07, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3,
  0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE3,
  0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xC0,
  0xF8, 0x3F, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x8F, 0xE0,
  0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x83, 0xE1, 0xF0,
  0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1F, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x83, 0xFE, 0x78, 0x3F, 0xC7,
  0x87, 0xFC, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C,
  0x7C, 0x07, 0x87, 0xC0, 0x78, 0x3F, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x7C, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0xF8,
  0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x7E, 0x7E, 0x03,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x7E, 0x1E, 0x01,
  0xF8, 0x3C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE1, 0xF8,
  0x07, 0x87, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xBE, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xE0,
  0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x7F, 0x83, 0xF9, 0xFC, 0x1E, 0xEF, 0xF0, 0x7B, 0xBB, 0xC1, 0xEF, 0xEF,
  0x07, 0xBF, 0x3C, 0x1E, 0xFC, 0xF0, 0x7B, 0xE7, 0x83, 0xC7, 0x9E, 0x0F,
  0x1C, 0x78, 0x3C, 0x71, 0xE0, 0xF1, 0x87, 0x83, 0xC0, 0x3E, 0x0F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0,
  0x78, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3,
  0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xF0, 0x78, 0x3F, 0x83,
  0xC1, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x78, 0x3C,
  0xE3, 0xC1, 0xE7, 0x1E, 0x1F, 0x3D, 0xF0, 0xF9, 0xEF, 0x87, 0xC7, 0x7C,
  0x3C, 0x3B, 0xC1, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0xF8, 0x3F, 0x87, 0xC1,
  0xFC, 0x3E, 0x0F, 0xE1, 0xE0, 0x7E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x87,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07,
  0xDE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E,
  0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07,
  0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07,
  0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F,
  0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8,
  0xF8, 0x3E, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x07, 0xE1, 0xF0,
  0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E,
  0x03, 0xE3, 0xE0, 0x7E, 0x3C, 0x3F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F,
  0x8F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F,
  0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x1F, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3E, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x70, 0x7B, 0xC3,
  0x87, 0xDE, 0x1C, 0x3C, 0xF1, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0xF1,
  0xE7, 0xC7, 0x8F, 0x3E, 0x3C, 0x79, 0xF1, 0xE3, 0xDF, 0x9E, 0x1E, 0xFC,
  0xF0, 0xF7, 0xE7, 0x87, 0xFF, 0x78, 0x3B, 0xBB, 0xC1, 0xDD, 0xDE, 0x0E,
  0xEE, 0xF0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x01,
  0xE1, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xF7, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07,
  0xCF, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0xF8,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x3C, 0x07, 0xC3,
  0xC0, 0xF8, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0,
  0x1F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0,
  0x1D, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x78, 0xF0, 0xE3, 0xC3, 0x9E, 0x0E,
  0x70, 0x3F, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE1, 0xE1, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xE1, 0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0x0F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xC3, 0xEF, 0x81, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0,
  0x7D, 0xF8, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x87, 0xF7, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x7E, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0xFE,
  0x7E, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7,
  0xC1, 0xF3, 0xF8, 0xFC, 0xFF, 0xFE, 0x3D, 0xFF, 0x0F, 0x3F, 0x80, 0x03,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE7, 0xE3, 0xC0, 0xFB, 0xE0, 0x7D,
  0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x17, 0x80, 0xF3, 0xE0, 0xF8, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x07,
  0xF7, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3E, 0x0F, 0x87, 0xF7,
  0xF0, 0x7F, 0xFE, 0x07, 0xFB, 0xC0, 0x7E, 0x78, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xE7, 0xE3, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x23, 0xE0, 0x30, 0xFC, 0x7E, 0x7F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF9, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xC7, 0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0x8F,
  0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF9, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0xC0,
  0x7C, 0x3C, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x7F, 0x07, 0xBF,
  0xE1, 0xFF, 0xF8, 0xFF, 0x7F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3C,
  0xF0, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x03, 0xF1, 0xE0, 0x7C, 0x1E, 0x1F, 0x83, 0xE3, 0xF0, 0x3E, 0x7E, 0x03,
  0xEF, 0xC0, 0x3D, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x80, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x79, 0xF0, 0x77, 0xFF, 0x87, 0xFF,
  0xFE, 0x3E, 0xFD, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7,
  0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0x78, 0x1E, 0x7F, 0x07, 0xBF, 0xE1,
  0xFF, 0xF8, 0xFE, 0x7F, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0x7E, 0x3E,
  0x07, 0x8F, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x01,
  0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC1, 0xF0,
  0xF8, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xBF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x1F, 0x07, 0xC3, 0xF8,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3C, 0xFE, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF3, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x7E, 0x7C,
  0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE3,
  0xF3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFB, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1F, 0x3F, 0x8F, 0x3F, 0xC7, 0xBF, 0xE3, 0xFF, 0xE1, 0xFC, 0x10,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7C, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xBE,
  0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xCC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFC, 0x3E, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x7C, 0x07,
  0x9F, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xCF,
  0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xF3,
  0xF8, 0x7F, 0xFE, 0x1F, 0xF7, 0x81, 0xF9, 0xE0, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1,
  0xE0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D,
  0xE0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0xE1, 0xFF, 0x0E, 0x1E, 0xF1, 0xE1, 0xEF, 0x1E,
  0x1C, 0xF1, 0xE3, 0xCF, 0x3E, 0x3C, 0xF3, 0xE3, 0x8F, 0x36, 0x78, 0xF7,
  0x67, 0x8F, 0x76, 0x70, 0xFE, 0x6F, 0x0F, 0xE6, 0xF0, 0xFC, 0x6E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F,
  0x8F, 0x80, 0x3C, 0xFC, 0x01, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xEF, 0x00, 0x3E, 0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x83,
  0xE0, 0x3E, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF8, 0x3C,
  0x03, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x79, 0xF0, 0x01,
  0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x1F, 0xC0, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x1F,
  0xC0, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x01, 0xC0, 0x00, 0x1F, 0x80, 0x83, 0xFE, 0x07, 0x7F, 0xF0, 0xF7, 0x9F,
  0xFE, 0xF0, 0x7F, 0xEE, 0x03, 0xFC, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 12, 9, 21, 6, -27 },
  { 45, 21, 26, 21, 0, -26 },
  { 114, 19, 34, 21, 2, -30 },
  { 195, 18, 26, 21, 2, -26 },
  { 254, 19, 26, 21, 1, -26 },
  { 316, 5, 9, 21, 9, -27 },
  { 322, 12, 37, 21, 6, -29 },
  { 378, 12, 37, 21, 3, -29 },
  { 434, 17, 18, 21, 3, -26 },
  { 473, 17, 18, 21, 2, -21 },
  { 512, 8, 11, 21, 3, -4 },
  { 523, 15, 4, 21, 4, -13 },
  { 531, 6, 6, 21, 6, -6 },
  { 536, 18, 28, 21, 2, -26 },
  { 599, 18, 26, 21, 2, -26 },
  { 658, 12, 26, 21, 4, -26 },
  { 697, 19, 26, 21, 0, -26 },
  { 759, 19, 26, 21, 1, -26 },
  { 821, 19, 26, 21, 0, -26 },
  { 883, 19, 26, 21, 2, -26 },
  { 945, 16, 26, 21, 2, -26 },
  { 997, 19, 26, 21, 2, -26 },
  { 1059, 19, 26, 21, 1, -26 },
  { 1121, 16, 26, 21, 3, -26 },
  { 1173, 9, 21, 21, 6, -21 },
  { 1197, 11, 28, 21, 5, -21 },
  { 1236, 17, 16, 21, 2, -19 },
  { 1270, 18, 12, 21, 2, -17 },
  { 1297, 18, 16, 21, 1, -19 },
  { 1333, 16, 26, 21, 4, -26 },
  { 1385, 20, 25, 21, 1, -25 },
  { 1448, 20, 26, 21, -1, -26 },
  { 1513, 20, 26, 21, 1, -26 },
  { 1578, 20, 26, 21, 1, -26 },
  { 1643, 20, 26, 21, 0, -26 },
  { 1708, 21, 26, 21, 1, -26 },
  { 1777, 21, 26, 21, 1, -26 },
  { 1846, 20, 26, 21, 1, -26 },
  { 1911, 21, 26, 21, 0, -26 },
  { 1980, 19, 26, 21, 1, -26 },
  { 2042, 20, 26, 21, 1, -26 },
  { 2107, 23, 26, 21, 1, -26 },
  { 2182, 17, 26, 21, 1, -26 },
  { 2238, 22, 26, 21, 0, -26 },
  { 2310, 21, 26, 21, 0, -26 },
  { 2379, 19, 26, 21, 1, -26 },
  { 2441, 20, 26, 21, 1, -26 },
  { 2506, 19, 30, 21, 1, -26 },
  { 2578, 20, 26, 21, 1, -26 },
  { 2643, 20, 26, 21, 1, -26 },
  { 2708, 20, 26, 21, 3, -26 },
  { 2773, 19, 26, 21, 2, -26 },
  { 2835, 20, 26, 21, 3, -26 },
  { 2900, 21, 26, 21, 2, -26 },
  { 2969, 24, 26, 21, -1, -26 },
  { 3047, 20, 26, 21, 3, -26 },
  { 3112, 21, 26, 21, 0, -26 },
  { 3181, 13, 36, 21, 4, -30 },
  { 3240, 8, 28, 21, 7, -26 },
  { 3268, 13, 36, 21, 4, -30 },
  { 3327, 14, 14, 21, 4, -26 },
  { 3352, 16, 4, 21, 0, 0 },
  { 3360, 7, 5, 21, 10, -26 },
  { 3365, 17, 19, 21, 1, -19 },
  { 3406, 18, 27, 21, 1, -27 },
  { 3467, 17, 19, 21, 2, -19 },
  { 3508, 19, 27, 21, 2, -27 },
  { 3573, 17, 19, 21, 2, -19 },
  { 3614, 19, 28, 21, 3, -28 },
  { 3681, 19, 27, 21, 1, -19 },
  { 3746, 18, 27, 21, 1, -27 },
  { 3807, 16, 26, 21, 2, -26 },
  { 3859, 16, 34, 21, 1, -26 },
  { 3927, 20, 27, 21, 1, -27 },
  { 3995, 16, 27, 21, 2, -27 },
  { 4049, 21, 19, 21, -1, -19 },
  { 4099, 18, 19, 21, 1, -19 },
  { 4142, 18, 19, 21, 1, -19 },
  { 4185, 20, 26, 21, -1, -19 },
  { 4250, 18, 26, 21, 2, -19 },
  { 4309, 17, 19, 21, 3, -19 },
  { 4350, 18, 19, 21, 1, -19 },
  { 4393, 16, 24, 21, 3, -24 },
  { 4441, 18, 19, 21, 2, -19 },
  { 4484, 18, 19, 21, 3, -19 },
  { 4527, 20, 19, 21, 2, -19 },
  { 4575, 21, 19, 21, 0, -19 },
  { 4625, 22, 27, 21, 0, -19 },
  { 4700, 19, 19, 21, 1, -19 },
  { 4746, 14, 34, 21, 5, -28 },
  { 4806, 8, 33, 21, 6, -26 },
  { 4839, 14, 34, 21, 3, -28 },
  { 4899, 20, 7, 21, 0, -14 },
};

const GFXfont RobotoMono_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC36PT7B_H_
