#ifndef _ROBOTOMONO_SEMIBOLDITALIC41PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x0F, 0xC3, 0xF0,
  0x78, 0x00, 0x3C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0x38, 0x39,
  0xC3, 0xCE, 0x1E, 0xF0, 0xF7, 0x87, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00,
  0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xE1, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC3, 0x80, 0x03,
  0x87, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F,
  0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7E,
  0x0F, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x78, 0xF0, 0x87, 0x0F, 0x0E, 0x70, 0xF1, 0xC7, 0x0F, 0x3C, 0x70,
  0xE3, 0x87, 0x1E, 0x70, 0x7F, 0xEF, 0x03, 0xFC, 0xE0, 0x1F, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xCF, 0xC0, 0x39, 0xFE, 0x07, 0xBF, 0xF0, 0xF3, 0x8F, 0x0E, 0x78,
  0x71, 0xE7, 0x87, 0x3C, 0x78, 0x70, 0x87, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xF8, 0x3C, 0xFF, 0xE0, 0xF7, 0xE7, 0xC7, 0xDF, 0x1F,
  0x9F, 0xFC, 0x3E, 0xFB, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E, 0x07, 0xFC,
  0xF8, 0x0F, 0xE3, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xC7, 0xE0, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x9C, 0x71,
  0xCF, 0x00, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x02, 0x07, 0x81, 0x38, 0x70, 0xF7,
  0xE7, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x3E, 0x1E,
  0x07, 0xC0, 0xF0, 0x1C, 0x0E, 0x00, 0x80, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF0, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x10,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x3F, 0x1F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F,
  0x3E, 0x0F, 0xF3, 0xE1, 0xFF, 0x7C, 0x7F, 0xF7, 0xCF, 0x9F, 0x7F, 0xF3,
  0xE7, 0xFC, 0x3E, 0x7F, 0x83, 0xE7, 0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x3C, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xE1, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x01,
  0xE0, 0x3F, 0x87, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xEF, 0xBC, 0x7C, 0x81,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00,
  0xFC, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F,
  0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xBF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x00, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0xF8, 0x3E, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC3, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBE,
  0x01, 0xF3, 0xE0, 0x7E, 0x7E, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xF8, 0x3F,
  0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x3E, 0x1F, 0x87, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xF8, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF,
  0xC1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xF3,
  0xE0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xF7, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x02, 0x03, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0xE1,
  0xF8, 0xFF, 0x3F, 0x87, 0xE1, 0xF0, 0x00, 0x80, 0x3E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xE0, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x03, 0xC0, 0x78, 0x03, 0xC1,
  0xE0, 0x03, 0x83, 0x87, 0xC7, 0x0E, 0x1F, 0xE6, 0x3C, 0x7F, 0xCE, 0x71,
  0xE3, 0x1C, 0xE7, 0x8E, 0x3B, 0x8E, 0x1C, 0x77, 0x3C, 0x38, 0xCE, 0x70,
  0x63, 0xB8, 0xE1, 0xC7, 0x71, 0xC3, 0x8E, 0xE3, 0x87, 0x1D, 0xC7, 0x0E,
  0x33, 0x8E, 0x38, 0xE7, 0x1C, 0xF3, 0x8E, 0x3F, 0xFF, 0x1C, 0x7E, 0xFC,
  0x3C, 0x30, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x08, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0x0F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E,
  0x01, 0xF8, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0x5F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC,
  0x07, 0xC1, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7C, 0x3F, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x03,
  0xF0, 0x7C, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xE0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF, 0xBE, 0x0F, 0xFD,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xFC, 0x03, 0xE3, 0xF0, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xC0, 0x1F, 0xC3, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E,
  0x03, 0xF8, 0x0F, 0x81, 0xFC, 0x03, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF3, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x07,
  0xF1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xFB,
  0xDE, 0x07, 0xBD, 0xFF, 0x03, 0xDF, 0xEF, 0x83, 0xEF, 0xF7, 0xC1, 0xF7,
  0xF3, 0xC0, 0xF9, 0xF9, 0xE0, 0x7C, 0xF9, 0xF0, 0x3C, 0x7C, 0xF8, 0x1E,
  0x3C, 0x7C, 0x1F, 0x1E, 0x3E, 0x0F, 0x8E, 0x1E, 0x07, 0xC7, 0x0F, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8,
  0x7C, 0x1F, 0xFC, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C,
  0xFC, 0x1F, 0x1E, 0xF8, 0x1F, 0x1E, 0xF8, 0x3F, 0x1E, 0xF8, 0x3E, 0x1E,
  0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07,
  0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7C,
  0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7C, 0x07, 0xE7, 0xE0, 0x1F, 0x3E,
  0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB,
  0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC3,
  0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x78, 0x3F,
  0xF0, 0xF0, 0x7F, 0xE1, 0xE0, 0xF7, 0xC3, 0xC3, 0xEF, 0x8F, 0x87, 0xDF,
  0x1F, 0x0F, 0x3E, 0x3E, 0x1E, 0x7C, 0xFC, 0x7C, 0xF9, 0xF8, 0xF9, 0xF3,
  0xF1, 0xE3, 0xEF, 0xE7, 0xC7, 0xDF, 0xCF, 0x8F, 0x3B, 0x9E, 0x1E, 0x77,
  0x3C, 0x3D, 0xEE, 0xF8, 0x7B, 0xDD, 0xF0, 0xF7, 0x3B, 0xC1, 0xFE, 0x77,
  0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x00, 0xF7, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xDC, 0x07, 0x9E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xF8, 0x7C, 0x7C, 0x3E,
  0x1E, 0x0F, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x03, 0xE7, 0xE0,
  0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC1, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xF7, 0xC1, 0xFE, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0xF8, 0x07,
  0xDF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x7E, 0x07,
  0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x83, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7D, 0xFF, 0x83, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7E, 0x07, 0xDF, 0x80, 0xFB,
  0xE0, 0x0F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xCF,
  0x83, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0xDF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFE, 0x3F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x07,
  0xC1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0x07, 0xE0, 0x78, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xFD, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E,
  0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F,
  0xDF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x20, 0x0F, 0x81, 0xC0, 0x7E,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0xFC, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xBF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xFC, 0x7C,
  0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC7,
  0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0x80,
  0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xBE,
  0x3C, 0x0F, 0x7E, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0x9F,
  0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78,
  0x78, 0xF8, 0x78, 0xF8, 0x0F, 0x1F, 0x80, 0xF9, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xC0,
  0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0x8F, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x0F, 0xC7, 0xC1, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xC7, 0xC0,
  0x1F, 0x7F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xF1, 0xFC, 0x1F,
  0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3E, 0xFF, 0xC0, 0xF9, 0xFE, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F,
  0xE7, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0x81, 0xF9,
  0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x0F, 0xE3, 0xE7, 0xFC, 0x7D, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xC0, 0x8F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xE3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x3C,
  0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0x7F, 0x3F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF3, 0xE0, 0x1F, 0x1F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0x78, 0x0F, 0xE3, 0xC0, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x9E,
  0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3C,
  0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x38, 0x3F, 0xF0, 0xF0, 0x7B, 0xE1, 0xE1,
  0xF7, 0xC3, 0xC3, 0xEF, 0x8F, 0x87, 0x9F, 0x1F, 0x1F, 0x3E, 0x7E, 0x3E,
  0x7C, 0xFC, 0x78, 0xF9, 0xF8, 0xF1, 0xE7, 0xF3, 0xE3, 0xCE, 0xE7, 0x87,
  0x9D, 0xCF, 0x0F, 0x73, 0xBC, 0x1E, 0xE7, 0x78, 0x3D, 0xCE, 0xF0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x03,
  0xF3, 0xF0, 0x01, 0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xC7, 0xC0, 0x0F,
  0x87, 0xE0, 0x1F, 0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x81,
  0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x1E, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x3C, 0xFF, 0xE0, 0x73, 0xFF, 0xE1, 0xE7, 0x87, 0xFF,
  0xDE, 0x07, 0xFF, 0x3C, 0x07, 0xFC, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 29, 24, 7, -29 },
  { 38, 13, 11, 24, 7, -31 },
  { 56, 24, 29, 24, 0, -29 },
  { 143, 21, 38, 24, 2, -34 },
  { 243, 20, 30, 24, 2, -30 },
  { 318, 22, 30, 24, 1, -30 },
  { 401, 6, 11, 24, 10, -31 },
  { 410, 14, 42, 24, 6, -33 },
  { 484, 14, 42, 24, 3, -33 },
  { 558, 20, 20, 24, 3, -29 },
  { 608, 20, 21, 24, 2, -24 },
  { 661, 8, 13, 24, 4, -5 },
  { 674, 17, 4, 24, 5, -15 },
  { 683, 7, 7, 24, 7, -7 },
  { 690, 21, 32, 24, 2, -29 },
  { 774, 20, 30, 24, 2, -30 },
  { 849, 14, 29, 24, 5, -29 },
  { 900, 22, 30, 24, 0, -30 },
  { 983, 21, 30, 24, 1, -30 },
  { 1062, 22, 29, 24, 0, -29 },
  { 1142, 21, 29, 24, 2, -29 },
  { 1219, 19, 29, 24, 2, -29 },
  { 1288, 21, 29, 24, 3, -29 },
  { 1365, 20, 30, 24, 2, -30 },
  { 1440, 19, 30, 24, 3, -30 },
  { 1512, 10, 24, 24, 7, -24 },
  { 1542, 12, 32, 24, 6, -24 },
  { 1590, 19, 19, 24, 3, -22 },
  { 1636, 21, 13, 24, 2, -19 },
  { 1671, 19, 19, 24, 2, -22 },
  { 1717, 18, 30, 24, 5, -30 },
  { 1785, 23, 29, 24, 1, -29 },
  { 1869, 22, 29, 24, -1, -29 },
  { 1949, 23, 29, 24, 1, -29 },
  { 2033, 22, 30, 24, 2, -30 },
  { 2116, 23, 29, 24, 0, -29 },
  { 2200, 24, 29, 24, 1, -29 },
  { 2287, 24, 29, 24, 1, -29 },
  { 2374, 21, 30, 24, 2, -30 },
  { 2453, 24, 29, 24, 0, -29 },
  { 2540, 21, 29, 24, 2, -29 },
  { 2617, 23, 29, 24, 1, -29 },
  { 2701, 26, 29, 24, 1, -29 },
  { 2796, 19, 29, 24, 1, -29 },
  { 2865, 25, 29, 24, 0, -29 },
  { 2956, 24, 29, 24, 0, -29 },
  { 3043, 21, 30, 24, 2, -30 },
  { 3122, 23, 29, 24, 1, -29 },
  { 3206, 21, 35, 24, 2, -30 },
  { 3298, 23, 29, 24, 1, -29 },
  { 3382, 23, 30, 24, 1, -30 },
  { 3469, 23, 29, 24, 3, -29 },
  { 3553, 22, 29, 24, 2, -29 },
  { 3633, 23, 29, 24, 3, -29 },
  { 3717, 23, 29, 24, 3, -29 },
  { 3801, 27, 29, 24, -1, -29 },
  { 3899, 23, 29, 24, 4, -29 },
  { 3983, 24, 29, 24, 0, -29 },
  { 4070, 15, 41, 24, 5, -34 },
  { 4147, 10, 32, 24, 8, -29 },
  { 4187, 15, 41, 24, 5, -34 },
  { 4264, 16, 15, 24, 4, -29 },
  { 4294, 19, 4, 24, 0, 0 },
  { 4304, 8, 6, 24, 11, -30 },
  { 4310, 20, 22, 24, 1, -22 },
  { 4365, 21, 31, 24, 1, -31 },
  { 4447, 19, 22, 24, 2, -22 },
  { 4500, 22, 31, 24, 2, -31 },
  { 4586, 20, 22, 24, 2, -22 },
  { 4641, 22, 32, 24, 4, -32 },
  { 4729, 22, 31, 24, 1, -22 },
  { 4815, 21, 31, 24, 1, -31 },
  { 4897, 18, 30, 24, 2, -30 },
  { 4965, 19, 39, 24, 1, -30 },
  { 5058, 23, 31, 24, 1, -31 },
  { 5148, 18, 31, 24, 2, -31 },
  { 5218, 24, 22, 24, -1, -22 },
  { 5284, 21, 22, 24, 1, -22 },
  { 5342, 20, 22, 24, 2, -22 },
  { 5397, 22, 30, 24, -1, -22 },
  { 5480, 21, 30, 24, 2, -22 },
  { 5559, 19, 22, 24, 4, -22 },
  { 5612, 20, 22, 24, 2, -22 },
  { 5667, 19, 27, 24, 3, -27 },
  { 5732, 21, 22, 24, 2, -22 },
  { 5790, 21, 22, 24, 3, -22 },
  { 5848, 23, 22, 24, 2, -22 },
  { 5912, 24, 22, 24, 0, -22 },
  { 5978, 25, 31, 24, 0, -22 },
  { 6075, 22, 22, 24, 1, -22 },
  { 6136, 16, 39, 24, 6, -32 },
  { 6214, 9, 37, 24, 7, -29 },
  { 6256, 16, 39, 24, 4, -32 },
  { 6334, 23, 8, 24, 0, -16 },
};

const GFXfont RobotoMono_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC41PT7B_H_
