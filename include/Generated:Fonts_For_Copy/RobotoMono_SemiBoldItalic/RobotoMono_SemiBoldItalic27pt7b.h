#ifndef _ROBOTOMONO_SEMIBOLDITALIC27PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x1C, 0x00, 0x00,
  0x10, 0xE3, 0xCE, 0x00, 0x63, 0xE3, 0xE7, 0xC7, 0xC6, 0xC6, 0xC6, 0x00,
  0xC6, 0x01, 0xCC, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x98, 0x3F, 0xFF, 0x3F,
  0xFF, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0x18, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x73,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0xFC, 0x0F, 0xF8, 0x7D, 0xF1,
  0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0xF0, 0x3B, 0xC0, 0xE7, 0x07, 0x9F, 0x7C,
  0x3F, 0xE0, 0x7F, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x81, 0x8C, 0x4C, 0x67, 0x63, 0x33, 0x3B, 0x1F, 0xB0, 0x7B, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0xDE, 0x0D, 0xF8, 0xCC, 0xEE, 0xE7, 0x67,
  0x38, 0x39, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x07, 0x78, 0x0F, 0xE0, 0x0F,
  0x00, 0x3E, 0x01, 0xFC, 0x73, 0xBC, 0xEF, 0x39, 0xDC, 0x7F, 0x38, 0x7E,
  0x70, 0x78, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xE0, 0x6F, 0xFF, 0xB0, 0x01,
  0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x02, 0x00, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x30,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x86, 0x17, 0x33, 0xFF, 0xFC, 0x7F,
  0xC0, 0xE0, 0x0F, 0x80, 0xEC, 0x0E, 0x70, 0xE1, 0xC2, 0x08, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0x39, 0xDE, 0xE7, 0x7B, 0x98, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x79, 0xE3, 0x87, 0x38, 0x3D, 0xC1,
  0xEE, 0x0F, 0xF1, 0xFF, 0x9F, 0xBB, 0xDD, 0xF8, 0xEF, 0x87, 0x70, 0x7B,
  0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0xDE, 0x1F, 0xE0, 0x7E, 0x00, 0x01, 0x87,
  0xDF, 0xEF, 0xFF, 0x74, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x07, 0xF0, 0x3F, 0xE1,
  0xF7, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xE3, 0xE7, 0x8E,
  0x0F, 0x38, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x07, 0xE0, 0x1F, 0x80,
  0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xCE, 0x07, 0x38, 0x3C, 0xFB, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0E, 0xE0, 0x73, 0x83, 0xDE, 0x0E, 0x78, 0x71, 0xC3, 0x87, 0x1C,
  0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x98, 0x0F, 0xF8, 0x3F, 0xF1, 0xE3, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xEF, 0x07, 0x3C, 0x3C, 0x7F, 0xE0, 0xFF, 0x81, 0xF8, 0x00,
  0x01, 0xF0, 0x3F, 0x83, 0xFC, 0x3E, 0x01, 0xC0, 0x1C, 0x00, 0xE7, 0x0E,
  0xFC, 0x7F, 0xF3, 0xC7, 0x9C, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xCE, 0x1E, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE7, 0x8F, 0x0F,
  0x38, 0x3C, 0xE0, 0xE3, 0xC3, 0x87, 0x1E, 0x1F, 0xE0, 0x7F, 0x83, 0xFF,
  0x1C, 0x1C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x3C, 0x3C, 0x7F, 0xF1, 0xFF,
  0x83, 0xF8, 0x00, 0x0F, 0xC3, 0xFE, 0x7C, 0xF7, 0x87, 0x70, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x1F, 0x7F, 0xF3, 0xFE, 0x1C, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x7F, 0x07, 0xE0, 0x78, 0x00, 0x3C, 0xF3, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0xFB, 0xCF, 0x00, 0x0E, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0xC0, 0x00, 0x10, 0x03, 0x01, 0xF0, 0x7F, 0x3F, 0xCF,
  0xE0, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x40,
  0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0xBF, 0xFC, 0x30, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C,
  0x07, 0xE1, 0xFE, 0x7F, 0x87, 0xF0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x70, 0x70, 0xC0, 0x63,
  0x1E, 0x4C, 0xFC, 0x99, 0x99, 0xF6, 0x32, 0xCC, 0x65, 0x99, 0x9B, 0x73,
  0x36, 0xC6, 0x6D, 0xDD, 0x99, 0xFF, 0x33, 0x9C, 0x60, 0x00, 0x60, 0x80,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C,
  0x70, 0x70, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x9C, 0x0F, 0x78, 0x1E,
  0xE0, 0x1F, 0xC0, 0x38, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E,
  0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x3C, 0x3F, 0xF8, 0x3F, 0xF8,
  0x38, 0x7C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x87,
  0x9F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xBC, 0x1E, 0x70, 0x71,
  0xFF, 0xC3, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE1,
  0xE1, 0xC1, 0xE3, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x70, 0x3C,
  0xE0, 0x79, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x1E, 0x38, 0x7C, 0x7F,
  0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE7, 0xCF, 0x07,
  0x38, 0x1D, 0xE0, 0x77, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC7, 0xFF, 0x1F,
  0xFC, 0x7E, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0x9C, 0x1E, 0x7F, 0xF8, 0xFF,
  0xC1, 0xFC, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0xF0, 0x78, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0x78, 0x78, 0x7F, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0x0E, 0x07, 0xC7, 0x83, 0xC1, 0xE1, 0xE0, 0x70, 0xF0,
  0x1C, 0x78, 0x07, 0x3C, 0x01, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87,
  0x01, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x0F, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F,
  0x3E, 0x1F, 0x7E, 0x3B, 0x6E, 0x3B, 0xEE, 0x3B, 0xEE, 0x3B, 0xCE, 0x3B,
  0xDC, 0x39, 0x9C, 0x79, 0x9C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70,
  0x38, 0x70, 0x38, 0xF0, 0x38, 0x1E, 0x0F, 0x1E, 0x0F, 0x1F, 0x0E, 0x1F,
  0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x3F, 0x9E, 0x3F, 0x9E, 0x39, 0x9C, 0x39,
  0x9C, 0x39, 0xDC, 0x39, 0xFC, 0x78, 0xFC, 0x78, 0xFC, 0x70, 0xF8, 0x70,
  0xF8, 0x70, 0x78, 0x70, 0x78, 0xF0, 0x78, 0x07, 0xF0, 0x3F, 0xE1, 0xE7,
  0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xEF, 0x07, 0x9C, 0x3C, 0x7F,
  0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE0,
  0xF3, 0xC1, 0xE7, 0x03, 0xCE, 0x07, 0x9C, 0x0E, 0x78, 0x3C, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xF7, 0x8F, 0x0F,
  0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xEF, 0x07, 0x9C, 0x3C, 0x7F, 0xE0, 0xFF,
  0x01, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1C, 0x0E, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x38, 0xF0, 0x78, 0x70,
  0x78, 0x70, 0x70, 0x78, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x3C, 0x07, 0xF0,
  0x3F, 0xF0, 0x79, 0xF1, 0xE0, 0xE3, 0x81, 0xE7, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x0E,
  0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x07, 0x3C,
  0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x0F,
  0x3C, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0xF0, 0x1E,
  0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1E, 0x3C, 0x3C,
  0x78, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70,
  0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE3, 0x8F,
  0xC7, 0x1F, 0x8E, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xF7, 0xBB, 0xEE, 0x76,
  0xDC, 0xED, 0xB9, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xC3, 0x83, 0x87, 0x00, 0x0F, 0x03,
  0xC3, 0xC1, 0xE0, 0x70, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x00, 0xEF, 0x00,
  0x3B, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xCE, 0x01, 0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x1C,
  0x1E, 0x07, 0x8F, 0x81, 0xE0, 0xE0, 0x3F, 0xC0, 0x73, 0xC1, 0xE3, 0x87,
  0x87, 0x0E, 0x0E, 0x3C, 0x1E, 0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x7C, 0x3F, 0x00, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE0, 0x0F,
  0xC3, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0xFC, 0x3F, 0x00, 0x07, 0x01, 0xE0, 0xF8,
  0x36, 0x1D, 0x8E, 0x63, 0x9D, 0xC7, 0x70, 0xF8, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF3, 0x8E, 0x70, 0x01, 0x00, 0xFF, 0x0F, 0xFC, 0x78, 0xF7,
  0x87, 0x80, 0x3C, 0x1F, 0xE7, 0xFE, 0x7C, 0x77, 0x83, 0xB8, 0x1D, 0xC1,
  0xEF, 0xBF, 0x3F, 0xF8, 0xFB, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x40, 0xEF, 0x87, 0xFE, 0x3C, 0x7B, 0xC3, 0xDE, 0x0E,
  0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xFE, 0x0E, 0xF0, 0xF7, 0xFF, 0xBF,
  0xF9, 0xDF, 0x80, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x1C, 0xE1, 0xE7, 0xDE,
  0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x47, 0x83, 0xFF, 0x1F, 0xFE, 0x3C, 0x78, 0xF0, 0x71, 0xC0,
  0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0x70, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xF7, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x78,
  0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00,
  0xE0, 0x47, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x0F,
  0xF0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x3F, 0xFC, 0xFF, 0xF8,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x0F, 0xDC, 0x3F, 0xF8, 0xF1, 0xF3, 0xC1, 0xC7, 0x03, 0x8E, 0x07,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xE1, 0xC3, 0xC3, 0xFF, 0x87,
  0xFF, 0x07, 0xFE, 0x00, 0x38, 0x20, 0x70, 0xE3, 0xE3, 0xFF, 0x81, 0xFE,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x60, 0xEF, 0xC7, 0xFF, 0x3C, 0x7B, 0xC1, 0xDE, 0x0E, 0xE0, 0x77, 0x03,
  0xB8, 0x3F, 0xC1, 0xFE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xE0,
  0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x3F, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x4E, 0x0F, 0x1C, 0x7C,
  0x39, 0xF0, 0xF7, 0xC1, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x79, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0xC0, 0x0F,
  0xE1, 0xFE, 0x1F, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x08, 0x7F, 0xF8, 0xFF, 0xF9, 0xDE,
  0x77, 0x9C, 0xEE, 0x39, 0xDC, 0xE3, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x3B,
  0x8E, 0x77, 0x1C, 0xEE, 0x71, 0xDC, 0xE7, 0xB9, 0xCE, 0x00, 0x00, 0xC1,
  0xDF, 0x8F, 0xFE, 0x78, 0xF7, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x7F, 0x83, 0xFC, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xC0, 0x01,
  0x00, 0x7F, 0x07, 0xFC, 0x79, 0xF7, 0x83, 0xB8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x83, 0xFC, 0x1E, 0xE1, 0xE7, 0xDE, 0x1F, 0xE0, 0x7E, 0x00,
  0x00, 0x40, 0x77, 0xC1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C, 0xF0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x7F, 0xF1, 0xFF,
  0xC7, 0x7C, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x02,
  0x00, 0x3F, 0x73, 0xFF, 0xCF, 0x1E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x07, 0x1C, 0x3C, 0x7F, 0xF1, 0xFF, 0xC3,
  0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x20,
  0xEF, 0xC7, 0xFE, 0x7F, 0xF3, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x7F, 0x8F, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x00, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x07, 0xB8, 0x1D, 0xE0, 0xE7, 0x8F, 0x3F, 0xF0, 0x7F, 0x00,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x17, 0xFF, 0x7F, 0xF8, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x70, 0x3B, 0x83, 0xDC, 0x1F, 0xE0,
  0xEF, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xF7, 0x07, 0x38, 0x79,
  0xFF, 0xCF, 0xEE, 0x3E, 0x70, 0xE0, 0x3F, 0xC1, 0xE7, 0x07, 0x1C, 0x3C,
  0x70, 0xE1, 0xC7, 0x83, 0x1C, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0xE7, 0x1F, 0x1C, 0x7C, 0x73, 0xB3,
  0xCE, 0xCF, 0x3B, 0x3D, 0xCD, 0xB7, 0x36, 0xDC, 0xDB, 0x63, 0xCF, 0x8F,
  0x3C, 0x38, 0xF0, 0xE3, 0xC3, 0x8E, 0x00, 0x3C, 0x0F, 0x1E, 0x1E, 0x0E,
  0x3C, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0xF0, 0x3C, 0x3C,
  0x0F, 0x9E, 0x07, 0x87, 0x07, 0x83, 0x83, 0x81, 0xC3, 0xC0, 0xF1, 0xC0,
  0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0xC0, 0xF0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC1, 0xF0,
  0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x00, 0x1C, 0x71, 0x86, 0x18, 0x61, 0x8E,
  0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30,
  0x0C, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xC0, 0x70, 0x08, 0x00,
  0x1C, 0x00, 0x7E, 0x0D, 0xFE, 0x3F, 0x1F, 0xEE, 0x1F, 0xC0, 0x0F, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 8, 7, 16, 5, -20 },
  { 23, 16, 19, 16, 0, -19 },
  { 61, 14, 25, 16, 1, -22 },
  { 105, 13, 20, 16, 2, -20 },
  { 138, 15, 20, 16, 0, -20 },
  { 176, 3, 7, 16, 7, -20 },
  { 179, 9, 27, 16, 4, -21 },
  { 210, 9, 27, 16, 2, -21 },
  { 241, 13, 13, 16, 2, -19 },
  { 263, 14, 14, 16, 1, -16 },
  { 288, 5, 8, 16, 3, -3 },
  { 293, 11, 3, 16, 3, -10 },
  { 298, 4, 4, 16, 5, -4 },
  { 300, 14, 21, 16, 1, -19 },
  { 337, 13, 20, 16, 2, -20 },
  { 370, 9, 19, 16, 3, -19 },
  { 392, 14, 19, 16, 0, -19 },
  { 426, 14, 19, 16, 1, -19 },
  { 460, 14, 19, 16, 0, -19 },
  { 494, 14, 19, 16, 1, -19 },
  { 528, 13, 19, 16, 1, -19 },
  { 559, 14, 19, 16, 2, -19 },
  { 593, 14, 19, 16, 1, -19 },
  { 627, 12, 19, 16, 2, -19 },
  { 656, 6, 15, 16, 5, -15 },
  { 668, 8, 20, 16, 4, -15 },
  { 688, 12, 13, 16, 2, -15 },
  { 708, 14, 8, 16, 1, -12 },
  { 722, 13, 12, 16, 1, -14 },
  { 742, 12, 20, 16, 3, -20 },
  { 772, 15, 19, 16, 1, -19 },
  { 808, 15, 19, 16, -1, -19 },
  { 844, 16, 19, 16, 0, -19 },
  { 882, 14, 20, 16, 1, -20 },
  { 917, 15, 19, 16, 0, -19 },
  { 953, 15, 19, 16, 1, -19 },
  { 989, 15, 19, 16, 1, -19 },
  { 1025, 14, 19, 16, 1, -19 },
  { 1059, 16, 19, 16, 0, -19 },
  { 1097, 14, 19, 16, 1, -19 },
  { 1131, 15, 19, 16, 1, -19 },
  { 1167, 18, 19, 16, 0, -19 },
  { 1210, 12, 19, 16, 1, -19 },
  { 1239, 16, 19, 16, 0, -19 },
  { 1277, 16, 19, 16, 0, -19 },
  { 1315, 14, 19, 16, 1, -19 },
  { 1349, 15, 19, 16, 1, -19 },
  { 1385, 14, 22, 16, 1, -19 },
  { 1424, 16, 19, 16, 0, -19 },
  { 1462, 15, 19, 16, 1, -19 },
  { 1498, 15, 19, 16, 2, -19 },
  { 1534, 15, 19, 16, 1, -19 },
  { 1570, 15, 19, 16, 2, -19 },
  { 1606, 15, 19, 16, 2, -19 },
  { 1642, 18, 19, 16, -1, -19 },
  { 1685, 15, 19, 16, 3, -19 },
  { 1721, 16, 19, 16, 0, -19 },
  { 1759, 10, 26, 16, 3, -22 },
  { 1792, 7, 21, 16, 5, -19 },
  { 1811, 10, 26, 16, 3, -22 },
  { 1844, 10, 10, 16, 3, -19 },
  { 1857, 12, 3, 16, 0, 0 },
  { 1862, 5, 4, 16, 7, -20 },
  { 1865, 13, 15, 16, 1, -15 },
  { 1890, 13, 20, 16, 1, -20 },
  { 1923, 13, 15, 16, 1, -15 },
  { 1948, 15, 20, 16, 1, -20 },
  { 1986, 13, 15, 16, 1, -15 },
  { 2011, 15, 21, 16, 2, -21 },
  { 2051, 15, 21, 16, 0, -15 },
  { 2091, 13, 20, 16, 1, -20 },
  { 2124, 12, 20, 16, 1, -20 },
  { 2154, 12, 26, 16, 1, -20 },
  { 2193, 15, 20, 16, 1, -20 },
  { 2231, 12, 20, 16, 1, -20 },
  { 2261, 15, 15, 16, 0, -15 },
  { 2290, 13, 15, 16, 1, -15 },
  { 2315, 13, 15, 16, 1, -15 },
  { 2340, 14, 20, 16, 0, -15 },
  { 2375, 14, 20, 16, 1, -15 },
  { 2410, 13, 15, 16, 2, -15 },
  { 2435, 13, 15, 16, 1, -15 },
  { 2460, 13, 18, 16, 2, -18 },
  { 2490, 13, 14, 16, 2, -14 },
  { 2513, 14, 14, 16, 2, -14 },
  { 2538, 14, 14, 16, 2, -14 },
  { 2563, 16, 14, 16, 0, -14 },
  { 2591, 17, 20, 16, 0, -14 },
  { 2634, 15, 14, 16, 0, -14 },
  { 2661, 10, 26, 16, 4, -21 },
  { 2694, 6, 24, 16, 5, -19 },
  { 2712, 11, 26, 16, 2, -21 },
  { 2748, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC27PT7B_H_
