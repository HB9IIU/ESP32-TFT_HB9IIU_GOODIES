#ifndef _ROBOTOMONO_SEMIBOLDITALIC67PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x00, 0x08, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7E,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x30, 0x7C, 0x07, 0xC0, 0x7C, 0xFC, 0x07,
  0xC0, 0x7E, 0xFC, 0x07, 0xC0, 0xFC, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xC1, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x1F,
  0x8F, 0xC0, 0x7F, 0x7F, 0x8F, 0x80, 0x7F, 0xFF, 0x1F, 0x80, 0x3F, 0xFF,
  0x3F, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x00, 0xC0,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x3E,
  0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0xF8,
  0xFF, 0xFF, 0x01, 0xF9, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x03, 0xE3,
  0xF0, 0x3F, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x83,
  0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0x03, 0xF0, 0x3F, 0x02, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF8,
  0x00, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xFF, 0x00, 0xFE, 0x1F,
  0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xBF, 0xE0, 0x7F, 0x8F, 0xF8, 0xFF, 0x83,
  0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x7F, 0xC0,
  0x7F, 0x9F, 0xE3, 0xFC, 0x03, 0xFE, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF, 0xF1,
  0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9,
  0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x03, 0xE0,
  0x02, 0x38, 0x03, 0xE0, 0x0E, 0x7E, 0x03, 0xE0, 0x7E, 0x7F, 0x83, 0xE1,
  0xFE, 0xFF, 0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x01, 0xFC, 0x3F,
  0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0,
  0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0x3F, 0xC0,
  0x3F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x7F, 0xC7,
  0xFD, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xBF, 0xE1, 0xFE, 0x7F, 0xFF,
  0x81, 0xFE, 0x7F, 0xFF, 0x01, 0xFE, 0x7F, 0xFC, 0x03, 0xFE, 0xFF, 0xF8,
  0x03, 0xFC, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xFB, 0xFE, 0xFF, 0x0F, 0xF3, 0xE0, 0x3F, 0xCC, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFB,
  0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x1C, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0x3F, 0xC7,
  0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFB,
  0xFC, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0x80, 0xF8, 0x1F,
  0xFE, 0x1E, 0x07, 0xE0, 0xFF, 0xFC, 0x78, 0x1F, 0x07, 0xFF, 0xE1, 0xE0,
  0xFC, 0x3F, 0xC7, 0x87, 0xC3, 0xE1, 0xFC, 0x3E, 0x1F, 0x1F, 0x87, 0xE0,
  0xF8, 0x7C, 0x7C, 0x3F, 0x03, 0xC1, 0xF1, 0xF0, 0xF8, 0x0F, 0x07, 0x8F,
  0x87, 0xE0, 0x7C, 0x1E, 0x3E, 0x1F, 0x01, 0xF0, 0x78, 0xF8, 0x7C, 0x07,
  0xC3, 0xE7, 0xE3, 0xF0, 0x1E, 0x0F, 0x9F, 0x0F, 0xC0, 0xF8, 0x3E, 0x7C,
  0x3E, 0x03, 0xE0, 0xF1, 0xF0, 0xF8, 0x0F, 0x83, 0xC7, 0xC3, 0xE0, 0x3C,
  0x0F, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x7C, 0x3E, 0x07, 0xC1, 0xE1, 0xF0,
  0xF8, 0x1F, 0x07, 0x8F, 0xC3, 0xE0, 0xFC, 0x3C, 0x1F, 0x0F, 0xC7, 0xF1,
  0xF0, 0x7C, 0x3F, 0xFF, 0xFF, 0x81, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xC1,
  0xFF, 0x3F, 0xF0, 0x1F, 0x03, 0xF8, 0xFF, 0x80, 0x7C, 0x07, 0x80, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0x80,
  0x3F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x3F,
  0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x1F,
  0xE3, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xBF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x80, 0x7F, 0x7C, 0x3F, 0x7F, 0x00, 0xFE, 0xF8, 0xFF, 0xFE, 0x03,
  0xFD, 0xF9, 0xFB, 0xFC, 0x07, 0xFB, 0xF7, 0xF7, 0xF8, 0x0F, 0xE7, 0xEF,
  0xCF, 0xE0, 0x1F, 0xCF, 0xFF, 0x9F, 0xC0, 0x3F, 0x9F, 0xFE, 0x3F, 0x80,
  0xFF, 0x3F, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0xE3, 0xF8, 0x07, 0xF8, 0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x0F, 0xE0, 0x7C, 0x1F, 0xE0, 0x3F, 0xC0,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0xC0, 0x7F, 0xBF, 0x81, 0xFE, 0x01, 0xFE,
  0x7E, 0x07, 0xF8, 0x0F, 0xF9, 0xF8, 0x1F, 0xE0, 0x3F, 0xE7, 0xF0, 0xFF,
  0x80, 0xFF, 0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xE3, 0xFC,
  0x07, 0xFC, 0x1F, 0x9F, 0xF0, 0x1F, 0xE0, 0x7F, 0x7F, 0xC0, 0x7F, 0x81,
  0xFD, 0xFE, 0x01, 0xFE, 0x07, 0xF7, 0xF8, 0x0F, 0xF8, 0x0F, 0xDF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x07,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x9F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x01, 0xFE,
  0x7F, 0x01, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xF8, 0x0F, 0xF3, 0xFC, 0x07,
  0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x7F, 0x83,
  0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFC, 0x3F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0xC3, 0xFC, 0x1F, 0xC3, 0xFF, 0x87, 0xF8, 0x3F, 0x87, 0xFF, 0x0F,
  0xE0, 0x7F, 0x0F, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0xF1, 0xFC, 0x07, 0xF1, 0xFF, 0xE7,
  0xF8, 0x0F, 0xE7, 0xEF, 0xCF, 0xF0, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0x3F,
  0x9F, 0xBF, 0x3F, 0x80, 0x7F, 0x7E, 0x7E, 0xFF, 0x00, 0xFE, 0xFC, 0xFD,
  0xFC, 0x01, 0xFD, 0xF9, 0xFB, 0xF8, 0x03, 0xFB, 0xE3, 0xFF, 0xF0, 0x07,
  0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xFE, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xE7, 0xF8,
  0x03, 0xFF, 0x87, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x0F, 0xF1, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0xC0,
  0x3F, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0xC7,
  0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x7F,
  0x00, 0x07, 0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x1C, 0x03, 0xFF,
  0x00, 0x3F, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0C,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0x03,
  0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x40, 0xFF, 0x80, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xE0, 0x00,
  0x1F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE7, 0xFC, 0x7F,
  0xC0, 0x3F, 0xBF, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0x1F, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFC, 0x03,
  0xFB, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0xE0, 0x00, 0xFF, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0xE7, 0xFF,
  0xF0, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xF3, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x1F, 0xFF, 0x03, 0xFC, 0x7F, 0xFE, 0x03, 0xF8, 0xFF, 0xFE, 0x07, 0xF9,
  0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x1F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0x07,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xC7, 0xF0,
  0x01, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE,
  0x03, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x07, 0xF8, 0x1F,
  0xEF, 0xE0, 0x7F, 0x81, 0xFC, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF,
  0x83, 0xFC, 0xFE, 0x0F, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x83, 0xF8, 0xFE,
  0x1F, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0xF8, 0x7F,
  0x0F, 0xE3, 0xEF, 0x8F, 0xF0, 0xFE, 0x3E, 0xF8, 0xFE, 0x0F, 0xE7, 0xEF,
  0x8F, 0xE0, 0xFE, 0x7C, 0xF8, 0xFC, 0x0F, 0xC7, 0xCF, 0x9F, 0xC0, 0xFC,
  0xF8, 0xF9, 0xFC, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF8, 0xFB, 0xF8,
  0x0F, 0xDF, 0x0F, 0xBF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0xC0, 0x03, 0xF1, 0xFF,
  0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0x1F,
  0xCF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0xE3, 0xF0, 0x07,
  0xFF, 0xFF, 0x1F, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x40, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 16, 49, 39, 12, -48 },
  { 99, 21, 17, 39, 12, -50 },
  { 144, 39, 48, 39, 0, -48 },
  { 378, 35, 62, 39, 3, -55 },
  { 650, 32, 49, 39, 4, -48 },
  { 846, 37, 49, 39, 1, -48 },
  { 1073, 9, 17, 39, 17, -50 },
  { 1093, 23, 68, 39, 10, -53 },
  { 1289, 23, 68, 39, 5, -53 },
  { 1485, 32, 34, 39, 6, -48 },
  { 1621, 33, 34, 39, 3, -39 },
  { 1762, 14, 21, 39, 6, -8 },
  { 1799, 27, 6, 39, 8, -24 },
  { 1820, 12, 12, 39, 11, -11 },
  { 1838, 35, 52, 39, 3, -48 },
  { 2066, 32, 49, 39, 4, -48 },
  { 2262, 22, 48, 39, 8, -48 },
  { 2394, 35, 48, 39, 0, -48 },
  { 2604, 34, 49, 39, 2, -48 },
  { 2813, 34, 48, 39, 1, -48 },
  { 3017, 35, 49, 39, 3, -48 },
  { 3232, 31, 49, 39, 3, -48 },
  { 3422, 34, 48, 39, 5, -48 },
  { 3626, 33, 49, 39, 3, -48 },
  { 3829, 31, 48, 39, 5, -48 },
  { 4015, 16, 39, 39, 12, -38 },
  { 4093, 20, 51, 39, 9, -38 },
  { 4221, 31, 31, 39, 5, -36 },
  { 4342, 34, 21, 39, 3, -31 },
  { 4432, 31, 31, 39, 3, -36 },
  { 4553, 30, 48, 39, 8, -48 },
  { 4733, 38, 47, 39, 1, -47 },
  { 4957, 37, 48, 39, -2, -48 },
  { 5179, 38, 48, 39, 1, -48 },
  { 5407, 35, 49, 39, 3, -48 },
  { 5622, 37, 48, 39, 1, -48 },
  { 5844, 39, 48, 39, 1, -48 },
  { 6078, 39, 48, 39, 2, -48 },
  { 6312, 35, 49, 39, 3, -48 },
  { 6527, 39, 48, 39, 1, -48 },
  { 6761, 35, 48, 39, 3, -48 },
  { 6971, 37, 49, 39, 2, -48 },
  { 7198, 43, 48, 39, 1, -48 },
  { 7456, 31, 48, 39, 2, -48 },
  { 7642, 39, 48, 39, 1, -48 },
  { 7876, 38, 48, 39, 1, -48 },
  { 8104, 35, 49, 39, 3, -48 },
  { 8319, 37, 48, 39, 2, -48 },
  { 8541, 36, 56, 39, 2, -48 },
  { 8793, 38, 48, 39, 1, -48 },
  { 9021, 37, 49, 39, 2, -48 },
  { 9248, 38, 48, 39, 5, -48 },
  { 9476, 37, 49, 39, 3, -48 },
  { 9703, 36, 48, 39, 6, -48 },
  { 9919, 39, 48, 39, 4, -48 },
  { 10153, 45, 48, 39, -2, -48 },
  { 10423, 37, 48, 39, 6, -48 },
  { 10645, 40, 48, 39, 0, -48 },
  { 10885, 24, 66, 39, 8, -55 },
  { 11083, 16, 52, 39, 13, -48 },
  { 11187, 24, 66, 39, 8, -55 },
  { 11385, 26, 26, 39, 7, -48 },
  { 11470, 30, 7, 39, 0, 0 },
  { 11497, 13, 9, 39, 18, -48 },
  { 11512, 32, 37, 39, 2, -36 },
  { 11660, 34, 51, 39, 1, -50 },
  { 11877, 32, 37, 39, 3, -36 },
  { 12025, 36, 51, 39, 3, -50 },
  { 12255, 33, 37, 39, 3, -36 },
  { 12408, 36, 52, 39, 6, -52 },
  { 12642, 36, 50, 39, 1, -36 },
  { 12867, 34, 50, 39, 1, -50 },
  { 13080, 30, 49, 39, 3, -49 },
  { 13264, 31, 63, 39, 1, -49 },
  { 13509, 38, 50, 39, 1, -50 },
  { 13747, 30, 50, 39, 3, -50 },
  { 13935, 38, 36, 39, -1, -36 },
  { 14106, 34, 36, 39, 1, -36 },
  { 14259, 33, 37, 39, 3, -36 },
  { 14412, 36, 50, 39, -1, -36 },
  { 14637, 34, 50, 39, 3, -36 },
  { 14850, 32, 36, 39, 6, -36 },
  { 14994, 33, 37, 39, 3, -36 },
  { 15147, 30, 45, 39, 6, -44 },
  { 15316, 33, 36, 39, 4, -35 },
  { 15465, 34, 35, 39, 5, -35 },
  { 15614, 36, 35, 39, 4, -35 },
  { 15772, 40, 35, 39, 0, -35 },
  { 15947, 41, 49, 39, 0, -35 },
  { 16199, 36, 35, 39, 1, -35 },
  { 16357, 26, 64, 39, 10, -52 },
  { 16565, 15, 61, 39, 12, -48 },
  { 16680, 26, 64, 39, 6, -52 },
  { 16888, 37, 15, 39, 0, -27 },
};

const GFXfont RobotoMono_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC67PT7B_H_
