#ifndef _ROBOTOMONO_SEMIBOLDITALIC8PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xB4, 0x29, 0x9E, 0xAE, 0x50, 0x11, 0x96, 0x83, 0x49,
  0xC4, 0x4B, 0x62, 0x73, 0x22, 0x98, 0xDB, 0x78, 0xC0, 0x29, 0x49, 0x22,
  0x55, 0x5A, 0x5D, 0x50, 0x22, 0xF6, 0xE0, 0xE0, 0xC0, 0x11, 0x22, 0x4C,
  0x35, 0x57, 0x96, 0x39, 0x24, 0x80, 0x35, 0x12, 0x4F, 0x35, 0x13, 0x96,
  0x13, 0x55, 0xF2, 0x7A, 0x18, 0x29, 0x30, 0x34, 0x7D, 0x96, 0xF2, 0x24,
  0x88, 0x35, 0x57, 0x97, 0x76, 0xF3, 0x80, 0x43, 0x60, 0x29, 0x00, 0x71,
  0x80, 0x70, 0xF0, 0x61, 0xE0, 0x6A, 0x24, 0x0C, 0x33, 0x77, 0xDF, 0x30,
  0x23, 0x55, 0xF9, 0x72, 0x54, 0xE9, 0x78, 0x32, 0x51, 0x09, 0x38, 0x65,
  0x55, 0x9E, 0x7A, 0x10, 0xE8, 0x78, 0x7A, 0x10, 0xE8, 0x40, 0x32, 0x51,
  0x69, 0x38, 0x4A, 0x55, 0xE9, 0x48, 0x79, 0x08, 0x42, 0x78, 0x08, 0x44,
  0x29, 0x30, 0x4A, 0x98, 0xC9, 0x48, 0x44, 0x44, 0x8F, 0x5A, 0xDD, 0x69,
  0x48, 0x4A, 0x5C, 0xEB, 0x48, 0x32, 0x93, 0x29, 0x30, 0x72, 0x52, 0xE8,
  0x40, 0x32, 0x93, 0x29, 0x30, 0x40, 0x72, 0x54, 0xE9, 0x48, 0x32, 0x50,
  0x69, 0x38, 0xF4, 0x44, 0x48, 0x4A, 0x54, 0xA9, 0x30, 0x9B, 0xAA, 0xCC,
  0xDD, 0xDA, 0xAA, 0x4A, 0x8C, 0x45, 0x48, 0x9A, 0xA4, 0x4C, 0x78, 0x88,
  0x44, 0x78, 0x69, 0x25, 0x26, 0x95, 0x50, 0x64, 0xA4, 0x96, 0x4E, 0x80,
  0xF0, 0xC0, 0x77, 0x9F, 0x44, 0x75, 0x9F, 0x78, 0x87, 0x08, 0x9D, 0x29,
  0x38, 0x7F, 0x87, 0x74, 0xE4, 0x88, 0x79, 0x97, 0xB6, 0x44, 0x75, 0x99,
  0x30, 0x62, 0x2F, 0x10, 0x72, 0x22, 0x2C, 0x42, 0x54, 0xCE, 0x48, 0x72,
  0x22, 0x2F, 0xFB, 0xBD, 0x75, 0x99, 0x79, 0x96, 0x75, 0x9F, 0x88, 0x79,
  0x97, 0x12, 0xF8, 0x88, 0x76, 0x97, 0x5E, 0x4E, 0x55, 0x97, 0xBA, 0xCC,
  0xAD, 0xBD, 0xE0, 0x59, 0x19, 0xA0, 0x5A, 0x98, 0x44, 0x40, 0x72, 0x4F,
  0x29, 0x44, 0x90, 0x55, 0x5A, 0x49, 0x14, 0xA0, 0xF1,
};

const GFXglyph RobotoMono_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 2, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -6 },
  { 24, 2, 8, 5, 1, -6 },
  { 26, 3, 4, 5, 1, -6 },
  { 28, 4, 4, 5, 0, -5 },
  { 30, 1, 3, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 2, 1, 5, 1, -1 },
  { 33, 4, 6, 5, 0, -6 },
  { 36, 4, 6, 5, 0, -6 },
  { 39, 3, 6, 5, 1, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 3, 6, 5, 1, -6 },
  { 67, 2, 4, 5, 1, -4 },
  { 68, 3, 6, 5, 1, -4 },
  { 71, 3, 3, 5, 1, -4 },
  { 73, 4, 3, 5, 0, -4 },
  { 75, 4, 3, 5, 0, -4 },
  { 77, 4, 6, 5, 1, -6 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 4, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 5, 7, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 4, 6, 5, 1, -6 },
  { 168, 4, 6, 5, 1, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 4, 6, 5, 1, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 3, 8, 5, 1, -7 },
  { 185, 2, 6, 5, 1, -6 },
  { 187, 3, 8, 5, 1, -7 },
  { 190, 3, 3, 5, 1, -6 },
  { 192, 4, 1, 5, 0, 0 },
  { 193, 2, 1, 5, 2, -6 },
  { 194, 4, 4, 5, 0, -4 },
  { 196, 4, 6, 5, 0, -6 },
  { 199, 4, 4, 5, 0, -4 },
  { 201, 5, 6, 5, 0, -6 },
  { 205, 4, 4, 5, 0, -4 },
  { 207, 4, 6, 5, 1, -6 },
  { 210, 4, 6, 5, 0, -4 },
  { 213, 4, 6, 5, 0, -6 },
  { 216, 4, 6, 5, 0, -6 },
  { 219, 4, 8, 5, 0, -6 },
  { 223, 5, 6, 5, 0, -6 },
  { 227, 4, 6, 5, 0, -6 },
  { 230, 4, 4, 5, 0, -4 },
  { 232, 4, 4, 5, 0, -4 },
  { 234, 4, 4, 5, 0, -4 },
  { 236, 4, 6, 5, 0, -4 },
  { 239, 4, 6, 5, 0, -4 },
  { 242, 4, 4, 5, 1, -4 },
  { 244, 4, 4, 5, 0, -4 },
  { 246, 3, 5, 5, 1, -5 },
  { 248, 4, 4, 5, 0, -4 },
  { 250, 4, 4, 5, 1, -4 },
  { 252, 5, 4, 5, 0, -4 },
  { 255, 5, 4, 5, 0, -4 },
  { 258, 5, 6, 5, 0, -4 },
  { 262, 4, 4, 5, 0, -4 },
  { 264, 3, 7, 5, 1, -6 },
  { 267, 2, 8, 5, 1, -6 },
  { 269, 3, 7, 5, 1, -6 },
  { 272, 4, 2, 5, 0, -3 },
};

const GFXfont RobotoMono_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC8PT7B_H_
