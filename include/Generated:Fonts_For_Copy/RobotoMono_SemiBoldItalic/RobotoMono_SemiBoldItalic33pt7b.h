#ifndef _ROBOTOMONO_SEMIBOLDITALIC33PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0xF0, 0xF0,
  0x71, 0xDC, 0x77, 0x1F, 0x87, 0xE1, 0xB8, 0xEE, 0x3B, 0x8E, 0xC3, 0x80,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0x86, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x3C, 0x1E,
  0x3E, 0x0F, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC0, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0xE3, 0x84, 0xE3, 0x8E, 0xE3, 0x9C, 0xE3,
  0x98, 0xE7, 0xB8, 0x7F, 0x70, 0x7E, 0x60, 0x08, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x3C, 0x0E, 0xFE, 0x0C, 0xFF, 0x1D, 0xC7, 0x39,
  0xC7, 0x71, 0xC7, 0x11, 0xC7, 0x01, 0xCE, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0x1E, 0x03, 0x87,
  0x80, 0xE1, 0xE0, 0x38, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0xF7, 0xDE, 0x3B, 0xE7, 0x9E, 0xF0,
  0xF7, 0xBC, 0x3F, 0xCF, 0x07, 0xF3, 0xC1, 0xF8, 0xF8, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0x3E, 0x3B, 0xDC, 0xE7, 0x39, 0xDC, 0xE0, 0x00,
  0x60, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0C, 0x00, 0x04, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x61, 0x82, 0xF9, 0x9E, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0x70,
  0x70, 0x20, 0x40, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8E, 0x3C, 0xF0,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x78, 0x3F, 0x78, 0x7F, 0x79, 0xFF, 0x7B, 0xDE, 0xFF, 0x1E, 0xFE,
  0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x78,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0xE0, 0xFC, 0xFF, 0x3F,
  0xEF, 0xFD, 0xE7, 0xA0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1,
  0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x3C, 0x07, 0x9E, 0x07,
  0xCF, 0x87, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xBC,
  0x03, 0xDE, 0x03, 0xCF, 0x03, 0xCF, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1,
  0xE1, 0xE0, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1D, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x70,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x3E, 0x07, 0x87, 0x81, 0xE1, 0xF1, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0x3D, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFE, 0x7E, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xE0, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xC7, 0xC7, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0x78,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x3E,
  0x01, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x18,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x7C, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0E,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x06, 0x1C, 0x01,
  0xCE, 0x3F, 0x33, 0x1F, 0xCD, 0xCE, 0x73, 0x63, 0x1C, 0xD9, 0xC6, 0x3E,
  0x61, 0x9F, 0x98, 0xE7, 0xCE, 0x39, 0xB3, 0x8C, 0x6C, 0xE3, 0x3B, 0x3B,
  0xCC, 0xC7, 0xFE, 0x38, 0xE7, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x60,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0x9C, 0x01,
  0xE7, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3C, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xCF, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x78, 0x7C, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC7, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x7C, 0x0F,
  0x9E, 0x03, 0xC7, 0x83, 0xF1, 0xE3, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x7F, 0x9E, 0x1F, 0xEF,
  0x87, 0xFB, 0xE2, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x7C, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x1F, 0x3C,
  0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0xFC, 0x3C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC1, 0xF0,
  0x0F, 0x0F, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x01,
  0xF0, 0x78, 0x07, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xDF, 0xE1, 0xFD, 0xDC, 0x1F, 0xFD, 0xC1,
  0xCF, 0xBC, 0x1C, 0xFB, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0xC3, 0xCE, 0x38,
  0x3C, 0xE7, 0x83, 0x8C, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x0F,
  0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF1, 0xFC, 0x3E, 0x3F,
  0x87, 0x87, 0xF0, 0xF0, 0xFF, 0x1E, 0x1E, 0xE3, 0xC3, 0xDC, 0x78, 0xFB,
  0x9F, 0x1E, 0x7B, 0xC3, 0xC7, 0x78, 0x78, 0xEF, 0x0F, 0x1D, 0xE1, 0xE3,
  0xFC, 0x7C, 0x3F, 0x8F, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x1F, 0x87, 0x81,
  0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0x0F, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1F,
  0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0x81,
  0xF1, 0xE0, 0x78, 0x7C, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC1,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0x0F, 0x87, 0x81, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x7C, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x03, 0xC7, 0x81, 0xF1, 0xE0,
  0x78, 0x7C, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xC3, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x0F,
  0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0xC7, 0x80,
  0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x3C, 0x03, 0xEF, 0x00, 0xF3, 0xE0, 0x3C, 0x7C, 0x3F, 0x1F, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E,
  0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xE3, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x80, 0xF3, 0xE0,
  0x3C, 0xF8, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7C,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0xE1, 0xEE, 0x1C,
  0x39, 0xC7, 0x8F, 0x38, 0xF1, 0xE7, 0x1E, 0x3C, 0xE7, 0xC7, 0x1C, 0xF9,
  0xE3, 0x9F, 0x3C, 0xF7, 0xE7, 0x1E, 0xFD, 0xE3, 0xDF, 0xBC, 0x7B, 0x77,
  0x8F, 0xEE, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0,
  0x3C, 0x3C, 0x00, 0x0F, 0x80, 0xFC, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x00,
  0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7B,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0x81, 0xE0, 0x3E, 0x07,
  0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0xDE, 0x03, 0xE7,
  0x80, 0xF1, 0xE0, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1,
  0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xF0, 0x70,
  0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x9E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x38, 0x77,
  0x07, 0xF0, 0x7E, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0x8F, 0x1C, 0x01, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3E, 0x3C, 0x1F,
  0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xBE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x70, 0x1D, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0xF8, 0x1E, 0xFC, 0x7E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xF7, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF7,
  0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x03, 0xDE, 0x07, 0xBE, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x07, 0x1E, 0x0F, 0xEF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xCF, 0x87, 0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0xC7,
  0xE1, 0xFF, 0xF0, 0xFF, 0x70, 0x3F, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x1C, 0xF0,
  0x0E, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x61, 0xF8, 0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xFE, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x07, 0xC7, 0x81, 0xF3,
  0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xE3, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xF7, 0x80, 0x01, 0xE0, 0x80, 0x78, 0x30, 0x3E, 0x3F, 0x3F, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x38, 0x3C,
  0xFE, 0x3D, 0xFF, 0x3F, 0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x00, 0x70, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x04, 0x7E, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x01, 0x1E, 0x0F, 0x8F, 0x07,
  0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8,
  0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0, 0x1F, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0xE3,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0xF1, 0xCE, 0x3C, 0x73,
  0x8F, 0x3D, 0xE3, 0xCF, 0x78, 0xE3, 0xDE, 0x78, 0xF7, 0x9E, 0x39, 0xC7,
  0x8E, 0x71, 0xE7, 0xBC, 0x71, 0xEF, 0x1C, 0x7B, 0xCF, 0x1E, 0xF3, 0xC7,
  0x38, 0xF3, 0xC0, 0x00, 0x38, 0x3C, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC3,
  0xE1, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07,
  0xBC, 0x03, 0xDF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xF0, 0xF0, 0x7F,
  0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x7F, 0x07, 0xFF,
  0xC3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF3, 0xE0, 0x79,
  0xF8, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3D, 0xFC, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xEF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7C, 0x1E, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x3F, 0x1E, 0xFE, 0x1D, 0xFE, 0x3F, 0xFE, 0x3F, 0xC6,
  0x3F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xE3, 0xE3, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x20, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x3C,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xBC, 0x3F, 0x38, 0xF8, 0x0F, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC3, 0x81, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0x0E, 0x78, 0x07, 0x38, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0xC3,
  0xF8, 0x70, 0xEE, 0x3C, 0x7B, 0x8F, 0x1E, 0xE3, 0xC7, 0x39, 0xF3, 0xCE,
  0x6C, 0xE3, 0x9B, 0x38, 0xEE, 0xDE, 0x3B, 0x37, 0x0F, 0xCD, 0xC3, 0xF3,
  0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0xF0, 0x7C, 0x0F, 0x8F, 0x80, 0x78, 0xF0, 0x03,
  0xDE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x3C, 0x01, 0xE1, 0xE0,
  0x3E, 0x1E, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF1, 0xE0,
  0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F,
  0x0F, 0x00, 0xF1, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x27, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x00,
  0x30, 0x07, 0x80, 0x7E, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x03, 0xF8, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0x60, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0x61, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x04, 0x00, 0x38, 0x03, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xC1,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x18, 0x00, 0x1F, 0x00,
  0x0F, 0xF0, 0x77, 0xFE, 0x1D, 0xC7, 0xFF, 0xE0, 0xFF, 0xB8, 0x1F, 0xC0,
  0x01, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 10, 9, 19, 6, -25 },
  { 36, 19, 23, 19, 0, -23 },
  { 91, 17, 30, 19, 2, -27 },
  { 155, 16, 24, 19, 2, -24 },
  { 203, 18, 24, 19, 1, -24 },
  { 257, 5, 9, 19, 8, -25 },
  { 263, 11, 33, 19, 5, -26 },
  { 309, 11, 33, 19, 3, -26 },
  { 355, 16, 16, 19, 3, -23 },
  { 387, 17, 17, 19, 1, -19 },
  { 424, 7, 10, 19, 3, -4 },
  { 433, 13, 3, 19, 4, -12 },
  { 438, 5, 5, 19, 6, -5 },
  { 442, 18, 25, 19, 1, -23 },
  { 499, 16, 24, 19, 2, -24 },
  { 547, 11, 23, 19, 4, -23 },
  { 579, 17, 24, 19, 0, -24 },
  { 630, 17, 24, 19, 1, -24 },
  { 681, 17, 23, 19, 0, -23 },
  { 730, 18, 23, 19, 1, -23 },
  { 782, 16, 24, 19, 1, -24 },
  { 830, 17, 23, 19, 2, -23 },
  { 879, 17, 24, 19, 1, -24 },
  { 930, 16, 24, 19, 2, -24 },
  { 978, 8, 18, 19, 6, -18 },
  { 996, 10, 24, 19, 4, -18 },
  { 1026, 16, 15, 19, 2, -18 },
  { 1056, 16, 10, 19, 2, -15 },
  { 1076, 16, 16, 19, 1, -18 },
  { 1108, 15, 24, 19, 4, -24 },
  { 1153, 18, 23, 19, 1, -23 },
  { 1205, 18, 23, 19, -1, -23 },
  { 1257, 19, 23, 19, 0, -23 },
  { 1312, 18, 24, 19, 1, -24 },
  { 1366, 18, 23, 19, 0, -23 },
  { 1418, 19, 23, 19, 1, -23 },
  { 1473, 19, 23, 19, 1, -23 },
  { 1528, 18, 24, 19, 1, -24 },
  { 1582, 19, 23, 19, 0, -23 },
  { 1637, 18, 23, 19, 1, -23 },
  { 1689, 18, 23, 19, 1, -23 },
  { 1741, 22, 23, 19, 0, -23 },
  { 1805, 15, 23, 19, 1, -23 },
  { 1849, 20, 23, 19, 0, -23 },
  { 1907, 19, 23, 19, 0, -23 },
  { 1962, 18, 24, 19, 1, -24 },
  { 2016, 18, 23, 19, 1, -23 },
  { 2068, 18, 28, 19, 1, -24 },
  { 2131, 18, 23, 19, 1, -23 },
  { 2183, 18, 24, 19, 1, -24 },
  { 2237, 19, 23, 19, 2, -23 },
  { 2292, 18, 23, 19, 2, -23 },
  { 2344, 18, 23, 19, 3, -23 },
  { 2396, 19, 23, 19, 2, -23 },
  { 2451, 22, 23, 19, -1, -23 },
  { 2515, 18, 23, 19, 3, -23 },
  { 2567, 20, 23, 19, 0, -23 },
  { 2625, 12, 32, 19, 4, -27 },
  { 2673, 8, 25, 19, 6, -23 },
  { 2698, 12, 32, 19, 4, -27 },
  { 2746, 12, 12, 19, 4, -23 },
  { 2764, 15, 3, 19, 0, 0 },
  { 2770, 6, 5, 19, 9, -24 },
  { 2774, 16, 18, 19, 1, -18 },
  { 2810, 16, 25, 19, 1, -25 },
  { 2860, 15, 18, 19, 2, -18 },
  { 2894, 17, 25, 19, 2, -25 },
  { 2948, 17, 18, 19, 1, -18 },
  { 2987, 18, 26, 19, 3, -26 },
  { 3046, 18, 25, 19, 0, -18 },
  { 3103, 16, 25, 19, 1, -25 },
  { 3153, 14, 24, 19, 2, -24 },
  { 3195, 15, 31, 19, 1, -24 },
  { 3254, 18, 25, 19, 1, -25 },
  { 3311, 15, 25, 19, 1, -25 },
  { 3358, 18, 18, 19, 0, -18 },
  { 3399, 16, 18, 19, 1, -18 },
  { 3435, 17, 18, 19, 1, -18 },
  { 3474, 17, 25, 19, 0, -18 },
  { 3528, 16, 25, 19, 2, -18 },
  { 3578, 16, 18, 19, 3, -18 },
  { 3614, 17, 18, 19, 1, -18 },
  { 3653, 15, 22, 19, 3, -22 },
  { 3695, 16, 17, 19, 2, -17 },
  { 3729, 17, 17, 19, 2, -17 },
  { 3766, 18, 17, 19, 2, -17 },
  { 3805, 20, 17, 19, 0, -17 },
  { 3848, 20, 24, 19, 0, -17 },
  { 3908, 18, 17, 19, 0, -17 },
  { 3947, 13, 32, 19, 5, -26 },
  { 3999, 7, 30, 19, 6, -23 },
  { 4026, 13, 32, 19, 3, -26 },
  { 4078, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC33PT7B_H_
