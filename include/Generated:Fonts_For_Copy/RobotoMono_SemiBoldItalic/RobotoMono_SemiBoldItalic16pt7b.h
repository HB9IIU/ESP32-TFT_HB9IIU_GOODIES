#ifndef _ROBOTOMONO_SEMIBOLDITALIC16PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x66, 0x40, 0x0C, 0xC0, 0xDE, 0xE5, 0x20, 0x0D, 0x84,
  0x82, 0x4F, 0xF1, 0x20, 0x90, 0xD9, 0xFE, 0x2C, 0x34, 0x12, 0x00, 0x04,
  0x0C, 0x3E, 0x73, 0x63, 0x60, 0x78, 0x1C, 0x06, 0xC6, 0xC6, 0xEE, 0x7C,
  0x10, 0x30, 0x20, 0xF0, 0x92, 0x96, 0xFC, 0x08, 0x10, 0x3E, 0x2B, 0x5B,
  0x1A, 0x0E, 0x04, 0x0F, 0x0C, 0xC6, 0x63, 0x60, 0xE0, 0xE0, 0xDB, 0xED,
  0xE3, 0x9B, 0xCF, 0xF0, 0x7F, 0x04, 0x31, 0x8C, 0x21, 0x86, 0x18, 0x41,
  0x0C, 0x10, 0x41, 0x06, 0x0C, 0x10, 0x10, 0xC1, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x21, 0x86, 0x10, 0xC6, 0x30, 0x80, 0x0C, 0x08, 0x6B, 0xFE, 0x18,
  0x2C, 0x66, 0x04, 0x18, 0x18, 0x18, 0xFF, 0xFE, 0x30, 0x30, 0x30, 0x33,
  0x66, 0xC0, 0xFF, 0xF0, 0x5F, 0x00, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0xC0, 0x08, 0x3E, 0x66, 0x63, 0x63, 0xCF,
  0xDE, 0xE6, 0xC6, 0xC6, 0xEC, 0x78, 0x1F, 0xF6, 0x33, 0x18, 0xC6, 0x31,
  0x98, 0x04, 0x3F, 0x33, 0x63, 0x03, 0x07, 0x06, 0x1C, 0x38, 0x70, 0xFF,
  0xFF, 0x04, 0x0F, 0x8C, 0xE6, 0x30, 0x30, 0xF8, 0x78, 0x06, 0x03, 0x61,
  0x9F, 0x87, 0x80, 0x03, 0x07, 0x0F, 0x1B, 0x33, 0x26, 0x66, 0xFF, 0x06,
  0x06, 0x0C, 0x3F, 0x20, 0x60, 0x60, 0x7C, 0xC6, 0x06, 0x06, 0xC6, 0xEC,
  0x78, 0x1E, 0x71, 0x83, 0x4F, 0xFC, 0xF1, 0xE3, 0xC7, 0xD9, 0xE0, 0xFF,
  0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x08, 0x3E,
  0x67, 0x63, 0x66, 0x7E, 0x7C, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x08, 0x3E,
  0x66, 0xC2, 0xC2, 0xC6, 0xEE, 0x7E, 0x06, 0x0C, 0x78, 0x70, 0x27, 0x70,
  0x00, 0x04, 0xEC, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x23, 0x18, 0xCC, 0x00,
  0x01, 0x06, 0x3E, 0xF0, 0xE0, 0x7C, 0x0E, 0x02, 0xFF, 0x00, 0x00, 0xFE,
  0xFE, 0x80, 0xC1, 0xE0, 0x70, 0xEF, 0xB8, 0x40, 0x10, 0xFB, 0x9E, 0x30,
  0xE3, 0x8E, 0x18, 0x20, 0x01, 0x83, 0x00, 0x1F, 0x18, 0x4B, 0xAB, 0x55,
  0x2A, 0x97, 0x53, 0xBE, 0x52, 0x32, 0x0F, 0x00, 0x03, 0x03, 0x81, 0x41,
  0xA0, 0xD0, 0xCC, 0x66, 0x7F, 0x3F, 0xB0, 0xF8, 0x60, 0x3F, 0x18, 0xCC,
  0x66, 0x37, 0xF3, 0xF9, 0x8C, 0xC3, 0x63, 0x7F, 0xBF, 0x80, 0x08, 0x3E,
  0x63, 0x63, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6, 0xFE, 0x78, 0x3E, 0x19,
  0x8C, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x67, 0x7F, 0x3E, 0x00, 0x3F,
  0xCC, 0x03, 0x00, 0xC0, 0x7F, 0x1F, 0xC6, 0x01, 0x80, 0x60, 0x1F, 0xCF,
  0xF0, 0x3F, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x1F, 0xC6, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x00, 0x08, 0x3E, 0x63, 0x63, 0xC0, 0xC0, 0xCF, 0xCF, 0xC6,
  0xC6, 0xFE, 0x7C, 0x31, 0x98, 0xCC, 0x6C, 0x37, 0xFB, 0xF9, 0x8C, 0xC6,
  0x63, 0x61, 0xB0, 0xC0, 0x7F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x30, 0xFC, 0xFC, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0xC6,
  0xFC, 0x78, 0x31, 0xE6, 0x70, 0xDC, 0x1F, 0x06, 0xC0, 0xF8, 0x1F, 0x83,
  0x30, 0x66, 0x18, 0x63, 0x0E, 0x00, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x60, 0x7F, 0xFF, 0x39, 0xCE, 0xE3, 0xB9, 0xBE, 0x6D, 0x9B,
  0x66, 0x91, 0x8C, 0x43, 0x30, 0xCC, 0x30, 0x31, 0x9C, 0xCE, 0x6D, 0x36,
  0x9B, 0x79, 0xBC, 0xCE, 0x67, 0x63, 0xB1, 0xC0, 0x08, 0x3E, 0x67, 0x63,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x78, 0x3F, 0x18, 0xCC, 0x66,
  0x32, 0x1B, 0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x08, 0x3E, 0x67,
  0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x7C, 0x0E, 0x04, 0x3F,
  0x18, 0xCC, 0x66, 0x36, 0x3B, 0xF9, 0xF8, 0xCC, 0x66, 0x31, 0xB0, 0xC0,
  0x04, 0x0F, 0x8C, 0x66, 0x33, 0x01, 0xE0, 0x78, 0x06, 0x01, 0xB1, 0x9D,
  0xC7, 0xC0, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x63, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xC6,
  0xFC, 0x78, 0xE3, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0x38,
  0x1C, 0x0C, 0x00, 0xC9, 0xEC, 0xF6, 0x5B, 0x6F, 0xB7, 0xD3, 0xB9, 0xDC,
  0xEE, 0x66, 0x33, 0x00, 0x71, 0xCC, 0x61, 0xB0, 0x78, 0x1E, 0x07, 0x01,
  0xE0, 0xD8, 0x76, 0x18, 0xCC, 0x30, 0xE1, 0xB1, 0x99, 0xC6, 0xC3, 0xC1,
  0xE0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x3F, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xCF, 0xF0, 0x3C, 0xC3, 0x0C,
  0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x0F, 0x38, 0xCC, 0xC4, 0x66,
  0x66, 0x22, 0x33, 0x3C, 0x61, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C,
  0x30, 0xCE, 0x38, 0x18, 0xE2, 0x9A, 0xCE, 0x30, 0xFF, 0xFC, 0xCC, 0x80,
  0x18, 0xFF, 0x98, 0x37, 0xF8, 0xF1, 0xEE, 0xF6, 0x30, 0x30, 0x30, 0x34,
  0x3F, 0x73, 0x63, 0x63, 0x63, 0x63, 0x7E, 0xDE, 0x18, 0xFD, 0x9E, 0x3C,
  0x18, 0x31, 0xF6, 0x78, 0x03, 0x03, 0x03, 0x13, 0x7F, 0xE6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xFE, 0x74, 0x18, 0x7E, 0x66, 0xC2, 0xFE, 0xC0, 0xC0, 0xEE,
  0x7C, 0x0F, 0x8E, 0x06, 0x03, 0x0F, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x00, 0x0C, 0x1F, 0xCC, 0xEC, 0x66, 0x33, 0x19, 0x8C, 0xFE,
  0x3B, 0x03, 0x33, 0x8F, 0x80, 0x30, 0x30, 0x30, 0x36, 0x3F, 0x73, 0x63,
  0x63, 0x63, 0x63, 0x63, 0xC3, 0x0C, 0x18, 0x00, 0x07, 0xC3, 0x06, 0x0C,
  0x18, 0x33, 0xFF, 0xF0, 0x02, 0x07, 0x00, 0x00, 0x1E, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xF8, 0x30, 0x18, 0x0C, 0x06, 0x13,
  0x33, 0x31, 0xB0, 0xF8, 0x7C, 0x33, 0x19, 0x98, 0x60, 0x3C, 0xF8, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x09, 0x3F, 0xDB, 0x6D,
  0xB4, 0x9E, 0x4B, 0x6D, 0xB6, 0xDB, 0x00, 0x16, 0x2F, 0x73, 0x63, 0x63,
  0x63, 0x63, 0x63, 0xC3, 0x18, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xF6, 0x78,
  0x04, 0x3F, 0x73, 0x63, 0x63, 0x63, 0x63, 0x76, 0xDE, 0xC0, 0xC0, 0xC0,
  0x10, 0x7F, 0xE6, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE, 0x74, 0x0C, 0x0C, 0x0C,
  0x03, 0x3F, 0x39, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x18, 0x7E, 0x67,
  0xE0, 0x7C, 0x1E, 0xC6, 0xCE, 0x7C, 0x18, 0x18, 0x19, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x3E, 0x3E, 0x63, 0x43, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE,
  0x76, 0xC3, 0x46, 0x66, 0x6C, 0x6C, 0x38, 0x38, 0x30, 0xD9, 0xED, 0xB6,
  0xDD, 0x4A, 0xE7, 0x73, 0x31, 0x98, 0x73, 0x9D, 0x87, 0x81, 0x81, 0xC1,
  0xB1, 0x99, 0xC6, 0x61, 0xCC, 0x63, 0x30, 0xDC, 0x36, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0C, 0x0E, 0x00, 0x7F, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFD, 0xFE, 0x04, 0x31, 0x86, 0x18, 0x63, 0x3C, 0xE0, 0xC3, 0x0C, 0x30,
  0x83, 0x04, 0x24, 0xB6, 0x92, 0x4B, 0x69, 0x00, 0x18, 0x10, 0x20, 0xC1,
  0x83, 0x03, 0x87, 0x18, 0x60, 0xC1, 0x83, 0x1C, 0x10, 0x00, 0x79, 0xEF,
  0xD1, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 4, 9, 3, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 15, 9, 1, -13 },
  { 38, 8, 12, 9, 1, -12 },
  { 50, 9, 12, 9, 0, -12 },
  { 64, 2, 4, 9, 4, -12 },
  { 65, 6, 17, 9, 2, -13 },
  { 78, 6, 17, 9, 1, -13 },
  { 91, 8, 8, 9, 1, -11 },
  { 99, 8, 8, 9, 1, -9 },
  { 107, 4, 5, 9, 1, -2 },
  { 110, 6, 2, 9, 2, -6 },
  { 112, 3, 3, 9, 3, -3 },
  { 114, 8, 12, 9, 1, -11 },
  { 126, 8, 12, 9, 1, -12 },
  { 138, 5, 11, 9, 2, -11 },
  { 145, 8, 12, 9, 0, -12 },
  { 157, 9, 12, 9, 0, -12 },
  { 171, 8, 11, 9, 0, -11 },
  { 182, 8, 11, 9, 1, -11 },
  { 193, 7, 11, 9, 1, -11 },
  { 203, 8, 11, 9, 1, -11 },
  { 214, 8, 12, 9, 1, -12 },
  { 226, 8, 12, 9, 1, -12 },
  { 238, 4, 10, 9, 3, -10 },
  { 243, 5, 13, 9, 2, -10 },
  { 252, 8, 8, 9, 1, -9 },
  { 260, 8, 5, 9, 1, -7 },
  { 265, 7, 8, 9, 1, -9 },
  { 272, 7, 12, 9, 2, -12 },
  { 283, 9, 11, 9, 0, -11 },
  { 296, 9, 11, 9, -1, -11 },
  { 309, 9, 11, 9, 0, -11 },
  { 322, 8, 12, 9, 1, -12 },
  { 334, 9, 11, 9, 0, -11 },
  { 347, 10, 11, 9, 0, -11 },
  { 361, 10, 11, 9, 0, -11 },
  { 375, 8, 12, 9, 1, -12 },
  { 387, 9, 11, 9, 0, -11 },
  { 400, 8, 11, 9, 1, -11 },
  { 411, 8, 11, 9, 1, -11 },
  { 422, 11, 11, 9, 0, -11 },
  { 438, 8, 11, 9, 0, -11 },
  { 449, 10, 11, 9, 0, -11 },
  { 463, 9, 11, 9, 0, -11 },
  { 476, 8, 12, 9, 1, -12 },
  { 488, 9, 11, 9, 0, -11 },
  { 501, 8, 14, 9, 1, -12 },
  { 515, 9, 11, 9, 0, -11 },
  { 528, 9, 12, 9, 0, -12 },
  { 542, 9, 11, 9, 1, -11 },
  { 555, 8, 11, 9, 1, -11 },
  { 566, 9, 11, 9, 1, -11 },
  { 579, 9, 11, 9, 1, -11 },
  { 592, 10, 11, 9, 0, -11 },
  { 606, 9, 11, 9, 1, -11 },
  { 619, 10, 11, 9, 0, -11 },
  { 633, 6, 16, 9, 2, -13 },
  { 645, 4, 12, 9, 3, -11 },
  { 651, 6, 16, 9, 2, -13 },
  { 663, 6, 6, 9, 2, -11 },
  { 668, 7, 2, 9, 0, 0 },
  { 670, 3, 3, 9, 4, -12 },
  { 672, 7, 9, 9, 1, -9 },
  { 680, 8, 12, 9, 0, -12 },
  { 692, 7, 9, 9, 1, -9 },
  { 700, 8, 12, 9, 1, -12 },
  { 712, 8, 9, 9, 1, -9 },
  { 721, 9, 12, 9, 1, -12 },
  { 735, 9, 12, 9, 0, -9 },
  { 749, 8, 12, 9, 0, -12 },
  { 761, 7, 12, 9, 1, -12 },
  { 772, 8, 15, 9, 0, -12 },
  { 787, 9, 12, 9, 0, -12 },
  { 801, 7, 12, 9, 1, -12 },
  { 812, 9, 9, 9, 0, -9 },
  { 823, 8, 9, 9, 0, -9 },
  { 832, 7, 9, 9, 1, -9 },
  { 840, 8, 12, 9, 0, -9 },
  { 852, 8, 12, 9, 1, -9 },
  { 864, 8, 9, 9, 1, -9 },
  { 873, 8, 9, 9, 1, -9 },
  { 882, 8, 11, 9, 1, -11 },
  { 893, 8, 8, 9, 1, -8 },
  { 901, 8, 8, 9, 1, -8 },
  { 909, 9, 8, 9, 1, -8 },
  { 918, 9, 8, 9, 0, -8 },
  { 927, 10, 11, 9, 0, -8 },
  { 941, 9, 8, 9, 0, -8 },
  { 950, 6, 16, 9, 2, -13 },
  { 962, 3, 14, 9, 3, -11 },
  { 968, 7, 15, 9, 1, -12 },
  { 982, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC16PT7B_H_
