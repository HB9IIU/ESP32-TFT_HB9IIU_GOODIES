#ifndef _ROBOTOMONO_SEMIBOLDITALIC42PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F,
  0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0x83,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1C, 0x70, 0x73, 0xC3,
  0xCF, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x07,
  0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7C, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x87,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE1, 0xCE, 0x1E, 0x1E, 0xE1, 0xE3, 0xCE, 0x1E, 0x78, 0xE1, 0xE7, 0x0F,
  0x3C, 0xE0, 0xFF, 0xDE, 0x07, 0xF9, 0xC0, 0x1E, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x70, 0x03, 0x9F,
  0xC0, 0x73, 0xFE, 0x0F, 0x7D, 0xE0, 0xE7, 0x8F, 0x1C, 0x70, 0xF3, 0xCF,
  0x0F, 0x78, 0xF0, 0xF1, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x78,
  0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x3E, 0x7F, 0xF8, 0x7D, 0xF9, 0xF0, 0xF3, 0xE1,
  0xF3, 0xEF, 0xC3, 0xF7, 0xDF, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x07,
  0xF8, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x83, 0xFF, 0xDF, 0x01, 0xFE, 0x3F, 0x00, 0x7B, 0xDE, 0xF7, 0xFB, 0xDE,
  0xF7, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0xE0, 0xCF, 0x8F,
  0x1E, 0x7F, 0x77, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xF3, 0xC0, 0x1F, 0x1E,
  0x01, 0xF0, 0x78, 0x1F, 0x03, 0xE0, 0x38, 0x1C, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x02,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87,
  0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0xFF, 0x7C, 0x1F, 0xF7, 0xC7, 0xFE, 0xFC,
  0xFB, 0xEF, 0xBF, 0x3E, 0xFF, 0xC3, 0xEF, 0xF8, 0x3E, 0xFE, 0x07, 0xEF,
  0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8,
  0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0xBF, 0x3E, 0xE0, 0xFA, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x03,
  0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x3E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF1, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0x81,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC,
  0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0xF0, 0x1F, 0x7F, 0x87, 0xDF, 0xF8, 0xFF,
  0xFF, 0x9F, 0xF7, 0xFB, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0x7C, 0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x07, 0xC0, 0xFE,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xF8, 0x7E, 0x1F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xE0, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7C, 0x0F,
  0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0xFF,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xF3, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x07,
  0xE1, 0xFC, 0x7F, 0x3F, 0xC7, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xC3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC1, 0xF0, 0x01, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE7, 0xF0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x83, 0xC0,
  0x03, 0x8F, 0x0F, 0xC7, 0x1C, 0x7F, 0xCE, 0x78, 0xFF, 0x9C, 0xE3, 0xC7,
  0x3B, 0xCF, 0x0C, 0x77, 0x1C, 0x38, 0xEE, 0x38, 0x71, 0xDC, 0xF0, 0xE3,
  0xF9, 0xC1, 0xC7, 0xE3, 0x87, 0x0D, 0xC7, 0x0E, 0x3B, 0x8E, 0x1C, 0x77,
  0x1C, 0x79, 0xCE, 0x3D, 0xF3, 0x9C, 0x7F, 0xFE, 0x38, 0x7D, 0xF8, 0x78,
  0x20, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x10, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8,
  0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x3F,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x03, 0xF9, 0xF8,
  0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8,
  0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xDF, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x3F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8,
  0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xFE, 0xF8, 0x3F, 0xFB, 0xE0, 0xFF, 0xEF,
  0x83, 0xFF, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x3F, 0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF8, 0x3F, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x03, 0xF8, 0x03, 0xE0, 0xFE, 0x00,
  0x7C, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x03, 0xE3, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0x7C, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07,
  0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9,
  0xFF, 0x07, 0xFD, 0xEF, 0x83, 0xFE, 0xF7, 0x81, 0xEF, 0xF3, 0xC1, 0xF3,
  0xFB, 0xE0, 0xF9, 0xF9, 0xF0, 0x7C, 0xFC, 0xF8, 0x3E, 0x7E, 0x7C, 0x1F,
  0x3E, 0x3C, 0x0F, 0x1F, 0x3E, 0x0F, 0x8F, 0x1F, 0x07, 0xC7, 0x8F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x3F,
  0x80, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07,
  0xFC, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xF7, 0x87, 0xC1, 0xFB, 0xC7, 0xE0,
  0xFD, 0xE3, 0xE0, 0x7C, 0xF9, 0xF0, 0x3E, 0x3C, 0xF8, 0x1F, 0x1E, 0x7C,
  0x0F, 0x8F, 0x7E, 0x0F, 0xC7, 0xFF, 0x07, 0xC1, 0xFF, 0x03, 0xE0, 0xFF,
  0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x0F, 0xF0, 0x7E, 0x07,
  0xF8, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC,
  0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xCF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xCF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0,
  0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFD, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x3F, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8,
  0xFF, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7E,
  0x01, 0xF8, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x3F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8,
  0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00,
  0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C,
  0x3E, 0xF8, 0x7C, 0x3C, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC,
  0x7C, 0xF9, 0xFC, 0x78, 0xF9, 0xFC, 0xF8, 0xF9, 0xFC, 0xF8, 0xF9, 0xFC,
  0xF0, 0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xF0, 0xFB, 0xBD, 0xF0, 0xFF, 0xBD,
  0xE0, 0xF7, 0xBF, 0xE0, 0xF7, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C,
  0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF0, 0x03,
  0xF3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00,
  0xF9, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xC7, 0x03, 0xC3,
  0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x1F, 0xF0, 0x0F, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3C, 0x3E,
  0x1E, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFE, 0xFF, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x3F, 0x81, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0,
  0x3F, 0x1F, 0x03, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0x9F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x30, 0x03, 0xEF, 0xF0, 0x3E, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F,
  0x80, 0xF8, 0xFE, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xEF, 0xFC,
  0x1F, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x02, 0xFC, 0x07, 0xC7, 0xC0, 0x7C,
  0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0xC1, 0xF0, 0x0F, 0xF3, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFD, 0xF0, 0x07, 0xF3, 0xC0, 0x00, 0x38, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8, 0x3F,
  0x3F, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x18, 0x7E, 0x07, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xF9, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC3, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xEF, 0x80,
  0x7F, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x3F, 0x07, 0x01,
  0xF8, 0x3F, 0x9F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x38, 0x03, 0xE7, 0xF0, 0x3E, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0xFD, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x23, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF8,
  0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F,
  0x8F, 0xC0, 0x1F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x9F,
  0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x0C, 0x18, 0x0F, 0xBF, 0x7E, 0x0F, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x9F, 0x9F, 0x1F, 0x1F,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F,
  0x1F, 0x3E, 0x1E, 0x1F, 0x3E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x7C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x7C, 0xF8, 0x78,
  0x7C, 0x00, 0x07, 0x00, 0x78, 0xFF, 0x07, 0xDF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xE0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x3F,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x9F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xF0, 0x7E, 0x3E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xC0, 0x7C, 0x7E,
  0x1F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0x9F, 0xE0, 0x1F, 0x7F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xDF, 0xF8, 0x0F, 0x9F, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0x81, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0xBF, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0x87, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0x3F, 0xBE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x81, 0xF1, 0xFF, 0x1F, 0x3F, 0xE1, 0xF7, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3, 0xF0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x08, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xF0, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x7C, 0x0F, 0xE3, 0xE0, 0xF8,
  0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x83, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7C,
  0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x3C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xF7, 0xC3, 0xE3, 0xEF,
  0x8F, 0xC7, 0xDF, 0x1F, 0x8F, 0x3E, 0x3F, 0x3E, 0x7C, 0xEE, 0x7C, 0xF9,
  0xDC, 0xF1, 0xF7, 0xB9, 0xE3, 0xEE, 0x77, 0xC7, 0xDC, 0xEF, 0x0F, 0xF9,
  0xDE, 0x1E, 0xE3, 0xF8, 0x3D, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x83, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xF0,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x3F,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xC0, 0x18, 0xFF, 0xC0, 0x7B, 0xFF, 0xE0, 0xF7, 0xFF,
  0xE3, 0xEF, 0x07, 0xFF, 0xBC, 0x07, 0xFF, 0x78, 0x07, 0xFC, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 14, 11, 25, 7, -32 },
  { 63, 25, 30, 25, 0, -30 },
  { 157, 22, 39, 25, 2, -35 },
  { 265, 20, 30, 25, 3, -30 },
  { 340, 23, 30, 25, 1, -30 },
  { 427, 5, 11, 25, 11, -32 },
  { 434, 15, 42, 25, 6, -33 },
  { 513, 15, 42, 25, 3, -33 },
  { 592, 21, 21, 25, 3, -30 },
  { 648, 21, 22, 25, 2, -25 },
  { 706, 9, 13, 25, 4, -5 },
  { 721, 17, 4, 25, 5, -15 },
  { 730, 7, 7, 25, 7, -7 },
  { 737, 22, 33, 25, 2, -30 },
  { 828, 20, 30, 25, 3, -30 },
  { 903, 14, 30, 25, 5, -30 },
  { 956, 22, 30, 25, 0, -30 },
  { 1039, 22, 30, 25, 1, -30 },
  { 1122, 22, 30, 25, 0, -30 },
  { 1205, 22, 30, 25, 2, -30 },
  { 1288, 19, 30, 25, 2, -30 },
  { 1360, 22, 30, 25, 3, -30 },
  { 1443, 21, 30, 25, 2, -30 },
  { 1522, 19, 30, 25, 3, -30 },
  { 1594, 10, 24, 25, 8, -24 },
  { 1624, 12, 32, 25, 6, -24 },
  { 1672, 19, 20, 25, 3, -23 },
  { 1720, 21, 13, 25, 2, -19 },
  { 1755, 20, 20, 25, 2, -23 },
  { 1805, 19, 30, 25, 5, -30 },
  { 1877, 23, 30, 25, 1, -30 },
  { 1964, 23, 30, 25, -1, -30 },
  { 2051, 23, 30, 25, 1, -30 },
  { 2138, 22, 31, 25, 2, -30 },
  { 2224, 24, 30, 25, 0, -30 },
  { 2314, 24, 30, 25, 1, -30 },
  { 2404, 24, 30, 25, 1, -30 },
  { 2494, 22, 30, 25, 2, -30 },
  { 2577, 25, 30, 25, 0, -30 },
  { 2671, 22, 30, 25, 2, -30 },
  { 2754, 24, 30, 25, 1, -30 },
  { 2844, 27, 30, 25, 1, -30 },
  { 2946, 20, 30, 25, 1, -30 },
  { 3021, 25, 30, 25, 0, -30 },
  { 3115, 25, 30, 25, 0, -30 },
  { 3209, 22, 30, 25, 2, -30 },
  { 3292, 24, 30, 25, 1, -30 },
  { 3382, 22, 35, 25, 2, -30 },
  { 3479, 23, 30, 25, 1, -30 },
  { 3566, 23, 30, 25, 1, -30 },
  { 3653, 24, 30, 25, 3, -30 },
  { 3743, 23, 30, 25, 2, -30 },
  { 3830, 22, 30, 25, 4, -30 },
  { 3913, 24, 30, 25, 3, -30 },
  { 4003, 28, 30, 25, -1, -30 },
  { 4108, 23, 30, 25, 4, -30 },
  { 4195, 25, 30, 25, 0, -30 },
  { 4289, 15, 42, 25, 5, -35 },
  { 4368, 10, 33, 25, 8, -30 },
  { 4410, 15, 42, 25, 5, -35 },
  { 4489, 17, 16, 25, 4, -30 },
  { 4523, 19, 4, 25, 0, 0 },
  { 4533, 8, 5, 25, 11, -30 },
  { 4538, 21, 23, 25, 1, -23 },
  { 4599, 21, 32, 25, 1, -32 },
  { 4683, 20, 23, 25, 2, -23 },
  { 4741, 23, 32, 25, 2, -32 },
  { 4833, 20, 23, 25, 2, -23 },
  { 4891, 22, 32, 25, 4, -32 },
  { 4979, 22, 32, 25, 1, -23 },
  { 5067, 21, 32, 25, 1, -32 },
  { 5151, 19, 31, 25, 2, -31 },
  { 5225, 19, 40, 25, 1, -31 },
  { 5320, 23, 32, 25, 1, -32 },
  { 5412, 19, 32, 25, 2, -32 },
  { 5488, 24, 23, 25, -1, -23 },
  { 5557, 21, 23, 25, 1, -23 },
  { 5618, 20, 24, 25, 2, -23 },
  { 5678, 23, 32, 25, -1, -23 },
  { 5770, 21, 32, 25, 2, -23 },
  { 5854, 20, 23, 25, 4, -23 },
  { 5912, 20, 23, 25, 2, -23 },
  { 5970, 19, 28, 25, 4, -28 },
  { 6037, 21, 22, 25, 2, -22 },
  { 6095, 22, 22, 25, 3, -22 },
  { 6156, 23, 22, 25, 2, -22 },
  { 6220, 25, 22, 25, 0, -22 },
  { 6289, 26, 31, 25, 0, -22 },
  { 6390, 22, 22, 25, 1, -22 },
  { 6451, 16, 40, 25, 6, -33 },
  { 6531, 10, 38, 25, 7, -30 },
  { 6579, 16, 40, 25, 4, -33 },
  { 6659, 23, 9, 25, 0, -17 },
};

const GFXfont RobotoMono_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC42PT7B_H_
