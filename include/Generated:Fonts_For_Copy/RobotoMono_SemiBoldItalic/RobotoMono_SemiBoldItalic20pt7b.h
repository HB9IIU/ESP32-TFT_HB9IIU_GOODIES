#ifndef _ROBOTOMONO_SEMIBOLDITALIC20PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x70, 0x00, 0xCE, 0x30, 0x66, 0xCD,
  0x92, 0x6C, 0xC0, 0x03, 0x60, 0x66, 0x06, 0x40, 0x4C, 0x3F, 0xF0, 0xD8,
  0x19, 0x81, 0x90, 0xFF, 0xCF, 0xFC, 0x32, 0x02, 0x60, 0x66, 0x06, 0xC0,
  0x03, 0x00, 0xC0, 0x20, 0x7E, 0x3F, 0xCC, 0x33, 0x0C, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xB8, 0x6E, 0x39, 0xFE, 0x3E, 0x06, 0x01, 0x80,
  0x78, 0x13, 0x2C, 0xDB, 0x34, 0xFB, 0x1D, 0x80, 0x40, 0x20, 0x1B, 0x8D,
  0xB2, 0xCD, 0xB3, 0x0C, 0x81, 0xE0, 0x0F, 0x83, 0xF0, 0x67, 0x0C, 0xC1,
  0xB8, 0x3E, 0x07, 0x81, 0xF3, 0x76, 0x6C, 0xFF, 0x8F, 0x71, 0xC7, 0xFC,
  0x7D, 0xC0, 0x6F, 0x6C, 0x02, 0x1C, 0x70, 0xC3, 0x06, 0x18, 0x30, 0x61,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC0, 0x81, 0x81, 0x00, 0x10,
  0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x8E, 0x31,
  0xCE, 0x30, 0x80, 0x0C, 0x06, 0x23, 0x3D, 0x7F, 0xF8, 0xC0, 0xF0, 0xCC,
  0xC6, 0x22, 0x00, 0x06, 0x03, 0x80, 0xE0, 0x30, 0xFF, 0xFF, 0xF1, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x77, 0x66, 0xC4, 0x7F, 0xFF, 0x80, 0x7F,
  0x70, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1F, 0x8F, 0xE3, 0x1D,
  0xC7, 0x61, 0xD8, 0xF6, 0xFF, 0xE6, 0xF1, 0xB8, 0x6E, 0x3B, 0x8C, 0x7F,
  0x0F, 0x80, 0x06, 0x7D, 0xFF, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60,
  0xC3, 0x87, 0x00, 0x0F, 0x87, 0xF8, 0xC3, 0x38, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFD, 0xFF, 0x00, 0x0F,
  0xC3, 0xF8, 0xE3, 0x80, 0x70, 0x0E, 0x03, 0x83, 0xE0, 0x7C, 0x01, 0xC0,
  0x39, 0x87, 0x30, 0xC7, 0xF8, 0x7E, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0xDC, 0x3B, 0x06, 0x61, 0x8C, 0x63, 0xBF, 0xFB, 0xFF, 0x01, 0x80,
  0x30, 0x0E, 0x00, 0x1F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x1F, 0xC7, 0xF8,
  0x0E, 0x01, 0x80, 0x6C, 0x3B, 0x8E, 0x7F, 0x0F, 0x80, 0x07, 0x8F, 0x8E,
  0x06, 0x06, 0x03, 0xFB, 0xFF, 0xC7, 0xE1, 0xE0, 0xF0, 0xFC, 0x67, 0xF1,
  0xF0, 0x7F, 0xEF, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0x8F, 0xE3,
  0x1D, 0xC7, 0x71, 0xCC, 0xE3, 0xF1, 0xFC, 0xE3, 0xB0, 0x6C, 0x3B, 0x8E,
  0xFF, 0x1F, 0x80, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0x61, 0xD8, 0x76, 0x19,
  0xFE, 0x3D, 0x80, 0xE0, 0x70, 0x38, 0x7C, 0x1E, 0x00, 0x77, 0x70, 0x00,
  0x00, 0xEE, 0xE0, 0x18, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x18,
  0x63, 0x08, 0x00, 0x00, 0x40, 0xE0, 0xF9, 0xF8, 0x70, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x40,
  0x38, 0x1F, 0x03, 0xE0, 0x38, 0x3C, 0xF9, 0xF0, 0xC0, 0x40, 0x00, 0x3F,
  0x3F, 0xD8, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x81, 0x80, 0x07, 0xC0, 0xC6, 0x10, 0x23, 0x7A, 0x6C, 0xB6, 0x9A,
  0x59, 0x25, 0x92, 0xD9, 0x2D, 0xB4, 0x4D, 0x86, 0x00, 0x72, 0x01, 0xE0,
  0x01, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x1D, 0x83, 0x30, 0xE7, 0x18,
  0xE3, 0xFC, 0xFF, 0x98, 0x37, 0x07, 0xC0, 0xC0, 0x1F, 0xC3, 0xFE, 0x38,
  0x63, 0x87, 0x30, 0x63, 0x0E, 0x3F, 0x87, 0xFC, 0x70, 0xE7, 0x0E, 0x60,
  0xE6, 0x1C, 0x7F, 0xCF, 0xF0, 0x1F, 0x8F, 0xF7, 0x0D, 0x83, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0x1F,
  0x87, 0xF8, 0xE3, 0x9C, 0x73, 0x06, 0x60, 0xCC, 0x1B, 0x87, 0x70, 0xEE,
  0x19, 0x87, 0x31, 0xCF, 0xF1, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x3F, 0xC3, 0xFC, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x7F, 0xCF, 0xFC, 0x1F, 0xF1, 0xFF, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x3F, 0xC3, 0xFC, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x1F, 0x8F, 0xF7, 0x0D, 0x83, 0x60, 0x38, 0x0E, 0x03, 0x1F, 0xC7,
  0xF0, 0x6C, 0x1B, 0x86, 0x7F, 0x8F, 0x80, 0x18, 0x73, 0x86, 0x38, 0x63,
  0x06, 0x30, 0x63, 0x0E, 0x7F, 0xE7, 0xFC, 0x70, 0xC6, 0x0C, 0x61, 0xC6,
  0x1C, 0xE1, 0xCE, 0x18, 0x3F, 0xCF, 0xF0, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xFF, 0x3F, 0xC0, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x33,
  0x0E, 0x71, 0x8F, 0xF0, 0xFC, 0x00, 0x18, 0x79, 0xC7, 0x8E, 0x38, 0x73,
  0x83, 0x38, 0x1B, 0x80, 0xF8, 0x0F, 0xE0, 0x7B, 0x03, 0x9C, 0x18, 0xE0,
  0xC3, 0x86, 0x1C, 0x70, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x7F, 0xFF, 0xF0, 0x1C,
  0x73, 0xCF, 0x3C, 0xF3, 0xDE, 0x3D, 0xE3, 0x76, 0x37, 0x67, 0x6E, 0x66,
  0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE0, 0xCE, 0x1C, 0x18, 0x73, 0xC6, 0x3C,
  0x63, 0xC6, 0x3C, 0xE3, 0x6E, 0x76, 0xE7, 0x6C, 0x76, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0xE3, 0xCE, 0x18, 0x1F, 0x8F, 0xE7, 0x1D, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0x1F,
  0xC1, 0xFE, 0x38, 0x73, 0x87, 0x38, 0x73, 0x06, 0x31, 0xE3, 0xFC, 0x7F,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x1F, 0x8F, 0xF7, 0x1D,
  0x83, 0x60, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1B, 0x8E, 0x7F,
  0x0F, 0xC0, 0x38, 0x06, 0x1F, 0xC3, 0xFE, 0x38, 0x63, 0x87, 0x30, 0x63,
  0x0E, 0x33, 0xE7, 0xF8, 0x7F, 0x87, 0x38, 0x61, 0x86, 0x1C, 0x61, 0xCE,
  0x1C, 0x1F, 0x87, 0xF9, 0xC3, 0x30, 0x77, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0x80, 0x3B, 0x07, 0x71, 0xC7, 0xF8, 0x7C, 0x00, 0x7F, 0xFF, 0xFE,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0xEE, 0x1D, 0xC3, 0x38, 0x66,
  0x0C, 0xC3, 0x98, 0x77, 0x0E, 0xE1, 0x9C, 0x33, 0x8E, 0x71, 0xC7, 0xF0,
  0x7C, 0x00, 0xC0, 0xFC, 0x3B, 0x86, 0x71, 0xCE, 0x30, 0xCE, 0x19, 0xC3,
  0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x66, 0x76,
  0x66, 0x6E, 0x66, 0xEE, 0x6E, 0xC7, 0xEC, 0xFE, 0xCF, 0xFC, 0xF7, 0x8F,
  0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0x1C, 0x3C, 0x30, 0xE0, 0xE7,
  0x03, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x37,
  0x01, 0xCC, 0x0E, 0x38, 0x70, 0xE3, 0xC1, 0xC0, 0xE0, 0xFC, 0x39, 0x8E,
  0x31, 0xC7, 0x70, 0x6C, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xFF, 0xCF,
  0xFC, 0x1F, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x78, 0xF8, 0xC6, 0x31, 0xC6, 0x31,
  0x8C, 0x63, 0x8C, 0x63, 0x18, 0xE0, 0x1F, 0x1E, 0x06, 0x06, 0x0E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x78,
  0xF8, 0x0C, 0x1E, 0x1E, 0x36, 0x36, 0x63, 0xE3, 0xFF, 0xFF, 0xC0, 0xE3,
  0x1E, 0x1F, 0x9C, 0xEC, 0x30, 0x1B, 0xFF, 0x8F, 0x87, 0xC3, 0x7F, 0x9E,
  0xC0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0xB0, 0x7F, 0x8E, 0x71, 0x86,
  0x30, 0xCE, 0x19, 0xC3, 0x38, 0x67, 0x1C, 0xFF, 0x3B, 0xC0, 0x0E, 0x1F,
  0xDC, 0xEC, 0x3E, 0x07, 0x03, 0x01, 0xC7, 0xE3, 0xBF, 0x8F, 0x80, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x61, 0xDC, 0x7F, 0x9C, 0xF3, 0x0C, 0xE1, 0x9C,
  0x33, 0x0E, 0x61, 0xCE, 0x38, 0xFE, 0x1E, 0xC0, 0x0E, 0x0F, 0xE7, 0x39,
  0x87, 0xE1, 0xFF, 0xFF, 0xFB, 0x80, 0xE1, 0x1F, 0xE3, 0xE0, 0x07, 0xC3,
  0xF1, 0xC0, 0x60, 0xFF, 0xBF, 0xE3, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x00, 0x0E, 0x63, 0xFC, 0xE7, 0x98, 0x77, 0x0C,
  0xE1, 0x98, 0x33, 0x8E, 0x71, 0xC7, 0xF8, 0xFE, 0x00, 0xC4, 0x39, 0xFE,
  0x0F, 0x80, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0xB8, 0x6F, 0x8E, 0x71,
  0x87, 0x30, 0xEE, 0x19, 0xC3, 0x30, 0x66, 0x1C, 0xC3, 0xB8, 0x70, 0x02,
  0x03, 0x81, 0xC0, 0x03, 0xE1, 0xF1, 0xF8, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC7, 0xFF, 0xFC, 0x01, 0x80, 0x70, 0x18, 0x00, 0x0F, 0x83, 0xE1,
  0xF8, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x1F, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0xF3,
  0x9C, 0x33, 0x83, 0x70, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x63, 0x86,
  0x38, 0xE1, 0xC0, 0x3F, 0x1F, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x81, 0xC7, 0xFF, 0xFE, 0x36, 0xCD, 0xFD, 0xDD,
  0xB3, 0x36, 0x66, 0xCD, 0xDB, 0xBF, 0x66, 0xCC, 0xD9, 0x9B, 0x33, 0x00,
  0x33, 0x86, 0xF8, 0xE7, 0x18, 0x73, 0x0C, 0xE1, 0x9C, 0x33, 0x06, 0x61,
  0xCC, 0x3B, 0x86, 0x00, 0x0E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF0, 0x7C,
  0x1B, 0x06, 0xE3, 0x9F, 0xC3, 0xE0, 0x3B, 0x0F, 0xF3, 0x9C, 0xC3, 0x30,
  0xDC, 0x37, 0x0D, 0x87, 0x71, 0xDF, 0xEE, 0xF3, 0x80, 0xE0, 0x30, 0x0C,
  0x00, 0x1C, 0xCF, 0xF7, 0x3D, 0x86, 0xE1, 0xB8, 0x6C, 0x3B, 0x0E, 0xE3,
  0x9F, 0xC7, 0xB0, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x33, 0xBF, 0xDF, 0xEE,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x00, 0x0E, 0x0F, 0xE7,
  0x19, 0x87, 0x70, 0x0F, 0x80, 0xF8, 0x0E, 0xC3, 0xBF, 0xC7, 0xE0, 0x18,
  0x0C, 0x3F, 0xFF, 0xF3, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x07,
  0xC3, 0xF0, 0x70, 0xDC, 0x36, 0x1D, 0x87, 0x61, 0xB8, 0x6E, 0x1B, 0x8E,
  0xE3, 0x9F, 0xE7, 0xB0, 0xE0, 0xEC, 0x19, 0x87, 0x30, 0xC7, 0x38, 0x66,
  0x0D, 0x81, 0xB0, 0x3C, 0x03, 0x80, 0x60, 0x00, 0xC4, 0x79, 0x9F, 0x33,
  0x66, 0x6D, 0xCD, 0xAB, 0x35, 0x67, 0xAC, 0xE7, 0x1C, 0xE3, 0x9C, 0x00,
  0x30, 0x73, 0x8E, 0x19, 0xC1, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x3B, 0x87, 0x18, 0xE1, 0xC0, 0x70, 0x33, 0x07, 0x30, 0xE3, 0x8E, 0x39,
  0xC1, 0x98, 0x1B, 0x81, 0xB0, 0x1F, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38,
  0x0F, 0x80, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x0F, 0xFB, 0xFF, 0x00, 0x02, 0x07, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x18, 0x08, 0x33, 0x32, 0x26, 0x66, 0x64, 0x44, 0xCC, 0xCC,
  0x88, 0x10, 0x38, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0F, 0x0E,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0xE0, 0x80, 0x38, 0x4F, 0x8F,
  0x1F, 0xE1, 0xE0,
};

const GFXglyph RobotoMono_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 14, 12, 3, -14 },
  { 10, 7, 5, 12, 3, -15 },
  { 15, 12, 14, 12, 0, -14 },
  { 36, 10, 19, 12, 1, -17 },
  { 60, 10, 14, 12, 1, -14 },
  { 78, 11, 14, 12, 0, -14 },
  { 98, 3, 5, 12, 5, -15 },
  { 100, 7, 21, 12, 3, -16 },
  { 119, 6, 21, 12, 2, -16 },
  { 135, 9, 10, 12, 2, -14 },
  { 147, 10, 11, 12, 1, -12 },
  { 161, 4, 6, 12, 2, -2 },
  { 164, 9, 2, 12, 2, -7 },
  { 167, 4, 3, 12, 3, -3 },
  { 169, 10, 15, 12, 1, -14 },
  { 188, 10, 14, 12, 1, -14 },
  { 206, 7, 14, 12, 2, -14 },
  { 219, 11, 14, 12, 0, -14 },
  { 239, 11, 14, 12, 0, -14 },
  { 259, 11, 14, 12, 0, -14 },
  { 279, 10, 14, 12, 1, -14 },
  { 297, 9, 14, 12, 1, -14 },
  { 313, 11, 14, 12, 1, -14 },
  { 333, 10, 14, 12, 1, -14 },
  { 351, 10, 14, 12, 1, -14 },
  { 369, 4, 11, 12, 4, -11 },
  { 375, 6, 15, 12, 3, -11 },
  { 387, 10, 9, 12, 1, -11 },
  { 399, 10, 6, 12, 1, -9 },
  { 407, 9, 10, 12, 1, -11 },
  { 419, 9, 14, 12, 2, -14 },
  { 435, 12, 14, 12, 0, -14 },
  { 456, 11, 14, 12, -1, -14 },
  { 476, 12, 14, 12, 0, -14 },
  { 497, 10, 14, 12, 1, -14 },
  { 515, 11, 14, 12, 0, -14 },
  { 535, 12, 14, 12, 0, -14 },
  { 556, 12, 14, 12, 0, -14 },
  { 577, 10, 14, 12, 1, -14 },
  { 595, 12, 14, 12, 0, -14 },
  { 616, 10, 14, 12, 1, -14 },
  { 634, 11, 14, 12, 1, -14 },
  { 654, 13, 14, 12, 0, -14 },
  { 677, 10, 14, 12, 0, -14 },
  { 695, 12, 14, 12, 0, -14 },
  { 716, 12, 14, 12, 0, -14 },
  { 737, 10, 14, 12, 1, -14 },
  { 755, 12, 14, 12, 0, -14 },
  { 776, 10, 16, 12, 1, -14 },
  { 796, 12, 14, 12, 0, -14 },
  { 817, 11, 14, 12, 1, -14 },
  { 837, 12, 14, 12, 1, -14 },
  { 858, 11, 14, 12, 1, -14 },
  { 878, 11, 14, 12, 2, -14 },
  { 898, 12, 14, 12, 1, -14 },
  { 919, 14, 14, 12, -1, -14 },
  { 944, 11, 14, 12, 2, -14 },
  { 964, 12, 14, 12, 0, -14 },
  { 985, 8, 19, 12, 2, -16 },
  { 1004, 5, 15, 12, 4, -14 },
  { 1014, 8, 19, 12, 2, -16 },
  { 1033, 8, 7, 12, 2, -14 },
  { 1040, 9, 2, 12, 0, 0 },
  { 1043, 4, 2, 12, 5, -14 },
  { 1044, 9, 11, 12, 1, -11 },
  { 1057, 11, 15, 12, 0, -15 },
  { 1078, 9, 11, 12, 1, -11 },
  { 1091, 11, 15, 12, 1, -15 },
  { 1112, 10, 11, 12, 1, -11 },
  { 1126, 10, 15, 12, 2, -15 },
  { 1145, 11, 15, 12, 0, -11 },
  { 1166, 11, 15, 12, 0, -15 },
  { 1187, 9, 15, 12, 1, -15 },
  { 1204, 10, 19, 12, 0, -15 },
  { 1228, 12, 15, 12, 0, -15 },
  { 1251, 9, 15, 12, 1, -15 },
  { 1268, 11, 11, 12, 0, -11 },
  { 1284, 11, 11, 12, 0, -11 },
  { 1300, 10, 11, 12, 1, -11 },
  { 1314, 10, 15, 12, 0, -11 },
  { 1333, 10, 15, 12, 1, -11 },
  { 1352, 9, 11, 12, 2, -11 },
  { 1365, 10, 11, 12, 1, -11 },
  { 1379, 9, 13, 12, 2, -13 },
  { 1394, 10, 11, 12, 1, -11 },
  { 1408, 11, 11, 12, 1, -11 },
  { 1424, 11, 11, 12, 1, -11 },
  { 1440, 12, 11, 12, 0, -11 },
  { 1457, 12, 15, 12, 0, -11 },
  { 1480, 11, 11, 12, 0, -11 },
  { 1496, 8, 20, 12, 3, -16 },
  { 1516, 4, 18, 12, 4, -14 },
  { 1525, 8, 20, 12, 2, -16 },
  { 1545, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC20PT7B_H_
