#ifndef _ROBOTOMONO_SEMIBOLDITALIC50PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8,
  0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0x7C, 0x1C, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3C, 0xF0, 0x7C, 0x78, 0xF0,
  0x78, 0xF0, 0xF8, 0x78, 0xF0, 0xF8, 0xF9, 0xE0, 0x7F, 0xF3, 0xC0, 0x7F,
  0xE7, 0xC0, 0x1F, 0xC7, 0x80, 0x02, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF1, 0xF8, 0x01, 0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xCF, 0xFF, 0x07,
  0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x3C,
  0x3E, 0x0F, 0x0C, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x81, 0xF1, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF,
  0x07, 0xCF, 0xE7, 0xF1, 0xFB, 0xF8, 0x7E, 0x3E, 0x7E, 0x0F, 0xEF, 0xDF,
  0xC0, 0xFD, 0xFB, 0xF0, 0x1F, 0xFE, 0x7E, 0x01, 0xFF, 0xCF, 0xC0, 0x3F,
  0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFE, 0x03, 0xFF, 0x0F,
  0xE0, 0x04, 0x00, 0x00, 0x3D, 0xF7, 0xDF, 0x7D, 0xF7, 0xBE, 0xFB, 0xEF,
  0x3C, 0xF0, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x20, 0x1E, 0x02, 0x38, 0x1E, 0x0F, 0x7F, 0x1C, 0x7F, 0x7F, 0xDD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xCF,
  0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1C, 0x03, 0xC0, 0x08, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x07, 0x00, 0x80, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x3F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x7F,
  0x03, 0xFF, 0x7F, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0x7E, 0x3F, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7F, 0xFC, 0x7E, 0x7F, 0xF0, 0x7E, 0xFF, 0xE0, 0x7E, 0xFF,
  0x80, 0xFE, 0xFF, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x03,
  0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7E, 0x3F, 0x38, 0x1F, 0x90, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF1,
  0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0x00, 0x3F, 0x3F, 0xE0, 0x3F,
  0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xFC, 0x7F,
  0xC0, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F,
  0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0xC1, 0xFC,
  0x07, 0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xFC, 0x03, 0xF9, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x03, 0xFC, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x7E,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0,
  0xFF, 0x07, 0xE0, 0x08, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x07, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF9, 0xFF, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x3E, 0x0E, 0x0F, 0x0F, 0xF8, 0xE1, 0xF1, 0xFF,
  0xCF, 0x1E, 0x3F, 0xFC, 0xF3, 0xC3, 0xE3, 0x8F, 0x3C, 0x7C, 0x38, 0xF3,
  0xC7, 0x87, 0x8F, 0x78, 0xF0, 0x78, 0xF7, 0x8F, 0x07, 0x0E, 0x78, 0xF0,
  0x70, 0xE7, 0x1E, 0x0F, 0x0E, 0xF1, 0xE0, 0xF0, 0xEF, 0x1E, 0x0E, 0x1E,
  0xF1, 0xE0, 0xE1, 0xCF, 0x1E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE3, 0xCF, 0x1F,
  0x7E, 0x78, 0xF1, 0xFF, 0xFF, 0x0F, 0x0F, 0xEF, 0xF0, 0x70, 0x7C, 0xFC,
  0x07, 0x80, 0x01, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x80, 0x01, 0xFE, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF8, 0x7E, 0x01, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0,
  0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0,
  0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0,
  0xFC, 0x07, 0xF8, 0x1F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x1F, 0xFE, 0x7F, 0x03, 0xFF, 0xCF, 0xE0, 0x7F, 0xF9, 0xF8, 0x0F, 0xFF,
  0x3F, 0x03, 0xFF, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xC1, 0xFE, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x0F, 0xC7, 0xF8, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xE0, 0x00,
  0x3F, 0xE7, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE3, 0xFF, 0x83, 0xEF, 0x1E, 0xF8,
  0x1F, 0x79, 0xF7, 0xC0, 0xFB, 0xCF, 0x7E, 0x0F, 0xDF, 0xFB, 0xF0, 0x7E,
  0xFF, 0xDF, 0x83, 0xF7, 0xFC, 0xF8, 0x1F, 0x9F, 0xE7, 0xC0, 0xF8, 0xFE,
  0x7E, 0x07, 0xC7, 0xF3, 0xF0, 0x7E, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0xFC,
  0x1F, 0x8F, 0x87, 0xC0, 0xFC, 0x7C, 0x3E, 0x07, 0xC3, 0xC3, 0xF0, 0x3E,
  0x1E, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x03, 0xF0, 0x3F, 0xC0,
  0x1F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0xC0, 0x7E,
  0x07, 0xFE, 0x03, 0xF0, 0x3F, 0xF0, 0x1F, 0x81, 0xFF, 0x81, 0xFC, 0x0F,
  0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x83, 0xF0, 0x3F, 0x3C,
  0x1F, 0x81, 0xF9, 0xF0, 0xFC, 0x0F, 0xCF, 0x8F, 0xE0, 0x7E, 0x7C, 0x7F,
  0x07, 0xF1, 0xF3, 0xF0, 0x3F, 0x8F, 0x9F, 0x81, 0xF8, 0x7C, 0xFC, 0x0F,
  0xC3, 0xE7, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0x83,
  0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x03, 0xFF,
  0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0xFF, 0x81, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFE,
  0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE1, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F,
  0x80, 0x7F, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x0F, 0x81, 0xFB, 0xF0, 0x7C, 0x0F, 0x9F, 0x83,
  0xE0, 0xFC, 0xFC, 0x1F, 0x07, 0xE7, 0xE1, 0xF8, 0x3F, 0x3F, 0x0F, 0xC1,
  0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0x87, 0xF0, 0xFC, 0x7C, 0x3F, 0x87, 0xC3,
  0xE1, 0xFC, 0x3E, 0x1F, 0x1F, 0xE3, 0xF0, 0xF8, 0xFF, 0x1F, 0x87, 0xC7,
  0xF8, 0xF8, 0x3E, 0x3F, 0xCF, 0xC1, 0xF3, 0xFE, 0x7E, 0x0F, 0x9E, 0xF3,
  0xE0, 0x7C, 0xF7, 0x9F, 0x03, 0xEF, 0xBD, 0xF8, 0x1F, 0x79, 0xEF, 0xC0,
  0xFB, 0xCF, 0x7C, 0x07, 0xFE, 0x7B, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x83, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7,
  0xE0, 0x1E, 0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0x80, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x07, 0xF8, 0xFF,
  0xBF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x0F,
  0xF1, 0xFC, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFF, 0x80, 0x7E, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xCF, 0xFE,
  0x07, 0xE3, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x03,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x0F, 0xE0,
  0x1F, 0xF9, 0xF8, 0x07, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xCF, 0x80,
  0x0F, 0xF3, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0x87, 0xF0, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x1F,
  0x80, 0x0F, 0x9F, 0xC0, 0x07, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x02, 0x07, 0xF0, 0x03,
  0x01, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xEF, 0xC0, 0x0F, 0xF3, 0xF0, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x40, 0x03, 0xF8, 0x0C, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7F, 0xC0, 0x7E, 0x7F, 0xF0,
  0x3F, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xF0, 0x1F,
  0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xDF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x0F,
  0xC1, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFE, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x3E, 0xFE,
  0x7F, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xF3, 0xFD, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F,
  0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xE3, 0xFE, 0x03, 0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x7F, 0xC0, 0x0F, 0xDF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xF7, 0xFF, 0x00, 0xFC, 0x7F, 0xC0, 0x1F, 0x80, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x7F, 0xE3,
  0xE0, 0x3F, 0xFD, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFC,
  0x7F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE3,
  0xFF, 0x07, 0xCF, 0xFF, 0x07, 0xDF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07,
  0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x1F, 0x80,
  0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB,
  0xF0, 0x3F, 0xF9, 0xF8, 0x07, 0xF8, 0xF8, 0x00, 0x40, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x07,
  0xFF, 0x03, 0xC0, 0xFB, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0x07, 0xEF, 0x83,
  0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC7, 0xE7, 0xC7, 0xF8, 0xF8,
  0xF8, 0xFF, 0x1F, 0x1F, 0x1F, 0xE7, 0xE3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF7,
  0x9F, 0x0F, 0x9C, 0xF7, 0xE1, 0xF7, 0x9E, 0xF8, 0x3E, 0xF3, 0xDF, 0x07,
  0xFC, 0x7B, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0C,
  0x1F, 0xFE, 0x01, 0xF3, 0xFF, 0xF0, 0x1E, 0x7F, 0xFF, 0x83, 0xE7, 0xE3,
  0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xFC, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00,
};

const GFXglyph RobotoMono_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 36, 29, 9, -36 },
  { 55, 16, 13, 29, 9, -38 },
  { 81, 29, 36, 29, 0, -36 },
  { 212, 27, 46, 29, 2, -41 },
  { 368, 24, 37, 29, 3, -36 },
  { 479, 27, 37, 29, 1, -36 },
  { 604, 6, 13, 29, 13, -38 },
  { 614, 17, 51, 29, 8, -40 },
  { 723, 17, 51, 29, 4, -40 },
  { 832, 24, 25, 29, 4, -36 },
  { 907, 25, 25, 29, 2, -29 },
  { 986, 10, 16, 29, 5, -6 },
  { 1006, 20, 5, 29, 6, -18 },
  { 1019, 9, 9, 29, 8, -8 },
  { 1030, 26, 39, 29, 2, -36 },
  { 1157, 24, 37, 29, 3, -36 },
  { 1268, 17, 36, 29, 6, -36 },
  { 1345, 26, 36, 29, 0, -36 },
  { 1462, 26, 37, 29, 1, -36 },
  { 1583, 25, 36, 29, 1, -36 },
  { 1696, 26, 37, 29, 2, -36 },
  { 1817, 24, 37, 29, 2, -36 },
  { 1928, 26, 36, 29, 3, -36 },
  { 2045, 25, 37, 29, 2, -36 },
  { 2161, 23, 36, 29, 4, -36 },
  { 2265, 12, 29, 29, 9, -28 },
  { 2309, 15, 38, 29, 7, -28 },
  { 2381, 24, 23, 29, 3, -27 },
  { 2450, 24, 16, 29, 3, -23 },
  { 2498, 24, 23, 29, 2, -27 },
  { 2567, 22, 36, 29, 6, -36 },
  { 2666, 28, 35, 29, 1, -35 },
  { 2789, 28, 36, 29, -2, -36 },
  { 2915, 28, 36, 29, 1, -36 },
  { 3041, 27, 37, 29, 2, -36 },
  { 3166, 27, 36, 29, 1, -36 },
  { 3288, 29, 36, 29, 1, -36 },
  { 3419, 29, 36, 29, 1, -36 },
  { 3550, 27, 37, 29, 2, -36 },
  { 3675, 30, 36, 29, 0, -36 },
  { 3810, 26, 36, 29, 2, -36 },
  { 3927, 27, 37, 29, 2, -36 },
  { 4052, 32, 36, 29, 1, -36 },
  { 4196, 24, 36, 29, 1, -36 },
  { 4304, 29, 36, 29, 1, -36 },
  { 4435, 29, 36, 29, 0, -36 },
  { 4566, 26, 37, 29, 2, -36 },
  { 4687, 28, 36, 29, 1, -36 },
  { 4813, 26, 42, 29, 2, -36 },
  { 4950, 28, 36, 29, 1, -36 },
  { 5076, 27, 37, 29, 2, -36 },
  { 5201, 28, 36, 29, 4, -36 },
  { 5327, 28, 37, 29, 2, -36 },
  { 5457, 28, 36, 29, 4, -36 },
  { 5583, 29, 36, 29, 3, -36 },
  { 5714, 33, 36, 29, -1, -36 },
  { 5863, 27, 36, 29, 5, -36 },
  { 5985, 30, 36, 29, 0, -36 },
  { 6120, 18, 49, 29, 6, -41 },
  { 6231, 12, 39, 29, 9, -36 },
  { 6290, 18, 49, 29, 6, -41 },
  { 6401, 20, 19, 29, 5, -36 },
  { 6449, 23, 5, 29, 0, 0 },
  { 6464, 10, 7, 29, 13, -36 },
  { 6473, 24, 28, 29, 2, -27 },
  { 6557, 25, 39, 29, 1, -38 },
  { 6679, 24, 28, 29, 2, -27 },
  { 6763, 27, 39, 29, 2, -38 },
  { 6895, 25, 28, 29, 2, -27 },
  { 6983, 27, 39, 29, 4, -39 },
  { 7115, 27, 37, 29, 1, -27 },
  { 7240, 25, 38, 29, 1, -38 },
  { 7359, 22, 37, 29, 2, -37 },
  { 7461, 23, 48, 29, 1, -37 },
  { 7599, 28, 38, 29, 1, -38 },
  { 7732, 23, 38, 29, 2, -38 },
  { 7842, 29, 27, 29, -1, -27 },
  { 7940, 25, 27, 29, 1, -27 },
  { 8025, 25, 28, 29, 2, -27 },
  { 8113, 27, 37, 29, -1, -27 },
  { 8238, 26, 37, 29, 2, -27 },
  { 8359, 24, 27, 29, 4, -27 },
  { 8440, 25, 28, 29, 2, -27 },
  { 8528, 23, 34, 29, 4, -33 },
  { 8626, 25, 27, 29, 3, -26 },
  { 8711, 25, 26, 29, 4, -26 },
  { 8793, 27, 26, 29, 3, -26 },
  { 8881, 30, 26, 29, 0, -26 },
  { 8979, 31, 37, 29, 0, -26 },
  { 9123, 27, 26, 29, 1, -26 },
  { 9211, 20, 48, 29, 7, -39 },
  { 9331, 11, 46, 29, 9, -36 },
  { 9395, 19, 48, 29, 5, -39 },
  { 9509, 28, 11, 29, 0, -20 },
};

const GFXfont RobotoMono_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC50PT7B_H_
