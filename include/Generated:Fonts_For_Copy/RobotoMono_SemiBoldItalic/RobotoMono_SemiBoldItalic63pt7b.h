#ifndef _ROBOTOMONO_SEMIBOLDITALIC63PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x08,
  0x3F, 0x03, 0xE0, 0x38, 0xFC, 0x0F, 0x81, 0xF3, 0xF0, 0x3E, 0x0F, 0xCF,
  0x80, 0xF8, 0x3E, 0x3E, 0x07, 0xE1, 0xF0, 0xF8, 0x1F, 0x8F, 0xC3, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC3, 0xF1, 0xF0, 0x3F, 0xFF, 0xCF, 0x80, 0x7F, 0xFE,
  0x3E, 0x00, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0x8F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x7C, 0x7F, 0xE0, 0x03,
  0xF3, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0x03, 0xF3,
  0xF0, 0xFC, 0x0F, 0x8F, 0x83, 0xF0, 0x7C, 0x7E, 0x07, 0xC3, 0xE1, 0xF8,
  0x1F, 0x1F, 0x87, 0xE0, 0x7C, 0xFC, 0x1F, 0x01, 0xF0, 0xE0, 0x7C, 0x0F,
  0xC1, 0x81, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0xFE, 0x01,
  0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0x3F,
  0xC1, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0x9F, 0xF0, 0x7F, 0x8F, 0xF3, 0xFC,
  0x07, 0xF9, 0xFC, 0x7F, 0x80, 0xFF, 0x7F, 0x9F, 0xE0, 0x0F, 0xFF, 0xE3,
  0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0x0F, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xF0,
  0x07, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x60, 0x0F, 0x80, 0x73, 0xE0,
  0x3C, 0x07, 0xCF, 0xE0, 0xF0, 0xFF, 0x7F, 0xE3, 0xCF, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x06, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1F, 0x0F, 0xF3, 0xFF, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xCF, 0xF0, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF3, 0xFC,
  0x01, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x7F, 0x80, 0xFF, 0xFD, 0xFE, 0x0F,
  0xFF, 0xF7, 0xF8, 0x7F, 0xBF, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xC7,
  0xF9, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0x01, 0xFE,
  0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0x80, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0x1F, 0xC3, 0xFC, 0x7C, 0x0F, 0xF1,
  0x80, 0x3F, 0x88, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0x07, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x1F, 0xC7,
  0xFE, 0x01, 0xFE, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0x7F, 0xCF,
  0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xE7, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F, 0xE1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xF7, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x9F, 0xC0, 0x3F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x04,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF,
  0x83, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x83,
  0xE0, 0x7E, 0x0F, 0xFE, 0x1E, 0x07, 0xC1, 0xFF, 0xF1, 0xE0, 0xF8, 0x3F,
  0xFF, 0x1E, 0x0F, 0x87, 0xF9, 0xE1, 0xE1, 0xF0, 0xFE, 0x1E, 0x1E, 0x1F,
  0x0F, 0x81, 0xE1, 0xE1, 0xE1, 0xF8, 0x3E, 0x1E, 0x3E, 0x1F, 0x03, 0xC1,
  0xE3, 0xE1, 0xF0, 0x3C, 0x1E, 0x3C, 0x3E, 0x03, 0xC1, 0xE7, 0xC3, 0xE0,
  0x7C, 0x3E, 0x7C, 0x3E, 0x07, 0xC3, 0xE7, 0xC7, 0xC0, 0x78, 0x3C, 0x7C,
  0x7C, 0x0F, 0x83, 0xC7, 0x87, 0xC0, 0xF8, 0x3C, 0x78, 0x7C, 0x0F, 0x87,
  0x8F, 0x87, 0xC0, 0xF0, 0x78, 0xF8, 0x7C, 0x1F, 0x07, 0x8F, 0x87, 0xC1,
  0xF0, 0xF0, 0xF8, 0x7E, 0x7F, 0x1F, 0x07, 0x83, 0xFF, 0xFF, 0xE0, 0x78,
  0x3F, 0xFF, 0xFC, 0x07, 0xC3, 0xFE, 0xFF, 0x80, 0x7C, 0x1F, 0x87, 0xF0,
  0x07, 0xC0, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x0F,
  0xF8, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x03, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x7F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xF9, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0x80, 0x7F,
  0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xCF, 0xF0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xEF, 0x87, 0xFF, 0xC0, 0x7F, 0x7C,
  0x7E, 0xFE, 0x03, 0xFB, 0xE3, 0xF7, 0xF0, 0x1F, 0xDF, 0x3F, 0x7F, 0x00,
  0xFE, 0xF9, 0xFB, 0xF8, 0x07, 0xF7, 0xFF, 0xDF, 0xC0, 0x7F, 0x3F, 0xFC,
  0xFE, 0x03, 0xF9, 0xFF, 0xE7, 0xF0, 0x1F, 0xCF, 0xFE, 0x7F, 0x80, 0xFE,
  0x3F, 0xF3, 0xF8, 0x07, 0xF1, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xF8, 0xFE,
  0x03, 0xFC, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0x07, 0xF0, 0x1F, 0xE0, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0x83,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFC, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xF7, 0xE0, 0x7F, 0x80,
  0xFF, 0x7F, 0x07, 0xF8, 0x0F, 0xF3, 0xF0, 0x7F, 0x80, 0xFF, 0x3F, 0x07,
  0xF8, 0x0F, 0xF3, 0xF0, 0x7F, 0x80, 0xFF, 0x3F, 0x87, 0xF0, 0x1F, 0xE1,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFC, 0xFF, 0x01,
  0xFE, 0x0F, 0xCF, 0xF0, 0x1F, 0xE0, 0xFC, 0xFF, 0x01, 0xFE, 0x0F, 0xDF,
  0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xC0,
  0x7F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0x80,
  0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x8F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0x80, 0xFF, 0x7F, 0x01, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0xFE,
  0x7F, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xF8,
  0x1F, 0xC7, 0xF0, 0x7F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0xC7, 0xF0,
  0x7F, 0x83, 0xF8, 0x7F, 0x0F, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x83, 0xF8,
  0x7F, 0x0F, 0xF8, 0x7F, 0x87, 0xF1, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xF8,
  0x7F, 0x07, 0xF1, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xF8, 0xFE, 0x07, 0xF3,
  0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0xF8, 0xFE, 0x07, 0xE3, 0xEF, 0x8F, 0xE0,
  0x7E, 0x7E, 0xF9, 0xFC, 0x07, 0xE7, 0xEF, 0x9F, 0xC0, 0x7E, 0x7C, 0xF9,
  0xFC, 0x07, 0xEF, 0xCF, 0xBF, 0x80, 0x7E, 0xFC, 0xFB, 0xF8, 0x07, 0xEF,
  0x8F, 0xBF, 0x80, 0x7E, 0xF8, 0xFB, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xF0, 0x00,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFD, 0xF8,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFC, 0x3F, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0xFF, 0xE0, 0x03, 0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFF, 0xC0, 0x7F, 0x1F, 0xFF, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x3F, 0xC0, 0x07, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xF7, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xDF, 0xC0, 0x03, 0xFF, 0xE7, 0xF0, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF1, 0xFE, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x80, 0xFF, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x1F, 0x01,
  0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x02, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0xF3,
  0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xF1, 0xFC,
  0x00, 0x00, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x04, 0x00, 0x07, 0xF8, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0xF0, 0x03, 0xF8, 0xFF, 0xF8,
  0x03, 0xFB, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x04, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x03, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x01,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x0F, 0xF3, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08,
  0xF8, 0x0F, 0x00, 0x3F, 0x3F, 0xE3, 0xFC, 0x03, 0xF7, 0xFE, 0x7F, 0xE0,
  0x7F, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x7F, 0xF0, 0x03, 0xF9, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x07,
  0xF7, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0xC7, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x0F, 0xEF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFC, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xFE, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x00,
  0x70, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F,
  0x0F, 0xFF, 0x81, 0xFC, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x30, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x70, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x87,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0,
  0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xE0, 0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x03,
  0xFB, 0xF0, 0x1F, 0x80, 0xFE, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x03, 0xF8,
  0x1F, 0xCF, 0xC0, 0xFE, 0x07, 0xF3, 0xF0, 0x7F, 0x83, 0xF8, 0xFC, 0x1F,
  0xE0, 0xFE, 0x3F, 0x0F, 0xF8, 0x3F, 0x8F, 0xC3, 0xFE, 0x1F, 0xC3, 0xF0,
  0xFF, 0x87, 0xF0, 0xFC, 0x7D, 0xE1, 0xF8, 0x3F, 0x1F, 0x78, 0x7E, 0x0F,
  0xC7, 0xDF, 0x3F, 0x83, 0xF3, 0xE7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF3, 0xF0,
  0x3F, 0x3C, 0x7D, 0xFC, 0x0F, 0xDF, 0x1F, 0x7E, 0x03, 0xF7, 0xC7, 0xDF,
  0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x3F, 0xFF, 0x00, 0x1F,
  0x8F, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0xF0,
  0x1F, 0x9F, 0xF3, 0xFF, 0xDF, 0xF3, 0xF8, 0x1F, 0xFF, 0xFC, 0x7E, 0x01,
  0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
};

const GFXglyph RobotoMono_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 46, 37, 11, -45 },
  { 93, 20, 16, 37, 11, -47 },
  { 133, 37, 45, 37, 0, -45 },
  { 342, 33, 59, 37, 3, -52 },
  { 586, 30, 47, 37, 4, -46 },
  { 763, 35, 47, 37, 1, -46 },
  { 969, 8, 16, 37, 16, -47 },
  { 985, 21, 64, 37, 10, -50 },
  { 1153, 22, 64, 37, 5, -50 },
  { 1329, 30, 32, 37, 5, -45 },
  { 1449, 31, 33, 37, 3, -37 },
  { 1577, 13, 19, 37, 6, -7 },
  { 1608, 25, 6, 37, 8, -23 },
  { 1627, 11, 11, 37, 11, -10 },
  { 1643, 32, 49, 37, 3, -45 },
  { 1839, 30, 47, 37, 4, -46 },
  { 2016, 22, 45, 37, 7, -45 },
  { 2140, 33, 45, 37, 0, -45 },
  { 2326, 32, 46, 37, 2, -45 },
  { 2510, 32, 45, 37, 1, -45 },
  { 2690, 33, 46, 37, 3, -45 },
  { 2880, 29, 46, 37, 3, -45 },
  { 3047, 33, 45, 37, 4, -45 },
  { 3233, 32, 46, 37, 2, -45 },
  { 3417, 28, 45, 37, 5, -45 },
  { 3575, 16, 37, 37, 11, -36 },
  { 3649, 20, 48, 37, 8, -36 },
  { 3769, 30, 29, 37, 4, -34 },
  { 3878, 32, 20, 37, 3, -29 },
  { 3958, 30, 29, 37, 2, -34 },
  { 4067, 27, 46, 37, 8, -46 },
  { 4223, 36, 45, 37, 1, -45 },
  { 4426, 35, 45, 37, -2, -45 },
  { 4623, 35, 45, 37, 1, -45 },
  { 4820, 34, 47, 37, 2, -46 },
  { 5020, 34, 45, 37, 1, -45 },
  { 5212, 37, 45, 37, 1, -45 },
  { 5421, 37, 45, 37, 1, -45 },
  { 5630, 33, 46, 37, 3, -45 },
  { 5820, 36, 45, 37, 1, -45 },
  { 6023, 34, 45, 37, 2, -45 },
  { 6215, 35, 46, 37, 2, -45 },
  { 6417, 40, 45, 37, 1, -45 },
  { 6642, 29, 45, 37, 2, -45 },
  { 6806, 37, 45, 37, 1, -45 },
  { 7015, 36, 45, 37, 1, -45 },
  { 7218, 34, 46, 37, 2, -45 },
  { 7414, 36, 45, 37, 1, -45 },
  { 7617, 34, 53, 37, 2, -45 },
  { 7843, 36, 45, 37, 1, -45 },
  { 8046, 35, 46, 37, 2, -45 },
  { 8248, 35, 45, 37, 5, -45 },
  { 8445, 34, 46, 37, 3, -45 },
  { 8641, 35, 45, 37, 5, -45 },
  { 8838, 36, 45, 37, 4, -45 },
  { 9041, 42, 45, 37, -2, -45 },
  { 9278, 35, 45, 37, 6, -45 },
  { 9475, 38, 45, 37, 0, -45 },
  { 9689, 22, 62, 37, 8, -52 },
  { 9860, 15, 49, 37, 12, -45 },
  { 9952, 23, 62, 37, 7, -52 },
  { 10131, 24, 24, 37, 7, -45 },
  { 10203, 29, 6, 37, 0, 0 },
  { 10225, 12, 9, 37, 17, -46 },
  { 10239, 30, 35, 37, 2, -34 },
  { 10371, 32, 48, 37, 1, -47 },
  { 10563, 30, 35, 37, 3, -34 },
  { 10695, 34, 48, 37, 3, -47 },
  { 10899, 31, 35, 37, 3, -34 },
  { 11035, 34, 49, 37, 5, -49 },
  { 11244, 34, 47, 37, 1, -34 },
  { 11444, 32, 47, 37, 1, -47 },
  { 11632, 28, 46, 37, 3, -46 },
  { 11793, 29, 60, 37, 1, -46 },
  { 12011, 35, 47, 37, 1, -47 },
  { 12217, 28, 47, 37, 3, -47 },
  { 12382, 36, 34, 37, -1, -34 },
  { 12535, 32, 34, 37, 1, -34 },
  { 12671, 30, 35, 37, 3, -34 },
  { 12803, 34, 47, 37, -1, -34 },
  { 13003, 32, 47, 37, 3, -34 },
  { 13191, 30, 34, 37, 6, -34 },
  { 13319, 31, 35, 37, 3, -34 },
  { 13455, 29, 42, 37, 5, -41 },
  { 13608, 31, 34, 37, 4, -33 },
  { 13740, 32, 33, 37, 5, -33 },
  { 13872, 34, 33, 37, 4, -33 },
  { 14013, 37, 33, 37, 0, -33 },
  { 14166, 39, 47, 37, 0, -33 },
  { 14396, 34, 33, 37, 1, -33 },
  { 14537, 24, 60, 37, 9, -49 },
  { 14717, 14, 58, 37, 11, -45 },
  { 14819, 24, 60, 37, 6, -49 },
  { 14999, 35, 13, 37, 0, -25 },
};

const GFXfont RobotoMono_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC63PT7B_H_
