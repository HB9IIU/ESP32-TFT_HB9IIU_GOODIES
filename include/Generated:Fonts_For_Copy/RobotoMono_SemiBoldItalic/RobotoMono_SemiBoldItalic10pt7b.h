#ifndef _ROBOTOMONO_SEMIBOLDITALIC10PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x57, 0x88, 0xB6, 0x80, 0x1C, 0xA7, 0xCC, 0xF9, 0x4E, 0x00, 0x10,
  0xE6, 0xD8, 0x30, 0x24, 0x9E, 0x20, 0xCD, 0xE4, 0x7B, 0x30, 0x39, 0xA7,
  0x18, 0xDE, 0x67, 0x80, 0xE0, 0x2B, 0x49, 0x24, 0x98, 0x44, 0x92, 0x4A,
  0x50, 0x25, 0x5C, 0xC9, 0x00, 0x10, 0x9F, 0x42, 0x00, 0x78, 0xF0, 0xC0,
  0x0C, 0x21, 0x04, 0x20, 0x84, 0x30, 0x79, 0x9F, 0x99, 0xE0, 0x3E, 0x22,
  0x26, 0x40, 0x7A, 0x42, 0x22, 0x23, 0xE0, 0x3A, 0x42, 0x60, 0xE5, 0xC0,
  0x18, 0xCA, 0xBF, 0x88, 0x40, 0x3D, 0x87, 0x16, 0x0B, 0x27, 0x00, 0x3B,
  0x1C, 0x9C, 0xA5, 0xC0, 0xF8, 0x8C, 0x44, 0x22, 0x00, 0x3A, 0x52, 0xE4,
  0xE5, 0xC0, 0x79, 0x9B, 0x52, 0xC0, 0x70, 0xB0, 0x24, 0x00, 0x94, 0x3C,
  0xC3, 0xF0, 0xFF, 0x60, 0xCF, 0x80, 0x76, 0xC4, 0x44, 0x01, 0x00, 0x39,
  0x56, 0xED, 0xBA, 0x27, 0x00, 0x11, 0x8A, 0xD7, 0xE6, 0x20, 0x79, 0x34,
  0xDE, 0x4B, 0x2F, 0x00, 0x39, 0x34, 0x10, 0xC1, 0x27, 0x00, 0x79, 0x24,
  0xD3, 0x4B, 0x6F, 0x00, 0x7D, 0x04, 0x1E, 0x43, 0x0F, 0x80, 0x7D, 0x04,
  0x1E, 0x43, 0x0C, 0x00, 0x39, 0x34, 0x16, 0xC9, 0x27, 0x80, 0x65, 0x34,
  0x9E, 0x4B, 0x29, 0x80, 0x7C, 0x41, 0x0C, 0x20, 0x8F, 0x80, 0x04, 0x30,
  0x82, 0x0B, 0x27, 0x00, 0x6E, 0x91, 0x43, 0x85, 0x1B, 0x22, 0x00, 0x62,
  0x10, 0x84, 0x23, 0xE0, 0x6D, 0xB7, 0xDE, 0x6B, 0x28, 0x80, 0x65, 0xB6,
  0x96, 0x5B, 0x69, 0x80, 0x39, 0x34, 0xD3, 0xC9, 0x27, 0x00, 0x79, 0x14,
  0xDE, 0x43, 0x0C, 0x00, 0x39, 0x34, 0xD3, 0xC9, 0x27, 0x02, 0x79, 0x34,
  0xDE, 0x53, 0x68, 0x80, 0x39, 0x16, 0x0E, 0x0B, 0x27, 0x80, 0xF9, 0x08,
  0xC4, 0x21, 0x00, 0x65, 0x34, 0x92, 0x49, 0x27, 0x00, 0x8C, 0xE5, 0xEE,
  0x31, 0x00, 0xAD, 0x7F, 0xEF, 0x5A, 0x80, 0x6C, 0xA3, 0x8C, 0x71, 0x6C,
  0x80, 0x8E, 0x94, 0xC6, 0x21, 0x00, 0x7C, 0x21, 0x0C, 0x61, 0x0F, 0x80,
  0x36, 0x64, 0x44, 0x44, 0xCC, 0xAB, 0x55, 0x33, 0x22, 0x22, 0x26, 0x4C,
  0x25, 0x59, 0xF8, 0xC0, 0x78, 0x5F, 0xB7, 0x80, 0x23, 0x10, 0xF4, 0xA7,
  0x3E, 0x7A, 0x50, 0x97, 0x00, 0x04, 0x30, 0xDE, 0x4B, 0x24, 0x9E, 0x7A,
  0x7E, 0x97, 0x80, 0x19, 0x1B, 0xE4, 0x21, 0x18, 0x7D, 0x2C, 0x92, 0x7A,
  0x6F, 0x00, 0x63, 0x10, 0xF4, 0xA7, 0x3B, 0x18, 0x1C, 0x23, 0x1B, 0xE0,
  0x18, 0x0C, 0x21, 0x08, 0xC4, 0xE0, 0x21, 0x84, 0x56, 0x71, 0xCD, 0x36,
  0x39, 0x84, 0x21, 0x18, 0xDF, 0x7F, 0xEA, 0xAA, 0xA8, 0x7A, 0x53, 0x9D,
  0x80, 0x7A, 0x72, 0x97, 0x00, 0x7A, 0x53, 0x9F, 0x42, 0x00, 0x7D, 0x2C,
  0x92, 0x78, 0x41, 0x00, 0x7A, 0x31, 0x08, 0x00, 0x7A, 0x0F, 0x97, 0x00,
  0x64, 0xF4, 0x44, 0x70, 0x9C, 0xA5, 0x2F, 0x00, 0x9C, 0xA8, 0xC4, 0x00,
  0xAF, 0xBD, 0x6A, 0x00, 0x6C, 0xC3, 0x1C, 0xC8, 0x4D, 0x27, 0x8C, 0x21,
  0x8C, 0x00, 0x7C, 0x42, 0x10, 0xF8, 0x12, 0x22, 0x6C, 0x64, 0x42, 0x55,
  0xAA, 0x80, 0x42, 0x22, 0x32, 0x44, 0x48, 0x66, 0x60,
};

const GFXglyph RobotoMono_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 4, 7, 6, 1, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 1, 3, 6, 3, -8 },
  { 29, 3, 10, 6, 2, -8 },
  { 33, 3, 10, 6, 1, -8 },
  { 37, 5, 5, 6, 1, -7 },
  { 41, 5, 5, 6, 0, -6 },
  { 45, 2, 3, 6, 1, -1 },
  { 46, 4, 1, 6, 1, -4 },
  { 47, 1, 2, 6, 2, -2 },
  { 48, 6, 8, 6, 0, -7 },
  { 54, 4, 7, 6, 1, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 6, 7, 6, 0, -7 },
  { 83, 5, 7, 6, 0, -7 },
  { 88, 5, 7, 6, 1, -7 },
  { 93, 5, 7, 6, 0, -7 },
  { 98, 4, 7, 6, 1, -7 },
  { 102, 2, 6, 6, 2, -6 },
  { 104, 3, 8, 6, 1, -6 },
  { 107, 4, 4, 6, 1, -5 },
  { 109, 4, 4, 6, 1, -5 },
  { 111, 5, 4, 6, 0, -5 },
  { 114, 5, 7, 6, 1, -7 },
  { 119, 6, 7, 6, 0, -7 },
  { 125, 5, 7, 6, 0, -7 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 6, 7, 6, 0, -7 },
  { 142, 6, 7, 6, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 6, 7, 6, 0, -7 },
  { 166, 6, 7, 6, 0, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 6, 7, 6, 0, -7 },
  { 184, 7, 7, 6, 0, -7 },
  { 191, 5, 7, 6, 0, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 6, 7, 6, 0, -7 },
  { 208, 6, 7, 6, 0, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 6, 8, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 5, 7, 6, 1, -7 },
  { 243, 6, 7, 6, 0, -7 },
  { 249, 5, 7, 6, 1, -7 },
  { 254, 5, 7, 6, 1, -7 },
  { 259, 6, 7, 6, 0, -7 },
  { 265, 5, 7, 6, 1, -7 },
  { 270, 6, 7, 6, 0, -7 },
  { 276, 4, 10, 6, 1, -8 },
  { 281, 2, 8, 6, 2, -7 },
  { 283, 4, 10, 6, 1, -8 },
  { 288, 4, 4, 6, 1, -7 },
  { 290, 5, 1, 6, 0, 0 },
  { 291, 2, 1, 6, 3, -7 },
  { 292, 5, 5, 6, 0, -5 },
  { 296, 5, 8, 6, 0, -8 },
  { 301, 5, 5, 6, 0, -5 },
  { 305, 6, 8, 6, 0, -8 },
  { 311, 5, 5, 6, 0, -5 },
  { 315, 5, 8, 6, 1, -8 },
  { 320, 6, 7, 6, 0, -5 },
  { 326, 5, 8, 6, 0, -8 },
  { 331, 5, 7, 6, 0, -7 },
  { 336, 5, 9, 6, 0, -7 },
  { 342, 6, 8, 6, 0, -8 },
  { 348, 5, 8, 6, 0, -8 },
  { 353, 6, 5, 6, 0, -5 },
  { 357, 5, 5, 6, 0, -5 },
  { 361, 5, 5, 6, 0, -5 },
  { 365, 5, 7, 6, 0, -5 },
  { 370, 6, 7, 6, 0, -5 },
  { 376, 5, 5, 6, 1, -5 },
  { 380, 5, 5, 6, 0, -5 },
  { 384, 4, 7, 6, 1, -7 },
  { 388, 5, 5, 6, 1, -5 },
  { 392, 5, 5, 6, 1, -5 },
  { 396, 5, 5, 6, 1, -5 },
  { 400, 6, 5, 6, 0, -5 },
  { 404, 6, 7, 6, 0, -5 },
  { 410, 6, 5, 6, 0, -5 },
  { 414, 4, 10, 6, 1, -8 },
  { 419, 2, 9, 6, 2, -7 },
  { 422, 4, 10, 6, 1, -8 },
  { 427, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC10PT7B_H_
