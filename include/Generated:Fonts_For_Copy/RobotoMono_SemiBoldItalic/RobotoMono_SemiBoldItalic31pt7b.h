#ifndef _ROBOTOMONO_SEMIBOLDITALIC31PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0xF8, 0x70, 0x71,
  0xDC, 0x77, 0x1D, 0xC7, 0x71, 0x98, 0x66, 0x3B, 0x8E, 0x00, 0x71, 0x80,
  0x38, 0xE0, 0x0E, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x81, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xC0, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60,
  0x06, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x1C, 0x70, 0x07,
  0x18, 0x01, 0x8E, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0x9C, 0x27, 0x18, 0xEE, 0x31, 0x9C, 0xE7,
  0x39, 0xDC, 0x7F, 0x30, 0x7C, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xDF, 0x83, 0x7F, 0x0E, 0xE7, 0x39, 0x8E, 0xE7, 0x1C, 0x8E,
  0x38, 0x1C, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3D,
  0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0x3F, 0xE3,
  0x8F, 0x78, 0xE7, 0x8F, 0x79, 0xE3, 0xFE, 0x78, 0x7F, 0x1E, 0x0F, 0x87,
  0x87, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF3, 0xE0, 0x77, 0x7E, 0xEE,
  0xEC, 0x00, 0x40, 0x30, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x20, 0x04, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC1, 0xF0, 0x1C, 0x02,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x43, 0x87, 0xCC, 0xFF,
  0xFF, 0xCF, 0xFE, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0E, 0x70, 0x78, 0xE3,
  0xC3, 0xC2, 0x0C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x83, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x1C, 0xF3, 0xCF, 0x3C, 0xE7, 0x9C, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x79, 0xEF, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1,
  0xE3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x7E, 0xE1, 0xFD,
  0xCF, 0x77, 0xBD, 0xEF, 0xE3, 0xDF, 0x87, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x79, 0xE0, 0xF3, 0xC3, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x00,
  0xC1, 0xF1, 0xFF, 0xFE, 0xFF, 0xBD, 0xE8, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xDE, 0x07,
  0x9E, 0x07, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x01, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x70, 0x3B, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0xE1,
  0xE7, 0x81, 0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x70, 0x3C, 0xF0, 0x79,
  0xE1, 0xE1, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x1E, 0x1E, 0x3E, 0x0F, 0xFC,
  0x07, 0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x78, 0x3C, 0x78, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0x77, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x83, 0xDF, 0x3F, 0x7F, 0xFC, 0xFF,
  0xE0, 0xF7, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x0F, 0xF0, 0x3F,
  0x01, 0xF0, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x3E, 0x7C, 0xF9, 0xE0, 0x07, 0x83, 0xE0, 0xFC, 0x3E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x38, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8,
  0x1F, 0x80, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0x00, 0x06, 0x00, 0x04, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x20,
  0x00, 0x30, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xF8, 0x07, 0xC0, 0x1C,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0x07,
  0xF8, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xE7, 0x81, 0xC0,
  0x61, 0xC0, 0x31, 0xCF, 0xCC, 0xCF, 0xE6, 0xE7, 0x33, 0x67, 0x39, 0xF3,
  0x18, 0xFB, 0x8C, 0xF9, 0xC6, 0x6C, 0xC7, 0x36, 0x63, 0x1B, 0x3B, 0x99,
  0x9F, 0xFC, 0xC7, 0xBC, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x08, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7,
  0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x1E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F,
  0x80, 0x3C, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x3F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x0F, 0x0F, 0x01, 0xC3, 0xC0, 0x78,
  0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x83, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1,
  0xE3, 0xE0, 0x71, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1F, 0x1E, 0x1F, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xC3, 0xE1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x1E, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xFB,
  0xC0, 0x79, 0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x87, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C,
  0x07, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC2, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x1E, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07,
  0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7,
  0x80, 0x1E, 0xF8, 0x01, 0xDF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xF7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0xC0, 0x78, 0x3C, 0x07,
  0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0x67, 0xF0, 0xEF, 0xDC, 0x1D, 0xFB,
  0x87, 0xBE, 0x70, 0xF7, 0xDE, 0x1E, 0xF3, 0xC3, 0xDE, 0x70, 0x71, 0x8E,
  0x0E, 0x31, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38,
  0x38, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF8, 0x3C, 0x7E, 0x0F, 0x1F, 0x83, 0x87, 0xE1, 0xE1, 0xFC, 0x78,
  0x7F, 0x1E, 0x1F, 0xC7, 0x8F, 0x71, 0xE3, 0xCE, 0x70, 0xF3, 0xBC, 0x3C,
  0xEF, 0x0F, 0x3F, 0xC3, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7E, 0x1E, 0x1F,
  0x87, 0x83, 0xE1, 0xE0, 0xF8, 0x70, 0x3E, 0x3C, 0x07, 0x80, 0x03, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0,
  0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E,
  0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x1F, 0xC7, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x38, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1E, 0x1F,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C,
  0x3E, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0x87, 0x83, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1F, 0x3C, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0xE1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x79, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07,
  0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE1, 0xC1, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x01, 0xCE, 0x00,
  0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x71, 0xC3, 0xDC, 0x70, 0xEF, 0x1C, 0x7B,
  0xC7, 0x1E, 0xF3, 0xC7, 0x3C, 0xF1, 0xCF, 0x3C, 0xF3, 0xDF, 0x3C, 0xF7,
  0xCE, 0x3D, 0xB3, 0x8F, 0xED, 0xE3, 0xFB, 0x70, 0xFE, 0xDC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x7C, 0x0F,
  0x81, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F,
  0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07,
  0xC0, 0xF8, 0x7C, 0x03, 0xC0, 0xF0, 0x0F, 0xF8, 0x07, 0x9E, 0x07, 0x8F,
  0x03, 0xC7, 0x83, 0xC1, 0xC3, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0,
  0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0xE1, 0xF8, 0x3F,
  0x00, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xC3,
  0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC3, 0x87, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x0E,
  0xE0, 0xEE, 0x1C, 0xE1, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x7F, 0x07, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xE3, 0xC7, 0x01, 0xC0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFE, 0x3F,
  0xFC, 0xFC, 0x79, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0xBF, 0xFE,
  0x3F, 0xFC, 0x3F, 0x3C, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x18, 0x1E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xF0,
  0x79, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xE0, 0x3F, 0xC0, 0xF7, 0xC3, 0xEF, 0xFF, 0x9F, 0xFE, 0x39, 0xF8, 0x00,
  0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x78, 0x3D, 0xC0, 0xFF, 0x01,
  0xFC, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0xF0, 0x7B, 0xC3,
  0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x0E, 0x3C, 0x1F, 0xDE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x38, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F,
  0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7E, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3C, 0x1E, 0x3C, 0x0E, 0x78, 0x0E, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x08, 0x7C, 0x18, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xE1, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xE0, 0xF9, 0xF0, 0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F,
  0x1C, 0x07, 0x9E, 0x03, 0xC7, 0x01, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xDE, 0x00, 0x1E, 0x08, 0x0F, 0x0E, 0x0F, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x1C, 0x1E, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFC, 0xF0, 0x79, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x00, 0x00, 0x60, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x04,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x02, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0x3E, 0x0F, 0x3E, 0x07, 0x3E,
  0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7D, 0xE0, 0x3C,
  0xF8, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xE3, 0xC0, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC6, 0x1F, 0xF7, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0x8E, 0x39, 0xC7, 0x1D, 0xE7, 0x8E, 0xF3, 0xCF, 0x79, 0xE7,
  0xB8, 0xE3, 0x9C, 0x71, 0xCE, 0x38, 0xEF, 0x3C, 0xF7, 0x9E, 0x7B, 0xCF,
  0x3D, 0xC7, 0x1C, 0xE3, 0x8E, 0x00, 0x00, 0x70, 0x7B, 0xF8, 0xFF, 0xF9,
  0xFF, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF7, 0x83, 0xCF, 0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x70,
  0x1E, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x1E,
  0x7C, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7B, 0xF0, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0xEF,
  0x1F, 0xFF, 0x3F, 0x7F, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x3C, 0x78, 0x7C,
  0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xB8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3A, 0x79, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xF0, 0x47, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x3C, 0x0E,
  0x3C, 0x0F, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0xF0, 0x1C, 0xF8, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x87, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCE, 0x07, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x0F, 0x9F,
  0xFF, 0x1F, 0xFE, 0x1F, 0x3C, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0x38, 0x78, 0x38, 0x70, 0x38, 0xF0, 0x3C, 0xE0, 0x3D,
  0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0xE1, 0x87, 0xF1, 0xC3, 0xB8, 0xE3, 0xDC, 0xF9, 0xCE, 0x7C, 0xE7,
  0x3E, 0xF3, 0xBF, 0x71, 0xDB, 0xB8, 0xED, 0xFC, 0x7E, 0xFC, 0x3E, 0x7E,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC3, 0x81, 0xC1, 0xC0, 0x1E,
  0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x1E, 0x78, 0x07, 0xBC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3D, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0xC1, 0xE3, 0xE0, 0x3C, 0x3C,
  0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x1C,
  0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0xEF, 0x00, 0x1D,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xF9,
  0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x07,
  0xE0, 0x78, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x06, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x87,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xF0,
  0x3F, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x01,
  0x3F, 0xC1, 0xDF, 0xF9, 0xFE, 0x3F, 0xEE, 0x0F, 0xF0, 0x01, 0xF0,
};

const GFXglyph RobotoMono_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 5, -22 },
  { 23, 10, 8, 18, 5, -23 },
  { 33, 18, 22, 18, 0, -22 },
  { 83, 17, 29, 18, 1, -26 },
  { 145, 15, 22, 18, 2, -22 },
  { 187, 18, 22, 18, 0, -22 },
  { 237, 4, 8, 18, 8, -23 },
  { 241, 10, 32, 18, 5, -25 },
  { 281, 11, 32, 18, 2, -25 },
  { 325, 14, 15, 18, 3, -22 },
  { 352, 16, 16, 18, 1, -18 },
  { 384, 6, 10, 18, 3, -4 },
  { 392, 12, 3, 18, 4, -11 },
  { 397, 6, 5, 18, 5, -5 },
  { 401, 16, 24, 18, 1, -22 },
  { 449, 15, 22, 18, 2, -22 },
  { 491, 10, 22, 18, 4, -22 },
  { 519, 16, 22, 18, 0, -22 },
  { 563, 16, 22, 18, 1, -22 },
  { 607, 16, 22, 18, 0, -22 },
  { 651, 17, 22, 18, 1, -22 },
  { 698, 15, 22, 18, 1, -22 },
  { 740, 16, 22, 18, 2, -22 },
  { 784, 16, 22, 18, 1, -22 },
  { 828, 14, 22, 18, 2, -22 },
  { 867, 7, 18, 18, 6, -18 },
  { 883, 10, 24, 18, 4, -18 },
  { 913, 15, 15, 18, 2, -17 },
  { 942, 15, 9, 18, 2, -14 },
  { 959, 15, 15, 18, 1, -17 },
  { 988, 13, 22, 18, 4, -22 },
  { 1024, 17, 22, 18, 1, -22 },
  { 1071, 17, 22, 18, -1, -22 },
  { 1118, 18, 22, 18, 0, -22 },
  { 1168, 17, 22, 18, 1, -22 },
  { 1215, 17, 22, 18, 0, -22 },
  { 1262, 18, 22, 18, 1, -22 },
  { 1312, 18, 22, 18, 1, -22 },
  { 1362, 17, 22, 18, 1, -22 },
  { 1409, 18, 22, 18, 0, -22 },
  { 1459, 17, 22, 18, 1, -22 },
  { 1506, 17, 22, 18, 1, -22 },
  { 1553, 20, 22, 18, 0, -22 },
  { 1608, 14, 22, 18, 1, -22 },
  { 1647, 19, 22, 18, 0, -22 },
  { 1700, 18, 22, 18, 0, -22 },
  { 1750, 17, 22, 18, 1, -22 },
  { 1797, 17, 22, 18, 1, -22 },
  { 1844, 17, 26, 18, 1, -22 },
  { 1900, 18, 22, 18, 0, -22 },
  { 1950, 17, 22, 18, 1, -22 },
  { 1997, 18, 22, 18, 2, -22 },
  { 2047, 17, 22, 18, 1, -22 },
  { 2094, 17, 22, 18, 3, -22 },
  { 2141, 18, 22, 18, 2, -22 },
  { 2191, 21, 22, 18, -1, -22 },
  { 2249, 17, 22, 18, 3, -22 },
  { 2296, 18, 22, 18, 0, -22 },
  { 2346, 11, 31, 18, 4, -26 },
  { 2389, 7, 24, 18, 6, -22 },
  { 2410, 11, 31, 18, 4, -26 },
  { 2453, 12, 12, 18, 3, -22 },
  { 2471, 14, 3, 18, 0, 0 },
  { 2477, 6, 4, 18, 8, -22 },
  { 2480, 15, 17, 18, 1, -17 },
  { 2512, 15, 23, 18, 1, -23 },
  { 2556, 14, 17, 18, 2, -17 },
  { 2586, 17, 23, 18, 1, -23 },
  { 2635, 16, 17, 18, 1, -17 },
  { 2669, 16, 24, 18, 3, -24 },
  { 2717, 17, 24, 18, 0, -17 },
  { 2768, 15, 23, 18, 1, -23 },
  { 2812, 13, 23, 18, 2, -23 },
  { 2850, 14, 30, 18, 1, -23 },
  { 2903, 17, 23, 18, 1, -23 },
  { 2952, 14, 23, 18, 1, -23 },
  { 2993, 17, 17, 18, 0, -17 },
  { 3030, 15, 17, 18, 1, -17 },
  { 3062, 15, 17, 18, 1, -17 },
  { 3094, 16, 23, 18, 0, -17 },
  { 3140, 16, 23, 18, 1, -17 },
  { 3186, 15, 17, 18, 3, -17 },
  { 3218, 16, 17, 18, 1, -17 },
  { 3252, 14, 20, 18, 3, -20 },
  { 3287, 15, 16, 18, 2, -16 },
  { 3317, 16, 16, 18, 2, -16 },
  { 3349, 17, 16, 18, 2, -16 },
  { 3383, 18, 16, 18, 0, -16 },
  { 3419, 19, 23, 18, 0, -16 },
  { 3474, 17, 16, 18, 0, -16 },
  { 3508, 12, 29, 18, 4, -24 },
  { 3552, 7, 28, 18, 5, -22 },
  { 3577, 12, 30, 18, 3, -24 },
  { 3622, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC31PT7B_H_
