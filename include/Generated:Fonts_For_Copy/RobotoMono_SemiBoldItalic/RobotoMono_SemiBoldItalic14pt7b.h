#ifndef _ROBOTOMONO_SEMIBOLDITALIC14PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x60, 0x4C, 0x4A, 0xD7, 0xA0, 0x0B, 0x0A, 0x12,
  0x7F, 0x14, 0x24, 0xFE, 0x68, 0x48, 0x58, 0x08, 0x10, 0xF3, 0x36, 0x6C,
  0x1C, 0x0E, 0x0D, 0x0B, 0x33, 0xC2, 0x00, 0x61, 0x6A, 0xF7, 0x41, 0x06,
  0x0F, 0x2B, 0xD4, 0x38, 0x1C, 0x36, 0x26, 0x3C, 0x38, 0x7B, 0x4B, 0xCE,
  0xCE, 0x7E, 0xF0, 0x08, 0x88, 0xC4, 0x23, 0x18, 0xC6, 0x30, 0x84, 0x10,
  0x20, 0x84, 0x31, 0x8C, 0x63, 0x10, 0x8C, 0x46, 0x40, 0x18, 0x23, 0x5B,
  0xE3, 0x0D, 0x33, 0x00, 0x18, 0x23, 0xFF, 0xE3, 0x06, 0x08, 0x00, 0x2D,
  0xAC, 0xF8, 0xFC, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x41, 0x82,
  0x00, 0x3C, 0xD9, 0x1E, 0x3D, 0xDC, 0xB3, 0x66, 0xD8, 0xF0, 0x1F, 0xF3,
  0x32, 0x26, 0x66, 0x1C, 0x6D, 0x88, 0x30, 0x61, 0x86, 0x18, 0xE1, 0xFC,
  0x1E, 0x36, 0x63, 0x02, 0x1C, 0x1C, 0x06, 0xC6, 0x6E, 0x7C, 0x06, 0x1C,
  0x38, 0xB3, 0x6C, 0xBF, 0xFF, 0x0C, 0x18, 0x3E, 0xFD, 0x82, 0x8F, 0xC1,
  0x83, 0x46, 0xDC, 0xF0, 0x1C, 0xE6, 0x36, 0xFF, 0x38, 0xE3, 0xD9, 0xE0,
  0xFF, 0xFC, 0x30, 0x61, 0x82, 0x0C, 0x30, 0x61, 0x80, 0x3C, 0xD9, 0x1A,
  0x27, 0xCF, 0x33, 0x46, 0xDD, 0xF0, 0x39, 0xBC, 0x71, 0xCF, 0xF7, 0xC2,
  0x39, 0x80, 0x7C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x66, 0x4C, 0x80, 0x04,
  0x37, 0xB0, 0xF0, 0xF0, 0x80, 0xFE, 0x03, 0xF7, 0xE0, 0x83, 0x87, 0x83,
  0x3F, 0x88, 0x00, 0x7B, 0x38, 0xC3, 0x18, 0xC6, 0x00, 0x41, 0x80, 0x0E,
  0x33, 0x6D, 0x55, 0x55, 0xA5, 0xAE, 0x96, 0x40, 0x38, 0x0C, 0x18, 0x70,
  0xA3, 0x64, 0xDF, 0xBF, 0xC7, 0x84, 0x3E, 0x3F, 0x63, 0x63, 0x7E, 0x7E,
  0x63, 0x42, 0xCE, 0xFC, 0x3C, 0xCF, 0x1E, 0x0C, 0x10, 0x20, 0x46, 0xCC,
  0xF0, 0x3C, 0x3E, 0x63, 0x63, 0x63, 0x63, 0x62, 0x46, 0xCC, 0xF8, 0x3F,
  0x3F, 0x20, 0x60, 0x7E, 0x7E, 0x60, 0x40, 0x40, 0xFE, 0x3F, 0x3F, 0x20,
  0x60, 0x7E, 0x7E, 0x60, 0x60, 0x40, 0xC0, 0x3C, 0xCF, 0x1E, 0x0C, 0x13,
  0xE1, 0x46, 0xCC, 0xF0, 0x33, 0x23, 0x63, 0x63, 0x7E, 0x7E, 0x46, 0x46,
  0xC6, 0xC6, 0x7E, 0xFC, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x21, 0xF0, 0x03,
  0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0xC6, 0x6C, 0x78, 0x31, 0x91, 0x99,
  0x8D, 0x87, 0x83, 0xE1, 0xB0, 0x98, 0xC6, 0x63, 0x80, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x41, 0xFC, 0x33, 0x33, 0x77, 0x77, 0x7B, 0x7A,
  0x5A, 0x42, 0xC6, 0xC6, 0x33, 0x33, 0x73, 0x73, 0x7A, 0x6A, 0x4E, 0x4E,
  0xCE, 0xC6, 0x3C, 0xDB, 0x1E, 0x3C, 0x70, 0xE1, 0x46, 0xDC, 0xF0, 0x3E,
  0x3F, 0x23, 0x63, 0x63, 0x7E, 0x60, 0x60, 0x40, 0xC0, 0x3C, 0xDB, 0x1E,
  0x3C, 0x70, 0xE1, 0xC6, 0xDC, 0xF0, 0x30, 0x40, 0x3E, 0x3F, 0x23, 0x63,
  0x67, 0x7C, 0x6C, 0x44, 0xC6, 0xC6, 0x1E, 0x33, 0x63, 0x60, 0x38, 0x0E,
  0x06, 0xC2, 0x66, 0x3C, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x66, 0x8F, 0x1E, 0x3C, 0x78, 0xB3, 0x46, 0xDC, 0xF0, 0xC3,
  0xC6, 0x46, 0x4C, 0x6C, 0x68, 0x78, 0x70, 0x70, 0x30, 0xDB, 0xDA, 0xDA,
  0xFE, 0xFE, 0xFC, 0xFC, 0xDC, 0xD8, 0xD8, 0x61, 0x99, 0x8D, 0x82, 0x81,
  0xC0, 0xE0, 0xF0, 0xC8, 0x66, 0x63, 0x00, 0xC3, 0x66, 0x64, 0x6C, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x20, 0x7F, 0x7F, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xFE, 0x39, 0xC8, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x70,
  0x93, 0x6C, 0x92, 0x6D, 0x80, 0x39, 0xC4, 0x23, 0x18, 0xC6, 0x21, 0x18,
  0xC6, 0x70, 0x18, 0x63, 0x8B, 0xCC, 0xFC, 0xD0, 0x08, 0x7D, 0x98, 0x77,
  0xE8, 0xF3, 0xBF, 0x30, 0x60, 0x81, 0x47, 0xEC, 0xD8, 0xB1, 0x46, 0xDF,
  0xF0, 0x11, 0xFC, 0x70, 0x82, 0x1C, 0xDE, 0x02, 0x0C, 0x19, 0x37, 0xF9,
  0xB3, 0x46, 0x8D, 0xBB, 0xF0, 0x11, 0xFC, 0x71, 0xFE, 0x0C, 0xDE, 0x0F,
  0x1F, 0x10, 0x30, 0xFE, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x08, 0x3F,
  0x62, 0x62, 0x46, 0x46, 0x6E, 0x3E, 0x04, 0xDC, 0x78, 0x30, 0x60, 0x81,
  0x27, 0xEC, 0x58, 0xB3, 0x46, 0x8F, 0x18, 0x18, 0x20, 0x1E, 0x18, 0x43,
  0x0C, 0x33, 0xF0, 0x06, 0x08, 0x01, 0xE0, 0xC1, 0x83, 0x04, 0x08, 0x30,
  0x65, 0xCF, 0x00, 0x30, 0x30, 0x20, 0x21, 0x66, 0x6C, 0x78, 0x78, 0x6C,
  0x4C, 0xC6, 0x79, 0xE1, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xCF, 0xC0, 0x12,
  0x7F, 0x5B, 0x5B, 0xDA, 0xDA, 0xD2, 0x96, 0x04, 0xFD, 0x8B, 0x16, 0x68,
  0xD1, 0xE3, 0x11, 0xFC, 0xF1, 0x86, 0x3D, 0xDE, 0x08, 0xFD, 0x9B, 0x16,
  0x28, 0xDB, 0xFE, 0xC1, 0x83, 0x00, 0x10, 0xFF, 0x16, 0x68, 0xD1, 0xB7,
  0x7E, 0x08, 0x30, 0x60, 0x04, 0xFD, 0xC3, 0x06, 0x08, 0x10, 0x60, 0x11,
  0xFC, 0x78, 0x78, 0x3C, 0xDE, 0x30, 0x67, 0xF1, 0x82, 0x0C, 0x18, 0x32,
  0x3C, 0xC7, 0x8B, 0x16, 0x6C, 0xDB, 0xBF, 0x00, 0xC7, 0x99, 0x32, 0xC7,
  0x8E, 0x0C, 0x00, 0x93, 0x6E, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x73, 0x36,
  0x1C, 0x18, 0x3C, 0x64, 0xC6, 0x63, 0xB1, 0x89, 0x86, 0x83, 0xC1, 0xC0,
  0x60, 0x60, 0xE0, 0x60, 0x00, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE,
  0x08, 0x8C, 0x63, 0x13, 0x1C, 0x63, 0x18, 0xC3, 0x00, 0x32, 0x22, 0x22,
  0x64, 0x44, 0x44, 0xC0, 0x30, 0x41, 0x04, 0x10, 0x40, 0xC6, 0x30, 0xC2,
  0x08, 0xC2, 0x00, 0x20, 0xFB, 0x8E,
};

const GFXglyph RobotoMono_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 5, 4, 8, 2, -11 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 13, 8, 1, -12 },
  { 31, 7, 10, 8, 1, -10 },
  { 40, 8, 10, 8, 0, -10 },
  { 50, 1, 4, 8, 4, -11 },
  { 51, 5, 14, 8, 2, -11 },
  { 60, 5, 14, 8, 1, -11 },
  { 69, 7, 7, 8, 1, -10 },
  { 76, 7, 7, 8, 1, -8 },
  { 83, 3, 5, 8, 1, -2 },
  { 85, 5, 1, 8, 2, -5 },
  { 86, 3, 2, 8, 2, -2 },
  { 87, 7, 11, 8, 1, -10 },
  { 97, 7, 10, 8, 1, -10 },
  { 106, 4, 10, 8, 2, -10 },
  { 111, 7, 10, 8, 0, -10 },
  { 120, 8, 10, 8, 0, -10 },
  { 130, 7, 10, 8, 0, -10 },
  { 139, 7, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 7, 10, 8, 1, -10 },
  { 165, 7, 10, 8, 1, -10 },
  { 174, 6, 10, 8, 1, -10 },
  { 182, 3, 8, 8, 3, -8 },
  { 185, 4, 11, 8, 2, -8 },
  { 191, 6, 7, 8, 1, -8 },
  { 197, 7, 4, 8, 1, -6 },
  { 201, 6, 7, 8, 1, -8 },
  { 207, 6, 10, 8, 2, -10 },
  { 215, 8, 10, 8, 0, -10 },
  { 225, 7, 10, 8, 0, -10 },
  { 234, 8, 10, 8, 0, -10 },
  { 244, 7, 10, 8, 1, -10 },
  { 253, 8, 10, 8, 0, -10 },
  { 263, 8, 10, 8, 0, -10 },
  { 273, 8, 10, 8, 0, -10 },
  { 283, 7, 10, 8, 1, -10 },
  { 292, 8, 10, 8, 0, -10 },
  { 302, 7, 10, 8, 1, -10 },
  { 311, 8, 10, 8, 0, -10 },
  { 321, 9, 10, 8, 0, -10 },
  { 333, 7, 10, 8, 0, -10 },
  { 342, 8, 10, 8, 0, -10 },
  { 352, 8, 10, 8, 0, -10 },
  { 362, 7, 10, 8, 1, -10 },
  { 371, 8, 10, 8, 0, -10 },
  { 381, 7, 12, 8, 1, -10 },
  { 392, 8, 10, 8, 0, -10 },
  { 402, 8, 10, 8, 0, -10 },
  { 412, 8, 10, 8, 1, -10 },
  { 422, 7, 10, 8, 1, -10 },
  { 431, 8, 10, 8, 1, -10 },
  { 441, 8, 10, 8, 1, -10 },
  { 451, 9, 10, 8, 0, -10 },
  { 463, 8, 10, 8, 1, -10 },
  { 473, 8, 10, 8, 0, -10 },
  { 483, 5, 14, 8, 2, -12 },
  { 492, 3, 11, 8, 3, -10 },
  { 497, 5, 14, 8, 2, -12 },
  { 506, 6, 5, 8, 1, -10 },
  { 510, 6, 1, 8, 0, 0 },
  { 511, 2, 2, 8, 4, -10 },
  { 512, 7, 8, 8, 0, -8 },
  { 519, 7, 11, 8, 0, -11 },
  { 529, 6, 8, 8, 1, -8 },
  { 535, 7, 11, 8, 1, -11 },
  { 545, 6, 8, 8, 1, -8 },
  { 551, 8, 11, 8, 1, -11 },
  { 562, 8, 11, 8, 0, -8 },
  { 573, 7, 11, 8, 0, -11 },
  { 583, 6, 10, 8, 1, -10 },
  { 591, 7, 13, 8, 0, -10 },
  { 603, 8, 11, 8, 0, -11 },
  { 614, 6, 11, 8, 1, -11 },
  { 623, 8, 8, 8, 0, -8 },
  { 631, 7, 8, 8, 0, -8 },
  { 638, 6, 8, 8, 1, -8 },
  { 644, 7, 11, 8, 0, -8 },
  { 654, 7, 11, 8, 1, -8 },
  { 664, 7, 8, 8, 1, -8 },
  { 671, 6, 8, 8, 1, -8 },
  { 677, 7, 9, 8, 1, -9 },
  { 685, 7, 7, 8, 1, -7 },
  { 692, 7, 7, 8, 1, -7 },
  { 699, 7, 7, 8, 1, -7 },
  { 706, 8, 7, 8, 0, -7 },
  { 713, 9, 10, 8, 0, -7 },
  { 725, 8, 7, 8, 0, -7 },
  { 732, 5, 13, 8, 2, -11 },
  { 741, 4, 13, 8, 2, -10 },
  { 748, 6, 14, 8, 1, -11 },
  { 759, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC14PT7B_H_
