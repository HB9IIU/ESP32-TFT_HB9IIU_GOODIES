#ifndef _ROBOTOMONO_SEMIBOLDITALIC22PT7B_H_
#define _ROBOTOMONO_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x98, 0xCE, 0x73, 0x98, 0x00, 0x73, 0x9C, 0x66,
  0xCF, 0x16, 0x6C, 0xD9, 0x80, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0xC0,
  0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x08, 0x80, 0xCC, 0x3F, 0xF9, 0xFF,
  0xC3, 0x30, 0x19, 0x81, 0x98, 0x0C, 0xC0, 0x01, 0x80, 0x10, 0x07, 0x81,
  0xFC, 0x3D, 0xE3, 0x86, 0x30, 0x63, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xCE, 0x0C, 0xE0, 0xCF, 0x1C, 0x7F, 0x83, 0xF0, 0x0C, 0x00,
  0x80, 0x38, 0x0F, 0x81, 0xB1, 0x66, 0x6C, 0xD8, 0xFA, 0x1E, 0xC0, 0x30,
  0x04, 0x01, 0xB0, 0x6F, 0x1B, 0x33, 0x66, 0xCC, 0xC1, 0xB0, 0x1E, 0x03,
  0x80, 0x7E, 0x03, 0xB0, 0x39, 0xC1, 0x8C, 0x0E, 0xE0, 0x7E, 0x01, 0xE0,
  0x1E, 0x39, 0xF9, 0x9C, 0xCC, 0xC7, 0xEE, 0x1E, 0x38, 0xE1, 0xFF, 0x87,
  0xDE, 0xFB, 0x6D, 0x80, 0x03, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x30,
  0x38, 0x10, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x70, 0xE1, 0x83, 0x0E, 0x18, 0x70, 0xC3, 0x0C, 0x10, 0x00, 0x06, 0x01,
  0x80, 0x62, 0x11, 0xE5, 0xDF, 0xF0, 0xC0, 0x78, 0x36, 0x38, 0xC4, 0x30,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x00, 0x39, 0x8C, 0xE7, 0x33, 0x00, 0xFF, 0xFF, 0x80,
  0x4E, 0xFE, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x83, 0xF8, 0xF7, 0x1C, 0x77, 0x0E, 0xE1, 0xDC, 0x7B,
  0xBF, 0x6E, 0xEF, 0x1B, 0xC3, 0x70, 0xEE, 0x1C, 0xE7, 0x1F, 0xC1, 0xF0,
  0x02, 0x1D, 0xFF, 0xEC, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87,
  0x0E, 0x18, 0x07, 0x81, 0xFE, 0x3C, 0xE3, 0x87, 0x30, 0x74, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF,
  0xEF, 0xFC, 0x0F, 0x03, 0xF8, 0xE7, 0xB8, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x7C, 0x1F, 0x80, 0x78, 0x07, 0x00, 0xEC, 0x1D, 0xC7, 0x3F, 0xE3, 0xF0,
  0x00, 0x60, 0x0E, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x6E, 0x0C, 0xC1, 0xCC,
  0x39, 0xC7, 0x1C, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80, 0x38,
  0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0x80, 0x38, 0x03, 0x00, 0x7F, 0x87, 0xFC,
  0x31, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x83, 0xE0,
  0x01, 0xC1, 0xE1, 0xF8, 0xF0, 0x38, 0x1C, 0x06, 0xF9, 0xFF, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0xE7, 0xF8, 0xF8, 0x7F, 0xF7, 0xFF, 0x7F,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x07, 0x83, 0xF8, 0xF7,
  0x9C, 0x73, 0x0E, 0x61, 0xCE, 0x70, 0xFC, 0x3F, 0x8E, 0x3B, 0x87, 0x70,
  0xEE, 0x1D, 0xC7, 0x1F, 0xE1, 0xF0, 0x1E, 0x0F, 0xC7, 0x3B, 0x86, 0xE1,
  0xF0, 0x7C, 0x1F, 0x86, 0xE7, 0x9F, 0xE3, 0xB8, 0x0C, 0x07, 0x07, 0x87,
  0xC3, 0xC0, 0x11, 0xDE, 0x70, 0x00, 0x00, 0x02, 0x3D, 0xEE, 0x00, 0x08,
  0x38, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0x83, 0x0E, 0x1C,
  0x70, 0xC0, 0x00, 0x40, 0xF0, 0xF9, 0xFC, 0xF8, 0x38, 0x0F, 0x80, 0xFC,
  0x0F, 0x00, 0xC0, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0xBF,
  0xF0, 0x40, 0x1C, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x70, 0xFD, 0xF8, 0xF8,
  0x30, 0x00, 0x1E, 0x3F, 0xBD, 0xFC, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x80, 0x3F, 0x03,
  0x0C, 0x30, 0x23, 0x3D, 0x93, 0x6D, 0xB3, 0x6D, 0x93, 0x48, 0x92, 0x4C,
  0xB2, 0x6C, 0x9F, 0xC4, 0x4C, 0x30, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xC0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x1D, 0x81, 0xCC, 0x0E,
  0x60, 0xE3, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0x38, 0x39, 0xC0, 0xDC, 0x07,
  0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x70, 0x73, 0x83, 0x9C, 0x18, 0xE1, 0xC7,
  0xFC, 0x3F, 0xE3, 0x83, 0x1C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0xF1, 0xFF,
  0x1F, 0xF0, 0x07, 0x81, 0xFC, 0x3D, 0xE7, 0x06, 0x70, 0x76, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0C, 0xE1, 0xCE, 0x3C, 0x7F,
  0x83, 0xF0, 0x1F, 0x01, 0xFC, 0x1F, 0xE3, 0x87, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x07, 0x30, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE6, 0x3C, 0x7F,
  0x8F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xFC, 0x3F, 0xE1, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xFF, 0x9F, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0xFC, 0x7F, 0xC6, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0x07, 0x81, 0xFC, 0x3D, 0xE3, 0x86, 0x70, 0x76,
  0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xEE, 0x7E, 0xE0, 0xEE, 0x0C, 0xE0, 0xC7,
  0x1C, 0x7F, 0xC3, 0xF0, 0x1C, 0x38, 0xC1, 0xC6, 0x0E, 0x70, 0x63, 0x83,
  0x1C, 0x38, 0xE1, 0xC7, 0xFE, 0x7F, 0xF3, 0x83, 0x1C, 0x18, 0xE1, 0xC7,
  0x0E, 0x30, 0x73, 0x83, 0x9C, 0x18, 0x1F, 0xE7, 0xFC, 0xFF, 0x83, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x3F, 0xE7, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xCE, 0x1C, 0xE1, 0xCE,
  0x38, 0x7F, 0x03, 0xE0, 0x1C, 0x1C, 0x70, 0xE1, 0x87, 0x0E, 0x3C, 0x39,
  0xE0, 0xEF, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xB8, 0x1C,
  0x70, 0x71, 0xC1, 0xC3, 0x86, 0x0E, 0x38, 0x3C, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0x1C, 0x38, 0xE3, 0xC7, 0x9E, 0x7D, 0xF3, 0xEF,
  0x9F, 0xF8, 0xDE, 0xC6, 0xF6, 0x37, 0x73, 0xBB, 0x9D, 0x98, 0xE0, 0xC6,
  0x06, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x78,
  0x63, 0xE7, 0x1F, 0x38, 0xF9, 0xC6, 0xCE, 0x73, 0x73, 0x9B, 0x1C, 0xF8,
  0xE7, 0xC7, 0x1E, 0x30, 0xF3, 0x87, 0x9C, 0x38, 0x07, 0x83, 0xF8, 0xF7,
  0xB8, 0x77, 0x06, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x6E, 0x1D, 0xC7, 0x1F, 0xE1, 0xF0, 0x3F, 0x03, 0xFC, 0x3F, 0xE3, 0x07,
  0x30, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x7F, 0xC7, 0xF8, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x81, 0xFC, 0x3D, 0xE3, 0x0E,
  0x70, 0x66, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xCE, 0x38, 0x7F, 0x83, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0x1F,
  0x80, 0xFF, 0x07, 0xFC, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x1E,
  0x3F, 0xE3, 0xFC, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0x83, 0x9C,
  0x1C, 0x07, 0x81, 0xFE, 0x3C, 0xE7, 0x07, 0x70, 0x77, 0x00, 0x38, 0x03,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xEC, 0x0E, 0xE0, 0xEE, 0x1C, 0x7F, 0xC3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x73, 0x07, 0x30, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE6,
  0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x83,
  0xE0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xC6, 0x1C, 0x63, 0x87,
  0x38, 0x77, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x63, 0x3B, 0x39, 0xD9, 0xCC, 0xCE, 0x66, 0x77, 0x37, 0xB9, 0xBD,
  0x8D, 0xEC, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x79, 0xC3,
  0x8E, 0x1C, 0x70, 0x1C, 0x0E, 0x38, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0x67,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3B, 0x00,
  0x77, 0x01, 0xCE, 0x07, 0x0E, 0x1E, 0x1C, 0x78, 0x3C, 0xE0, 0x7E, 0x0F,
  0x60, 0xE7, 0x1C, 0x71, 0xC3, 0x38, 0x37, 0x03, 0xF0, 0x3E, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xFF, 0x9F, 0xFC, 0x1F,
  0x1E, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xF8, 0xF0, 0xF0, 0xE7, 0x38, 0xC6,
  0x31, 0xCE, 0x71, 0x8C, 0x63, 0x9C, 0x63, 0x18, 0x1F, 0x1E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x38, 0xF0, 0xF0, 0xF0, 0x06, 0x07, 0x03, 0xC3, 0x61, 0xB1,
  0x98, 0xCC, 0xC3, 0xE1, 0x80, 0xFF, 0xFF, 0xF0, 0xE6, 0x30, 0x0F, 0x0F,
  0xE7, 0x9D, 0xC7, 0x01, 0xCF, 0xF7, 0xFF, 0x87, 0xE1, 0xB8, 0xEF, 0xF9,
  0xF6, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0xB8, 0x3F, 0xE3,
  0xCE, 0x38, 0x63, 0x07, 0x30, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x71, 0xC7,
  0xFC, 0xEF, 0x80, 0x0F, 0x07, 0xF0, 0xE7, 0x38, 0x66, 0x0D, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xCC, 0x71, 0xFE, 0x1F, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0xEE, 0x3F, 0xE7, 0x9E, 0x70, 0xEE, 0x0C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xC7, 0xF8, 0x3D, 0x80, 0x0F, 0x03,
  0xF0, 0xE7, 0x38, 0x66, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x31,
  0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x0F, 0x10, 0xE0, 0x1C, 0x0F, 0xFC,
  0xFF, 0xC1, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x00, 0x07, 0x31, 0xFF, 0x3C, 0xF3, 0x87, 0x70,
  0x77, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x9E, 0x3F, 0xE1, 0xEC, 0x01,
  0xC4, 0x1C, 0xFF, 0x87, 0xF0, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x9C, 0x3F, 0xE3, 0xCE, 0x38, 0x73, 0x07, 0x30, 0x67,
  0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xC0, 0x03, 0x80, 0xE0,
  0x30, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x8F, 0xFF, 0xFE, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x00, 0xFC,
  0x1F, 0x83, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xF8, 0x3E, 0x0F, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x3C, 0xE3, 0xC7, 0x38, 0x3B,
  0x81, 0xB8, 0x0F, 0xC0, 0xFE, 0x07, 0xB8, 0x39, 0xC1, 0xC7, 0x0C, 0x38,
  0xE0, 0xE0, 0x1F, 0x87, 0xE3, 0xF8, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0,
  0x36, 0x63, 0xFF, 0x77, 0xF7, 0x73, 0x67, 0x36, 0x77, 0x66, 0x7E, 0x67,
  0xE6, 0x6E, 0xE6, 0xCE, 0x6C, 0xEE, 0x39, 0xC3, 0xFE, 0x3C, 0xE3, 0x87,
  0x30, 0x73, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0C,
  0x0F, 0x07, 0xF1, 0xE7, 0x38, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE1,
  0xDC, 0x71, 0xFE, 0x1F, 0x00, 0x3B, 0x83, 0xFE, 0x3D, 0xE3, 0x86, 0x30,
  0x73, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x1C, 0x7F, 0xC6, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x67, 0xFD, 0xE7, 0xB8, 0x7E, 0x0D,
  0xC1, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x79, 0xFE, 0x1E, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x3B, 0xCD, 0xF3, 0xFD, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0x07, 0xF9, 0xE7, 0x38, 0x77,
  0x00, 0x7C, 0x07, 0xE0, 0x1E, 0xE1, 0xDC, 0x39, 0xFE, 0x1F, 0x80, 0x1C,
  0x07, 0x0F, 0xFF, 0xFF, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xE0, 0x3F, 0x07, 0xC0, 0x30, 0x6E, 0x1D, 0xC3, 0xB8, 0x77, 0x0E,
  0xC1, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x79, 0xFF, 0x1E, 0xC0, 0xC0, 0xFC,
  0x3B, 0x87, 0x71, 0xC6, 0x38, 0xC6, 0x19, 0xC3, 0xB0, 0x7E, 0x07, 0x80,
  0xE0, 0x1C, 0x00, 0xE6, 0x3E, 0x67, 0xE6, 0x7E, 0xE6, 0xEA, 0xED, 0xAC,
  0xDA, 0xCD, 0x2C, 0xF3, 0x8F, 0x38, 0xE3, 0x8E, 0x30, 0x38, 0x38, 0xC3,
  0x87, 0x38, 0x1B, 0x80, 0xFC, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1D, 0x81,
  0xCE, 0x1C, 0x31, 0xC1, 0xC0, 0x30, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x1C,
  0x18, 0xE0, 0x63, 0x81, 0xDC, 0x07, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x7F, 0xEF, 0xFE, 0x03, 0x83, 0x83, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x7C, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x31, 0x18,
  0xC6, 0x31, 0x88, 0xC6, 0x31, 0x80, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x0E, 0x03, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x1C, 0x0C, 0x00, 0x38, 0x07, 0xE3, 0xFF, 0x7C, 0x3E,
  0x01, 0xC0,
};

const GFXglyph RobotoMono_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 6, 13, 4, -17 },
  { 17, 13, 16, 13, 0, -16 },
  { 43, 12, 20, 13, 1, -18 },
  { 73, 11, 16, 13, 1, -16 },
  { 95, 13, 16, 13, 0, -16 },
  { 121, 3, 6, 13, 6, -17 },
  { 124, 8, 22, 13, 3, -17 },
  { 146, 7, 22, 13, 2, -17 },
  { 166, 10, 11, 13, 2, -16 },
  { 180, 11, 11, 13, 1, -13 },
  { 196, 5, 7, 13, 2, -3 },
  { 201, 9, 2, 13, 3, -8 },
  { 204, 4, 4, 13, 4, -4 },
  { 206, 11, 17, 13, 1, -16 },
  { 230, 11, 16, 13, 1, -16 },
  { 252, 7, 16, 13, 3, -16 },
  { 266, 12, 16, 13, 0, -16 },
  { 290, 11, 16, 13, 1, -16 },
  { 312, 12, 16, 13, 0, -16 },
  { 336, 12, 16, 13, 1, -16 },
  { 360, 10, 16, 13, 1, -16 },
  { 380, 12, 16, 13, 1, -16 },
  { 404, 11, 16, 13, 1, -16 },
  { 426, 10, 16, 13, 2, -16 },
  { 446, 5, 13, 13, 4, -13 },
  { 455, 7, 17, 13, 3, -13 },
  { 470, 10, 10, 13, 2, -12 },
  { 483, 11, 7, 13, 1, -10 },
  { 493, 10, 10, 13, 1, -12 },
  { 506, 9, 16, 13, 3, -16 },
  { 524, 13, 16, 13, 0, -16 },
  { 550, 13, 16, 13, -1, -16 },
  { 576, 13, 16, 13, 0, -16 },
  { 602, 12, 16, 13, 1, -16 },
  { 626, 12, 16, 13, 0, -16 },
  { 650, 13, 16, 13, 0, -16 },
  { 676, 12, 16, 13, 1, -16 },
  { 700, 12, 16, 13, 1, -16 },
  { 724, 13, 16, 13, 0, -16 },
  { 750, 11, 16, 13, 1, -16 },
  { 772, 12, 16, 13, 1, -16 },
  { 796, 14, 16, 13, 0, -16 },
  { 824, 10, 16, 13, 1, -16 },
  { 844, 13, 16, 13, 0, -16 },
  { 870, 13, 16, 13, 0, -16 },
  { 896, 11, 16, 13, 1, -16 },
  { 918, 12, 16, 13, 1, -16 },
  { 942, 12, 19, 13, 1, -16 },
  { 971, 13, 16, 13, 0, -16 },
  { 997, 12, 16, 13, 1, -16 },
  { 1021, 12, 16, 13, 2, -16 },
  { 1045, 12, 16, 13, 1, -16 },
  { 1069, 12, 16, 13, 2, -16 },
  { 1093, 13, 16, 13, 1, -16 },
  { 1119, 15, 16, 13, -1, -16 },
  { 1149, 12, 16, 13, 2, -16 },
  { 1173, 13, 16, 13, 0, -16 },
  { 1199, 8, 22, 13, 3, -18 },
  { 1221, 5, 17, 13, 4, -16 },
  { 1232, 8, 22, 13, 3, -18 },
  { 1254, 9, 9, 13, 2, -16 },
  { 1265, 10, 2, 13, 0, 0 },
  { 1268, 4, 3, 13, 6, -16 },
  { 1270, 10, 12, 13, 1, -12 },
  { 1285, 12, 17, 13, 0, -17 },
  { 1311, 11, 12, 13, 1, -12 },
  { 1328, 12, 17, 13, 1, -17 },
  { 1354, 11, 12, 13, 1, -12 },
  { 1371, 12, 17, 13, 2, -17 },
  { 1397, 12, 17, 13, 0, -12 },
  { 1423, 12, 17, 13, 0, -17 },
  { 1449, 10, 16, 13, 1, -16 },
  { 1469, 11, 21, 13, 0, -16 },
  { 1498, 13, 17, 13, 0, -17 },
  { 1526, 10, 17, 13, 1, -17 },
  { 1548, 12, 12, 13, 0, -12 },
  { 1566, 12, 12, 13, 0, -12 },
  { 1584, 11, 12, 13, 1, -12 },
  { 1601, 12, 16, 13, 0, -12 },
  { 1625, 11, 16, 13, 1, -12 },
  { 1647, 10, 12, 13, 2, -12 },
  { 1662, 11, 12, 13, 1, -12 },
  { 1679, 10, 14, 13, 2, -14 },
  { 1697, 11, 12, 13, 1, -12 },
  { 1714, 11, 12, 13, 2, -12 },
  { 1731, 12, 12, 13, 1, -12 },
  { 1749, 13, 12, 13, 0, -12 },
  { 1769, 14, 17, 13, 0, -12 },
  { 1799, 12, 12, 13, 0, -12 },
  { 1817, 9, 21, 13, 3, -17 },
  { 1841, 5, 20, 13, 4, -16 },
  { 1854, 9, 21, 13, 2, -17 },
  { 1878, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_SEMIBOLDITALIC22PT7B_H_
