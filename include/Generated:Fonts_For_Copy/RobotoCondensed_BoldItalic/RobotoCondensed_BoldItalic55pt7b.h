#ifndef _ROBOTOCONDENSED_BOLDITALIC55PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x04, 0x00, 0x3F,
  0x1F, 0x3F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x78, 0x7C, 0x78,
  0x7C, 0xF8, 0x78, 0xF8, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x03, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x1F, 0x01,
  0x0F, 0xC7, 0xC0, 0xF3, 0xE0, 0xF0, 0x7C, 0xF8, 0x3C, 0x1F, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF3, 0xE0, 0xF8, 0x7C, 0xF8, 0x3E,
  0x3E, 0x7C, 0x0F, 0xFF, 0xBE, 0x01, 0xFF, 0xCF, 0x80, 0x3F, 0xE7, 0xC0,
  0x07, 0xF3, 0xE0, 0x00, 0x20, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE7, 0xF8, 0x00,
  0xFB, 0xFF, 0x00, 0x7D, 0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x1F, 0x3F, 0x3E,
  0x07, 0xCF, 0x87, 0x83, 0xE7, 0xC1, 0xF1, 0xF1, 0xF0, 0x7C, 0x7C, 0x7C,
  0x1E, 0x3E, 0x1F, 0x0F, 0x9F, 0x07, 0xC3, 0xE7, 0xC1, 0xF0, 0xF8, 0xE0,
  0x7E, 0x7E, 0x10, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0xC7, 0xFF, 0xE1,
  0xF8, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xCF, 0xEF, 0xF3, 0xF9, 0xF9, 0xFC,
  0x7F, 0xBF, 0x7F, 0x87, 0xFF, 0xEF, 0xF0, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF,
  0x3F, 0xC1, 0xFF, 0xE7, 0xF8, 0x1F, 0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xE0, 0x3F, 0xF1, 0xFE, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x08,
  0x0F, 0x81, 0x3C, 0x1E, 0x0E, 0x7E, 0x3C, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x3E,
  0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0xF8, 0x07, 0x01, 0xC0,
  0x04, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x00,
  0x80, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0,
  0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x3F,
  0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0xFF,
  0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0x7F, 0x3E,
  0x7F, 0x98, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xEF, 0xF0, 0x03, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x7F,
  0x80, 0x30, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F,
  0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xEF,
  0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x83, 0xFC, 0x7F,
  0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF9, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE,
  0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0x7E, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x07, 0xE0, 0x1E, 0x07, 0xC0, 0x7F, 0xE0, 0x78, 0x1F, 0x03, 0xFF, 0xE1,
  0xF0, 0xF8, 0x1F, 0xFF, 0x87, 0xC3, 0xE0, 0xFF, 0xFE, 0x1F, 0x1F, 0x03,
  0xF0, 0xF8, 0x3C, 0x7C, 0x1F, 0x87, 0xC0, 0xF3, 0xE0, 0xFC, 0x1F, 0x07,
  0xCF, 0x83, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x81, 0xF0, 0x7D, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF7, 0xC1, 0xF0, 0x3E, 0x07, 0xDF, 0x07, 0xC0, 0xF8, 0x1E,
  0x7C, 0x3F, 0x03, 0xE0, 0x7B, 0xF0, 0xFC, 0x1F, 0x81, 0xEF, 0x83, 0xF0,
  0x7C, 0x0F, 0xBE, 0x0F, 0x81, 0xF0, 0x3E, 0xF8, 0x3E, 0x07, 0xC0, 0xF3,
  0xE0, 0xF8, 0x3F, 0x03, 0xCF, 0x83, 0xE0, 0xF8, 0x1F, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0xF8, 0x3E, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0xFF, 0x1F, 0x0F,
  0x83, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xFD, 0xFF, 0xE0, 0xF8, 0x1F, 0xF3,
  0xFF, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x07, 0xC0, 0x10, 0x06, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE, 0x7E,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x01, 0xFF,
  0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x8F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xE7,
  0xF8, 0x3F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x8F, 0xE0,
  0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFF,
  0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xC0,
  0x03, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFB, 0xF8, 0x1F, 0xDF,
  0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x07, 0xF3, 0xE0, 0x7E,
  0xFE, 0x03, 0xF9, 0xF0, 0x7F, 0x7F, 0x01, 0xFC, 0xF8, 0x3F, 0x3F, 0x81,
  0xFE, 0x7E, 0x3F, 0xBF, 0xC0, 0xFF, 0x3F, 0x1F, 0x9F, 0xE0, 0x7F, 0x9F,
  0x8F, 0xCF, 0xE0, 0x3F, 0x8F, 0xCF, 0xC7, 0xF0, 0x1F, 0xC7, 0xE7, 0xE3,
  0xF8, 0x0F, 0xE3, 0xF7, 0xE3, 0xFC, 0x0F, 0xF0, 0xFB, 0xF1, 0xFE, 0x07,
  0xF8, 0x7F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xF8, 0x7F, 0x01, 0xFE, 0x1F,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xFE, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x1F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xC0, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x01, 0xFD, 0xF0, 0x3F,
  0x80, 0x7F, 0x7C, 0x1F, 0xE0, 0x3F, 0xDF, 0x87, 0xF8, 0x0F, 0xF7, 0xE1,
  0xFE, 0x03, 0xFC, 0xF8, 0x7F, 0x80, 0xFF, 0x3E, 0x1F, 0xC0, 0x3F, 0x8F,
  0xC7, 0xF0, 0x1F, 0xE3, 0xF3, 0xFC, 0x07, 0xF8, 0x7C, 0xFF, 0x01, 0xFE,
  0x1F, 0xBF, 0xC0, 0x7F, 0x87, 0xEF, 0xF0, 0x1F, 0xC1, 0xFB, 0xF8, 0x07,
  0xF0, 0x3E, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1B, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x9F,
  0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0x1F,
  0xEF, 0xE0, 0x3F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x01, 0xFC, 0xFE, 0x03,
  0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xFF, 0x0F, 0xF0,
  0xFE, 0x1F, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFF,
  0xC7, 0xF8, 0x3F, 0x8F, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xFC, 0x7F, 0x03,
  0xF9, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xEF, 0xCF, 0xE0, 0x3F, 0x9F, 0xBF,
  0x3F, 0x80, 0xFE, 0xFE, 0xFC, 0xFE, 0x03, 0xFB, 0xF3, 0xF7, 0xF0, 0x0F,
  0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xFF, 0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x7F,
  0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x07, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0x83, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xF3, 0xC0,
  0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x3E, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x87, 0xF8,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x81, 0xFE, 0x7F, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFE,
  0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xC1, 0xFC, 0xFF,
  0xC0, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01,
  0xF9, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8,
  0x0F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x18, 0x3F, 0xC0, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x1F, 0xFD, 0xFC, 0x0F, 0xFF, 0x7F, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01,
  0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x00,
  0x04, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0C, 0x03, 0xFC,
  0x07, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x40,
  0x07, 0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF,
  0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFC,
  0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x3F, 0xE0,
  0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0xC0, 0x3F, 0x9F,
  0xF0, 0x07, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xF0,
  0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0xC0, 0xFE,
  0x3F, 0xC1, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x81, 0xFC,
  0x7F, 0x03, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE,
  0x07, 0xF9, 0xFE, 0x07, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81,
  0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00,
  0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x80,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0x80, 0x7F, 0x1F, 0xE0,
  0x0F, 0xE0, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0xCF, 0xE0,
  0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xC3, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07,
  0xF9, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC,
  0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80,
  0x04, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0xFE, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x30, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x08, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE,
  0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xE0,
  0x7F, 0xFE, 0x07, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0,
  0xFE, 0xFE, 0x0F, 0xE1, 0xFE, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE1,
  0xFC, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x3F, 0xE3,
  0xF8, 0x7E, 0x7F, 0xE3, 0xF0, 0x7E, 0x7F, 0xE7, 0xF0, 0x7E, 0xFF, 0xE7,
  0xF0, 0x7E, 0xFF, 0xE7, 0xE0, 0x7E, 0xFB, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF9,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xEF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF1,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xF1, 0xFF, 0xC0, 0xFC, 0xFF, 0xF0,
  0x3E, 0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0xEF, 0xE7, 0xF7, 0xFF, 0xF1, 0xF8,
  0x7F, 0xFC, 0xFC, 0x1F, 0xFE, 0x3F, 0x03, 0xFF, 0x8F, 0x80, 0x7F, 0xC0,
  0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_BoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 16, 15, 17, 3, -41 },
  { 101, 27, 39, 28, 1, -39 },
  { 233, 24, 52, 27, 2, -46 },
  { 389, 26, 41, 34, 5, -40 },
  { 523, 27, 41, 31, 1, -40 },
  { 662, 8, 15, 9, 3, -41 },
  { 677, 16, 56, 17, 3, -44 },
  { 789, 17, 55, 17, -2, -43 },
  { 906, 23, 24, 24, 3, -39 },
  { 975, 24, 28, 25, 1, -32 },
  { 1059, 11, 16, 13, -3, -7 },
  { 1081, 14, 6, 19, 3, -20 },
  { 1092, 9, 9, 16, 1, -8 },
  { 1103, 25, 42, 18, -4, -39 },
  { 1235, 24, 41, 27, 2, -40 },
  { 1358, 17, 39, 27, 6, -39 },
  { 1441, 26, 40, 27, 0, -40 },
  { 1571, 25, 41, 27, 1, -40 },
  { 1700, 25, 39, 27, 1, -39 },
  { 1822, 25, 40, 27, 2, -39 },
  { 1947, 23, 40, 27, 2, -39 },
  { 2062, 26, 39, 27, 2, -39 },
  { 2189, 25, 41, 27, 1, -40 },
  { 2318, 22, 40, 27, 4, -40 },
  { 2428, 13, 31, 15, 1, -30 },
  { 2479, 16, 39, 14, -3, -30 },
  { 2557, 22, 26, 24, 1, -30 },
  { 2629, 23, 17, 27, 2, -26 },
  { 2678, 22, 25, 24, 1, -29 },
  { 2747, 20, 41, 24, 4, -40 },
  { 2850, 38, 50, 41, 1, -38 },
  { 3088, 30, 39, 32, -2, -39 },
  { 3235, 29, 39, 30, 0, -39 },
  { 3377, 29, 41, 30, 2, -40 },
  { 3526, 29, 39, 30, 0, -39 },
  { 3668, 29, 39, 26, 0, -39 },
  { 3810, 28, 39, 25, 0, -39 },
  { 3947, 29, 41, 31, 2, -40 },
  { 4096, 34, 39, 33, 0, -39 },
  { 4262, 14, 39, 14, 1, -39 },
  { 4331, 27, 40, 26, 0, -39 },
  { 4466, 34, 39, 30, 0, -39 },
  { 4632, 23, 39, 26, 0, -39 },
  { 4745, 41, 39, 40, 0, -39 },
  { 4945, 34, 39, 33, 0, -39 },
  { 5111, 29, 41, 32, 2, -40 },
  { 5260, 30, 39, 30, 0, -39 },
  { 5407, 29, 47, 32, 2, -40 },
  { 5578, 30, 39, 30, 0, -39 },
  { 5725, 28, 41, 29, 1, -40 },
  { 5869, 28, 39, 29, 4, -39 },
  { 6006, 30, 40, 30, 2, -39 },
  { 6156, 30, 39, 31, 4, -39 },
  { 6303, 38, 39, 40, 5, -39 },
  { 6489, 35, 39, 30, -2, -39 },
  { 6660, 28, 39, 29, 5, -39 },
  { 6797, 31, 39, 28, -1, -39 },
  { 6949, 19, 55, 14, -1, -46 },
  { 7080, 14, 42, 20, 4, -39 },
  { 7154, 19, 55, 14, -3, -46 },
  { 7285, 18, 20, 21, 2, -39 },
  { 7330, 21, 6, 21, -3, 0 },
  { 7346, 12, 8, 18, 5, -41 },
  { 7358, 23, 31, 25, 0, -30 },
  { 7448, 25, 42, 26, 0, -41 },
  { 7580, 23, 31, 25, 1, -30 },
  { 7670, 27, 42, 26, 1, -41 },
  { 7812, 23, 31, 26, 1, -30 },
  { 7902, 19, 42, 17, 2, -42 },
  { 8002, 26, 41, 27, 0, -30 },
  { 8136, 24, 41, 26, 0, -41 },
  { 8259, 14, 40, 13, 0, -40 },
  { 8329, 20, 51, 13, -6, -40 },
  { 8457, 27, 41, 26, 0, -41 },
  { 8596, 15, 41, 13, 0, -41 },
  { 8673, 37, 30, 40, 0, -30 },
  { 8812, 24, 30, 26, 0, -30 },
  { 8902, 24, 31, 27, 1, -30 },
  { 8995, 27, 41, 26, -2, -30 },
  { 9134, 25, 41, 27, 1, -30 },
  { 9263, 19, 30, 18, 0, -30 },
  { 9335, 23, 31, 24, 0, -30 },
  { 9425, 15, 37, 16, 2, -36 },
  { 9495, 25, 30, 26, 1, -29 },
  { 9589, 22, 29, 24, 3, -29 },
  { 9669, 32, 29, 34, 3, -29 },
  { 9785, 27, 29, 24, -2, -29 },
  { 9883, 27, 40, 24, -1, -29 },
  { 10018, 25, 29, 24, -1, -29 },
  { 10109, 17, 53, 16, 1, -43 },
  { 10222, 12, 46, 14, 1, -39 },
  { 10291, 17, 53, 16, -2, -43 },
  { 10404, 26, 12, 30, 2, -22 },
};

const GFXfont RobotoCondensed_BoldItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_BOLDITALIC55PT7B_H_
