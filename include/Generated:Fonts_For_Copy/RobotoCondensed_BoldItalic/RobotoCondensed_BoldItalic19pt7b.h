#ifndef _ROBOTOCONDENSED_BOLDITALIC19PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x73, 0x00, 0xCE, 0x30, 0x6D, 0xA5,
  0xB6, 0xD8, 0x06, 0x81, 0x60, 0xD8, 0x34, 0x3F, 0xCF, 0xF1, 0xA0, 0x48,
  0x7F, 0x3F, 0xC2, 0x40, 0xB0, 0x6C, 0x1A, 0x00, 0x04, 0x04, 0x1E, 0x3F,
  0x77, 0x63, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xC6, 0xCE, 0xFC, 0x78,
  0x20, 0x20, 0x70, 0x7C, 0x26, 0xD3, 0x4F, 0x67, 0xE0, 0x20, 0x30, 0x37,
  0x17, 0x9A, 0x79, 0x20, 0xF0, 0x70, 0x0E, 0x07, 0xC1, 0xB0, 0xCC, 0x3B,
  0x07, 0x81, 0xC0, 0xF3, 0x7F, 0xFB, 0xEE, 0x7B, 0x9C, 0x7F, 0x8F, 0xE0,
  0x6D, 0x6C, 0x08, 0x71, 0x8C, 0x71, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x82, 0x00, 0x10, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC7, 0x18, 0x63, 0x8C, 0x63, 0x88, 0x00, 0x08, 0x08, 0x5B, 0xFF,
  0x18, 0x38, 0x6C, 0x44, 0x18, 0x18, 0x18, 0x18, 0xFE, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x37, 0x66, 0xEC, 0xFF, 0x80, 0x7D, 0x80, 0x03, 0x03, 0x06,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0,
  0x1E, 0x3E, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0xE7, 0xC6, 0xC6, 0xC6, 0xCE,
  0xFC, 0x78, 0x0C, 0xFF, 0xB6, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x71,
  0xC0, 0x0F, 0x1F, 0x8C, 0xEE, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E,
  0x0E, 0x0E, 0x0F, 0xF7, 0xF8, 0x0E, 0x1F, 0x8E, 0xE6, 0x70, 0x38, 0x18,
  0x7C, 0x3C, 0x07, 0x01, 0xB8, 0xDC, 0xE7, 0xE1, 0xE0, 0x03, 0x83, 0xC1,
  0xE1, 0xE1, 0xB0, 0xF8, 0xDC, 0x6E, 0x67, 0x7F, 0xFF, 0xC1, 0xC0, 0xE0,
  0x70, 0x3F, 0x3F, 0x70, 0x60, 0x60, 0x7C, 0xFE, 0x66, 0x06, 0x06, 0xC6,
  0xCE, 0xFC, 0x78, 0x0E, 0x1E, 0x38, 0x70, 0x60, 0xFC, 0xFE, 0xE6, 0xC7,
  0xC6, 0xC6, 0xEE, 0x7C, 0x78, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00, 0x0F, 0x0F, 0xCE,
  0xE6, 0x73, 0x39, 0xD8, 0x7C, 0x7C, 0x77, 0x31, 0x99, 0xCC, 0xE7, 0xE1,
  0xE0, 0x1C, 0x3E, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0x7E, 0x7E, 0x0E, 0x0C,
  0x3C, 0x78, 0x60, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x67, 0x18, 0x18, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x1C, 0x61, 0x84, 0x00, 0x01, 0x07,
  0x1E, 0x7C, 0x60, 0xF8, 0x3E, 0x0E, 0x04, 0x7F, 0x7E, 0x00, 0x00, 0xFE,
  0xFE, 0x20, 0x38, 0x3C, 0x0F, 0x07, 0x1F, 0x7C, 0x70, 0x80, 0x3C, 0xFD,
  0x9F, 0x30, 0xE1, 0xC7, 0x1C, 0x30, 0x60, 0x03, 0x07, 0x0C, 0x00, 0x03,
  0xE0, 0x7F, 0x87, 0x06, 0x30, 0x13, 0x3C, 0xB3, 0xE5, 0x9B, 0x2D, 0x99,
  0x4C, 0xCE, 0x64, 0xF3, 0x67, 0x9F, 0x6C, 0xEE, 0x20, 0x01, 0x80, 0x07,
  0xE0, 0x1F, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x7C, 0x1F, 0x83,
  0x30, 0xE6, 0x18, 0xC7, 0xF8, 0xFF, 0x38, 0x67, 0x0F, 0xC1, 0xC0, 0x3F,
  0x0F, 0xF3, 0x9C, 0xC7, 0x31, 0xCC, 0x77, 0xF9, 0xFC, 0x73, 0x98, 0x66,
  0x39, 0x8E, 0xFF, 0x3F, 0x80, 0x1F, 0x0F, 0xE7, 0x39, 0x86, 0xE1, 0xF8,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0xEC, 0x33, 0x9C, 0x7E, 0x0F, 0x00, 0x3F,
  0x0F, 0xE3, 0x9C, 0xC7, 0x31, 0xCC, 0x77, 0x1D, 0xC7, 0x71, 0xD8, 0x66,
  0x39, 0x9C, 0xFF, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0xF1, 0xFC, 0x70, 0x18, 0x06, 0x01, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xE3, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0xF1, 0xFC, 0x70, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0xC7, 0x60, 0x38,
  0x0E, 0x03, 0x9E, 0xEF, 0xB0, 0xEE, 0x3B, 0x9E, 0x7F, 0x0F, 0x80, 0x38,
  0x73, 0x86, 0x38, 0x63, 0x0E, 0x30, 0xE3, 0x0E, 0x7F, 0xE7, 0xFC, 0x70,
  0xC6, 0x1C, 0x61, 0xC6, 0x1C, 0xE1, 0xCE, 0x18, 0x39, 0xCE, 0x73, 0x19,
  0xCE, 0x73, 0x98, 0xCE, 0x70, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0xB9, 0xDD, 0xC7, 0xE1, 0xC0, 0x38, 0xE3, 0x9C,
  0x39, 0xC3, 0x38, 0x37, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0x67, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xFF, 0xFE, 0x3C, 0x1C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x1F, 0x3C, 0x7C, 0xF1, 0xE7, 0xCD, 0x9F, 0x3E, 0x77, 0xB9,
  0x9E, 0xE6, 0x73, 0x99, 0xCC, 0xE7, 0x33, 0x99, 0xC0, 0x38, 0x73, 0x86,
  0x3C, 0x63, 0xCE, 0x3C, 0xE3, 0x4E, 0x76, 0xE7, 0x6C, 0x76, 0xC7, 0x3C,
  0x63, 0xC6, 0x3C, 0xE3, 0xCE, 0x18, 0x1F, 0x0F, 0xE7, 0x39, 0xC7, 0x61,
  0xF8, 0x7E, 0x1F, 0x86, 0xC1, 0xB0, 0xEE, 0x3B, 0x9C, 0x7E, 0x0F, 0x00,
  0x3F, 0x8F, 0xF3, 0x9C, 0xC3, 0x30, 0xCC, 0x77, 0x1D, 0xFE, 0x7F, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x0F, 0xE7, 0x39, 0xC7, 0x61,
  0xF8, 0x7E, 0x1F, 0x86, 0xC1, 0xB0, 0xEE, 0x3B, 0x9C, 0x7E, 0x0F, 0x80,
  0x70, 0x08, 0x3F, 0x0F, 0xF3, 0x9C, 0xC7, 0x31, 0xCC, 0x77, 0x39, 0xFE,
  0x7F, 0x19, 0xC6, 0x71, 0x8C, 0xE3, 0xB8, 0xE0, 0x0F, 0x07, 0xE3, 0x9C,
  0xC7, 0x30, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0xEE, 0x39, 0xCE, 0x7F,
  0x0F, 0x80, 0x7F, 0xDF, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x71, 0xDC, 0x77, 0x1D,
  0x86, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB0, 0xCC, 0x33, 0x9C, 0xFE,
  0x1F, 0x00, 0x60, 0xEC, 0x39, 0x87, 0x39, 0xC7, 0x38, 0xE6, 0x1D, 0xC3,
  0xB8, 0x76, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x00, 0xC6, 0x3E,
  0x31, 0xB3, 0x9D, 0x9C, 0xEC, 0xE6, 0x6F, 0x73, 0x7B, 0x9B, 0xD8, 0xF6,
  0xC7, 0xBE, 0x3D, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0x80, 0x1C, 0x71, 0xCE,
  0x1C, 0xE0, 0xDC, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xF8,
  0x3B, 0x83, 0x98, 0x71, 0xC7, 0x1C, 0xC3, 0xF1, 0xB9, 0xDC, 0xC6, 0xE3,
  0x61, 0xF0, 0xF0, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x00, 0x3F, 0xCF,
  0xF0, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01,
  0x80, 0xFF, 0x3F, 0xC0, 0x1C, 0xF3, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0xC7,
  0x18, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0xCC, 0xCC, 0xEE, 0xE6, 0x66,
  0x67, 0x77, 0x70, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8E,
  0x30, 0xC3, 0x1C, 0x73, 0xCF, 0x00, 0x18, 0xE3, 0x9A, 0x6F, 0x3C, 0xC0,
  0xFF, 0xFC, 0xE6, 0x30, 0x1E, 0x3F, 0x77, 0x07, 0x3F, 0x7F, 0xE6, 0xE6,
  0xFE, 0x76, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0xF3, 0xF9, 0xCC, 0xE7, 0x63,
  0x31, 0x98, 0xDC, 0xEF, 0xE6, 0xE0, 0x1E, 0x3F, 0x73, 0x63, 0x60, 0xE0,
  0xE6, 0x66, 0x7E, 0x3C, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x3F, 0x8F, 0xE7,
  0x39, 0x8C, 0x63, 0x39, 0xCE, 0x73, 0x9C, 0x7E, 0x1F, 0x80, 0x1E, 0x3F,
  0x73, 0x63, 0x7F, 0x7F, 0x60, 0x62, 0x7E, 0x3C, 0x1C, 0xF3, 0x9C, 0xFB,
  0xE6, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x00, 0x1D, 0x9F, 0xDC, 0xEC, 0x76,
  0x37, 0x1B, 0x9C, 0xCE, 0x7F, 0x1F, 0x01, 0x89, 0xCF, 0xC3, 0xC0, 0x38,
  0x38, 0x30, 0x30, 0x3E, 0x7F, 0x73, 0x73, 0x63, 0x67, 0x67, 0xE7, 0xE6,
  0xE6, 0x11, 0xCE, 0x03, 0x19, 0xCE, 0x73, 0x18, 0xCE, 0x70, 0x04, 0x1C,
  0x38, 0x00, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18,
  0xF1, 0xC0, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x3B, 0xB9, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1F, 0x9D, 0xCE, 0x67, 0x38, 0x39, 0xCE, 0x63, 0x19, 0xCE, 0x73,
  0x18, 0xCE, 0x70, 0x3F, 0x73, 0xFF, 0xDC, 0xEE, 0xE6, 0x76, 0x33, 0xB3,
  0x9D, 0x9C, 0xDC, 0xE6, 0xE6, 0x77, 0x33, 0x80, 0x3F, 0x7F, 0x73, 0x73,
  0x63, 0x67, 0x67, 0xE7, 0xE6, 0xE6, 0x1E, 0x1F, 0x9C, 0xCC, 0x66, 0x37,
  0x1B, 0x8C, 0xCE, 0x7E, 0x1E, 0x00, 0x1F, 0x8F, 0xE3, 0x98, 0xE7, 0x31,
  0x8C, 0x63, 0x19, 0xCE, 0x7F, 0x1F, 0x86, 0x01, 0x80, 0x60, 0x38, 0x00,
  0x3D, 0x9F, 0xDC, 0xEC, 0x66, 0x37, 0x3B, 0x9D, 0xCE, 0x7F, 0x3F, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x3D, 0xF7, 0xDC, 0x61, 0x86, 0x38, 0xE3, 0x80,
  0x1E, 0x3F, 0x77, 0x70, 0x3C, 0x1E, 0x06, 0xE6, 0x7E, 0x3C, 0x73, 0x9D,
  0xFF, 0xB3, 0x9C, 0xE7, 0x31, 0xE6, 0x00, 0x33, 0xB9, 0xDC, 0xEE, 0x66,
  0x33, 0x39, 0x9C, 0xCE, 0x7E, 0x3F, 0x00, 0xE7, 0xE6, 0xEE, 0xEC, 0xFC,
  0x78, 0x78, 0x78, 0x70, 0x70, 0xCE, 0x79, 0xDF, 0x3B, 0x6F, 0x6D, 0xF9,
  0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE0, 0x39, 0x86, 0xE1, 0xB0, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x77, 0x19, 0xC0, 0x73, 0xBB, 0x9D, 0xCE,
  0xC7, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x00,
  0x3F, 0x7F, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xFE, 0xFE, 0x04, 0x31,
  0x86, 0x38, 0xE3, 0x0C, 0x63, 0x86, 0x1C, 0x61, 0x86, 0x18, 0x30, 0xC0,
  0x11, 0x33, 0x33, 0x22, 0x26, 0x66, 0x64, 0x44, 0xC0, 0x10, 0x61, 0x87,
  0x18, 0x61, 0x86, 0x0C, 0x73, 0x8C, 0x30, 0xC3, 0x1C, 0xE1, 0x00, 0x71,
  0xFD, 0xB7, 0xD9, 0xC0,
};

const GFXglyph RobotoCondensed_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 6, 1, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 8, 18, 9, 1, -16 },
  { 50, 9, 14, 12, 2, -14 },
  { 66, 10, 14, 11, 0, -14 },
  { 84, 3, 5, 3, 1, -14 },
  { 86, 6, 19, 6, 1, -15 },
  { 101, 6, 19, 6, -1, -15 },
  { 116, 8, 8, 8, 1, -14 },
  { 124, 8, 10, 9, 1, -11 },
  { 134, 4, 6, 5, -1, -2 },
  { 137, 5, 2, 7, 1, -7 },
  { 139, 3, 3, 5, 0, -3 },
  { 141, 8, 15, 6, -1, -14 },
  { 156, 8, 14, 9, 1, -14 },
  { 170, 6, 14, 9, 2, -14 },
  { 181, 9, 14, 9, 0, -14 },
  { 197, 9, 14, 9, 0, -14 },
  { 213, 9, 14, 9, 0, -14 },
  { 229, 8, 14, 9, 1, -14 },
  { 243, 8, 14, 9, 1, -14 },
  { 257, 9, 14, 9, 1, -14 },
  { 273, 9, 14, 9, 0, -14 },
  { 289, 8, 14, 9, 1, -14 },
  { 303, 5, 11, 5, 0, -11 },
  { 310, 6, 15, 5, -1, -11 },
  { 322, 8, 9, 8, 0, -10 },
  { 331, 8, 6, 9, 1, -9 },
  { 337, 8, 9, 8, 0, -10 },
  { 346, 7, 14, 8, 1, -14 },
  { 359, 13, 17, 14, 0, -13 },
  { 387, 11, 14, 11, -1, -14 },
  { 407, 10, 14, 10, 0, -14 },
  { 425, 10, 14, 11, 1, -14 },
  { 443, 10, 14, 10, 0, -14 },
  { 461, 10, 14, 9, 0, -14 },
  { 479, 10, 14, 9, 0, -14 },
  { 497, 10, 14, 11, 1, -14 },
  { 515, 12, 14, 11, 0, -14 },
  { 536, 5, 14, 5, 0, -14 },
  { 545, 9, 14, 9, 0, -14 },
  { 561, 12, 14, 10, 0, -14 },
  { 582, 8, 14, 9, 0, -14 },
  { 596, 14, 14, 14, 0, -14 },
  { 621, 12, 14, 11, 0, -14 },
  { 642, 10, 14, 11, 1, -14 },
  { 660, 10, 14, 10, 0, -14 },
  { 678, 10, 16, 11, 1, -14 },
  { 698, 10, 14, 10, 0, -14 },
  { 716, 10, 14, 10, 0, -14 },
  { 734, 10, 14, 10, 1, -14 },
  { 752, 10, 14, 11, 1, -14 },
  { 770, 11, 14, 11, 1, -14 },
  { 790, 13, 14, 14, 2, -14 },
  { 813, 12, 14, 10, -1, -14 },
  { 834, 9, 14, 10, 2, -14 },
  { 850, 10, 14, 10, 0, -14 },
  { 868, 6, 19, 5, 0, -16 },
  { 883, 4, 15, 7, 2, -14 },
  { 891, 6, 19, 5, -1, -16 },
  { 906, 6, 7, 7, 1, -14 },
  { 912, 7, 2, 7, -1, 0 },
  { 914, 4, 3, 6, 2, -14 },
  { 916, 8, 10, 9, 0, -10 },
  { 926, 9, 14, 9, 0, -14 },
  { 942, 8, 10, 8, 0, -10 },
  { 952, 10, 14, 9, 0, -14 },
  { 970, 8, 10, 9, 0, -10 },
  { 980, 6, 14, 6, 1, -14 },
  { 991, 9, 14, 9, 0, -10 },
  { 1007, 8, 14, 9, 0, -14 },
  { 1021, 5, 14, 5, 0, -14 },
  { 1030, 7, 18, 5, -2, -14 },
  { 1046, 9, 14, 9, 0, -14 },
  { 1062, 5, 14, 5, 0, -14 },
  { 1071, 13, 10, 14, 0, -10 },
  { 1088, 8, 10, 9, 0, -10 },
  { 1098, 9, 10, 9, 0, -10 },
  { 1110, 10, 14, 9, -1, -10 },
  { 1128, 9, 14, 9, 0, -10 },
  { 1144, 6, 10, 6, 0, -10 },
  { 1152, 8, 10, 8, 0, -10 },
  { 1162, 5, 13, 6, 1, -13 },
  { 1171, 9, 10, 9, 0, -10 },
  { 1183, 8, 10, 8, 1, -10 },
  { 1193, 11, 10, 12, 1, -10 },
  { 1207, 10, 10, 8, -1, -10 },
  { 1220, 9, 14, 8, 0, -10 },
  { 1236, 8, 10, 8, 0, -10 },
  { 1246, 6, 18, 6, 0, -15 },
  { 1260, 4, 17, 5, 0, -14 },
  { 1269, 6, 18, 6, -1, -15 },
  { 1283, 9, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_BOLDITALIC19PT7B_H_
