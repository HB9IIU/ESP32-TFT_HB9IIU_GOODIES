#ifndef _ROBOTOCONDENSED_BOLDITALIC35PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xC3, 0xE1, 0xE0, 0x70, 0x00, 0x79, 0xDE, 0x77, 0x9D, 0xCF, 0x73,
  0x9C, 0xEF, 0x3B, 0x8E, 0xE3, 0x00, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x3F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC1, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0x80,
  0x39, 0xC1, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x38, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x1E, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0E, 0x70,
  0xCF, 0x38, 0xF7, 0x1C, 0x73, 0x8E, 0x71, 0xC7, 0x70, 0xE7, 0xB8, 0x3F,
  0xB8, 0x1F, 0xF8, 0x07, 0xBC, 0x00, 0x1C, 0x00, 0x1D, 0xE0, 0x1D, 0xF8,
  0x0F, 0xFE, 0x0E, 0xE7, 0x0E, 0xF3, 0x8F, 0x71, 0xC7, 0x38, 0xE7, 0x1C,
  0x73, 0x8F, 0x38, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xF3, 0xE0, 0xF8, 0xF0, 0x78,
  0xF0, 0x3C, 0x78, 0x1F, 0x7C, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x79, 0xFE, 0x3D, 0xFF, 0xBF, 0xF7, 0xDE, 0xF9, 0xFF, 0x7C, 0xFF,
  0xBC, 0x3F, 0x9F, 0x1F, 0xCF, 0x87, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xBE, 0x1F, 0x9F, 0x00, 0x7B, 0xDE, 0xE7, 0x3B, 0xDE, 0xE0, 0x00, 0x40,
  0x70, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0x80, 0x20, 0x02, 0x00, 0x60, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xC0, 0x20, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x63, 0x8F, 0xEE, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F,
  0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x78, 0x78, 0xE1, 0xC3, 0x82, 0x04, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x3C,
  0x78, 0xF3, 0xC7, 0x9F, 0x3C, 0xF0, 0x40, 0xFF, 0x7F, 0xBF, 0xDF, 0xE0,
  0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E,
  0xF8, 0x3D, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x0F, 0xBC,
  0x1E, 0xF8, 0x3D, 0xF0, 0xFB, 0xE1, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEE, 0x7A, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF1,
  0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xF9, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1E, 0x0F,
  0x8F, 0x07, 0xC7, 0xC7, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBE, 0x07, 0xBE,
  0x0F, 0x3E, 0x1F, 0x3C, 0x1E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3D, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x1C, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xCF, 0x87, 0xDE, 0x0F, 0xBC, 0x1F,
  0xF8, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xCF, 0x8F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x1E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7C, 0x78, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3E, 0x7D, 0xF0, 0xF7,
  0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0xFD,
  0xFF, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x0F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x1E, 0x3E, 0x3F,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xF8, 0xF8, 0xF8, 0x70, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xCF, 0xFC,
  0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x80, 0x3E, 0x00, 0x38, 0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFF, 0xE7, 0xFF, 0xC0, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xF8, 0x0F, 0xE0, 0xFF,
  0x9F, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xF9, 0xE1, 0xEF, 0x8F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1C, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x1F, 0x06, 0x1C, 0x3F, 0xC7, 0x38, 0x7F,
  0xC7, 0x38, 0xF1, 0xC7, 0x78, 0xE3, 0xC7, 0x71, 0xE3, 0x87, 0x71, 0xC3,
  0x87, 0xF3, 0xC3, 0x87, 0xE3, 0xC7, 0x8E, 0xE3, 0xC7, 0x0E, 0xE3, 0x87,
  0x0E, 0xE3, 0x87, 0x0C, 0xE3, 0x8F, 0x1C, 0xE3, 0xDF, 0x3C, 0xE3, 0xFF,
  0xF8, 0xE1, 0xF7, 0xF0, 0xE1, 0xE3, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0,
  0x7C, 0x78, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0xDF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0xFC, 0x1E, 0x0F, 0x87, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xBE, 0x03, 0xC7,
  0x81, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xF8, 0xFC, 0x1E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x1E, 0x1F,
  0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F,
  0x8F, 0x80, 0xF1, 0xF0, 0x1F, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC7, 0xFC, 0xF8, 0xFF, 0x9F, 0x1F, 0xE3, 0xC3, 0xFC,
  0xF8, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE3, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00,
  0xF0, 0xF8, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xCF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83,
  0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0x8F, 0xC0, 0x7C, 0x7C,
  0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1E, 0xE0,
  0xFF, 0x87, 0xBC, 0x3F, 0xE1, 0xEF, 0x1E, 0xF8, 0xFB, 0xC7, 0xBC, 0x3E,
  0xF1, 0xEF, 0x0F, 0xBC, 0xF7, 0xC3, 0xEF, 0x3D, 0xF0, 0xFB, 0xDE, 0x7C,
  0x3C, 0x77, 0x9E, 0x1F, 0x1F, 0xCF, 0x87, 0xC7, 0xF3, 0xE1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xF0, 0x78, 0x7F, 0x87,
  0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x7C, 0x7C,
  0xE3, 0xC3, 0xE7, 0xBE, 0x1F, 0x3D, 0xF0, 0xF8, 0xEF, 0x87, 0xC7, 0x7C,
  0x3E, 0x3F, 0xE3, 0xE1, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x87, 0xC1,
  0xFC, 0x3E, 0x0F, 0xE1, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC,
  0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87,
  0xE3, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E,
  0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x1F, 0x9F, 0x07, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC,
  0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87,
  0xE3, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E,
  0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF8, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x0F, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x0F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0xC7, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E,
  0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x01, 0xEF, 0x80, 0x3D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x1F,
  0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x3E,
  0xF8, 0xFC, 0x3C, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0x7C, 0xF9, 0xFC, 0x78,
  0xF9, 0xFC, 0xF8, 0xFB, 0xDC, 0xF8, 0xFB, 0xDC, 0xF0, 0xFB, 0xDD, 0xF0,
  0xFF, 0x9D, 0xF0, 0xFF, 0x9D, 0xE0, 0xFF, 0x9D, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07,
  0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0x78, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x3E,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0x81, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x00, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xE0, 0xEE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7,
  0x8E, 0x78, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x3C, 0x3E, 0x1E, 0x0F, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3,
  0xE3, 0xE7, 0xC7, 0xC0, 0x0F, 0x83, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xF1,
  0xF3, 0xE3, 0xEF, 0x87, 0xDF, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3C, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F,
  0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xF1, 0xE0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F,
  0xFE, 0x7C, 0x7D, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x3E, 0xF0, 0xFB, 0xE3, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x9E, 0x0F, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC7, 0xE3, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0xC7,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0x78, 0x00, 0x07, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x7C, 0x3D, 0xF0, 0xF7, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xC7, 0xFF,
  0x1F, 0xFE, 0x3F, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0xE7, 0xFC, 0x7F, 0xCF, 0xFC,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xCF, 0x87,
  0xF7, 0xC7, 0xFF, 0xC3, 0xFF, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0xC7, 0xC3,
  0xE3, 0xE3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00,
  0x1F, 0x00, 0x1F, 0x06, 0x0F, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x78, 0x3F, 0xF8, 0x7F, 0xF9,
  0xFF, 0xF3, 0xE3, 0xE7, 0xC3, 0xCF, 0x87, 0x9E, 0x1F, 0x7C, 0x3E, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF0, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00,
  0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x70, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x8F, 0x1F, 0x87, 0x8F,
  0x87, 0xCF, 0x83, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xCF, 0x03, 0xC7, 0xC1,
  0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x00, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x00, 0x1E, 0x78, 0x7C, 0x1F, 0xFC, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x3F, 0x3F, 0x1F, 0x3E, 0x3E, 0x1F, 0x3E, 0x3E, 0x1F,
  0x3E, 0x3E, 0x1F, 0x3C, 0x3E, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3C, 0x3E,
  0x7C, 0x3C, 0x3E, 0x7C, 0x7C, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x3C,
  0xF8, 0x7C, 0x7C, 0xF8, 0x78, 0x7C, 0xF8, 0x78, 0x7C, 0x1E, 0x78, 0x3F,
  0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xE3, 0xE7, 0xC3, 0xCF, 0x87, 0x9E, 0x1F,
  0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC3, 0xCF, 0x0F, 0xBE,
  0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x1F, 0x3F, 0xFE, 0x3F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0x3C, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F,
  0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3E, 0x78, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x9E, 0x1F, 0xDE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x7E, 0x78, 0x3E, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0,
  0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x1E, 0x71, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xE3, 0xF0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xE3, 0xE7, 0x87, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xCF, 0x87, 0x9F, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0,
  0x1F, 0x00, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF,
  0xFF, 0x8F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x78,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF0, 0xF8, 0x7F, 0xE1, 0xEF, 0x8F,
  0xBE, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x1E, 0xF8, 0x7B, 0xC1, 0xEF,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x1F, 0xF1, 0xF1, 0xEF, 0x1F,
  0x1E, 0xF1, 0xF3, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xCF, 0x7F, 0x7C, 0xF7,
  0xF7, 0x8F, 0xF7, 0x78, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x83, 0xC0,
  0x1F, 0x0F, 0x87, 0x8F, 0x83, 0xC7, 0xC1, 0xF7, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF9, 0xE0, 0xF8, 0xF0, 0x7C, 0x7C,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x40, 0x70, 0x3C, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x8F, 0xC3, 0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x08,
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x00, 0x04, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x00,
  0x1F, 0xC3, 0xCF, 0xE1, 0xCF, 0xF9, 0xE7, 0x9F, 0xF7, 0x8F, 0xF3, 0xC3,
  0xF8, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 25, 9, 1, -25 },
  { 30, 10, 9, 11, 2, -26 },
  { 42, 17, 25, 18, 1, -25 },
  { 96, 16, 32, 17, 1, -29 },
  { 160, 17, 25, 22, 3, -25 },
  { 214, 17, 25, 20, 1, -25 },
  { 268, 5, 9, 6, 2, -26 },
  { 274, 10, 36, 11, 2, -28 },
  { 319, 11, 36, 11, -2, -28 },
  { 369, 14, 15, 15, 2, -25 },
  { 396, 15, 18, 16, 1, -21 },
  { 430, 7, 10, 8, -2, -4 },
  { 439, 9, 4, 12, 2, -13 },
  { 444, 5, 5, 10, 1, -5 },
  { 448, 15, 27, 11, -2, -25 },
  { 499, 15, 25, 17, 1, -25 },
  { 546, 10, 25, 17, 4, -25 },
  { 578, 17, 25, 17, 0, -25 },
  { 632, 17, 25, 17, 0, -25 },
  { 686, 16, 25, 17, 0, -25 },
  { 736, 16, 25, 17, 1, -25 },
  { 786, 15, 25, 17, 1, -25 },
  { 833, 17, 25, 17, 1, -25 },
  { 887, 16, 25, 17, 1, -25 },
  { 937, 14, 25, 17, 2, -25 },
  { 981, 8, 19, 9, 1, -19 },
  { 1000, 10, 25, 9, -2, -19 },
  { 1032, 14, 17, 15, 1, -19 },
  { 1062, 15, 12, 17, 1, -17 },
  { 1085, 14, 17, 15, 1, -19 },
  { 1115, 14, 25, 15, 2, -25 },
  { 1159, 24, 32, 26, 1, -24 },
  { 1255, 19, 25, 20, -1, -25 },
  { 1315, 19, 25, 19, 0, -25 },
  { 1375, 18, 25, 19, 1, -25 },
  { 1432, 19, 25, 19, 0, -25 },
  { 1492, 18, 25, 17, 0, -25 },
  { 1549, 18, 25, 16, 0, -25 },
  { 1606, 19, 25, 20, 1, -25 },
  { 1666, 21, 25, 21, 0, -25 },
  { 1732, 10, 25, 9, 0, -25 },
  { 1764, 17, 25, 17, 0, -25 },
  { 1818, 21, 25, 19, 0, -25 },
  { 1884, 14, 25, 16, 0, -25 },
  { 1928, 26, 25, 26, 0, -25 },
  { 2010, 21, 25, 21, 0, -25 },
  { 2076, 19, 25, 20, 1, -25 },
  { 2136, 19, 25, 19, 0, -25 },
  { 2196, 19, 29, 20, 1, -25 },
  { 2265, 19, 25, 19, 0, -25 },
  { 2325, 17, 25, 18, 1, -25 },
  { 2379, 17, 25, 18, 3, -25 },
  { 2433, 19, 25, 19, 1, -25 },
  { 2493, 19, 25, 20, 3, -25 },
  { 2553, 24, 25, 25, 3, -25 },
  { 2628, 22, 25, 19, -1, -25 },
  { 2697, 18, 25, 18, 3, -25 },
  { 2754, 20, 25, 18, -1, -25 },
  { 2817, 12, 35, 9, -1, -29 },
  { 2870, 8, 27, 13, 3, -25 },
  { 2897, 12, 35, 9, -2, -29 },
  { 2950, 12, 12, 13, 1, -25 },
  { 2968, 13, 4, 14, -2, 0 },
  { 2975, 8, 5, 11, 3, -26 },
  { 2980, 15, 18, 16, 0, -18 },
  { 3014, 16, 26, 17, 0, -26 },
  { 3066, 14, 18, 16, 1, -18 },
  { 3098, 17, 26, 17, 1, -26 },
  { 3154, 14, 18, 16, 1, -18 },
  { 3186, 12, 26, 11, 1, -26 },
  { 3225, 17, 25, 17, 0, -18 },
  { 3279, 15, 26, 17, 0, -26 },
  { 3328, 9, 25, 9, 0, -25 },
  { 3357, 13, 32, 8, -4, -25 },
  { 3409, 17, 26, 16, 0, -26 },
  { 3465, 9, 26, 9, 0, -26 },
  { 3495, 24, 18, 25, 0, -18 },
  { 3549, 15, 18, 17, 0, -18 },
  { 3583, 15, 18, 17, 1, -18 },
  { 3617, 17, 25, 17, -1, -18 },
  { 3671, 16, 25, 17, 1, -18 },
  { 3721, 12, 18, 11, 0, -18 },
  { 3748, 15, 18, 15, 0, -18 },
  { 3782, 10, 23, 10, 1, -23 },
  { 3811, 16, 18, 17, 1, -18 },
  { 3847, 14, 18, 15, 2, -18 },
  { 3879, 20, 18, 21, 2, -18 },
  { 3924, 17, 18, 15, -1, -18 },
  { 3963, 17, 25, 15, -1, -18 },
  { 4017, 15, 18, 15, 0, -18 },
  { 4051, 10, 33, 10, 1, -27 },
  { 4093, 7, 30, 9, 1, -25 },
  { 4120, 10, 33, 10, -1, -27 },
  { 4162, 17, 8, 19, 1, -14 },
};

const GFXfont RobotoCondensed_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_BOLDITALIC35PT7B_H_
