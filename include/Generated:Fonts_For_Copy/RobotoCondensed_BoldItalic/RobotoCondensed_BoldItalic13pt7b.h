#ifndef _ROBOTOCONDENSED_BOLDITALIC13PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x26, 0x66, 0x64, 0x0C, 0xC0, 0xAA, 0xA0, 0x14, 0x28, 0x53, 0xF2,
  0x9F, 0x94, 0x28, 0x50, 0x08, 0xE3, 0xDB, 0x60, 0xE0, 0xB3, 0x79, 0xC2,
  0x00, 0x62, 0xDA, 0x9E, 0x10, 0xF5, 0x75, 0x1C, 0x38, 0x78, 0xB1, 0xC3,
  0x6B, 0xB7, 0x7E, 0x7C, 0xEA, 0x22, 0x4C, 0xC8, 0x88, 0x88, 0x88, 0x40,
  0x20, 0x84, 0x21, 0x88, 0x42, 0x31, 0x88, 0xC4, 0x00, 0x21, 0x3E, 0xCF,
  0x48, 0x10, 0x47, 0xFF, 0x30, 0xC2, 0x00, 0x6D, 0x60, 0xE0, 0xF0, 0x0C,
  0x20, 0x84, 0x10, 0x82, 0x18, 0x43, 0x00, 0x73, 0xF7, 0xB9, 0xCE, 0x7E,
  0xE0, 0x17, 0xB3, 0x32, 0x66, 0x60, 0x39, 0xB6, 0xC3, 0x18, 0xC6, 0x38,
  0xF8, 0x39, 0xB6, 0xC3, 0x38, 0x2C, 0xFE, 0x70, 0x0C, 0x71, 0xCA, 0x6B,
  0x6F, 0xC6, 0x18, 0x3C, 0xF6, 0x1E, 0x6C, 0x3C, 0xDE, 0x70, 0x3B, 0xB1,
  0xEF, 0xCE, 0x7E, 0xE0, 0xFC, 0x21, 0x84, 0x31, 0x86, 0x30, 0xC0, 0x38,
  0xF6, 0xDB, 0x79, 0x2C, 0xDE, 0x70, 0x77, 0xF7, 0xBD, 0xBC, 0xDE, 0xC0,
  0x6C, 0x01, 0xB0, 0x33, 0x00, 0x02, 0x66, 0xC0, 0x09, 0xD9, 0xC3, 0x88,
  0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x43, 0x86, 0x7F, 0x40, 0x76, 0xF6, 0x66,
  0x20, 0x18, 0xC0, 0x0F, 0x08, 0xC8, 0x29, 0xD5, 0xAE, 0xB6, 0x53, 0x2A,
  0x9F, 0x60, 0x11, 0x07, 0x80, 0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x3E, 0x3E,
  0x63, 0x63, 0x3C, 0xFD, 0x9B, 0x67, 0xCD, 0x93, 0x7E, 0xF8, 0x1C, 0x7D,
  0x9B, 0x06, 0x08, 0x11, 0x3E, 0x38, 0x3C, 0xF9, 0x9B, 0x36, 0x6C, 0xD3,
  0x7E, 0xF8, 0x3E, 0xFD, 0x83, 0xE7, 0x8C, 0x10, 0x7C, 0xF8, 0x3E, 0xF9,
  0x83, 0xE7, 0x8C, 0x10, 0x60, 0xC0, 0x39, 0xFC, 0xF0, 0xC2, 0x78, 0xFE,
  0x78, 0x23, 0x63, 0x63, 0x7E, 0x7E, 0x66, 0x46, 0xC6, 0xC4, 0x26, 0x66,
  0x66, 0x4C, 0xC0, 0x04, 0x30, 0xC3, 0x0C, 0x2D, 0xBE, 0x70, 0x27, 0x66,
  0x6C, 0x78, 0x78, 0x78, 0x48, 0xCC, 0xCC, 0x23, 0x18, 0xC6, 0x31, 0x1F,
  0xF8, 0x31, 0xDC, 0x77, 0x39, 0xCE, 0x77, 0x95, 0x65, 0xDB, 0x64, 0xDB,
  0x00, 0x33, 0x73, 0x72, 0x72, 0x7E, 0x6E, 0x4E, 0xCE, 0xCC, 0x1C, 0x7D,
  0x8B, 0x16, 0x68, 0xD1, 0xBE, 0x38, 0x3C, 0xFD, 0x9B, 0x37, 0xEF, 0x90,
  0x60, 0xC0, 0x1C, 0x7D, 0x8B, 0x16, 0x68, 0xD1, 0xBE, 0x38, 0x18, 0x10,
  0x3C, 0xFD, 0x9B, 0x37, 0xCF, 0x12, 0x66, 0xCC, 0x3C, 0xFD, 0x9B, 0x83,
  0x81, 0xB3, 0x3E, 0x78, 0xFF, 0xF3, 0x0C, 0x21, 0x86, 0x18, 0x60, 0x22,
  0x66, 0x66, 0x66, 0x66, 0x46, 0xC4, 0x7C, 0x78, 0xC7, 0x9B, 0x36, 0x45,
  0x8B, 0x1C, 0x38, 0x60, 0xC9, 0xEC, 0xF6, 0xDB, 0x6F, 0xB7, 0x53, 0xB9,
  0xDC, 0xCC, 0x00, 0x66, 0x26, 0x3C, 0x38, 0x38, 0x38, 0x68, 0x6C, 0xCC,
  0xCD, 0x99, 0x63, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0x7E, 0xFC, 0x30, 0xC1,
  0x06, 0x18, 0x7E, 0xFC, 0x32, 0x66, 0x66, 0x44, 0xCC, 0xCC, 0xC0, 0xDB,
  0x24, 0xDB, 0x6C, 0x38, 0x84, 0x63, 0x18, 0xC6, 0x23, 0x18, 0xCE, 0x00,
  0x11, 0x8C, 0xB5, 0x80, 0xF8, 0x4C, 0x39, 0xA0, 0x9E, 0xDB, 0x67, 0x80,
  0x21, 0x86, 0x1E, 0x7D, 0x34, 0xF3, 0xFB, 0xE0, 0x39, 0xE4, 0xF0, 0xDB,
  0xE7, 0x00, 0x06, 0x08, 0x31, 0xE7, 0xC9, 0xB3, 0x64, 0xF8, 0xF0, 0x39,
  0xB4, 0xFF, 0xC1, 0xE7, 0x80, 0x19, 0xC8, 0xE6, 0x31, 0x8C, 0x46, 0x00,
  0x35, 0xB4, 0xF3, 0xCF, 0xE7, 0x86, 0xBB, 0xC0, 0x21, 0x86, 0x1E, 0x7D,
  0x34, 0xF2, 0xDB, 0x60, 0x24, 0x36, 0xD6, 0xD8, 0x11, 0x03, 0x33, 0x22,
  0x66, 0x6E, 0xC0, 0x21, 0x86, 0x1B, 0x79, 0xC7, 0x34, 0xDB, 0x60, 0x2D,
  0xB6, 0xD6, 0xD8, 0x7B, 0x3E, 0xD3, 0x69, 0x3C, 0x96, 0xCB, 0x6C, 0x79,
  0xF4, 0xD3, 0xCB, 0x6D, 0x80, 0x39, 0xB4, 0xF3, 0xCF, 0xE7, 0x00, 0x79,
  0xB4, 0xD3, 0xCF, 0xEF, 0xB0, 0x82, 0x00, 0x3D, 0xF4, 0xF3, 0xCB, 0xE7,
  0x86, 0x18, 0x60, 0x77, 0x44, 0xCC, 0xC0, 0x3B, 0x58, 0xE1, 0xED, 0xC0,
  0x22, 0x76, 0x66, 0x46, 0x60, 0x6D, 0xB4, 0xD3, 0xCB, 0xE7, 0x80, 0x9C,
  0xBD, 0xEE, 0x73, 0x00, 0x97, 0x6E, 0xD7, 0xED, 0xDB, 0x36, 0x00, 0x6D,
  0xE3, 0x8C, 0x73, 0x4D, 0x80, 0x4D, 0xA7, 0x9E, 0x71, 0xC6, 0x18, 0xC3,
  0x00, 0x7C, 0x61, 0x0C, 0x63, 0x0F, 0x80, 0x13, 0x22, 0x26, 0xC4, 0x44,
  0x44, 0x24, 0xA4, 0x92, 0x5A, 0x00, 0x42, 0x26, 0x62, 0x26, 0x4C, 0xC8,
  0x76, 0xF9, 0x30,
};

const GFXglyph RobotoCondensed_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 3, 4, 1, -10 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 6, 9, 8, 1, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 2, 4, 2, 1, -10 },
  { 41, 4, 13, 4, 1, -10 },
  { 48, 5, 13, 4, -1, -10 },
  { 57, 5, 6, 6, 1, -9 },
  { 61, 6, 7, 6, 0, -8 },
  { 67, 3, 4, 3, -1, -2 },
  { 69, 3, 1, 5, 1, -4 },
  { 70, 2, 2, 4, 0, -2 },
  { 71, 6, 10, 4, -1, -9 },
  { 79, 5, 9, 6, 1, -9 },
  { 85, 4, 9, 6, 1, -9 },
  { 90, 6, 9, 6, 0, -9 },
  { 97, 6, 9, 6, 0, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 5, 9, 6, 1, -9 },
  { 124, 6, 9, 6, 1, -9 },
  { 131, 6, 9, 6, 0, -9 },
  { 138, 5, 9, 6, 1, -9 },
  { 144, 3, 7, 4, 0, -7 },
  { 147, 4, 9, 3, -1, -7 },
  { 152, 5, 6, 6, 0, -7 },
  { 156, 6, 6, 6, 0, -7 },
  { 161, 5, 6, 6, 0, -7 },
  { 165, 5, 9, 6, 1, -9 },
  { 171, 9, 12, 10, 0, -9 },
  { 185, 8, 9, 8, -1, -9 },
  { 194, 7, 9, 7, 0, -9 },
  { 202, 7, 9, 7, 0, -9 },
  { 210, 7, 9, 7, 0, -9 },
  { 218, 7, 9, 6, 0, -9 },
  { 226, 7, 9, 6, 0, -9 },
  { 234, 6, 9, 7, 1, -9 },
  { 241, 8, 9, 8, 0, -9 },
  { 250, 4, 9, 3, 0, -9 },
  { 255, 6, 9, 6, 0, -9 },
  { 262, 8, 9, 7, 0, -9 },
  { 271, 5, 9, 6, 0, -9 },
  { 277, 10, 9, 10, 0, -9 },
  { 289, 8, 9, 8, 0, -9 },
  { 298, 7, 9, 8, 0, -9 },
  { 306, 7, 9, 7, 0, -9 },
  { 314, 7, 11, 8, 0, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 7, 9, 7, 0, -9 },
  { 340, 6, 9, 7, 1, -9 },
  { 347, 8, 9, 7, 0, -9 },
  { 356, 7, 9, 7, 1, -9 },
  { 364, 9, 9, 9, 1, -9 },
  { 375, 8, 9, 7, 0, -9 },
  { 384, 7, 9, 7, 1, -9 },
  { 392, 7, 9, 7, 0, -9 },
  { 400, 4, 13, 3, 0, -11 },
  { 407, 3, 10, 5, 1, -9 },
  { 411, 5, 13, 3, -1, -11 },
  { 420, 5, 5, 5, 0, -9 },
  { 424, 5, 1, 5, -1, 0 },
  { 425, 3, 2, 4, 1, -10 },
  { 426, 6, 7, 6, 0, -7 },
  { 432, 6, 10, 6, 0, -10 },
  { 440, 6, 7, 6, 0, -7 },
  { 446, 7, 10, 6, 0, -10 },
  { 455, 6, 7, 6, 0, -7 },
  { 461, 5, 10, 4, 0, -10 },
  { 468, 6, 10, 6, 0, -7 },
  { 476, 6, 10, 6, 0, -10 },
  { 484, 3, 10, 3, 0, -10 },
  { 488, 4, 13, 3, -1, -10 },
  { 495, 6, 10, 6, 0, -10 },
  { 503, 3, 10, 3, 0, -10 },
  { 507, 9, 7, 9, 0, -7 },
  { 515, 6, 7, 6, 0, -7 },
  { 521, 6, 7, 6, 0, -7 },
  { 527, 6, 10, 6, 0, -7 },
  { 535, 6, 10, 6, 0, -7 },
  { 543, 4, 7, 4, 0, -7 },
  { 547, 5, 7, 6, 0, -7 },
  { 552, 4, 9, 4, 0, -9 },
  { 557, 6, 7, 6, 0, -7 },
  { 563, 5, 7, 6, 1, -7 },
  { 568, 7, 7, 8, 1, -7 },
  { 575, 6, 7, 6, 0, -7 },
  { 581, 6, 10, 6, 0, -7 },
  { 589, 6, 7, 6, 0, -7 },
  { 595, 4, 12, 4, 0, -10 },
  { 601, 3, 11, 3, 0, -9 },
  { 606, 4, 12, 4, 0, -10 },
  { 612, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoCondensed_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_BOLDITALIC13PT7B_H_
