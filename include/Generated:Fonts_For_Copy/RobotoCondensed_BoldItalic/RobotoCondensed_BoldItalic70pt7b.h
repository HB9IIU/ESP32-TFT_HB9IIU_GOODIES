#ifndef _ROBOTOCONDENSED_BOLDITALIC70PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x00, 0x60, 0xFE, 0x1F, 0x80, 0x78, 0x7E, 0x0F,
  0xE0, 0x7F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x81, 0xF8, 0x3F, 0x1F, 0xC1,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0,
  0x3F, 0x1F, 0xC1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFE, 0x1F, 0xCF, 0xC0, 0x3F,
  0xBF, 0xCF, 0xE0, 0x1F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xE7, 0xE0, 0x03,
  0xFF, 0xE7, 0xF0, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0xF0, 0x00, 0x7E, 0x7F,
  0xFC, 0x00, 0x7E, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x3F, 0x3F,
  0xDF, 0xC0, 0x3F, 0x3F, 0x87, 0xF0, 0x3F, 0x9F, 0xC1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x0F, 0xC7, 0xE0,
  0x3F, 0x07, 0xE7, 0xE0, 0x1F, 0x83, 0xF0, 0xF0, 0x0F, 0xE3, 0xF8, 0x30,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xBF, 0xF1, 0xFE, 0x3F, 0xE3, 0xFF, 0x3F,
  0xCF, 0xFC, 0x7F, 0xEF, 0xF9, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xF0,
  0x1F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x18, 0x03, 0xE0, 0x18, 0xFC, 0x1F, 0x83, 0xE3, 0xFC, 0x7E,
  0x3F, 0x9F, 0xFD, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x0F, 0x07,
  0xF9, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01,
  0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F,
  0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF7, 0xFE, 0x7C, 0x3F, 0xE3,
  0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF1,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F,
  0xDF, 0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x3F, 0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0x00, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x07,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07,
  0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE,
  0x07, 0xFE, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0x8F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1,
  0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0x81,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xE0,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0xFC,
  0x3F, 0x01, 0xFE, 0x0F, 0xE0, 0x7E, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x3F,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0x8F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xE3, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF3, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xF9, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x7E, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x3F, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0xC0, 0xFE, 0x03, 0xF0,
  0x0F, 0xCF, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xC7, 0xF0, 0x7F, 0x81, 0xFC,
  0x07, 0xE3, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF1, 0xF8, 0x1F, 0xE0, 0xFF,
  0x01, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x7E, 0x03, 0xF8, 0x7F,
  0xC1, 0xF8, 0x3F, 0x01, 0xFE, 0x7F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFD, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFE,
  0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xE7, 0xFE,
  0x03, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFC,
  0x7F, 0xC0, 0x7F, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F,
  0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFB, 0xFE,
  0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFC, 0x03, 0xFD,
  0xFF, 0x00, 0x7F, 0xEF, 0xE0, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xF8, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F,
  0xC0, 0x7F, 0xBF, 0xF0, 0x07, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0x00, 0x3F,
  0xE7, 0xF8, 0x3F, 0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF9, 0xFE, 0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0x87, 0xF0, 0xFE, 0x3F,
  0xF0, 0x07, 0xFC, 0x3F, 0x8F, 0xF1, 0xFF, 0x80, 0x3F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F,
  0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xF9, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xDF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFE, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0xE7, 0xF0,
  0x3F, 0xE0, 0x0F, 0xFC, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x9F, 0xC1, 0xFF,
  0x80, 0x3F, 0xF1, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0x87, 0xFE, 0x00,
  0xFF, 0x87, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xE7, 0xFE, 0x00, 0xFF, 0xC1, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0x9F, 0xF8, 0x03, 0xFE, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x7F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0xF8, 0xFF, 0x80, 0x7F,
  0xC7, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF7, 0xF8, 0xFF, 0x80, 0x7F,
  0x8F, 0xF7, 0xF9, 0xFF, 0x00, 0x7F, 0x8F, 0xF7, 0xF9, 0xFF, 0x00, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE7, 0xFB, 0xFF, 0x00, 0x7F,
  0x9F, 0xE7, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xC7, 0xFB, 0xFE, 0x00, 0x7F,
  0xBF, 0xC7, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC7, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xFD, 0xFC,
  0x03, 0xF9, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0x7F,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F,
  0xE3, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xEF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0x80,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0x7F,
  0xC7, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0x83,
  0xFE, 0x7F, 0xFE, 0x07, 0xFC, 0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x0F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x3F, 0xF0,
  0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x3F, 0xF0, 0x0F, 0x01,
  0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF1, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xC7, 0xF8, 0x03,
  0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x04, 0x00, 0x1F, 0xF0, 0x01, 0x80, 0x0F, 0xFC,
  0x00, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x07, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFD, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x8F, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x87,
  0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80,
  0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x9F,
  0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xEF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xF0, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0x8F, 0xFE,
  0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xEF, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0x01,
  0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xF0, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xFE, 0x7F, 0x03, 0xFE, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE7, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF2, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F,
  0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xFC,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x81, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80,
  0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0xF1,
  0xFF, 0x07, 0xFC, 0xFF, 0xF8, 0xFF, 0x81, 0xFE, 0x7F, 0xFC, 0x7F, 0x80,
  0xFF, 0x3F, 0xFE, 0x3F, 0xC0, 0x7F, 0xBF, 0xBF, 0xBF, 0xE0, 0x3F, 0xDF,
  0xDF, 0xDF, 0xE0, 0x1F, 0xFF, 0xEF, 0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF0, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xF8, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x7F,
  0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xE0, 0xFE,
  0x7F, 0xFF, 0xF1, 0xFE, 0x7F, 0x8F, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFC,
  0xFF, 0x03, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0,
  0xFE, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 51, 18, 1, -50 },
  { 116, 21, 19, 22, 4, -53 },
  { 166, 35, 50, 36, 1, -50 },
  { 385, 32, 66, 34, 2, -58 },
  { 649, 33, 52, 43, 6, -51 },
  { 864, 35, 52, 39, 1, -51 },
  { 1092, 10, 19, 11, 4, -53 },
  { 1116, 22, 71, 22, 3, -55 },
  { 1312, 22, 71, 22, -3, -55 },
  { 1508, 30, 30, 31, 3, -50 },
  { 1621, 29, 36, 32, 2, -41 },
  { 1752, 15, 21, 17, -4, -8 },
  { 1792, 18, 8, 24, 3, -25 },
  { 1810, 11, 11, 20, 1, -10 },
  { 1826, 31, 54, 23, -4, -50 },
  { 2036, 30, 52, 34, 3, -51 },
  { 2231, 21, 50, 34, 8, -50 },
  { 2363, 33, 51, 34, 0, -51 },
  { 2574, 32, 52, 34, 1, -51 },
  { 2782, 32, 50, 34, 1, -50 },
  { 2982, 32, 51, 34, 2, -50 },
  { 3186, 29, 51, 34, 3, -50 },
  { 3371, 33, 50, 34, 3, -50 },
  { 3578, 31, 52, 34, 2, -51 },
  { 3780, 28, 51, 34, 5, -51 },
  { 3959, 16, 39, 19, 1, -38 },
  { 4037, 20, 51, 18, -3, -38 },
  { 4165, 28, 33, 30, 1, -38 },
  { 4281, 29, 23, 34, 3, -34 },
  { 4365, 28, 34, 31, 1, -38 },
  { 4484, 26, 52, 30, 5, -51 },
  { 4653, 49, 63, 52, 1, -48 },
  { 5039, 39, 50, 41, -3, -50 },
  { 5283, 37, 50, 38, 0, -50 },
  { 5515, 36, 52, 39, 3, -51 },
  { 5749, 37, 50, 38, 0, -50 },
  { 5981, 37, 50, 33, 0, -50 },
  { 6213, 36, 50, 32, 0, -50 },
  { 6438, 36, 52, 40, 3, -51 },
  { 6672, 43, 50, 42, 0, -50 },
  { 6941, 18, 50, 18, 1, -50 },
  { 7054, 35, 51, 33, 0, -50 },
  { 7278, 43, 50, 38, 0, -50 },
  { 7547, 29, 50, 33, 0, -50 },
  { 7729, 53, 50, 51, 0, -50 },
  { 8061, 43, 50, 42, 0, -50 },
  { 8330, 37, 52, 41, 3, -51 },
  { 8571, 39, 50, 39, 0, -50 },
  { 8815, 37, 60, 41, 3, -51 },
  { 9093, 38, 50, 38, 0, -50 },
  { 9331, 36, 52, 37, 1, -51 },
  { 9565, 35, 50, 37, 5, -50 },
  { 9784, 38, 51, 39, 2, -50 },
  { 10027, 38, 50, 39, 5, -50 },
  { 10265, 48, 50, 51, 6, -50 },
  { 10565, 43, 50, 38, -2, -50 },
  { 10834, 36, 50, 37, 6, -50 },
  { 11059, 40, 50, 36, -1, -50 },
  { 11309, 23, 70, 18, -1, -58 },
  { 11511, 16, 54, 26, 6, -50 },
  { 11619, 24, 70, 18, -4, -58 },
  { 11829, 24, 25, 27, 2, -50 },
  { 11904, 27, 8, 27, -4, 0 },
  { 11931, 15, 11, 22, 7, -53 },
  { 11952, 29, 39, 32, 1, -38 },
  { 12094, 31, 54, 34, 0, -53 },
  { 12304, 29, 39, 31, 1, -38 },
  { 12446, 35, 54, 34, 1, -53 },
  { 12683, 29, 39, 33, 2, -38 },
  { 12825, 25, 54, 22, 2, -54 },
  { 12994, 34, 52, 34, 0, -38 },
  { 13215, 31, 53, 33, 0, -53 },
  { 13421, 18, 51, 17, 0, -51 },
  { 13536, 26, 65, 17, -8, -51 },
  { 13748, 35, 53, 32, 0, -53 },
  { 13980, 19, 53, 17, 0, -53 },
  { 14106, 48, 38, 50, 0, -38 },
  { 14334, 31, 38, 33, 0, -38 },
  { 14482, 31, 39, 34, 1, -38 },
  { 14634, 34, 52, 34, -3, -38 },
  { 14855, 32, 52, 34, 1, -38 },
  { 15063, 24, 38, 22, 0, -38 },
  { 15177, 29, 39, 31, 0, -38 },
  { 15319, 20, 47, 21, 2, -46 },
  { 15437, 31, 38, 33, 2, -37 },
  { 15585, 28, 37, 30, 4, -37 },
  { 15715, 41, 37, 43, 4, -37 },
  { 15905, 34, 37, 31, -2, -37 },
  { 16063, 35, 51, 30, -2, -37 },
  { 16287, 32, 37, 31, -1, -37 },
  { 16435, 22, 67, 20, 1, -55 },
  { 16620, 15, 59, 17, 1, -50 },
  { 16731, 22, 67, 20, -3, -55 },
  { 16916, 32, 16, 38, 3, -29 },
};

const GFXfont RobotoCondensed_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_BOLDITALIC70PT7B_H_
