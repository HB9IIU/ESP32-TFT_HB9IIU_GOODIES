#ifndef _ROBOTOCONDENSED_BOLDITALIC52PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xC0, 0x08, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3,
  0xEF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE7,
  0xC3, 0xCF, 0x8F, 0x9E, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3C, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xC3, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0xF8, 0x18, 0xF8, 0x78,
  0x3E, 0xF8, 0x78, 0x3C, 0xF0, 0x78, 0x7C, 0xF0, 0x78, 0xF8, 0xF0, 0xF8,
  0xF0, 0xF0, 0xF9, 0xF0, 0xF8, 0xFB, 0xE0, 0xFF, 0xF3, 0xC0, 0x7F, 0xF7,
  0xC0, 0x7F, 0xEF, 0x80, 0x3F, 0xCF, 0x00, 0x04, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF3,
  0xF8, 0x01, 0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x07, 0xDF, 0xFE, 0x07, 0x9F,
  0x1F, 0x0F, 0x9E, 0x1F, 0x1F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1F, 0x3E, 0x3E,
  0x1F, 0x7C, 0x3E, 0x1F, 0x78, 0x3E, 0x1E, 0x78, 0x3E, 0x3E, 0x30, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xC7, 0xFF, 0xC3,
  0xF3, 0xFF, 0xF1, 0xF8, 0xFE, 0xFE, 0x7E, 0x7F, 0x3F, 0xDF, 0x9F, 0xC7,
  0xFF, 0xEF, 0xE1, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0xFE, 0x0F, 0xFE, 0x3F,
  0x81, 0xFF, 0x8F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x9F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0x7F, 0x01, 0xFF, 0x1F, 0xE0, 0x0C, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0x00, 0x02,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xC1, 0xE0,
  0xEF, 0x8F, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0,
  0x1F, 0x1E, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x01, 0x80,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87,
  0xE1, 0xF8, 0x1E, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFC, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E,
  0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x80, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC7,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F,
  0x07, 0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFD, 0xF3, 0xFB, 0x87, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7D, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF8, 0x01,
  0xF3, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFD, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3F,
  0x03, 0xF9, 0xFC, 0x3F, 0xCF, 0xF7, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFD, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xC7, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xBF, 0xC7, 0xF8,
  0x7E, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xDF,
  0xE7, 0xF8, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x3F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x7C,
  0x03, 0xF0, 0x1E, 0x0F, 0xC0, 0xFF, 0xC1, 0xE0, 0xF8, 0x1F, 0xFF, 0x1F,
  0x1F, 0x03, 0xFF, 0xE0, 0xF1, 0xF0, 0x7F, 0x3E, 0x0F, 0x1E, 0x0F, 0xC3,
  0xE0, 0xF3, 0xE0, 0xF8, 0x3E, 0x0F, 0x3E, 0x1F, 0x83, 0xC0, 0xF3, 0xC1,
  0xF0, 0x7C, 0x1F, 0x7C, 0x1F, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x7C, 0x1E,
  0x7C, 0x3E, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF8, 0x1E, 0xF8, 0x7E, 0x0F,
  0x81, 0xEF, 0x87, 0xE0, 0xF8, 0x1E, 0xF8, 0x7E, 0x0F, 0x83, 0xCF, 0x87,
  0xC1, 0xF0, 0x3C, 0xF8, 0x7C, 0x1F, 0x03, 0xCF, 0x87, 0xC1, 0xF0, 0x78,
  0xF8, 0x7C, 0x3F, 0x07, 0x8F, 0x87, 0xE7, 0xF0, 0xF0, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0x83, 0xFE, 0xFF, 0xE0, 0xF8, 0x3F, 0xCF, 0xFC, 0x0F, 0x81,
  0xF8, 0x7F, 0x80, 0xF8, 0x02, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x18, 0x00, 0x01, 0xFF,
  0x9F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x3F,
  0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F,
  0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x87, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFF, 0x3F, 0x83,
  0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0xFE, 0x0F, 0xFF, 0xBF, 0xC1, 0xFF, 0xE7,
  0xF8, 0x3F, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01,
  0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x03,
  0xF8, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07,
  0xF3, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x81, 0xFD, 0xF0, 0x1F, 0xFF, 0x03, 0xFB, 0xE0, 0x7E, 0xFE, 0x07, 0xF7,
  0xC0, 0xFD, 0xF8, 0x0F, 0xEF, 0x83, 0xF7, 0xF0, 0x1F, 0x9F, 0x07, 0xEF,
  0xE0, 0x7F, 0x3E, 0x0F, 0x9F, 0xC0, 0xFE, 0x7E, 0x3F, 0x3F, 0x81, 0xFC,
  0xFC, 0x7E, 0x7F, 0x03, 0xF9, 0xF9, 0xF9, 0xFC, 0x07, 0xF3, 0xF3, 0xF3,
  0xF8, 0x0F, 0xE3, 0xE7, 0xC7, 0xF0, 0x3F, 0xC7, 0xDF, 0x8F, 0xE0, 0x7F,
  0x0F, 0xBE, 0x3F, 0xC0, 0xFE, 0x1F, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0x1F,
  0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x3E, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x01, 0xFC, 0x07, 0xFF,
  0x01, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0x83, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0x0F, 0xEF, 0xC3, 0xF8, 0x0F, 0xE7,
  0xC3, 0xF8, 0x0F, 0xE7, 0xC3, 0xF8, 0x0F, 0xE7, 0xC3, 0xF8, 0x1F, 0xE7,
  0xE7, 0xF8, 0x1F, 0xE3, 0xE7, 0xF0, 0x1F, 0xC3, 0xE7, 0xF0, 0x1F, 0xC3,
  0xE7, 0xF0, 0x1F, 0xC3, 0xF7, 0xF0, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0xC1,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0D, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7E, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x7F, 0x03, 0xF8, 0x0F, 0xEF,
  0xE0, 0x7F, 0x01, 0xFD, 0xFC, 0x1F, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0x0F,
  0xE7, 0xF0, 0x7F, 0xC1, 0xFC, 0xFE, 0x1F, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF,
  0x0F, 0xE3, 0xF8, 0x7F, 0xE1, 0xFC, 0x7F, 0x1F, 0xFC, 0x7F, 0x0F, 0xE3,
  0xFF, 0x8F, 0xE1, 0xFC, 0x7F, 0xF1, 0xFC, 0x3F, 0x9F, 0xFE, 0x3F, 0x07,
  0xF3, 0xFF, 0xCF, 0xE0, 0xFE, 0x7F, 0xF9, 0xFC, 0x1F, 0xDF, 0xBF, 0x3F,
  0x03, 0xF3, 0xF7, 0xEF, 0xE0, 0x7E, 0x7E, 0xFD, 0xFC, 0x0F, 0xDF, 0x9F,
  0xBF, 0x01, 0xFB, 0xF3, 0xFF, 0xE0, 0x3F, 0x7C, 0x7F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xEF, 0xE0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF8,
  0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF7, 0xF0, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xBC, 0x07, 0xDE, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1,
  0xF0, 0xF9, 0xF8, 0x7C, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xF8, 0xFE, 0x7F, 0x83, 0xF9,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x3F, 0xC7, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0x7E, 0x03, 0xF9, 0xFC, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xDF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xEF, 0xFE, 0x1F, 0xDF, 0xF8, 0x3F, 0x1F,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F,
  0x07, 0xF1, 0xFE, 0x7F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0xFE, 0x01, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xF7, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFD, 0xF8,
  0x01, 0xFE, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFE, 0x7F, 0x8F, 0xF0, 0x7E, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0x07, 0xFE, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE8, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x08, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x40, 0x1F,
  0xE0, 0x38, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xE7, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x60, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFE, 0x1F, 0xF0, 0x3F, 0x8F, 0xF8,
  0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xF9, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xE3,
  0xFF, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xEF, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0x81,
  0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF0, 0x7F,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x8F,
  0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81,
  0xFD, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x1F,
  0xC7, 0xFD, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xEF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xDF, 0xFC, 0x0F, 0xEF, 0xFC, 0x07, 0xF3, 0xFC, 0x03,
  0xF8, 0x30, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x7E, 0x07, 0xFE, 0x7E, 0x0F, 0xFF, 0x7E, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE7, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x01, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F,
  0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x03, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xBF, 0x87, 0xF0, 0xFE, 0xFE, 0x1F,
  0xC3, 0xFB, 0xF8, 0xFF, 0x0F, 0xCF, 0xE3, 0xFC, 0x7F, 0x3F, 0x1F, 0xF1,
  0xF8, 0xFC, 0x7F, 0xC7, 0xE3, 0xF1, 0xFF, 0x3F, 0x8F, 0xCF, 0xFC, 0xFC,
  0x3F, 0x3F, 0xF3, 0xF0, 0xFD, 0xFF, 0xDF, 0xC3, 0xF7, 0xDF, 0x7E, 0x0F,
  0xDF, 0x7D, 0xF8, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x1F, 0xDF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC,
  0x01, 0xF9, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x01, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF0, 0x1F, 0x1F, 0xF8, 0x1F, 0x3F, 0xF8, 0x1F, 0x3F, 0xFC,
  0x3F, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0xFC, 0x3F, 0xFE, 0xFC, 0x1F,
  0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 38, 13, 1, -37 },
  { 63, 15, 14, 16, 3, -39 },
  { 90, 26, 37, 27, 1, -37 },
  { 211, 23, 49, 26, 2, -43 },
  { 352, 24, 39, 32, 5, -38 },
  { 469, 26, 39, 29, 1, -38 },
  { 596, 8, 14, 8, 3, -39 },
  { 610, 16, 53, 16, 2, -41 },
  { 716, 16, 53, 16, -2, -41 },
  { 822, 21, 22, 23, 3, -37 },
  { 880, 22, 27, 24, 1, -31 },
  { 955, 11, 16, 12, -3, -6 },
  { 977, 13, 6, 18, 3, -19 },
  { 987, 8, 8, 15, 1, -7 },
  { 995, 23, 40, 17, -3, -37 },
  { 1110, 23, 39, 26, 2, -38 },
  { 1223, 15, 37, 26, 6, -37 },
  { 1293, 25, 38, 26, 0, -38 },
  { 1412, 24, 39, 26, 1, -38 },
  { 1529, 24, 37, 26, 1, -37 },
  { 1640, 25, 38, 26, 1, -37 },
  { 1759, 21, 38, 26, 2, -37 },
  { 1859, 25, 37, 26, 2, -37 },
  { 1975, 24, 39, 26, 1, -38 },
  { 2092, 21, 38, 26, 3, -38 },
  { 2192, 12, 29, 14, 1, -28 },
  { 2236, 14, 38, 13, -2, -28 },
  { 2303, 21, 24, 23, 1, -28 },
  { 2366, 22, 17, 25, 2, -25 },
  { 2413, 21, 25, 23, 1, -28 },
  { 2479, 20, 39, 23, 3, -38 },
  { 2577, 36, 48, 39, 1, -36 },
  { 2793, 29, 37, 30, -2, -37 },
  { 2928, 28, 37, 28, 0, -37 },
  { 3058, 27, 39, 29, 2, -38 },
  { 3190, 28, 37, 28, 0, -37 },
  { 3320, 27, 37, 25, 0, -37 },
  { 3445, 27, 37, 24, 0, -37 },
  { 3570, 27, 39, 30, 2, -38 },
  { 3702, 32, 37, 31, 0, -37 },
  { 3850, 13, 37, 14, 1, -37 },
  { 3911, 26, 38, 25, 0, -37 },
  { 4035, 32, 37, 28, 0, -37 },
  { 4183, 21, 37, 24, 0, -37 },
  { 4281, 39, 37, 38, 0, -37 },
  { 4462, 32, 37, 31, 0, -37 },
  { 4610, 27, 39, 30, 2, -38 },
  { 4742, 29, 37, 29, 0, -37 },
  { 4877, 27, 45, 30, 2, -38 },
  { 5029, 28, 37, 28, 0, -37 },
  { 5159, 26, 39, 27, 1, -38 },
  { 5286, 26, 37, 27, 4, -37 },
  { 5407, 28, 38, 29, 2, -37 },
  { 5540, 28, 37, 29, 4, -37 },
  { 5670, 35, 37, 38, 5, -37 },
  { 5832, 33, 37, 28, -2, -37 },
  { 5985, 27, 37, 27, 4, -37 },
  { 6110, 30, 37, 27, -1, -37 },
  { 6249, 18, 52, 13, -1, -43 },
  { 6366, 13, 40, 19, 4, -37 },
  { 6431, 18, 52, 13, -3, -43 },
  { 6548, 17, 18, 20, 2, -37 },
  { 6587, 20, 6, 20, -3, 0 },
  { 6602, 11, 8, 17, 5, -39 },
  { 6613, 22, 29, 24, 0, -28 },
  { 6693, 23, 40, 25, 0, -39 },
  { 6808, 21, 29, 23, 1, -28 },
  { 6885, 26, 40, 25, 1, -39 },
  { 7015, 22, 29, 24, 1, -28 },
  { 7095, 18, 40, 17, 2, -40 },
  { 7185, 25, 39, 25, 0, -28 },
  { 7307, 23, 39, 25, 0, -39 },
  { 7420, 14, 38, 13, 0, -38 },
  { 7487, 19, 49, 12, -6, -38 },
  { 7604, 26, 39, 24, 0, -39 },
  { 7731, 14, 39, 13, 0, -39 },
  { 7800, 35, 28, 37, 0, -28 },
  { 7923, 23, 28, 25, 0, -28 },
  { 8004, 22, 29, 25, 1, -28 },
  { 8084, 25, 39, 25, -2, -28 },
  { 8206, 24, 39, 25, 1, -28 },
  { 8323, 18, 28, 17, 0, -28 },
  { 8386, 22, 29, 23, 0, -28 },
  { 8466, 14, 35, 15, 2, -34 },
  { 8528, 24, 28, 25, 1, -27 },
  { 8612, 21, 27, 23, 3, -27 },
  { 8683, 30, 27, 32, 3, -27 },
  { 8785, 26, 27, 23, -2, -27 },
  { 8873, 25, 38, 22, -1, -27 },
  { 8992, 24, 27, 23, -1, -27 },
  { 9073, 16, 50, 15, 1, -41 },
  { 9173, 11, 44, 13, 1, -37 },
  { 9234, 16, 50, 15, -2, -41 },
  { 9334, 24, 12, 28, 2, -22 },
};

const GFXfont RobotoCondensed_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_BOLDITALIC52PT7B_H_
