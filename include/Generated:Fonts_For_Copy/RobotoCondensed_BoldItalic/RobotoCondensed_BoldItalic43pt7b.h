#ifndef _ROBOTOCONDENSED_BOLDITALIC43PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x1C, 0x00, 0x78, 0xF7, 0x8F, 0x78,
  0xF7, 0x9F, 0x79, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0xE3,
  0xCE, 0x3C, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1,
  0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x81, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x8E, 0x00, 0x3C,
  0xF0, 0x01, 0xC7, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x7C, 0x1F,
  0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x08,
  0xF1, 0xE0, 0xCF, 0x1E, 0x1E, 0xF1, 0xE3, 0xCF, 0x1E, 0x38, 0xF1, 0xE7,
  0x8F, 0x1E, 0xF0, 0xFF, 0xDE, 0x07, 0xFD, 0xE0, 0x7F, 0xBC, 0x01, 0xE7,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0xF8, 0x03,
  0xDF, 0xC0, 0x7B, 0xFE, 0x0F, 0x7F, 0xF0, 0xF7, 0x8F, 0x1E, 0x78, 0xF3,
  0xC7, 0x8F, 0x3C, 0x70, 0xF7, 0x87, 0x0F, 0xF0, 0x79, 0xE2, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0xF9, 0xFF, 0xC7, 0xDF, 0xBF, 0x3E, 0xFD, 0xFB,
  0xEF, 0xC7, 0xFF, 0x7E, 0x3F, 0xFB, 0xF0, 0xFF, 0x9F, 0x87, 0xFC, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0xBC,
  0xF3, 0xCF, 0x38, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x08, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x08, 0x3C, 0x37, 0x8E, 0x3D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xDE, 0x03, 0xE7, 0x80, 0xF0, 0xF0, 0x7C, 0x3E, 0x0E, 0x07,
  0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x02, 0x00, 0x7F, 0xEF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFC, 0x00, 0xFB, 0xF7, 0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xF8, 0x3F, 0x7E, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0,
  0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x07, 0x80, 0xFC, 0x3F, 0xE7,
  0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xE7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x87, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7D, 0xF8, 0x1F,
  0x3F, 0x03, 0xE7, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0,
  0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x7C, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xE1, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x9F, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x87, 0xC7, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7,
  0xC0, 0xF9, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F,
  0xC7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF1, 0xF8, 0xF9, 0xF8, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7E,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC0, 0xFB, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE1, 0xF8,
  0x7F, 0x1F, 0x87, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xC3, 0xF0, 0xFE, 0x3F, 0x8F,
  0xC1, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x78,
  0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x1F, 0x81, 0xC7, 0xC1, 0xFE, 0x0E, 0x3C, 0x1F, 0xFC, 0x73, 0xE1, 0xFF,
  0xC3, 0x9E, 0x1F, 0x1E, 0x1C, 0xF0, 0xF0, 0xF0, 0xEF, 0x0F, 0x07, 0x87,
  0x78, 0x78, 0x78, 0x3B, 0xC7, 0xC3, 0xC1, 0xDC, 0x3C, 0x1E, 0x0F, 0xE1,
  0xE0, 0xF0, 0xFF, 0x0F, 0x0F, 0x07, 0xF8, 0xF8, 0x78, 0x3B, 0xC7, 0xC3,
  0xC1, 0xDE, 0x3E, 0x1E, 0x1E, 0xF1, 0xF1, 0xF0, 0xE7, 0x8F, 0x9F, 0x8F,
  0x3C, 0x3F, 0xFC, 0xF1, 0xE1, 0xFF, 0xFF, 0x0F, 0x0F, 0xE7, 0xF0, 0x78,
  0x3E, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x01, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xF8,
  0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFC,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x3F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xE1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE1, 0xFF, 0xBF,
  0x07, 0xFE, 0xFC, 0x1F, 0xFB, 0xF0, 0xFF, 0xEF, 0xC3, 0xFF, 0xBF, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xFC, 0x07,
  0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xBC, 0x0F,
  0xFC, 0x1F, 0xBC, 0x1F, 0x7C, 0x1F, 0xBC, 0x1F, 0xFC, 0x1F, 0xBC, 0x3E,
  0xFC, 0x1F, 0xBC, 0x3E, 0xFC, 0x1F, 0x3E, 0x7C, 0xFC, 0x3F, 0x3E, 0x7C,
  0xF8, 0x3F, 0x3E, 0x79, 0xF8, 0x3F, 0x3E, 0xF9, 0xF8, 0x3F, 0x1E, 0xF1,
  0xF8, 0x3F, 0x1F, 0xF1, 0xF8, 0x3F, 0x1F, 0xF3, 0xF0, 0x7E, 0x1F, 0xE3,
  0xF0, 0x7E, 0x1F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x07,
  0xE0, 0xFC, 0x0F, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF8, 0x0F, 0xC1, 0xFE, 0x07,
  0xE0, 0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xFC, 0x1F, 0x83, 0xFF,
  0x07, 0xE0, 0xFF, 0xC3, 0xF0, 0x3F, 0xF0, 0xFC, 0x1F, 0xBE, 0x3F, 0x07,
  0xE7, 0x8F, 0xC1, 0xF9, 0xE3, 0xF0, 0x7E, 0x78, 0xFC, 0x1F, 0x9F, 0x7E,
  0x0F, 0xE3, 0xDF, 0x83, 0xF0, 0xF7, 0xE0, 0xFC, 0x3D, 0xF8, 0x3F, 0x0F,
  0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xC1, 0xFC, 0x1F, 0xF0, 0x7E,
  0x07, 0xFC, 0x1F, 0x80, 0xFF, 0x07, 0xE0, 0x3F, 0xC1, 0xF8, 0x0F, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0x87, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0x8F, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF1, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xFC,
  0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF,
  0x07, 0xE0, 0x7D, 0xF8, 0x3F, 0x07, 0xEF, 0xC3, 0xF8, 0x3F, 0x7E, 0x1F,
  0xC1, 0xFB, 0xF0, 0xFE, 0x1F, 0x9F, 0x8F, 0xF0, 0xFC, 0xFC, 0x7F, 0x87,
  0xE7, 0xE3, 0xFC, 0x7E, 0x3F, 0x3F, 0xE3, 0xF1, 0xF9, 0xFF, 0x1F, 0x8F,
  0xCF, 0xF8, 0xF8, 0x7E, 0xFB, 0xCF, 0xC3, 0xF7, 0xDE, 0x7E, 0x1F, 0xBE,
  0xF3, 0xE0, 0xFF, 0xE7, 0xBF, 0x07, 0xDF, 0x3D, 0xF8, 0x3E, 0xF9, 0xEF,
  0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x1F, 0x80, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x01,
  0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xDE, 0x0F, 0x3C, 0x3E, 0x78,
  0x78, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x80, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7E, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3C, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7,
  0xE1, 0xF9, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x03,
  0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF, 0xC1, 0xF9, 0xFC, 0x7F,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0x7F, 0x87, 0xC7, 0xE0,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F,
  0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0xBF, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7C,
  0xFC, 0x3F, 0x3F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x1F, 0x03, 0xFD, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xE7, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xF3, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x04, 0x1F, 0x83, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x83, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x3F,
  0xEF, 0x83, 0xFF, 0x7C, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xC3, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x1C, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF3, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC3, 0xE1, 0xFC, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0x9F, 0x07, 0xC0, 0x7D, 0xFC,
  0x7F, 0x87, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xC7, 0xF8, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x3F, 0x3F,
  0x07, 0xE1, 0xF9, 0xF8, 0x3E, 0x0F, 0xCF, 0xC1, 0xF0, 0x7E, 0x7E, 0x1F,
  0x83, 0xF3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xE1, 0xF9, 0xF8, 0x3F, 0x0F,
  0xCF, 0xC1, 0xF0, 0x7E, 0x7E, 0x0F, 0x83, 0xF3, 0xF0, 0xFC, 0x1F, 0x9F,
  0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x0F, 0xCF, 0xC1, 0xF8, 0x7E, 0x7E, 0x0F,
  0x83, 0xF3, 0xF0, 0x7C, 0x1F, 0x80, 0x0F, 0x9F, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87, 0xE3, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3,
  0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7E, 0xFC, 0x1F, 0xBF, 0x8F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F,
  0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xBF, 0xC0, 0xFC, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xE1, 0xFE, 0x7C, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7C, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xCF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x9E, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xDF, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7, 0xF7, 0xF1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F,
  0x87, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xCF, 0x80, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3F,
  0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x1E, 0x0F, 0x9F, 0x0F, 0x87,
  0xE7, 0xC3, 0xE1, 0xF9, 0xF1, 0xF8, 0x7C, 0x7C, 0x7E, 0x3F, 0x1F, 0x1F,
  0x8F, 0x87, 0xCF, 0xE3, 0xE1, 0xF3, 0xF9, 0xF8, 0x7D, 0xFE, 0x7C, 0x1F,
  0x7F, 0x9F, 0x07, 0xDF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x3E, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0xF8, 0x7E, 0x07,
  0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x9F, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x10, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x0F, 0x00, 0x03, 0xFC, 0x1F, 0x3F, 0xC1, 0xF7, 0xFE, 0x1E, 0x7F,
  0xF3, 0xEF, 0x9F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xFC, 0xF0, 0x3F, 0x80,
  0x01, 0xE0,
};

const GFXglyph RobotoCondensed_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 31, 11, 1, -31 },
  { 44, 12, 12, 13, 3, -32 },
  { 62, 21, 31, 22, 1, -31 },
  { 144, 20, 39, 21, 1, -35 },
  { 242, 20, 31, 27, 4, -31 },
  { 320, 21, 31, 24, 1, -31 },
  { 402, 6, 12, 7, 3, -32 },
  { 411, 13, 44, 13, 2, -34 },
  { 483, 14, 44, 13, -2, -34 },
  { 560, 18, 19, 19, 2, -31 },
  { 603, 18, 22, 20, 1, -25 },
  { 653, 9, 13, 10, -2, -5 },
  { 668, 11, 5, 15, 2, -16 },
  { 675, 7, 7, 12, 1, -7 },
  { 682, 19, 34, 14, -3, -31 },
  { 763, 18, 31, 21, 2, -31 },
  { 833, 13, 31, 21, 5, -31 },
  { 884, 20, 31, 21, 0, -31 },
  { 962, 19, 31, 21, 1, -31 },
  { 1036, 19, 31, 21, 1, -31 },
  { 1110, 20, 31, 21, 1, -31 },
  { 1188, 17, 31, 21, 2, -31 },
  { 1254, 20, 31, 21, 2, -31 },
  { 1332, 19, 31, 21, 1, -31 },
  { 1406, 17, 31, 21, 3, -31 },
  { 1472, 10, 24, 12, 1, -24 },
  { 1502, 12, 32, 11, -2, -24 },
  { 1550, 17, 20, 19, 1, -23 },
  { 1593, 18, 14, 21, 2, -21 },
  { 1625, 17, 20, 19, 1, -23 },
  { 1668, 16, 31, 19, 3, -31 },
  { 1730, 29, 40, 32, 1, -30 },
  { 1875, 24, 31, 25, -2, -31 },
  { 1968, 23, 31, 23, 0, -31 },
  { 2058, 22, 31, 24, 2, -31 },
  { 2144, 23, 31, 24, 0, -31 },
  { 2234, 22, 31, 20, 0, -31 },
  { 2320, 22, 31, 20, 0, -31 },
  { 2406, 22, 31, 24, 2, -31 },
  { 2492, 26, 31, 26, 0, -31 },
  { 2593, 12, 31, 11, 0, -31 },
  { 2640, 21, 31, 20, 0, -31 },
  { 2722, 26, 31, 23, 0, -31 },
  { 2823, 18, 31, 20, 0, -31 },
  { 2893, 32, 31, 32, 0, -31 },
  { 3017, 26, 31, 26, 0, -31 },
  { 3118, 22, 31, 25, 2, -31 },
  { 3204, 24, 31, 24, 0, -31 },
  { 3297, 22, 36, 25, 2, -31 },
  { 3396, 23, 31, 23, 0, -31 },
  { 3486, 22, 31, 23, 1, -31 },
  { 3572, 22, 31, 23, 3, -31 },
  { 3658, 24, 31, 24, 1, -31 },
  { 3751, 24, 31, 24, 3, -31 },
  { 3844, 29, 31, 31, 4, -31 },
  { 3957, 26, 31, 23, -1, -31 },
  { 4058, 22, 31, 23, 4, -31 },
  { 4144, 25, 31, 22, -1, -31 },
  { 4241, 15, 43, 11, -1, -36 },
  { 4322, 11, 34, 16, 3, -31 },
  { 4369, 14, 43, 11, -2, -36 },
  { 4445, 15, 15, 16, 1, -31 },
  { 4474, 17, 5, 17, -3, 0 },
  { 4485, 9, 6, 14, 4, -32 },
  { 4492, 18, 23, 20, 0, -23 },
  { 4544, 19, 32, 21, 0, -32 },
  { 4620, 18, 23, 19, 1, -23 },
  { 4672, 21, 32, 21, 1, -32 },
  { 4756, 18, 23, 20, 1, -23 },
  { 4808, 15, 32, 14, 1, -32 },
  { 4868, 21, 32, 21, 0, -23 },
  { 4952, 19, 32, 21, 0, -32 },
  { 5028, 11, 32, 11, 0, -32 },
  { 5072, 16, 41, 10, -5, -32 },
  { 5154, 21, 32, 20, 0, -32 },
  { 5238, 12, 32, 11, 0, -32 },
  { 5286, 29, 23, 31, 0, -23 },
  { 5370, 19, 23, 21, 0, -23 },
  { 5425, 18, 23, 21, 1, -23 },
  { 5477, 21, 32, 21, -2, -23 },
  { 5561, 19, 32, 21, 1, -23 },
  { 5637, 15, 23, 14, 0, -23 },
  { 5681, 18, 23, 19, 0, -23 },
  { 5733, 13, 28, 13, 1, -28 },
  { 5779, 19, 23, 21, 1, -23 },
  { 5834, 18, 23, 19, 2, -23 },
  { 5886, 26, 23, 26, 2, -23 },
  { 5961, 21, 23, 19, -1, -23 },
  { 6022, 21, 32, 19, -1, -23 },
  { 6106, 20, 23, 19, -1, -23 },
  { 6164, 13, 42, 12, 1, -34 },
  { 6233, 9, 37, 11, 1, -31 },
  { 6275, 14, 42, 12, -2, -34 },
  { 6349, 20, 10, 23, 2, -18 },
};

const GFXfont RobotoCondensed_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_BOLDITALIC43PT7B_H_
