#ifndef _ROBOTOCONDENSED_BOLDITALIC42PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x0F, 0xC3, 0xF0,
  0xF8, 0x1E, 0x00, 0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0x8F, 0x3C,
  0x79, 0xE3, 0x8F, 0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0x70, 0x00, 0x3C, 0xF0,
  0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x38,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xE0, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x79, 0xE0, 0x03, 0x8F, 0x00,
  0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE3,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x1E, 0x1D, 0xE3,
  0xC7, 0xBC, 0x78, 0xE7, 0x8F, 0x3C, 0xE1, 0xEF, 0x1E, 0x79, 0xC3, 0xFF,
  0x78, 0x7F, 0xDE, 0x07, 0xFF, 0x80, 0x7C, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xCF, 0x80, 0x7F, 0xF8, 0x1E, 0xFF, 0x87, 0xBF, 0xF0, 0xF7,
  0x8E, 0x3D, 0xE1, 0xCF, 0x3C, 0x39, 0xE7, 0x8F, 0x78, 0xF1, 0xFE, 0x1E,
  0x3C, 0x81, 0xEF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x1E, 0x3F, 0xF8, 0xF1, 0xFF, 0xCF, 0x9F, 0xBF,
  0x7D, 0xF9, 0xFB, 0xEF, 0xC7, 0xFE, 0x7E, 0x3F, 0xF3, 0xF0, 0xFF, 0x1F,
  0x87, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0x7E, 0x07, 0xE1, 0xF8, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E,
  0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x38, 0x67,
  0xCE, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x0F, 0x70, 0x07, 0x9E, 0x03, 0xC7, 0x81, 0xF0, 0xF0, 0x38, 0x38,
  0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF0, 0x20, 0x7F, 0xEF, 0xF9, 0xFF, 0x7F, 0xEF, 0xFC, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xC3,
  0xE3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD,
  0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F,
  0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF3,
  0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xC7, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xF0, 0x3F, 0x3E,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0xC0,
  0x7D, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3F, 0x07,
  0xC7, 0xE1, 0xF0, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x7C, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xBF, 0x80, 0xE1, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F,
  0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xBE, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF8,
  0x7E, 0xFC, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xE3, 0xE1,
  0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0xFE, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F,
  0x7E, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xEF, 0xC1, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xEF, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0xC7,
  0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xE0, 0x03,
  0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x10,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0x80, 0x3E,
  0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x70, 0x78, 0x1F, 0x03, 0x87, 0x83, 0xFE, 0x1E, 0x3C, 0x3F,
  0xF8, 0xF3, 0xC3, 0xFF, 0xC7, 0x9E, 0x1E, 0x1E, 0x3D, 0xE1, 0xF1, 0xE1,
  0xEF, 0x0F, 0x0F, 0x0F, 0x78, 0xF8, 0x78, 0x7F, 0x87, 0x83, 0xC3, 0xBC,
  0x3C, 0x3C, 0x1D, 0xE3, 0xE1, 0xE0, 0xEF, 0x1F, 0x0F, 0x0F, 0x78, 0xF0,
  0x78, 0x73, 0xC7, 0x87, 0x83, 0x9E, 0x3C, 0x3C, 0x3C, 0xE1, 0xF3, 0xE1,
  0xC7, 0x0F, 0xFF, 0x9E, 0x3C, 0x3F, 0xBF, 0xE1, 0xE1, 0xFD, 0xFE, 0x0F,
  0x07, 0x87, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x0F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0xFE, 0x07, 0xE7,
  0xE0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E,
  0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x1F, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F,
  0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0xBF, 0x0F,
  0xFC, 0xFC, 0x3F, 0xF3, 0xF0, 0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7E,
  0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x81, 0xF8,
  0x1F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xC1, 0xFC, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0,
  0x03, 0xF7, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1E, 0xF8, 0x1F, 0xBC, 0x3E, 0xF8, 0x1F, 0x3C, 0x3C,
  0xF8, 0x1F, 0x3C, 0x7D, 0xF8, 0x1F, 0x3C, 0x7D, 0xF8, 0x3F, 0x3C, 0xF9,
  0xF8, 0x3F, 0x3C, 0xF9, 0xF0, 0x3F, 0x3C, 0xF3, 0xF0, 0x3F, 0x3F, 0xF3,
  0xF0, 0x3F, 0x3F, 0xE3, 0xF0, 0x7E, 0x1F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x87,
  0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xFE, 0x07, 0xE0, 0xFF, 0x81, 0xF8,
  0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x3F, 0x03, 0xFF, 0x0F, 0xC0, 0xFB, 0xC3,
  0xF0, 0x7E, 0xF0, 0xFC, 0x1F, 0xBC, 0x3F, 0x07, 0xEF, 0x9F, 0x81, 0xF9,
  0xE7, 0xE0, 0x7E, 0x79, 0xF8, 0x1F, 0x1E, 0x7E, 0x0F, 0xC7, 0xDF, 0x83,
  0xF0, 0xF7, 0xC0, 0xFC, 0x3F, 0xF0, 0x3F, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF,
  0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0x80,
  0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x3E, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x1F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x07,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F,
  0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7E,
  0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1,
  0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8,
  0x7E, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8,
  0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0x80, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x03,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7E,
  0x03, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3F,
  0xF8, 0x1F, 0x83, 0xFF, 0x83, 0xF8, 0x3E, 0xF8, 0x3F, 0x87, 0xEF, 0x83,
  0xF8, 0x7E, 0xF8, 0x7F, 0x87, 0xCF, 0x87, 0xF8, 0xFC, 0xF8, 0x7F, 0x8F,
  0xCF, 0x8F, 0xF8, 0xF8, 0xF8, 0xFF, 0x9F, 0x8F, 0x8F, 0xF9, 0xF8, 0xF9,
  0xFF, 0x9F, 0x0F, 0x9F, 0xF9, 0xF0, 0xF9, 0xEF, 0xBF, 0x0F, 0xBE, 0xFB,
  0xE0, 0xFB, 0xEF, 0xBE, 0x0F, 0xBC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x9F,
  0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xDE, 0x0F, 0x78, 0x78,
  0xE1, 0xE3, 0xCF, 0x8F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xC0, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7C, 0x3F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xF1, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xDF, 0x9F, 0x87, 0xE7,
  0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xCF, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0xCF, 0x81,
  0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x7F, 0x87, 0xC7, 0xC0, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xFD, 0xF8,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0xFD, 0xF8, 0x7C, 0xFC, 0x7E, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE7,
  0xE0, 0xFF, 0x7C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF1,
  0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xF3, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x08, 0xFE, 0x0C, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0x9F, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFD, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x06, 0x07, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF9, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7E, 0x3F, 0x3F, 0x07,
  0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0,
  0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0xFC, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F,
  0xCF, 0xE0, 0x7E, 0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x0F, 0x9F, 0x07,
  0xC0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC7, 0xF1, 0xF8, 0x7C, 0x1F, 0x87, 0xC7, 0xE0,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC1, 0xF1, 0xF8, 0x7E, 0x0F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7C, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x3F, 0x3F, 0x07, 0xC1, 0xF1,
  0xF8, 0x7E, 0x0F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xE0,
  0xFC, 0x3F, 0x1F, 0x07, 0xC1, 0xF9, 0xF8, 0x3E, 0x0F, 0x8F, 0xC3, 0xF0,
  0x7C, 0x7E, 0x1F, 0x87, 0xE0, 0x0F, 0x9F, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F,
  0x07, 0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83,
  0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x9F, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC3, 0xE7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xBF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0,
  0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xF7, 0xF8, 0x1F, 0x9F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xE1, 0xFE, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3,
  0xE0, 0x7E, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xBC, 0x3F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x9F, 0x87,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF3, 0xF0, 0x7C,
  0xFC, 0x3F, 0x1F, 0x9F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x07, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFB, 0xE0, 0x3E, 0x7C,
  0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87, 0xE7, 0xC3, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0x9F, 0x1F, 0x87, 0xCF, 0x8F, 0xC7,
  0xE7, 0xC7, 0xE3, 0xE3, 0xE7, 0xF1, 0xF1, 0xF3, 0xF9, 0xF0, 0xFB, 0xFC,
  0xF8, 0x7D, 0xFE, 0x7C, 0x3E, 0xFF, 0x7C, 0x1F, 0xFF, 0xBE, 0x0F, 0xFB,
  0xDF, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFE,
  0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7D, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFB,
  0xE0, 0x1F, 0xBE, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x07, 0xE1, 0xF0, 0x7E,
  0x1F, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC,
  0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF3,
  0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3E,
  0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF8,
  0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x00, 0x01, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x0C, 0x00, 0x0F, 0x00,
  0x07, 0xF8, 0x3D, 0xFF, 0x07, 0xBF, 0xF1, 0xFF, 0xFF, 0xFD, 0xF3, 0xFF,
  0xBC, 0x3F, 0xE7, 0x83, 0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 30, 11, 1, -30 },
  { 39, 13, 11, 13, 2, -32 },
  { 57, 21, 30, 22, 1, -30 },
  { 136, 19, 38, 21, 1, -34 },
  { 227, 19, 30, 26, 4, -30 },
  { 299, 21, 30, 24, 1, -30 },
  { 378, 7, 11, 7, 2, -32 },
  { 388, 13, 42, 13, 2, -33 },
  { 457, 13, 42, 13, -2, -33 },
  { 526, 18, 18, 18, 2, -30 },
  { 567, 18, 21, 19, 1, -24 },
  { 615, 8, 13, 10, -2, -5 },
  { 628, 11, 5, 15, 2, -15 },
  { 635, 6, 6, 12, 1, -6 },
  { 640, 19, 33, 14, -3, -30 },
  { 719, 18, 30, 21, 2, -30 },
  { 787, 12, 30, 21, 5, -30 },
  { 832, 20, 30, 21, 0, -30 },
  { 907, 19, 30, 21, 1, -30 },
  { 979, 19, 30, 21, 1, -30 },
  { 1051, 20, 30, 21, 1, -30 },
  { 1126, 17, 30, 21, 2, -30 },
  { 1190, 20, 30, 21, 2, -30 },
  { 1265, 19, 30, 21, 1, -30 },
  { 1337, 17, 30, 21, 3, -30 },
  { 1401, 9, 23, 11, 1, -23 },
  { 1427, 12, 31, 11, -2, -23 },
  { 1474, 17, 20, 18, 1, -23 },
  { 1517, 17, 14, 20, 2, -20 },
  { 1547, 17, 20, 19, 1, -23 },
  { 1590, 16, 30, 18, 3, -30 },
  { 1650, 29, 38, 31, 1, -29 },
  { 1788, 24, 30, 24, -2, -30 },
  { 1878, 22, 30, 23, 0, -30 },
  { 1961, 21, 30, 23, 2, -30 },
  { 2040, 22, 30, 23, 0, -30 },
  { 2123, 22, 30, 20, 0, -30 },
  { 2206, 21, 30, 19, 0, -30 },
  { 2285, 22, 30, 24, 2, -30 },
  { 2368, 26, 30, 25, 0, -30 },
  { 2466, 11, 30, 11, 0, -30 },
  { 2508, 21, 30, 20, 0, -30 },
  { 2587, 26, 30, 23, 0, -30 },
  { 2685, 17, 30, 20, 0, -30 },
  { 2749, 32, 30, 31, 0, -30 },
  { 2869, 26, 30, 25, 0, -30 },
  { 2967, 22, 30, 25, 2, -30 },
  { 3050, 23, 30, 23, 0, -30 },
  { 3137, 22, 35, 25, 2, -30 },
  { 3234, 23, 30, 23, 0, -30 },
  { 3321, 21, 30, 22, 1, -30 },
  { 3400, 21, 30, 22, 3, -30 },
  { 3479, 23, 30, 23, 1, -30 },
  { 3566, 23, 30, 24, 3, -30 },
  { 3653, 28, 30, 31, 4, -30 },
  { 3758, 26, 30, 23, -1, -30 },
  { 3856, 22, 30, 22, 3, -30 },
  { 3939, 24, 30, 22, -1, -30 },
  { 4029, 14, 42, 11, -1, -35 },
  { 4103, 10, 33, 16, 3, -30 },
  { 4145, 14, 42, 11, -2, -35 },
  { 4219, 14, 15, 16, 1, -30 },
  { 4246, 17, 5, 16, -3, 0 },
  { 4257, 9, 6, 14, 4, -31 },
  { 4264, 18, 22, 19, 0, -22 },
  { 4314, 19, 32, 20, 0, -32 },
  { 4390, 17, 22, 19, 1, -22 },
  { 4437, 20, 32, 20, 1, -32 },
  { 4517, 17, 22, 20, 1, -22 },
  { 4564, 15, 32, 13, 1, -32 },
  { 4624, 20, 31, 21, 0, -22 },
  { 4702, 18, 32, 20, 0, -32 },
  { 4774, 11, 31, 10, 0, -31 },
  { 4817, 16, 40, 10, -5, -31 },
  { 4897, 21, 32, 19, 0, -32 },
  { 4981, 11, 32, 10, 0, -32 },
  { 5025, 29, 22, 30, 0, -22 },
  { 5105, 18, 22, 20, 0, -22 },
  { 5155, 18, 22, 20, 1, -22 },
  { 5205, 21, 31, 20, -2, -22 },
  { 5287, 19, 31, 20, 1, -22 },
  { 5361, 14, 22, 13, 0, -22 },
  { 5400, 18, 22, 19, 0, -22 },
  { 5450, 12, 28, 12, 1, -28 },
  { 5492, 19, 22, 20, 1, -22 },
  { 5545, 17, 22, 18, 2, -22 },
  { 5592, 25, 22, 26, 2, -22 },
  { 5661, 20, 22, 18, -1, -22 },
  { 5716, 21, 31, 18, -1, -22 },
  { 5798, 19, 22, 18, -1, -22 },
  { 5851, 13, 40, 12, 1, -33 },
  { 5916, 9, 36, 10, 1, -30 },
  { 5957, 13, 40, 12, -2, -33 },
  { 6022, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_BOLDITALIC42PT7B_H_
