#ifndef _ROBOTOCONDENSED_BOLDITALIC45PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7C, 0xFB, 0xE7,
  0xDF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0xDE, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0x79, 0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8E,
  0x00, 0x1C, 0x78, 0x00, 0xF1, 0xE0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3E, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x87, 0x8F, 0x06, 0x78, 0x78,
  0x7B, 0xC3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0xBC, 0x3C,
  0x7B, 0xE1, 0xFF, 0xDE, 0x07, 0xFD, 0xE0, 0x1F, 0xDE, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x7B, 0xF8, 0x07,
  0xBF, 0xE0, 0x7B, 0xFF, 0x83, 0xDE, 0x3C, 0x3D, 0xF1, 0xE3, 0xCF, 0x0F,
  0x3E, 0x78, 0x79, 0xE3, 0xC3, 0xDE, 0x1E, 0x1E, 0xE0, 0xF1, 0xE3, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F,
  0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F,
  0x00, 0xFC, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x7C, 0x7F, 0xF1, 0xF3, 0xFF,
  0xCF, 0xDF, 0xBF, 0xBF, 0x7E, 0x7E, 0xFB, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF,
  0xBF, 0x0F, 0xFC, 0xFC, 0x1F, 0xE3, 0xF0, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0x01, 0xF8,
  0x7E, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0xBE, 0xF3, 0xCF, 0x3C, 0x00, 0x08,
  0x00, 0x60, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x60, 0xE0, 0xDF, 0x1C, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xCF, 0x01, 0xF1, 0xF0, 0x7C, 0x1E, 0x03, 0x03, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87,
  0xC1, 0xE0, 0x10, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xE0,
  0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0x9F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFD, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x3F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87,
  0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xBF,
  0xFB, 0xFF, 0xDF, 0xFE, 0xF3, 0xF4, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF1, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC,
  0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0x7E, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x7C, 0xFC, 0x0F, 0x8F, 0xC1, 0xF9, 0xFC, 0x1F, 0x1F, 0x83, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7C, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xCF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFD, 0xF0, 0x7E, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x07, 0xE7, 0xE3, 0xF9,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFE, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x1F, 0x87, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x8F, 0xE7, 0xE7, 0xF0, 0xF9, 0xF8,
  0x3F, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0xFE, 0x3F, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xEF, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0x38, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0F,
  0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xFC, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x3C, 0x1F, 0x03, 0xF0, 0x38, 0x3C, 0x0F, 0xF0, 0x78, 0xF8, 0x7F,
  0xF8, 0xF1, 0xE0, 0xFF, 0xE1, 0xE7, 0xC3, 0xE3, 0xC3, 0xCF, 0x0F, 0x87,
  0x87, 0x9E, 0x1E, 0x0F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF0, 0x78,
  0x3D, 0xE1, 0xE0, 0xF0, 0x7F, 0xC7, 0xC1, 0xE0, 0xEF, 0x0F, 0x87, 0xC1,
  0xDE, 0x1F, 0x0F, 0x07, 0xBC, 0x3C, 0x1E, 0x0F, 0x78, 0x78, 0x3C, 0x1C,
  0xF0, 0xF0, 0xF8, 0x79, 0xE1, 0xE1, 0xF0, 0xE3, 0xC3, 0xE7, 0xE3, 0xC7,
  0x87, 0xFF, 0xFF, 0x0F, 0x0F, 0xFF, 0xFE, 0x1E, 0x0F, 0xE7, 0xF0, 0x3C,
  0x0F, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x3E, 0x00,
  0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xFE, 0x7F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F,
  0xE1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE3, 0xFC,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x7E, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xC0,
  0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xFE,
  0xFE, 0x1F, 0xFD, 0xFC, 0x3F, 0xFB, 0xF0, 0x7F, 0xF7, 0xE0, 0xFF, 0xEF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x07, 0xF8, 0x07, 0xE0, 0xFF, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xBE, 0x0F, 0xBF, 0x07, 0xEF, 0x83, 0xEF, 0xC1, 0xFB, 0xE1,
  0xF7, 0xE0, 0x7E, 0xF8, 0x7D, 0xF8, 0x1F, 0xBE, 0x1F, 0x7E, 0x07, 0xE7,
  0x8F, 0x9F, 0x81, 0xF9, 0xE3, 0xE7, 0xE0, 0xFE, 0x79, 0xF3, 0xF0, 0x3F,
  0x1E, 0x7C, 0xFC, 0x0F, 0xC7, 0xFE, 0x3F, 0x03, 0xF1, 0xFF, 0x8F, 0xC0,
  0xFC, 0x7F, 0xC7, 0xF0, 0x3F, 0x1F, 0xF1, 0xFC, 0x1F, 0xC7, 0xF8, 0x7E,
  0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xE0, 0xF8, 0x3F, 0x83, 0xF8, 0x3E,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x1F,
  0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF,
  0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF8,
  0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0x0F, 0xC0, 0xFD, 0xE1, 0xF8, 0x3F, 0xBC,
  0x3F, 0x07, 0xF7, 0xC7, 0xE0, 0xFC, 0xF8, 0xFC, 0x1F, 0x8F, 0x3F, 0x83,
  0xF1, 0xF7, 0xE0, 0x7E, 0x3E, 0xFC, 0x1F, 0xC3, 0xDF, 0x83, 0xF8, 0x7B,
  0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x1F, 0xF0, 0x3F,
  0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xF8, 0x0F, 0xF8, 0x3F, 0x00, 0xFF,
  0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x07, 0xF8, 0x1F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0x87,
  0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE1, 0xFE, 0x7F, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xE0, 0xFF, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE,
  0x3F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xFE,
  0x7F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80,
  0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0x8F, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0xFF,
  0xF8, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE, 0x0F, 0xEF,
  0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x0F, 0xF0, 0x7E, 0x7E,
  0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8, 0xFF, 0x87, 0xE3, 0xF1,
  0xFF, 0x1F, 0x87, 0xE3, 0xFE, 0x3F, 0x0F, 0xCF, 0xFC, 0x7E, 0x1F, 0x9F,
  0xF9, 0xF8, 0x3F, 0x3F, 0xF3, 0xF0, 0x7E, 0xFF, 0xE7, 0xE0, 0xFD, 0xF7,
  0xCF, 0x81, 0xFB, 0xE7, 0xBF, 0x03, 0xFF, 0x8F, 0x7E, 0x07, 0xFF, 0x1E,
  0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01,
  0xF9, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBC,
  0x1E, 0x78, 0x7C, 0xF8, 0xF1, 0xF3, 0xE1, 0xE7, 0x83, 0xDF, 0x07, 0xBE,
  0x0F, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x8F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0xFE, 0x1F, 0x9F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xF7, 0xE0, 0x7C, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xDF, 0xF8, 0xFD, 0xFF, 0x0F, 0xC7, 0xC0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFD,
  0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x0F,
  0xCF, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x3F, 0x01, 0xFE, 0xFC, 0x1F,
  0xFB, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0x1F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x41, 0xFC, 0x3C, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x0F, 0xF3, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x02, 0x03, 0xF8, 0x1C, 0x1F, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0x00, 0x80, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7E, 0x3F, 0x81, 0xF9, 0xFE, 0x07, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFE, 0xFC, 0x07,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0x0F, 0xCF, 0x83, 0xF0, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F, 0xFF, 0xBF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0xFF, 0x1F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC,
  0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0x7E, 0x3F,
  0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF8,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0x1F, 0x83,
  0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x8F,
  0x80, 0xFB, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC,
  0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x3F,
  0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F,
  0xCF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0xC3, 0xF9, 0xF8, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF7, 0xE0, 0x0F, 0xBF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFD, 0xFF, 0x83, 0xF7, 0xFC, 0x0F, 0xC7,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0xBF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xF8, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xDE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F,
  0xC7, 0xC1, 0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xF8, 0xFF, 0x87,
  0xF8, 0x7F, 0x01, 0xF0, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xDF, 0x01, 0xFB, 0xF0, 0xFC, 0x0F, 0xFF, 0x81, 0xF9, 0xF8, 0x7F, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x87, 0xEF, 0x87, 0xE1, 0xFB, 0xE1,
  0xF8, 0x7C, 0xF8, 0x7E, 0x3F, 0x3E, 0x3F, 0x8F, 0xCF, 0x8F, 0xE3, 0xE3,
  0xE7, 0xF9, 0xF8, 0xF9, 0xFE, 0x7E, 0x3E, 0x7F, 0x9F, 0x0F, 0xBF, 0xEF,
  0xC3, 0xEF, 0x7B, 0xF0, 0xFF, 0xDE, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xF9,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC3,
  0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0x3E, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x1F, 0xC1,
  0xF8, 0x3F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE0, 0xFC, 0x3F,
  0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x01, 0xF7,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x38, 0x00, 0x20, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x80, 0x01, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x7C,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xCF, 0xF8,
  0x3E, 0xFF, 0xE1, 0xE7, 0xFF, 0x9F, 0x7E, 0x7F, 0xFB, 0xE1, 0xFF, 0x9E,
  0x0F, 0xFC, 0xF0, 0x3F, 0xC0, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 32, 11, 1, -32 },
  { 45, 13, 12, 14, 3, -34 },
  { 65, 22, 32, 23, 1, -32 },
  { 153, 21, 41, 22, 1, -37 },
  { 261, 21, 32, 28, 4, -32 },
  { 345, 22, 32, 25, 1, -32 },
  { 433, 6, 12, 7, 3, -34 },
  { 442, 14, 46, 14, 2, -36 },
  { 523, 14, 46, 14, -2, -36 },
  { 604, 19, 19, 20, 2, -32 },
  { 650, 19, 24, 21, 1, -27 },
  { 707, 10, 13, 11, -3, -5 },
  { 724, 12, 5, 16, 2, -16 },
  { 732, 7, 7, 13, 1, -7 },
  { 739, 20, 35, 15, -3, -32 },
  { 827, 19, 32, 22, 2, -32 },
  { 903, 13, 32, 22, 5, -32 },
  { 955, 21, 32, 22, 0, -32 },
  { 1039, 20, 32, 22, 1, -32 },
  { 1119, 20, 32, 22, 1, -32 },
  { 1199, 21, 32, 22, 1, -32 },
  { 1283, 18, 32, 22, 2, -32 },
  { 1355, 21, 32, 22, 2, -32 },
  { 1439, 20, 32, 22, 1, -32 },
  { 1519, 18, 32, 22, 3, -32 },
  { 1591, 10, 25, 12, 1, -25 },
  { 1623, 13, 33, 11, -2, -25 },
  { 1677, 18, 21, 20, 1, -24 },
  { 1725, 19, 14, 22, 2, -21 },
  { 1759, 18, 21, 20, 1, -24 },
  { 1807, 17, 32, 20, 3, -32 },
  { 1875, 31, 41, 33, 1, -31 },
  { 2034, 25, 32, 26, -2, -32 },
  { 2134, 24, 32, 25, 0, -32 },
  { 2230, 23, 32, 25, 2, -32 },
  { 2322, 24, 32, 25, 0, -32 },
  { 2418, 24, 32, 21, 0, -32 },
  { 2514, 23, 32, 21, 0, -32 },
  { 2606, 23, 32, 26, 2, -32 },
  { 2698, 28, 32, 27, 0, -32 },
  { 2810, 12, 32, 12, 0, -32 },
  { 2858, 22, 32, 21, 0, -32 },
  { 2946, 28, 32, 24, 0, -32 },
  { 3058, 18, 32, 21, 0, -32 },
  { 3130, 34, 32, 33, 0, -32 },
  { 3266, 27, 32, 27, 0, -32 },
  { 3374, 24, 32, 26, 2, -32 },
  { 3470, 25, 32, 25, 0, -32 },
  { 3570, 23, 38, 26, 2, -32 },
  { 3680, 24, 32, 24, 0, -32 },
  { 3776, 23, 32, 24, 1, -32 },
  { 3868, 23, 32, 24, 3, -32 },
  { 3960, 25, 32, 25, 1, -32 },
  { 4060, 25, 32, 25, 3, -32 },
  { 4160, 31, 32, 33, 4, -32 },
  { 4284, 28, 32, 24, -1, -32 },
  { 4396, 23, 32, 24, 4, -32 },
  { 4488, 26, 32, 23, -1, -32 },
  { 4592, 15, 44, 11, -1, -37 },
  { 4675, 10, 35, 17, 4, -32 },
  { 4719, 16, 44, 11, -3, -37 },
  { 4807, 15, 16, 17, 1, -32 },
  { 4837, 18, 5, 17, -3, 0 },
  { 4849, 10, 7, 14, 4, -34 },
  { 4858, 19, 24, 21, 0, -24 },
  { 4915, 20, 34, 22, 0, -34 },
  { 5000, 18, 24, 20, 1, -24 },
  { 5054, 22, 34, 22, 1, -34 },
  { 5148, 19, 24, 21, 1, -24 },
  { 5205, 16, 34, 14, 1, -34 },
  { 5273, 22, 33, 22, 0, -24 },
  { 5364, 20, 34, 21, 0, -34 },
  { 5449, 12, 34, 11, 0, -34 },
  { 5500, 17, 43, 11, -5, -34 },
  { 5592, 22, 34, 21, 0, -34 },
  { 5686, 12, 34, 11, 0, -34 },
  { 5737, 31, 24, 32, 0, -24 },
  { 5830, 20, 24, 21, 0, -24 },
  { 5890, 19, 24, 22, 1, -24 },
  { 5947, 22, 33, 22, -2, -24 },
  { 6038, 20, 33, 22, 1, -24 },
  { 6121, 15, 24, 14, 0, -24 },
  { 6166, 19, 24, 20, 0, -24 },
  { 6223, 12, 30, 13, 2, -30 },
  { 6268, 20, 24, 21, 1, -24 },
  { 6328, 19, 24, 20, 2, -24 },
  { 6385, 26, 24, 28, 3, -24 },
  { 6463, 23, 24, 20, -2, -24 },
  { 6532, 22, 33, 19, -1, -24 },
  { 6623, 21, 24, 20, -1, -24 },
  { 6686, 14, 43, 13, 1, -35 },
  { 6762, 9, 38, 11, 1, -32 },
  { 6805, 14, 43, 13, -2, -35 },
  { 6881, 21, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_BOLDITALIC45PT7B_H_
