#ifndef _ROBOTOCONDENSED_BOLDITALIC18PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x19, 0xCC, 0x60, 0x19, 0xC6, 0x00, 0x4A, 0xF7,
  0xBD, 0x00, 0x05, 0x86, 0xC3, 0x47, 0xF3, 0xF8, 0xD0, 0x58, 0x6C, 0x7F,
  0x7F, 0x8B, 0x0D, 0x04, 0x80, 0x0C, 0x0C, 0x1C, 0x3E, 0x77, 0x67, 0x60,
  0x70, 0x3C, 0x1C, 0x0E, 0xCE, 0xCE, 0xFC, 0x78, 0x20, 0x20, 0x70, 0xF2,
  0x92, 0x96, 0xFC, 0xE8, 0x18, 0x3E, 0x2F, 0x7B, 0xDB, 0x9B, 0x0E, 0x0E,
  0x0F, 0x8E, 0xC6, 0x63, 0x60, 0xF0, 0xE0, 0xFB, 0x6F, 0xF3, 0xF9, 0xCF,
  0xE3, 0xF8, 0x6B, 0x6C, 0x08, 0xCC, 0x66, 0x31, 0x98, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0x61, 0x00, 0x10, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x71,
  0x86, 0x18, 0xC3, 0x18, 0xE2, 0x00, 0x18, 0x33, 0x6F, 0xF3, 0x8D, 0x1B,
  0x24, 0x0C, 0x0C, 0x1C, 0x7F, 0x7F, 0x18, 0x18, 0x18, 0x38, 0x36, 0x66,
  0xC0, 0xFF, 0x7D, 0x80, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x1C, 0x7D, 0x9B, 0x3E, 0x7C, 0xF1,
  0xE3, 0xC7, 0x9F, 0x37, 0xE7, 0x80, 0x0B, 0xFF, 0x73, 0x98, 0xC6, 0x33,
  0x9C, 0xC6, 0x00, 0x1E, 0x1F, 0x8C, 0xCE, 0x60, 0x30, 0x38, 0x18, 0x18,
  0x18, 0x1C, 0x1C, 0x1F, 0xEF, 0xE0, 0x1E, 0x1F, 0x9C, 0xC0, 0x60, 0x30,
  0xF0, 0x78, 0x0E, 0x07, 0x73, 0xB9, 0x8F, 0xC3, 0xC0, 0x03, 0x07, 0x0F,
  0x0F, 0x1F, 0x37, 0x36, 0x66, 0xFF, 0xFF, 0x0E, 0x0E, 0x0C, 0x3F, 0x7F,
  0x60, 0x60, 0x7C, 0xFC, 0x0E, 0x06, 0x0E, 0xCE, 0xCC, 0xFC, 0x78, 0x0E,
  0x7C, 0xE3, 0x07, 0xDF, 0xFB, 0xE3, 0xC7, 0x9F, 0x37, 0xE7, 0x80, 0x7F,
  0x7F, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0,
  0x0E, 0x1F, 0x8C, 0xC6, 0x73, 0x31, 0xF0, 0xF8, 0xCC, 0x67, 0x33, 0x99,
  0x8F, 0xC3, 0xC0, 0x1C, 0xFD, 0x9F, 0x3E, 0x7C, 0xF9, 0xBF, 0x7E, 0x18,
  0x73, 0xC6, 0x00, 0x33, 0x30, 0x00, 0x06, 0xE6, 0x19, 0xC6, 0x00, 0x00,
  0x00, 0x31, 0x98, 0xCC, 0x00, 0x02, 0x06, 0x1E, 0x78, 0x60, 0xF8, 0x3C,
  0x0C, 0x04, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x20, 0x30, 0x7C, 0x1F,
  0x06, 0x1E, 0x78, 0x60, 0x80, 0x3C, 0xFD, 0xBF, 0x70, 0xE3, 0x8E, 0x18,
  0x30, 0x01, 0x83, 0x06, 0x00, 0x03, 0xC0, 0x73, 0x86, 0x04, 0x60, 0x22,
  0x39, 0xB3, 0xED, 0xB2, 0x69, 0x93, 0xC9, 0x96, 0xCC, 0xB3, 0xE9, 0x9F,
  0x84, 0x00, 0x30, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0x61, 0xD8, 0x67, 0x3F, 0xCF, 0xF7, 0x0D, 0xC3, 0xE0, 0xC0,
  0x3F, 0x0F, 0xE3, 0x18, 0xC6, 0x31, 0x9F, 0xC7, 0xF1, 0xCE, 0x63, 0x98,
  0xE6, 0x73, 0xFC, 0xFE, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x1F, 0x03,
  0x01, 0x80, 0xC0, 0x61, 0xB9, 0xDF, 0xC7, 0xC0, 0x3E, 0x0F, 0xE3, 0x38,
  0xC6, 0x31, 0x9C, 0x67, 0x19, 0xC6, 0x63, 0x98, 0xE6, 0x73, 0xF8, 0xFC,
  0x00, 0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x03, 0xF9, 0xFC, 0xE0, 0x60, 0x30,
  0x18, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x03, 0x81, 0xFC,
  0xFC, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x3E,
  0x07, 0x03, 0xBF, 0x9E, 0xC3, 0x61, 0xB9, 0xCF, 0xE3, 0xC0, 0x38, 0xE7,
  0x1C, 0xC3, 0x98, 0x63, 0x0C, 0xFF, 0x9F, 0xF3, 0x8E, 0x61, 0xCC, 0x31,
  0x86, 0x70, 0xCE, 0x38, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x63, 0x19, 0xCE,
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x73,
  0x3B, 0x8F, 0x87, 0x80, 0x38, 0xE7, 0x38, 0xCE, 0x1B, 0x83, 0x60, 0xFC,
  0x1F, 0x83, 0xF0, 0x76, 0x0C, 0xE1, 0x9C, 0x73, 0x8E, 0x38, 0x38, 0x70,
  0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0xFF, 0xE0, 0x3C, 0x38,
  0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF9, 0xF3, 0xE7, 0xDF, 0x1B, 0x6C,
  0x6D, 0xB1, 0xBD, 0xC6, 0x77, 0x39, 0x9C, 0xE6, 0x60, 0x38, 0xE7, 0x1C,
  0xE3, 0x9E, 0x63, 0xCC, 0xF9, 0x9D, 0x73, 0xBE, 0x67, 0xCC, 0xF1, 0x8E,
  0x71, 0xCE, 0x38, 0x1E, 0x1F, 0x9C, 0xEC, 0x3E, 0x1F, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xB9, 0xCF, 0xC3, 0xC0, 0x3F, 0x0F, 0xE3, 0x1C, 0xC7, 0x31,
  0xDC, 0x67, 0xF9, 0xFC, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x1E,
  0x1F, 0x9C, 0xEC, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xB9, 0xCF,
  0xC3, 0xE0, 0x38, 0x08, 0x3F, 0x0F, 0xE3, 0x1C, 0xC7, 0x31, 0x9C, 0xE7,
  0xF1, 0xF8, 0x66, 0x19, 0xC6, 0x73, 0x9C, 0xE3, 0x00, 0x0F, 0x07, 0xE3,
  0x98, 0xC6, 0x30, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x38, 0xC6, 0x71, 0xFC,
  0x3C, 0x00, 0x7F, 0xFF, 0xC7, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x00, 0x71, 0xB0, 0xD8, 0xEC, 0x7E, 0x3F, 0x1B,
  0x8D, 0x86, 0xC7, 0x63, 0xB9, 0x9F, 0xC7, 0xC0, 0xE1, 0xD8, 0x66, 0x39,
  0x8E, 0x63, 0x19, 0xC7, 0x61, 0xF8, 0x7C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x00, 0xCE, 0x7C, 0xE6, 0xCE, 0x6D, 0xEE, 0xDE, 0xCD, 0xEC, 0xFF, 0xCF,
  0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xC7, 0x00, 0x18, 0xE1, 0xCE,
  0x1D, 0xC0, 0xDC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB8,
  0x3B, 0x87, 0x38, 0x71, 0x80, 0x61, 0x98, 0xE7, 0x31, 0xDC, 0x36, 0x0F,
  0x83, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x3F, 0xCF,
  0xF0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0xFC, 0xFF, 0x00, 0x3C, 0xF3, 0x0C, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x18,
  0x63, 0x8E, 0x30, 0xE3, 0x80, 0x63, 0x18, 0xC6, 0x39, 0xCE, 0x31, 0x8C,
  0x63, 0x9C, 0x1C, 0x71, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30,
  0xC7, 0x1C, 0xF3, 0x80, 0x18, 0xE7, 0x9E, 0xCB, 0x30, 0xFF, 0xFC, 0xE6,
  0x60, 0x1C, 0x3E, 0x77, 0x06, 0x3E, 0x76, 0xE6, 0xEE, 0xFE, 0x7E, 0x38,
  0x30, 0x30, 0x30, 0x3E, 0x7F, 0x73, 0x63, 0x63, 0x63, 0x67, 0xE6, 0xFE,
  0xDC, 0x1C, 0x3E, 0x77, 0x67, 0x60, 0xE0, 0xE0, 0x66, 0x7E, 0x3C, 0x01,
  0x80, 0xC0, 0xE0, 0x73, 0xB3, 0xF9, 0xDC, 0xC6, 0x67, 0x73, 0xB9, 0x9C,
  0xC7, 0xE3, 0xB0, 0x1E, 0x3E, 0x77, 0x63, 0x7F, 0x7F, 0xE0, 0x60, 0x7E,
  0x3C, 0x1C, 0xF7, 0x1C, 0xFB, 0xE6, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x00,
  0x3F, 0x9F, 0x9C, 0xCC, 0x66, 0x37, 0x3B, 0x9C, 0xCC, 0x7E, 0x1B, 0x01,
  0x81, 0xCF, 0xC3, 0xC0, 0x38, 0x30, 0x30, 0x30, 0x7E, 0x7F, 0x77, 0x67,
  0x67, 0x67, 0xE6, 0xE6, 0xE6, 0xC6, 0x11, 0xCC, 0x03, 0x39, 0xCE, 0x63,
  0x19, 0xCE, 0x70, 0x04, 0x1C, 0x30, 0x00, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0x60, 0xC3, 0x87, 0x0C, 0x18, 0xF1, 0xC0, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x3B, 0xB9, 0xF8, 0xF8, 0x7C, 0x3E, 0x1B, 0x1D, 0xCE, 0xE6, 0x30, 0x39,
  0xCC, 0x63, 0x19, 0xCE, 0x63, 0x19, 0xCE, 0x70, 0x3E, 0xE7, 0xFF, 0x77,
  0x36, 0x73, 0x67, 0x36, 0x67, 0x66, 0x7E, 0x67, 0xE6, 0x6C, 0xE6, 0x7E,
  0x7F, 0x77, 0x67, 0x67, 0x67, 0xE6, 0xE6, 0xE6, 0xC6, 0x1E, 0x3F, 0x77,
  0x63, 0x63, 0xE3, 0xE7, 0x66, 0x7E, 0x3C, 0x1F, 0x1F, 0xCE, 0x66, 0x33,
  0x19, 0x8C, 0xCE, 0xE6, 0x7F, 0x37, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x3B,
  0x3F, 0x9D, 0xCC, 0x66, 0x77, 0x3B, 0x99, 0xCC, 0x7E, 0x3B, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x3D, 0xF7, 0xD8, 0x61, 0x86, 0x38, 0xE3, 0x00, 0x1C,
  0x3E, 0x67, 0x70, 0x78, 0x1C, 0x0E, 0xCE, 0xFC, 0x78, 0x73, 0xBF, 0xE6,
  0x73, 0x9C, 0xC6, 0x39, 0xC0, 0x73, 0x73, 0x73, 0x67, 0x67, 0x67, 0x66,
  0x66, 0x7E, 0x76, 0xC7, 0x9F, 0x37, 0x6F, 0x9F, 0x1E, 0x38, 0x70, 0xC0,
  0xCC, 0xD9, 0x9B, 0x77, 0x6E, 0xCD, 0x59, 0xEF, 0x3D, 0xC7, 0x38, 0xE6,
  0x1C, 0xC0, 0x3B, 0x8D, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x6C, 0x76,
  0x33, 0x80, 0x63, 0x67, 0x76, 0x7E, 0x7C, 0x7C, 0x3C, 0x38, 0x38, 0x30,
  0x30, 0x60, 0xE0, 0xC0, 0x7F, 0x7F, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0x60,
  0xFE, 0xFC, 0x0C, 0x71, 0x8E, 0x30, 0xC3, 0x18, 0xE1, 0x86, 0x18, 0x61,
  0x86, 0x1C, 0x20, 0x13, 0x33, 0x22, 0x26, 0x66, 0x44, 0x44, 0xC0, 0x10,
  0x61, 0x86, 0x18, 0x61, 0x87, 0x1C, 0xE3, 0x0C, 0x30, 0xC6, 0x38, 0x40,
  0x73, 0xFB, 0xDE, 0x8E,
};

const GFXglyph RobotoCondensed_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 5, 5, 6, 1, -14 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 8, 17, 9, 1, -15 },
  { 46, 8, 13, 11, 2, -13 },
  { 59, 9, 13, 10, 0, -13 },
  { 74, 3, 5, 3, 1, -14 },
  { 76, 5, 18, 6, 1, -14 },
  { 88, 6, 18, 6, -1, -14 },
  { 102, 7, 8, 8, 1, -13 },
  { 109, 8, 9, 8, 0, -10 },
  { 118, 4, 5, 4, -1, -2 },
  { 121, 4, 2, 6, 1, -6 },
  { 122, 3, 3, 5, 0, -3 },
  { 124, 8, 14, 6, -1, -13 },
  { 138, 7, 13, 9, 1, -13 },
  { 150, 5, 13, 9, 2, -13 },
  { 159, 9, 13, 9, 0, -13 },
  { 174, 9, 13, 9, 0, -13 },
  { 189, 8, 13, 9, 0, -13 },
  { 202, 8, 13, 9, 1, -13 },
  { 215, 7, 13, 9, 1, -13 },
  { 227, 8, 13, 9, 1, -13 },
  { 240, 9, 13, 9, 0, -13 },
  { 255, 7, 13, 9, 1, -13 },
  { 267, 4, 10, 5, 0, -10 },
  { 272, 5, 13, 5, -1, -10 },
  { 281, 8, 9, 8, 0, -10 },
  { 290, 7, 6, 9, 1, -9 },
  { 296, 8, 9, 8, 0, -10 },
  { 305, 7, 13, 8, 1, -13 },
  { 317, 13, 16, 13, 0, -12 },
  { 343, 10, 13, 10, -1, -13 },
  { 360, 10, 13, 10, 0, -13 },
  { 377, 9, 13, 10, 1, -13 },
  { 392, 10, 13, 10, 0, -13 },
  { 409, 9, 13, 9, 0, -13 },
  { 424, 9, 13, 8, 0, -13 },
  { 439, 9, 13, 10, 1, -13 },
  { 454, 11, 13, 11, 0, -13 },
  { 472, 5, 13, 5, 0, -13 },
  { 481, 9, 13, 9, 0, -13 },
  { 496, 11, 13, 10, 0, -13 },
  { 514, 7, 13, 8, 0, -13 },
  { 526, 14, 13, 13, 0, -13 },
  { 549, 11, 13, 11, 0, -13 },
  { 567, 9, 13, 11, 1, -13 },
  { 582, 10, 13, 10, 0, -13 },
  { 599, 9, 15, 11, 1, -13 },
  { 616, 10, 13, 10, 0, -13 },
  { 633, 10, 13, 9, 0, -13 },
  { 650, 9, 13, 9, 1, -13 },
  { 665, 9, 13, 10, 1, -13 },
  { 680, 10, 13, 10, 1, -13 },
  { 697, 12, 13, 13, 2, -13 },
  { 717, 12, 13, 10, -1, -13 },
  { 737, 10, 13, 9, 1, -13 },
  { 754, 10, 13, 9, 0, -13 },
  { 771, 6, 18, 5, 0, -15 },
  { 785, 5, 14, 7, 1, -13 },
  { 794, 6, 18, 5, -1, -15 },
  { 808, 6, 6, 7, 1, -13 },
  { 813, 7, 2, 7, -1, 0 },
  { 815, 4, 3, 6, 2, -14 },
  { 817, 8, 10, 8, 0, -10 },
  { 827, 8, 14, 9, 0, -14 },
  { 841, 8, 10, 8, 0, -10 },
  { 851, 9, 14, 9, 0, -14 },
  { 867, 8, 10, 8, 0, -10 },
  { 877, 6, 14, 6, 1, -14 },
  { 888, 9, 14, 9, 0, -10 },
  { 904, 8, 14, 9, 0, -14 },
  { 918, 5, 14, 4, 0, -14 },
  { 927, 7, 18, 4, -2, -14 },
  { 943, 9, 14, 8, 0, -14 },
  { 959, 5, 14, 4, 0, -14 },
  { 968, 12, 10, 13, 0, -10 },
  { 983, 8, 10, 9, 0, -10 },
  { 993, 8, 10, 9, 0, -10 },
  { 1003, 9, 14, 9, -1, -10 },
  { 1019, 9, 14, 9, 0, -10 },
  { 1035, 6, 10, 6, 0, -10 },
  { 1043, 8, 10, 8, 0, -10 },
  { 1053, 5, 12, 5, 1, -12 },
  { 1061, 8, 10, 9, 0, -10 },
  { 1071, 7, 10, 8, 1, -10 },
  { 1080, 11, 10, 11, 1, -10 },
  { 1094, 9, 10, 8, -1, -10 },
  { 1106, 8, 14, 8, 0, -10 },
  { 1120, 8, 10, 8, 0, -10 },
  { 1130, 6, 17, 5, 0, -14 },
  { 1143, 4, 15, 4, 0, -13 },
  { 1151, 6, 17, 5, -1, -14 },
  { 1164, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_BOLDITALIC18PT7B_H_
