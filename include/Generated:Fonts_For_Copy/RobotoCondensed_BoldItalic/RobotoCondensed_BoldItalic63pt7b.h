#ifndef _ROBOTOCONDENSED_BOLDITALIC63PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFE, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x0E, 0x1F, 0x83, 0xE0, 0x7C, 0x7E, 0x0F, 0x81,
  0xF9, 0xF8, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E, 0x1F, 0x07, 0xE1, 0xF0,
  0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0x7E, 0x7E, 0x07, 0xC1, 0xF9, 0xF0, 0x1F,
  0x8F, 0xCF, 0xC0, 0x7F, 0xFF, 0x7E, 0x00, 0xFF, 0xF9, 0xF0, 0x03, 0xFF,
  0xEF, 0xC0, 0x07, 0xFF, 0x7E, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x06, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0x9F, 0xFC,
  0x00, 0x7E, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF, 0x80,
  0x7E, 0xFE, 0x3F, 0x03, 0xF3, 0xF0, 0xFC, 0x0F, 0x8F, 0xC3, 0xF0, 0x7E,
  0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xFC, 0x7E, 0x1F,
  0x83, 0xF3, 0xF0, 0x7E, 0x0F, 0xCF, 0x80, 0xF8, 0x3E, 0x3E, 0x03, 0xF1,
  0xF8, 0x30, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0xFF, 0xFF, 0x87,
  0xF3, 0xFE, 0xFF, 0x9F, 0xEF, 0xF9, 0xFF, 0x3F, 0x9F, 0xF1, 0xFF, 0x7F,
  0x3F, 0xC3, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xF3,
  0xFE, 0x07, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0x8F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x80,
  0x7C, 0x06, 0x3C, 0x0F, 0x83, 0xCF, 0xF1, 0xF3, 0xF9, 0xFF, 0xBD, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x3F, 0x87,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x01, 0xF0, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0x00, 0xF8, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xDF, 0xF0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x3F, 0xCF, 0x0F, 0xF9, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0xC0,
  0x07, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x7C, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0x83, 0xFE, 0x00, 0x38, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xC0, 0x3F, 0xDF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F,
  0xE3, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7,
  0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x07, 0xFE, 0xFF, 0x87,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xCF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0x7E, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x7E, 0x01,
  0xFF, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0xC3, 0xE0, 0xFC, 0x07, 0xFF,
  0xF8, 0x3E, 0x0F, 0xC0, 0xFF, 0x9F, 0x81, 0xF0, 0xF8, 0x0F, 0xE1, 0xF8,
  0x1F, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x81, 0xF0, 0x1F,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x3F,
  0x07, 0xE0, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x7E, 0x0F,
  0xE0, 0x7E, 0x03, 0xE7, 0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x7E, 0x0F, 0xC0,
  0x7E, 0x03, 0xE7, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x1F, 0xC0, 0x7C,
  0x07, 0xCF, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0xCF, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0x8F,
  0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC1,
  0xFC, 0x3F, 0x81, 0xF0, 0xFC, 0x1F, 0xC7, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF,
  0xFF, 0xC7, 0xE0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xEF,
  0xFF, 0x80, 0xFC, 0x07, 0xFC, 0x7F, 0xF0, 0x07, 0xC0, 0x3F, 0x83, 0xFE,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFC,
  0x7F, 0x80, 0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF,
  0x1F, 0xF0, 0x3F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xC7, 0xFC, 0x0F, 0xFF,
  0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F,
  0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x03,
  0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0x81, 0xFC, 0xFF, 0x01, 0xFF,
  0x7F, 0x03, 0xFB, 0xFE, 0x03, 0xFE, 0x7E, 0x0F, 0xE7, 0xF8, 0x07, 0xF8,
  0xFC, 0x1F, 0xCF, 0xF0, 0x0F, 0xF1, 0xF8, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3,
  0xF0, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xF1, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xE7, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xCF, 0xE3, 0xFC, 0x03, 0xFE, 0x3F,
  0xBF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x7F, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFC,
  0x07, 0xFD, 0xF8, 0x1F, 0xF0, 0x1F, 0xF7, 0xE0, 0x7F, 0x80, 0x7F, 0xDF,
  0xC1, 0xFE, 0x01, 0xFF, 0x7F, 0x0F, 0xF8, 0x07, 0xF8, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE3, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xE3, 0xFE, 0x03, 0xFE, 0x1F,
  0x8F, 0xF0, 0x0F, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0xC1, 0xF9, 0xFF, 0x01,
  0xFF, 0x07, 0xF7, 0xFC, 0x07, 0xFC, 0x0F, 0xDF, 0xF0, 0x1F, 0xF0, 0x3F,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFD, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x6F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF0, 0x0F, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xE1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0xE0, 0xFF,
  0x07, 0xF8, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xFF, 0x87, 0xF8, 0x1F,
  0xE3, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F,
  0xFF, 0xC7, 0xF8, 0x0F, 0xF3, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x7F,
  0x3F, 0xE0, 0x3F, 0xCF, 0xEF, 0xE7, 0xF8, 0x07, 0xFB, 0xFD, 0xFC, 0xFF,
  0x00, 0xFF, 0x7F, 0x1F, 0x9F, 0xE0, 0x1F, 0xEF, 0xE3, 0xF7, 0xF8, 0x03,
  0xFF, 0xF8, 0x7E, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xDF, 0xE0, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF7,
  0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xE7, 0xC0, 0x7E,
  0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF1,
  0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x00,
  0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF3, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xC3, 0xFC, 0x7F, 0xC1,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFE, 0x7F, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFB, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xFE,
  0x0F, 0xF1, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x81, 0xFF, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xEF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x1F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x03, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFE,
  0xFF, 0x03, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x02, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x03, 0x80, 0x3F, 0xE0,
  0x0F, 0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x02, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFF,
  0x83, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xE1, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0x9F, 0xE0, 0x3F, 0xC0, 0x1F, 0xEF, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x87, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFB, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01,
  0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC,
  0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0x9F, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0,
  0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xE0, 0x3F, 0xEF,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x04, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x7F, 0xF1, 0xFC, 0x07, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x30,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF7, 0xE0, 0x7F, 0xBF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF1,
  0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x18, 0x00, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F,
  0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0xC0, 0x1F, 0xF3, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF9,
  0xFE, 0x03, 0xFE, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xF8, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03,
  0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0x03, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xF8, 0x1F,
  0xEF, 0xF0, 0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF,
  0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0x87, 0xF8, 0xFE,
  0x3F, 0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F, 0xFC, 0xFF,
  0x0F, 0xE7, 0xFF, 0xCF, 0xE0, 0xFE, 0x7E, 0xFD, 0xFE, 0x0F, 0xEF, 0xEF,
  0xDF, 0xC0, 0xFE, 0xFE, 0xFD, 0xFC, 0x0F, 0xEF, 0xCF, 0xFF, 0xC0, 0xFF,
  0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE3,
  0xFE, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xF0,
  0xFF, 0xE0, 0x1F, 0xC7, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0x81, 0xF8, 0xFF,
  0xFF, 0x0F, 0xE3, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0xFC, 0x7F, 0x0F,
  0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0x87, 0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0x7F,
  0xF0, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 46, 16, 1, -45 },
  { 93, 18, 17, 20, 4, -47 },
  { 132, 32, 45, 32, 1, -45 },
  { 312, 28, 59, 31, 2, -52 },
  { 519, 30, 47, 39, 5, -46 },
  { 696, 31, 47, 35, 1, -46 },
  { 879, 9, 17, 10, 4, -47 },
  { 899, 19, 64, 20, 3, -50 },
  { 1051, 20, 64, 20, -3, -50 },
  { 1211, 27, 27, 28, 3, -45 },
  { 1303, 26, 33, 29, 2, -37 },
  { 1411, 14, 19, 15, -4, -8 },
  { 1445, 16, 7, 22, 3, -23 },
  { 1459, 10, 10, 18, 1, -9 },
  { 1472, 28, 49, 20, -4, -45 },
  { 1644, 27, 47, 31, 3, -46 },
  { 1803, 19, 45, 31, 7, -45 },
  { 1910, 30, 46, 31, 0, -46 },
  { 2083, 29, 47, 31, 1, -46 },
  { 2254, 29, 45, 31, 1, -45 },
  { 2418, 29, 46, 31, 2, -45 },
  { 2585, 25, 46, 31, 3, -45 },
  { 2729, 29, 45, 31, 3, -45 },
  { 2893, 28, 47, 31, 2, -46 },
  { 3058, 25, 46, 31, 4, -46 },
  { 3202, 15, 35, 17, 1, -34 },
  { 3268, 18, 45, 16, -3, -34 },
  { 3370, 25, 30, 27, 1, -34 },
  { 3464, 27, 20, 31, 2, -30 },
  { 3532, 25, 30, 28, 1, -34 },
  { 3626, 24, 47, 27, 4, -46 },
  { 3767, 44, 58, 47, 1, -44 },
  { 4086, 36, 45, 36, -3, -45 },
  { 4289, 33, 45, 34, 0, -45 },
  { 4475, 33, 47, 35, 2, -46 },
  { 4669, 33, 45, 35, 0, -45 },
  { 4855, 33, 45, 30, 0, -45 },
  { 5041, 32, 45, 29, 0, -45 },
  { 5221, 33, 47, 36, 2, -46 },
  { 5415, 39, 45, 38, 0, -45 },
  { 5635, 16, 45, 16, 1, -45 },
  { 5725, 31, 46, 30, 0, -45 },
  { 5904, 39, 45, 34, 0, -45 },
  { 6124, 26, 45, 29, 0, -45 },
  { 6271, 47, 45, 46, 0, -45 },
  { 6536, 38, 45, 37, 0, -45 },
  { 6750, 34, 47, 37, 2, -46 },
  { 6950, 35, 45, 35, 0, -45 },
  { 7147, 34, 54, 37, 2, -46 },
  { 7377, 34, 45, 34, 0, -45 },
  { 7569, 32, 47, 33, 1, -46 },
  { 7757, 31, 45, 33, 5, -45 },
  { 7932, 34, 46, 35, 2, -45 },
  { 8128, 34, 45, 35, 5, -45 },
  { 8320, 43, 45, 46, 6, -45 },
  { 8562, 39, 45, 34, -2, -45 },
  { 8782, 32, 45, 33, 5, -45 },
  { 8962, 36, 45, 32, -1, -45 },
  { 9165, 21, 62, 16, -1, -52 },
  { 9328, 15, 49, 23, 5, -45 },
  { 9420, 22, 62, 16, -4, -52 },
  { 9591, 21, 22, 24, 2, -45 },
  { 9649, 25, 7, 24, -4, 0 },
  { 9671, 14, 10, 20, 6, -48 },
  { 9689, 26, 35, 29, 1, -34 },
  { 9803, 28, 48, 30, 0, -47 },
  { 9971, 26, 35, 28, 1, -34 },
  { 10085, 31, 48, 30, 1, -47 },
  { 10271, 27, 35, 29, 1, -34 },
  { 10390, 22, 48, 20, 2, -48 },
  { 10522, 30, 47, 31, 0, -34 },
  { 10699, 28, 47, 30, 0, -47 },
  { 10864, 16, 46, 15, 0, -46 },
  { 10956, 23, 59, 15, -7, -46 },
  { 11126, 31, 47, 29, 0, -47 },
  { 11309, 17, 47, 15, 0, -47 },
  { 11409, 43, 34, 45, 0, -34 },
  { 11592, 28, 34, 30, 0, -34 },
  { 11711, 27, 35, 30, 1, -34 },
  { 11830, 30, 47, 30, -2, -34 },
  { 12007, 29, 47, 30, 1, -34 },
  { 12178, 22, 34, 20, 0, -34 },
  { 12272, 26, 35, 28, 0, -34 },
  { 12386, 18, 43, 19, 2, -42 },
  { 12483, 28, 34, 30, 2, -33 },
  { 12602, 26, 33, 27, 3, -33 },
  { 12710, 36, 33, 39, 4, -33 },
  { 12859, 31, 33, 28, -2, -33 },
  { 12987, 31, 46, 27, -2, -33 },
  { 13166, 29, 33, 28, -1, -33 },
  { 13286, 20, 60, 18, 1, -49 },
  { 13436, 14, 53, 15, 1, -45 },
  { 13529, 19, 60, 18, -2, -49 },
  { 13672, 30, 14, 34, 2, -26 },
};

const GFXfont RobotoCondensed_BoldItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_BOLDITALIC63PT7B_H_
