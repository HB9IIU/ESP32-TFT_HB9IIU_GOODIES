#ifndef _ROBOTOCONDENSED_BOLDITALIC72PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x81, 0xFC, 0x1F, 0x80, 0x78, 0x7F, 0x07, 0xE0, 0x3F,
  0x9F, 0x81, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x83,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x0F, 0xE0, 0x7E,
  0x3F, 0x83, 0xF8, 0x3F, 0x8F, 0xC0, 0x7E, 0x0F, 0xE7, 0xE0, 0x1F, 0x87,
  0xF3, 0xF8, 0x07, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xFE, 0x7E, 0x00, 0x3F,
  0xFF, 0xBF, 0x80, 0x07, 0xFF, 0xDF, 0xC0, 0x00, 0xFF, 0xE7, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xE0, 0x00, 0x7E,
  0x7F, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xFF, 0xE0, 0x07,
  0xE7, 0xFF, 0xF8, 0x03, 0xF3, 0xF8, 0x7F, 0x01, 0xFC, 0xFE, 0x1F, 0xC0,
  0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xF1, 0xFC, 0x1F, 0x81,
  0xFC, 0xFE, 0x07, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0x1F, 0x8F, 0x80, 0x7F,
  0x0F, 0xE1, 0xE0, 0x0F, 0xE7, 0xF8, 0x10, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F,
  0xE3, 0xFF, 0x1F, 0xFB, 0xFE, 0x7F, 0xE1, 0xFF, 0xBF, 0xE7, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xF8, 0xFF,
  0xC0, 0x7F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x07,
  0xE0, 0x08, 0xF0, 0x1F, 0x81, 0xE7, 0xF0, 0x7C, 0x3F, 0x9F, 0xF9, 0xF3,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xF0,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF,
  0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x7E, 0x1F, 0xF3, 0xC0, 0xFF, 0x90, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x07, 0xF9, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC7, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x1F,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xDF,
  0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0,
  0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xF9,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0x80,
  0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0xFC,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xC3, 0xF8, 0x0F, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC7, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0x03,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0xF9, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x7F, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x7F,
  0x80, 0xFE, 0x01, 0xF9, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x7E, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xCF, 0xE0,
  0x7F, 0x01, 0xFC, 0x03, 0xE3, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F,
  0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xE0,
  0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE0, 0x3F, 0xFE, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF,
  0x00, 0x7E, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0xFF,
  0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF,
  0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xF0,
  0x1F, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xFC,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xBF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x1F, 0xE7, 0xFC,
  0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0x7F, 0x03, 0xFE,
  0xFF, 0xC0, 0x1F, 0xF1, 0xFC, 0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0xC7, 0xF0,
  0x3F, 0xCF, 0xFC, 0x03, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC,
  0x7F, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFE, 0x00,
  0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xE7, 0xF8, 0x7F,
  0xE0, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0xFE, 0x7F,
  0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFB, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xFF, 0x7F, 0x01, 0xFF, 0x80, 0x3F, 0xF7, 0xF0, 0x1F, 0xF8,
  0x03, 0xFF, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0xF7, 0xF8, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0xE3, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F,
  0xC7, 0xFE, 0x00, 0xFF, 0xE1, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xE7,
  0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xE7, 0xFE,
  0x00, 0xFF, 0xC0, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xEB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF8, 0x07,
  0xFC, 0x7F, 0xBF, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0x00,
  0x7F, 0xCF, 0xF3, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0x8F, 0xF7, 0xFE,
  0x00, 0x7F, 0xDF, 0xE3, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0xFF, 0x7F,
  0xC0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x03,
  0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF,
  0x80, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFE, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xFD, 0xFF, 0x80,
  0x3F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xE3, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x8F,
  0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFE,
  0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x03, 0xFF, 0x00, 0x1C, 0x07, 0xFE,
  0x01, 0xF0, 0x1F, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xF9, 0xFF,
  0x00, 0x7F, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xDF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x03, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x08, 0x00, 0x3F, 0xF0, 0x03,
  0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0x80,
  0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x04, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x7F, 0xCF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xBF, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03,
  0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x80,
  0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0xC0,
  0x01, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x3F,
  0xE0, 0x3F, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0,
  0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFF,
  0x3F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF,
  0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0x7F, 0x8F, 0xFF, 0x87, 0xF8, 0x1F,
  0xE3, 0xFF, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0xF8, 0xFF, 0x81, 0xFE, 0x7F,
  0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xFF, 0x9F, 0xF0, 0x1F, 0xEF, 0xFF, 0xE7,
  0xFC, 0x07, 0xFB, 0xF9, 0xF9, 0xFE, 0x01, 0xFE, 0xFE, 0x7E, 0xFF, 0x80,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x07, 0xFF,
  0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x0F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0xF0, 0x07,
  0xF1, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xC3,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF,
  0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0x8F, 0xE0, 0x0F,
  0xFF, 0x87, 0xF0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 52, 18, 1, -51 },
  { 125, 21, 19, 22, 4, -54 },
  { 175, 36, 51, 37, 1, -51 },
  { 405, 33, 67, 35, 2, -59 },
  { 682, 34, 53, 45, 6, -52 },
  { 908, 36, 53, 40, 1, -52 },
  { 1147, 11, 19, 11, 4, -54 },
  { 1174, 22, 73, 23, 3, -57 },
  { 1375, 22, 73, 23, -3, -57 },
  { 1576, 30, 31, 32, 4, -51 },
  { 1693, 30, 37, 33, 2, -43 },
  { 1832, 15, 22, 17, -4, -9 },
  { 1874, 18, 8, 25, 4, -26 },
  { 1892, 12, 11, 20, 1, -10 },
  { 1909, 32, 55, 23, -5, -51 },
  { 2129, 31, 53, 35, 3, -52 },
  { 2335, 21, 51, 35, 8, -51 },
  { 2469, 34, 52, 35, 0, -52 },
  { 2690, 33, 53, 35, 1, -52 },
  { 2909, 33, 51, 35, 1, -51 },
  { 3120, 33, 52, 35, 2, -51 },
  { 3335, 29, 52, 35, 3, -51 },
  { 3524, 34, 51, 35, 3, -51 },
  { 3741, 32, 53, 35, 2, -52 },
  { 3953, 29, 52, 35, 5, -52 },
  { 4142, 16, 40, 19, 2, -39 },
  { 4222, 20, 52, 18, -3, -39 },
  { 4352, 28, 34, 31, 2, -39 },
  { 4471, 30, 23, 35, 3, -34 },
  { 4558, 29, 34, 32, 1, -39 },
  { 4682, 27, 53, 31, 5, -52 },
  { 4861, 50, 66, 54, 1, -50 },
  { 5274, 40, 51, 42, -3, -51 },
  { 5529, 38, 51, 39, 0, -51 },
  { 5772, 37, 53, 40, 3, -52 },
  { 6018, 38, 51, 39, 0, -51 },
  { 6261, 38, 51, 34, 0, -51 },
  { 6504, 37, 51, 33, 0, -51 },
  { 6740, 37, 53, 41, 3, -52 },
  { 6986, 44, 51, 43, 0, -51 },
  { 7267, 19, 51, 19, 1, -51 },
  { 7389, 36, 52, 34, 0, -51 },
  { 7623, 44, 51, 39, 0, -51 },
  { 7904, 29, 51, 33, 0, -51 },
  { 8089, 54, 51, 53, 0, -51 },
  { 8434, 44, 51, 43, 0, -51 },
  { 8715, 38, 53, 42, 3, -52 },
  { 8967, 40, 51, 40, 0, -51 },
  { 9222, 38, 61, 42, 3, -52 },
  { 9512, 39, 51, 39, 0, -51 },
  { 9761, 37, 53, 38, 1, -52 },
  { 10007, 36, 51, 38, 5, -51 },
  { 10237, 40, 52, 40, 2, -51 },
  { 10497, 39, 51, 40, 6, -51 },
  { 10746, 50, 51, 52, 6, -51 },
  { 11065, 45, 51, 39, -2, -51 },
  { 11352, 37, 51, 38, 6, -51 },
  { 11588, 41, 51, 37, -1, -51 },
  { 11850, 24, 72, 18, -1, -60 },
  { 12066, 17, 55, 27, 6, -51 },
  { 12183, 24, 72, 18, -4, -60 },
  { 12399, 24, 26, 27, 2, -51 },
  { 12477, 28, 8, 28, -4, 0 },
  { 12505, 16, 11, 23, 7, -54 },
  { 12527, 30, 40, 33, 1, -39 },
  { 12677, 32, 55, 35, 0, -54 },
  { 12897, 29, 40, 32, 2, -39 },
  { 13042, 36, 55, 35, 1, -54 },
  { 13290, 30, 40, 33, 2, -39 },
  { 13440, 26, 55, 23, 2, -55 },
  { 13619, 35, 54, 35, 0, -39 },
  { 13856, 32, 54, 34, 0, -54 },
  { 14072, 19, 54, 18, 0, -54 },
  { 14201, 27, 69, 17, -8, -54 },
  { 14434, 36, 54, 33, 0, -54 },
  { 14677, 19, 54, 18, 0, -54 },
  { 14806, 49, 39, 52, 0, -39 },
  { 15045, 32, 39, 34, 0, -39 },
  { 15201, 30, 40, 35, 2, -39 },
  { 15351, 35, 54, 35, -3, -39 },
  { 15588, 33, 54, 35, 1, -39 },
  { 15811, 25, 39, 23, 0, -39 },
  { 15933, 30, 40, 32, 0, -39 },
  { 16083, 21, 48, 21, 2, -47 },
  { 16209, 32, 39, 34, 2, -38 },
  { 16365, 29, 38, 31, 4, -38 },
  { 16503, 42, 38, 44, 4, -38 },
  { 16703, 35, 38, 32, -2, -38 },
  { 16870, 36, 53, 31, -2, -38 },
  { 17109, 33, 38, 32, -1, -38 },
  { 17266, 22, 69, 21, 2, -56 },
  { 17456, 16, 61, 18, 1, -51 },
  { 17578, 22, 69, 21, -3, -56 },
  { 17768, 33, 16, 39, 3, -29 },
};

const GFXfont RobotoCondensed_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_BOLDITALIC72PT7B_H_
