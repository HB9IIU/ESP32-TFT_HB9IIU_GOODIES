#ifndef _ROBOTOCONDENSED_BOLDITALIC41PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0,
  0x70, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x8E, 0x79,
  0xE7, 0x9E, 0x71, 0xE7, 0x1C, 0xF1, 0xC0, 0x00, 0x38, 0xE0, 0x07, 0x9E,
  0x00, 0x79, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x01, 0xE7, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0x1C, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xF0, 0x7C,
  0x3E, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x8F, 0x1C, 0x1D,
  0xE3, 0x87, 0xB8, 0x71, 0xE7, 0x0E, 0x78, 0xE1, 0xCE, 0x1C, 0x7B, 0xC3,
  0xDF, 0xF0, 0x7F, 0xDC, 0x07, 0xF7, 0x80, 0x7D, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x78, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1D, 0xEF, 0x07, 0xF8, 0xF1,
  0xEF, 0x1E, 0x79, 0xE3, 0xCE, 0x3C, 0x7B, 0xC7, 0x8F, 0xF0, 0xF1, 0xCC,
  0x1E, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0xBF,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xF1, 0xFF,
  0x1F, 0x3F, 0xF9, 0xF7, 0xFF, 0x9E, 0xFC, 0xFF, 0xEF, 0xCF, 0xFE, 0xF8,
  0x7F, 0xCF, 0x87, 0xFC, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x7C, 0x0F, 0xC7, 0xE0, 0x3C, 0xF3,
  0xCF, 0x7D, 0xE7, 0x9E, 0x79, 0xCF, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3C,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0x80,
  0x04, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x87, 0x0D, 0xF3, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xF3, 0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x08, 0x10, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x20, 0x7F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8,
  0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBF, 0x07, 0xDF, 0x03,
  0xEF, 0x81, 0xF7, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFC, 0x3F, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0x7E, 0x43, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xBE,
  0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x3F, 0x03, 0xE7, 0xE0, 0xF8, 0xFC,
  0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7D, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0xE0, 0x30, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xC3, 0xE1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0xF8, 0x7D, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7E,
  0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1,
  0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3E, 0xFE, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xC0, 0x01, 0xE0, 0x3E, 0x07, 0xF0,
  0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x30, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x03,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x10,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x3E, 0x0F, 0x1E, 0x0F, 0xF8, 0x73, 0xC1,
  0xFF, 0x87, 0x3C, 0x3F, 0xF8, 0x73, 0x87, 0xC7, 0x87, 0x78, 0x78, 0x78,
  0x77, 0x8F, 0x87, 0x07, 0x70, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0F, 0xF1,
  0xF0, 0xF0, 0xEF, 0x1E, 0x0E, 0x0E, 0xF1, 0xE1, 0xE0, 0xEE, 0x1E, 0x1E,
  0x1E, 0xE1, 0xE3, 0xE1, 0xCE, 0x1E, 0x3E, 0x3C, 0xE1, 0xFF, 0xE7, 0x8E,
  0x1F, 0xFF, 0xF0, 0xE0, 0xFC, 0xFE, 0x0F, 0x07, 0x87, 0xC0, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x83, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3,
  0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x1F,
  0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x87,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xFF, 0xDF, 0x87, 0xFE, 0xFC, 0x3F, 0xF7, 0xE1, 0xFF,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0,
  0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0,
  0xFC, 0x3F, 0x07, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x3F,
  0x81, 0xF8, 0x3F, 0x80, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7F,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xF7, 0xC1, 0xF7, 0xC3, 0xFF, 0x83, 0xEF, 0x8F, 0xBE, 0x07, 0xCF, 0x1F,
  0x7C, 0x0F, 0x9E, 0x3C, 0xF8, 0x3F, 0x3C, 0xFB, 0xF0, 0x7E, 0x79, 0xE7,
  0xE0, 0xFC, 0xF7, 0xCF, 0xC1, 0xF9, 0xEF, 0x1F, 0x03, 0xE3, 0xFE, 0x3E,
  0x0F, 0xC7, 0xF8, 0xFC, 0x1F, 0x8F, 0xF1, 0xF8, 0x3F, 0x1F, 0xE3, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x3F, 0x07,
  0xE0, 0xF8, 0x7E, 0x0F, 0xC1, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xE0, 0xFF, 0x01, 0xF0,
  0x7F, 0x81, 0xF8, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0x3F,
  0x07, 0xFC, 0x1F, 0x07, 0xEF, 0x0F, 0x83, 0xF7, 0x8F, 0xC1, 0xFB, 0xC7,
  0xE0, 0xFD, 0xE3, 0xF0, 0x7C, 0x79, 0xF8, 0x3E, 0x3C, 0xF8, 0x3F, 0x1E,
  0xFC, 0x1F, 0x8F, 0xFE, 0x0F, 0xC3, 0xFF, 0x07, 0xE1, 0xFF, 0x83, 0xE0,
  0xFF, 0x83, 0xF0, 0x7F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x7E,
  0x07, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x01, 0xF7,
  0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x9F, 0xC3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0xC3, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F,
  0x83, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80,
  0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF1,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3E,
  0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3E, 0xF8,
  0x3F, 0x07, 0xEF, 0x83, 0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xCF, 0x87, 0xF0,
  0xFC, 0xF8, 0x7F, 0x0F, 0xCF, 0x87, 0xF0, 0xF8, 0xF8, 0xFF, 0x1F, 0x8F,
  0x8F, 0xF1, 0xF8, 0xF8, 0xFF, 0x1F, 0x0F, 0x9F, 0xF3, 0xF0, 0xF9, 0xFF,
  0x3F, 0x0F, 0x9E, 0xF3, 0xE0, 0xFB, 0xEF, 0x3E, 0x0F, 0xBE, 0xF7, 0xE0,
  0xFB, 0xCF, 0x7C, 0x0F, 0xFC, 0xF7, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x80,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC,
  0x01, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xDE, 0x0F, 0x78, 0x79, 0xE1, 0xE7,
  0x8F, 0x0E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xFD, 0xF8,
  0xF8, 0x7C, 0xFC, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xFF, 0xC3, 0xFF,
  0xE7, 0xFF, 0xE7, 0xF9, 0xF3, 0xF0, 0xF9, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC,
  0x3F, 0x3F, 0x7F, 0x9F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xF9, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x81, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xF8, 0xFC, 0x7C, 0x1F,
  0x3F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0x9F, 0x87, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3E, 0x7F, 0x8F, 0x8F, 0x80, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF8,
  0x7E, 0xF8, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x7C, 0x0F, 0xF7,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xE0,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFB, 0xE0,
  0x1F, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF1, 0xF0, 0xFD, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x0C, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xBE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7,
  0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x60, 0x7E, 0x07, 0xDF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xEF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8,
  0x3E, 0x3E, 0x0F, 0x9F, 0x83, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F,
  0x9F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF,
  0x83, 0xF0, 0x03, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0x38, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7F,
  0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xF8, 0x1F, 0x7F,
  0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE7, 0xC0, 0x7E,
  0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x00,
  0x0F, 0x9E, 0x0F, 0x81, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xBF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x0F, 0xC3,
  0xF3, 0xF0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC3, 0xF3, 0xF0, 0xF8, 0x3E, 0x3E,
  0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xE7, 0xE1, 0xF8,
  0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7,
  0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0xCF, 0xC3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE0, 0xF8, 0x1F, 0xBE, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFD, 0xF8, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xFC, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xEF, 0x80, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0,
  0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0x7F, 0x03, 0xE3,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC7, 0xC3,
  0xFD, 0xF1, 0xFF, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0x87, 0xE7, 0xE0,
  0xF9, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xFC, 0x3F, 0x3F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xDF, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xF8, 0x7F, 0xE1, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0xFD, 0xF0, 0x7E, 0xFC, 0x3E, 0x3E, 0x3F, 0x1F, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x87, 0xFF, 0x7F, 0xF7, 0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0x00,
  0x3F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF,
  0x83, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x07, 0xE7, 0xC1,
  0xF9, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x7F, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xBE, 0x07,
  0xDF, 0x80, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xC7, 0xC7,
  0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x3C, 0x1F, 0xFC, 0x3C, 0x3F, 0xFC, 0x7C, 0x3E, 0xFC, 0x7C,
  0x3E, 0x7C, 0xFC, 0x7E, 0x78, 0xFC, 0x7C, 0x78, 0xFE, 0x7C, 0x79, 0xFE,
  0xF8, 0x79, 0xFE, 0xF8, 0x7B, 0xFE, 0xF8, 0x7B, 0xDF, 0xF0, 0x7B, 0xDF,
  0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x7E,
  0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x07, 0xDF, 0x80, 0x7D, 0xF8, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xBE, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x0F,
  0xC1, 0xF0, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F,
  0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x07, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x04, 0x00, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x70, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0x3F,
  0xE1, 0xE3, 0xFF, 0x1E, 0x7F, 0xFF, 0xE7, 0x8F, 0xFC, 0x78, 0x7F, 0xC7,
  0x83, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 12, 11, 13, 2, -31 },
  { 55, 20, 29, 21, 1, -29 },
  { 128, 19, 37, 20, 1, -33 },
  { 216, 19, 29, 25, 4, -29 },
  { 285, 20, 29, 23, 1, -29 },
  { 358, 6, 11, 6, 2, -31 },
  { 367, 13, 41, 13, 2, -32 },
  { 434, 13, 41, 13, -2, -32 },
  { 501, 17, 18, 18, 2, -29 },
  { 540, 17, 21, 19, 1, -24 },
  { 585, 8, 12, 10, -2, -5 },
  { 597, 10, 5, 14, 2, -15 },
  { 604, 6, 6, 12, 1, -6 },
  { 609, 19, 32, 13, -3, -29 },
  { 685, 17, 29, 20, 2, -29 },
  { 747, 13, 29, 20, 4, -29 },
  { 795, 20, 29, 20, 0, -29 },
  { 868, 18, 29, 20, 1, -29 },
  { 934, 19, 29, 20, 0, -29 },
  { 1003, 19, 29, 20, 1, -29 },
  { 1072, 16, 29, 20, 2, -29 },
  { 1130, 19, 29, 20, 2, -29 },
  { 1199, 19, 29, 20, 1, -29 },
  { 1268, 16, 29, 20, 3, -29 },
  { 1326, 9, 22, 11, 1, -22 },
  { 1351, 12, 29, 10, -2, -22 },
  { 1395, 16, 19, 18, 1, -22 },
  { 1433, 17, 14, 20, 2, -20 },
  { 1463, 16, 19, 18, 1, -22 },
  { 1501, 15, 29, 18, 3, -29 },
  { 1556, 28, 37, 30, 1, -28 },
  { 1686, 23, 29, 24, -2, -29 },
  { 1770, 22, 29, 22, 0, -29 },
  { 1850, 21, 29, 23, 2, -29 },
  { 1927, 22, 29, 22, 0, -29 },
  { 2007, 21, 29, 20, 0, -29 },
  { 2084, 21, 29, 19, 0, -29 },
  { 2161, 21, 29, 23, 2, -29 },
  { 2238, 25, 29, 24, 0, -29 },
  { 2329, 11, 29, 11, 0, -29 },
  { 2369, 20, 29, 20, 0, -29 },
  { 2442, 25, 29, 22, 0, -29 },
  { 2533, 17, 29, 19, 0, -29 },
  { 2595, 31, 29, 30, 0, -29 },
  { 2708, 25, 29, 24, 0, -29 },
  { 2799, 21, 29, 24, 2, -29 },
  { 2876, 23, 29, 23, 0, -29 },
  { 2960, 21, 34, 24, 2, -29 },
  { 3050, 22, 29, 22, 0, -29 },
  { 3130, 21, 29, 21, 1, -29 },
  { 3207, 21, 29, 22, 3, -29 },
  { 3284, 23, 29, 23, 1, -29 },
  { 3368, 22, 29, 23, 3, -29 },
  { 3448, 28, 29, 30, 4, -29 },
  { 3550, 25, 29, 22, -1, -29 },
  { 3641, 21, 29, 22, 3, -29 },
  { 3718, 24, 29, 21, -1, -29 },
  { 3805, 14, 41, 10, -1, -34 },
  { 3877, 10, 32, 15, 3, -29 },
  { 3917, 14, 41, 10, -2, -34 },
  { 3989, 14, 15, 16, 1, -29 },
  { 4016, 15, 5, 16, -2, 0 },
  { 4026, 9, 6, 13, 4, -31 },
  { 4033, 17, 22, 19, 0, -22 },
  { 4080, 18, 31, 20, 0, -31 },
  { 4150, 17, 22, 18, 1, -22 },
  { 4197, 20, 31, 20, 1, -31 },
  { 4275, 17, 22, 19, 1, -22 },
  { 4322, 15, 31, 13, 1, -31 },
  { 4381, 20, 30, 20, 0, -22 },
  { 4456, 18, 31, 20, 0, -31 },
  { 4526, 11, 31, 10, 0, -31 },
  { 4569, 15, 39, 10, -4, -31 },
  { 4643, 20, 31, 19, 0, -31 },
  { 4721, 11, 31, 10, 0, -31 },
  { 4764, 28, 22, 30, 0, -22 },
  { 4841, 18, 22, 20, 0, -22 },
  { 4891, 17, 22, 20, 1, -22 },
  { 4938, 20, 30, 20, -2, -22 },
  { 5013, 18, 30, 20, 1, -22 },
  { 5081, 14, 22, 13, 0, -22 },
  { 5120, 17, 22, 18, 0, -22 },
  { 5167, 12, 27, 12, 1, -27 },
  { 5208, 18, 22, 20, 1, -22 },
  { 5258, 17, 22, 18, 2, -22 },
  { 5305, 24, 22, 25, 2, -22 },
  { 5371, 20, 22, 18, -1, -22 },
  { 5426, 20, 30, 18, -1, -22 },
  { 5501, 19, 22, 18, -1, -22 },
  { 5554, 12, 39, 12, 1, -32 },
  { 5613, 8, 34, 10, 1, -29 },
  { 5647, 12, 39, 12, -1, -32 },
  { 5706, 20, 9, 22, 1, -16 },
};

const GFXfont RobotoCondensed_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_BOLDITALIC41PT7B_H_
