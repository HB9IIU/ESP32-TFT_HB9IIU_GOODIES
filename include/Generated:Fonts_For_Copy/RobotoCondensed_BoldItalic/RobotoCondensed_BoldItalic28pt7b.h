#ifndef _ROBOTOCONDENSED_BOLDITALIC28PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0x78, 0x70, 0x70, 0x67, 0x67, 0xE6,
  0xE6, 0xEE, 0xCE, 0xCE, 0xCC, 0x03, 0xB8, 0x0C, 0xC0, 0x33, 0x01, 0xDC,
  0x06, 0x70, 0x19, 0x83, 0xFF, 0x8F, 0xFE, 0x0C, 0xC0, 0x73, 0x01, 0xDC,
  0x06, 0x60, 0xFF, 0xE3, 0xFF, 0x83, 0x30, 0x0C, 0xC0, 0x77, 0x01, 0x98,
  0x06, 0x60, 0x3B, 0x80, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x7C, 0x0F, 0xE1,
  0xFF, 0x3C, 0xF3, 0xC7, 0x3C, 0x73, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xC0, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0x7F, 0xC7,
  0xF8, 0x1F, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xF8, 0x07, 0x71,
  0x19, 0xCE, 0x67, 0x33, 0x9D, 0x86, 0x6E, 0x1F, 0xB0, 0x3D, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xBC, 0x0F, 0xF8, 0x77, 0x61, 0xB9, 0xCC, 0xE7, 0x73,
  0x99, 0x8E, 0xE0, 0x1F, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0xC0, 0xFF, 0x03,
  0x9C, 0x1E, 0x70, 0x79, 0xC1, 0xEF, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF9, 0xCF, 0xE7, 0x7B, 0xDD, 0xEF, 0xF7, 0x1F, 0xBC, 0x7E, 0x79, 0xF1,
  0xFF, 0xE3, 0xFF, 0x87, 0xCF, 0x76, 0xEE, 0xEE, 0xCC, 0x01, 0x01, 0xC1,
  0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0,
  0x70, 0x1C, 0x06, 0x01, 0x00, 0x08, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x38, 0x10,
  0x00, 0x03, 0x80, 0x30, 0x03, 0x06, 0x31, 0x7F, 0xF7, 0xFF, 0x0F, 0x81,
  0xF0, 0x1F, 0x83, 0x98, 0x71, 0xC2, 0x10, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x0F, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x71, 0xCF, 0x39, 0xE7, 0x18,
  0x7E, 0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x38,
  0xF7, 0x87, 0x78, 0x77, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xC7, 0xF8, 0x7F, 0x81, 0xE0, 0x01,
  0x0F, 0x3F, 0x7F, 0xFF, 0xCF, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x03, 0xE0, 0x7F, 0x83, 0xFE,
  0x3C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xFF,
  0xBF, 0xFD, 0xFF, 0xC0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x7C, 0xF3, 0xC7,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0x7B, 0xC3, 0xCE, 0x1E, 0x79, 0xE3, 0xFF, 0x0F, 0xF0, 0x3E,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x0E, 0xF0, 0xE7, 0x8F, 0x38, 0x73, 0xC7, 0x9E, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFE, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0C, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0xC7, 0x9E, 0x3C,
  0xF3, 0xC3, 0xFE, 0x1F, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7E, 0x0F, 0xE1,
  0xF8, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0xBC, 0x7F, 0xE7, 0xFE, 0xF9, 0xEF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0x7B, 0xE7, 0xFC, 0x3F, 0x81,
  0xF0, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xF3, 0xCF, 0x1F, 0xE1,
  0xF8, 0x7F, 0xC7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF,
  0xFC, 0x7F, 0x83, 0xE0, 0x0F, 0x07, 0xF8, 0xFF, 0x3C, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xFF, 0xBF, 0xE3, 0xFC, 0x07, 0x81,
  0xE0, 0x3C, 0x1F, 0x0F, 0xC1, 0xF0, 0x78, 0x00, 0x38, 0xF3, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x0E, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x70, 0xE0, 0x40, 0x00, 0x20, 0x38, 0x1F, 0x0F, 0xE7, 0xF9, 0xF8,
  0x3C, 0x07, 0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x10, 0x3F, 0xF7,
  0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xEF, 0xFC, 0x10, 0x01,
  0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xE0, 0x7E, 0x1F, 0xC7,
  0xF0, 0x7C, 0x07, 0x00, 0x40, 0x00, 0x1F, 0x0F, 0xE7, 0xFF, 0xEF, 0xF3,
  0xFC, 0xF0, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xE3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x3C,
  0x73, 0x8F, 0xE3, 0x39, 0xEE, 0x33, 0x1C, 0xE3, 0x73, 0x8E, 0x77, 0x38,
  0xC7, 0x63, 0x8C, 0x66, 0x71, 0xC6, 0x67, 0x1C, 0x6E, 0x73, 0x8C, 0xE7,
  0xFD, 0xC6, 0x3F, 0xF8, 0x61, 0xCF, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3E, 0x70, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01,
  0xDE, 0x07, 0x9C, 0x0F, 0x38, 0x3C, 0x70, 0x78, 0xE1, 0xE1, 0xC3, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0x83,
  0x8F, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0xF8, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF,
  0x03, 0x9E, 0x07, 0xBC, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0x79, 0xF0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xF3, 0xE1,
  0xE1, 0xC3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0,
  0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x79, 0xF0,
  0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0x78, 0x00,
  0xF3, 0xFB, 0xC7, 0xF7, 0x8F, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E, 0x78,
  0x3C, 0x7C, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x83, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x38, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x80, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xCF, 0x1E, 0x3C, 0x78, 0xFB, 0xE1, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0x1E,
  0x0F, 0x8F, 0x0F, 0x87, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xF7, 0xC0,
  0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0xEF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8E, 0xF1, 0xFC, 0x77,
  0x0F, 0x67, 0xB8, 0x73, 0xBB, 0xC7, 0x9D, 0xDE, 0x3C, 0xFC, 0xF1, 0xE7,
  0xE7, 0x8F, 0x3E, 0x78, 0x79, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE1, 0x87, 0x80, 0x1F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xF1,
  0xF8, 0xF0, 0xFC, 0x78, 0xFE, 0x3C, 0x7B, 0x1E, 0x3D, 0xCF, 0x1E, 0xE7,
  0x0F, 0x77, 0x87, 0x9B, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF0,
  0xF8, 0x78, 0x7C, 0x38, 0x3E, 0x3C, 0x1F, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xF9, 0xE3, 0xC1, 0xC7, 0x03, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0E, 0x78, 0x3C, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0xF8, 0xFF, 0xF1, 0xFF, 0xC7, 0xFE,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF9, 0xE3, 0xC1, 0xC7,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xE0, 0x3F, 0xC0, 0xF7, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0x79, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x20, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F,
  0x3C, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x83,
  0xC0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3C, 0xE0, 0xF3,
  0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF3,
  0x83, 0xCF, 0x0F, 0x3C, 0x3C, 0xF9, 0xF1, 0xFF, 0x83, 0xFC, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF9, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFC,
  0x00, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x0F,
  0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x81, 0xDE, 0x03,
  0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x1E, 0x71, 0xF1, 0xE7, 0x1F,
  0x1E, 0x71, 0xF3, 0xC7, 0x3F, 0x3C, 0x73, 0xF3, 0xC7, 0x3F, 0x78, 0x77,
  0xF7, 0x87, 0x77, 0x78, 0x77, 0x77, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x78, 0x7C, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDC,
  0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x07, 0xC3, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x07,
  0x3C, 0x0E, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xC1, 0xF0, 0xFC, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xF1, 0xE3,
  0xC0, 0x07, 0xC1, 0xF0, 0xFC, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x1F, 0x07, 0xC1, 0xF0,
  0x07, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xDC, 0xEE, 0xE7, 0x73, 0xF1, 0xC0,
  0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x8F, 0x07, 0xC1, 0xFE, 0x3F,
  0xE3, 0xCF, 0x38, 0xF0, 0x0F, 0x0F, 0xE3, 0xFE, 0x7D, 0xEF, 0x9E, 0xF1,
  0xEF, 0x3E, 0x7F, 0xE7, 0xFC, 0x3D, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF7, 0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F,
  0x1E, 0x70, 0xF7, 0x87, 0xBC, 0x39, 0xE1, 0xCF, 0x1E, 0x70, 0xF3, 0xCF,
  0xBF, 0xF9, 0xFF, 0x8F, 0x78, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0x3C, 0xFF,
  0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x8F, 0x79, 0xEF, 0xF8,
  0xFE, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x7B, 0xC7, 0xFE, 0x7F, 0xF3, 0xCF, 0xBC, 0x39, 0xE1, 0xCF, 0x1E,
  0x78, 0xF3, 0x87, 0x9C, 0x3C, 0xE1, 0xC7, 0x9E, 0x3F, 0xF1, 0xFF, 0x87,
  0xBC, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0xBC, 0xF7, 0x0F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x78, 0xCF, 0xFC, 0xFF, 0x07, 0xC0, 0x07,
  0xC3, 0xF1, 0xF8, 0x78, 0x1E, 0x0F, 0x07, 0xF3, 0xFC, 0xFF, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x38, 0xFD, 0xCF, 0xFE, 0x79, 0xF7, 0x87, 0xBC, 0x3D,
  0xE1, 0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x9C, 0x3C, 0xF3, 0xE7, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0x3C, 0x01, 0xE3, 0x1E, 0x3F, 0xF1, 0xFF, 0x03, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3D, 0xE3,
  0xFF, 0x3F, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x8F, 0x70, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x0E, 0x3C, 0x78,
  0x70, 0x00, 0x07, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x3C, 0x78,
  0xE1, 0xC7, 0x8F, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0xFC, 0x3E,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC7, 0xCF, 0x3E, 0x3D, 0xF0, 0xF7, 0x83, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE0, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0x3D, 0xE3, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x9E, 0x7C, 0xF3, 0xCF, 0x1E,
  0x71, 0xE3, 0xDE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF1, 0xCF, 0x1C, 0x79,
  0xC3, 0x8F, 0x38, 0xF1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78, 0xE0,
  0x3D, 0xE3, 0xFF, 0x3F, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8F,
  0x78, 0xF7, 0x8F, 0x70, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x0F,
  0x83, 0xFC, 0x3F, 0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0E, 0xE0,
  0xEE, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x1E, 0xF0,
  0x7F, 0xE1, 0xFF, 0x87, 0x9E, 0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0E,
  0x3C, 0x38, 0xF1, 0xE3, 0x87, 0x8F, 0x3E, 0x7F, 0xF1, 0xFF, 0x87, 0xBC,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E,
  0x73, 0xFF, 0x7F, 0xF7, 0x9F, 0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xE1,
  0xEE, 0x1E, 0xE1, 0xCF, 0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3D, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0xCF, 0x38, 0xF3, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0xF1, 0xEF, 0x1E, 0x7F, 0xC7, 0xF8, 0x1F,
  0x00, 0x1C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFE, 0x38, 0x78, 0x78, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xF0, 0xFC, 0x7C, 0x38, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x8F, 0x70, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF,
  0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0xC0, 0xF0, 0xF7, 0x1E, 0x71, 0xE7, 0x1C,
  0x73, 0xC7, 0x3C, 0x7B, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x00, 0xE3, 0x8F, 0xE3, 0x8E, 0xE7, 0x9E, 0xE7,
  0x9E, 0xE7, 0x9C, 0xEF, 0xBC, 0xEF, 0xBC, 0xFD, 0xB8, 0xFD, 0xF8, 0xF9,
  0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0x1E,
  0x3C, 0x79, 0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0x78, 0x3D, 0xE1, 0xE7, 0x8F,
  0x8E, 0x00, 0x3C, 0x3C, 0x71, 0xE1, 0xC7, 0x87, 0x1E, 0x1C, 0xF0, 0x7B,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xCF, 0xFC,
  0xFF, 0xC0, 0x01, 0x07, 0x0F, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x78, 0xF0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0,
  0x70, 0x70, 0x70, 0x30, 0x10, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18,
  0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x08,
  0x06, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0xF0, 0xF0, 0x70, 0x30, 0x00, 0x3C, 0x3B, 0xF1, 0xDF, 0xDF, 0xEF,
  0xEE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 8, 8, 9, 2, -21 },
  { 29, 14, 20, 14, 1, -20 },
  { 64, 12, 26, 14, 1, -23 },
  { 103, 14, 20, 17, 2, -20 },
  { 138, 14, 20, 16, 0, -20 },
  { 173, 4, 8, 4, 2, -21 },
  { 177, 9, 28, 9, 1, -22 },
  { 209, 9, 28, 9, -1, -22 },
  { 241, 12, 12, 12, 1, -20 },
  { 259, 12, 15, 13, 1, -17 },
  { 282, 6, 8, 7, -2, -3 },
  { 288, 7, 3, 10, 1, -10 },
  { 291, 4, 4, 8, 1, -4 },
  { 293, 13, 22, 9, -2, -20 },
  { 329, 12, 20, 14, 1, -20 },
  { 359, 8, 20, 14, 3, -20 },
  { 379, 13, 20, 14, 0, -20 },
  { 412, 13, 20, 14, 0, -20 },
  { 445, 13, 20, 14, 0, -20 },
  { 478, 13, 20, 14, 1, -20 },
  { 511, 12, 20, 14, 1, -20 },
  { 541, 13, 20, 14, 1, -20 },
  { 574, 12, 20, 14, 1, -20 },
  { 604, 11, 20, 14, 2, -20 },
  { 632, 6, 15, 8, 1, -15 },
  { 644, 8, 20, 7, -1, -15 },
  { 664, 11, 13, 12, 1, -15 },
  { 682, 12, 8, 14, 1, -13 },
  { 694, 12, 13, 12, 0, -15 },
  { 714, 10, 20, 12, 2, -20 },
  { 739, 20, 25, 21, 0, -19 },
  { 802, 15, 20, 16, -1, -20 },
  { 840, 15, 20, 15, 0, -20 },
  { 878, 15, 20, 15, 1, -20 },
  { 916, 15, 20, 15, 0, -20 },
  { 954, 15, 20, 13, 0, -20 },
  { 992, 14, 20, 13, 0, -20 },
  { 1027, 15, 20, 16, 1, -20 },
  { 1065, 17, 20, 17, 0, -20 },
  { 1108, 8, 20, 7, 0, -20 },
  { 1128, 14, 20, 13, 0, -20 },
  { 1163, 17, 20, 15, 0, -20 },
  { 1206, 11, 20, 13, 0, -20 },
  { 1234, 21, 20, 21, 0, -20 },
  { 1287, 17, 20, 17, 0, -20 },
  { 1330, 15, 20, 16, 1, -20 },
  { 1368, 15, 20, 15, 0, -20 },
  { 1406, 15, 24, 16, 1, -20 },
  { 1451, 15, 20, 15, 0, -20 },
  { 1489, 14, 20, 15, 1, -20 },
  { 1524, 14, 20, 15, 2, -20 },
  { 1559, 15, 20, 16, 1, -20 },
  { 1597, 15, 20, 16, 2, -20 },
  { 1635, 20, 20, 20, 2, -20 },
  { 1685, 18, 20, 15, -1, -20 },
  { 1730, 15, 20, 15, 2, -20 },
  { 1768, 15, 20, 14, 0, -20 },
  { 1806, 10, 28, 7, -1, -23 },
  { 1841, 7, 22, 10, 2, -20 },
  { 1861, 10, 28, 7, -2, -23 },
  { 1896, 9, 10, 11, 1, -20 },
  { 1908, 11, 3, 11, -2, 0 },
  { 1913, 6, 4, 9, 3, -21 },
  { 1916, 12, 15, 13, 0, -15 },
  { 1939, 13, 21, 13, 0, -21 },
  { 1974, 11, 15, 13, 1, -15 },
  { 1995, 13, 21, 13, 1, -21 },
  { 2030, 11, 15, 13, 1, -15 },
  { 2051, 10, 21, 9, 1, -21 },
  { 2078, 13, 21, 14, 0, -15 },
  { 2113, 12, 21, 13, 0, -21 },
  { 2145, 7, 21, 7, 0, -21 },
  { 2164, 10, 27, 7, -3, -21 },
  { 2198, 14, 21, 13, 0, -21 },
  { 2235, 8, 21, 7, 0, -21 },
  { 2256, 19, 15, 20, 0, -15 },
  { 2292, 12, 15, 13, 0, -15 },
  { 2315, 12, 15, 14, 1, -15 },
  { 2338, 14, 21, 13, -1, -15 },
  { 2375, 12, 21, 14, 1, -15 },
  { 2407, 10, 15, 9, 0, -15 },
  { 2426, 12, 15, 12, 0, -15 },
  { 2449, 8, 18, 8, 1, -18 },
  { 2467, 12, 15, 13, 1, -15 },
  { 2490, 12, 15, 12, 1, -15 },
  { 2513, 16, 15, 17, 2, -15 },
  { 2543, 14, 15, 12, -1, -15 },
  { 2570, 14, 21, 12, -1, -15 },
  { 2607, 12, 15, 12, 0, -15 },
  { 2630, 8, 27, 8, 1, -22 },
  { 2657, 6, 24, 7, 0, -20 },
  { 2675, 9, 27, 8, -1, -22 },
  { 2706, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_BOLDITALIC28PT7B_H_
