#ifndef _ROBOTOCONDENSED_BOLDITALIC8PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0x74, 0x33, 0x76, 0x6A, 0x22, 0x54, 0x2A, 0x64, 0xDE,
  0xBE, 0xC0, 0x25, 0x67, 0xBF, 0x60, 0x29, 0x49, 0x22, 0x55, 0x58, 0x23,
  0x62, 0x22, 0xE4, 0xC0, 0xC0, 0x80, 0x11, 0x22, 0x44, 0x25, 0x59, 0xA6,
  0x35, 0x60, 0x65, 0x32, 0x4E, 0x65, 0x36, 0xAE, 0x13, 0x6A, 0xF2, 0x74,
  0x63, 0xA6, 0x24, 0x6B, 0xB6, 0x71, 0x22, 0x44, 0x25, 0x76, 0xAE, 0xD6,
  0xF5, 0x00, 0x42, 0x42, 0x80, 0x39, 0x80, 0x70, 0xE0, 0x47, 0x00, 0xDD,
  0x41, 0x00, 0x11, 0xA7, 0x6D, 0xD6, 0xE8, 0x18, 0x23, 0x55, 0xF9, 0x75,
  0x5F, 0x9E, 0x35, 0x4C, 0x96, 0x65, 0x5D, 0x9E, 0x74, 0x4E, 0x8E, 0x74,
  0x4E, 0x88, 0x35, 0x4F, 0x97, 0x4A, 0x57, 0xE9, 0x48, 0x55, 0xA0, 0x11,
  0x32, 0xAE, 0x5A, 0x99, 0xCA, 0x58, 0x49, 0x69, 0xC0, 0x4D, 0xB6, 0xFE,
  0xBA, 0xA0, 0x4A, 0x5F, 0xEB, 0x48, 0x32, 0x97, 0xA9, 0x38, 0x75, 0x5F,
  0x88, 0x32, 0x97, 0x29, 0x30, 0x40, 0x75, 0x5E, 0xAB, 0x35, 0x43, 0x96,
  0xF4, 0x44, 0xC8, 0x5A, 0x95, 0xA9, 0x30, 0x9A, 0xAE, 0xCC, 0xAD, 0x7D,
  0xEB, 0x50, 0x5A, 0x98, 0xC6, 0x58, 0xBA, 0xCC, 0xC8, 0x71, 0x26, 0x4F,
  0x69, 0x2D, 0x24, 0xAA, 0xA0, 0x55, 0x6A, 0x0D, 0x80, 0xE0, 0x80, 0x6E,
  0xF0, 0x44, 0x79, 0xAE, 0x72, 0x70, 0x11, 0x7A, 0xAE, 0x6E, 0x86, 0x6B,
  0xAD, 0x00, 0x7B, 0xAE, 0x2C, 0x44, 0x6A, 0xAA, 0x47, 0xA0, 0x20, 0xB4,
  0x94, 0x44, 0x6C, 0xEA, 0x57, 0xA0, 0x7D, 0x6B, 0x50, 0x6A, 0xAA, 0x69,
  0xAE, 0x79, 0xAE, 0x88, 0x7A, 0xAE, 0x22, 0x72, 0x40, 0x68, 0xF0, 0x59,
  0x6C, 0x5A, 0xAE, 0xE6, 0x64, 0xAD, 0x94, 0xA0, 0x66, 0x6A, 0xE6, 0x64,
  0x48, 0x66, 0x4E, 0x49, 0x45, 0x20, 0x55, 0xA8, 0x55, 0xA8, 0x70,
};

const GFXglyph RobotoCondensed_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 2, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 3, 6, 5, 1, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 2, 2, 1, 0, -6 },
  { 18, 3, 8, 3, 0, -6 },
  { 21, 2, 8, 3, 0, -6 },
  { 23, 4, 4, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 3, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 4, 6, 3, -1, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 3, 6, 4, 1, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 3, 3, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 3, 4, 0, -4 },
  { 71, 3, 6, 3, 1, -6 },
  { 74, 6, 8, 6, 0, -6 },
  { 80, 4, 6, 5, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 2, 6, 2, 0, -6 },
  { 107, 4, 6, 4, 0, -6 },
  { 110, 5, 6, 4, 0, -6 },
  { 114, 3, 6, 4, 0, -6 },
  { 117, 6, 6, 6, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 4, 6, 4, 0, -6 },
  { 133, 5, 7, 5, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 1, -6 },
  { 147, 5, 6, 4, 0, -6 },
  { 151, 4, 6, 4, 1, -6 },
  { 154, 5, 6, 6, 1, -6 },
  { 158, 5, 6, 4, 0, -6 },
  { 162, 4, 6, 4, 1, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 3, 8, 2, 0, -7 },
  { 171, 2, 6, 3, 1, -6 },
  { 173, 2, 8, 2, 0, -7 },
  { 175, 3, 3, 3, 0, -6 },
  { 177, 3, 1, 3, 0, 0 },
  { 178, 2, 1, 3, 1, -6 },
  { 179, 3, 4, 4, 0, -4 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 4, 6, 4, 0, -6 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 3, 6, 3, 0, -6 },
  { 194, 4, 6, 4, 0, -4 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 2, 6, 2, 0, -6 },
  { 202, 3, 8, 2, -1, -6 },
  { 205, 4, 6, 4, 0, -6 },
  { 208, 2, 6, 2, 0, -6 },
  { 210, 5, 4, 6, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 6, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 3, 4, 3, 0, -4 },
  { 225, 3, 4, 4, 0, -4 },
  { 227, 3, 5, 2, 0, -5 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 4, 4, 3, 0, -4 },
  { 233, 5, 4, 5, 0, -4 },
  { 236, 4, 4, 4, 0, -4 },
  { 238, 4, 6, 3, 0, -4 },
  { 241, 4, 4, 4, 0, -4 },
  { 243, 3, 7, 2, 0, -6 },
  { 246, 2, 7, 2, 0, -6 },
  { 248, 2, 7, 2, 0, -6 },
  { 250, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_BOLDITALIC8PT7B_H_
