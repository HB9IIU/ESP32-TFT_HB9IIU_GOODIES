#ifndef _JETBRAINSMONO_THINITALIC32PT7B_H_
#define _JETBRAINSMONO_THINITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x82,
  0x08, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x00, 0x70, 0xD8, 0x36, 0x0D, 0x86,
  0x61, 0x98, 0x64, 0x19, 0x06, 0xC1, 0x00, 0x00, 0xC0, 0xC0, 0x30, 0x60,
  0x08, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x40, 0xC3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x06, 0x06, 0x01, 0x81, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x18,
  0x02, 0x06, 0x01, 0x81, 0x03, 0xFF, 0xFC, 0x10, 0x30, 0x0C, 0x08, 0x03,
  0x06, 0x00, 0x81, 0x80, 0x60, 0x40, 0x18, 0x30, 0x0C, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0xF0, 0x03, 0xFC, 0x0E,
  0x46, 0x0C, 0x46, 0x18, 0x43, 0x18, 0x43, 0x10, 0xC0, 0x10, 0xC0, 0x18,
  0x80, 0x18, 0x80, 0x0E, 0x80, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xB8, 0x01,
  0x98, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0xC1, 0x0C, 0xC3, 0x0C, 0xC3,
  0x08, 0x62, 0x18, 0x72, 0x70, 0x1F, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x04, 0x1F, 0x80, 0x20, 0x43, 0x01, 0x03,
  0x0C, 0x08, 0x08, 0x30, 0x60, 0x20, 0xC3, 0x01, 0x83, 0x18, 0x06, 0x08,
  0xC0, 0x18, 0x22, 0x00, 0x31, 0x10, 0x00, 0xF8, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x84, 0x00, 0x0C, 0xFC, 0x00, 0x26, 0x18, 0x01,
  0x10, 0x60, 0x08, 0x41, 0x80, 0x63, 0x06, 0x03, 0x0C, 0x10, 0x18, 0x30,
  0x40, 0xC0, 0xC3, 0x06, 0x01, 0x18, 0x30, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0xC3, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0x18,
  0x19, 0x0C, 0x09, 0x83, 0x0C, 0xC0, 0xCC, 0x40, 0x6C, 0x20, 0x1C, 0x10,
  0x06, 0x18, 0x07, 0x0C, 0x02, 0x86, 0x06, 0x61, 0x86, 0x18, 0x7E, 0x06,
  0x6F, 0xED, 0xB6, 0x80, 0x00, 0x10, 0x0F, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x0F, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x04, 0x04, 0x07, 0xC2, 0x1C, 0xF9, 0x7D, 0x0F, 0xF0, 0x00, 0xC0, 0x00,
  0xA0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0xC0, 0x70,
  0x20, 0x10, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0E, 0x38, 0x70, 0xC3, 0x06, 0x18,
  0x30, 0x41, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0E, 0x0E,
  0x0C, 0x06, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02,
  0x30, 0x06, 0x20, 0x06, 0x21, 0xC6, 0x61, 0xC6, 0x61, 0x84, 0x60, 0x04,
  0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18,
  0x60, 0x30, 0x38, 0xE0, 0x1F, 0xC0, 0x00, 0xF0, 0x06, 0x80, 0x72, 0x03,
  0x18, 0x18, 0x60, 0x81, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x0F, 0xFF, 0xC0, 0x00,
  0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06, 0x10, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x10, 0x60, 0x30, 0x70, 0xE0, 0x1F, 0x80, 0x00, 0x1C, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x81, 0x8C, 0x06, 0x30, 0x19, 0x80, 0x6C, 0x01, 0x30,
  0x04, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x13, 0xF0, 0x34, 0x38, 0x38, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x40, 0x18, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x17, 0xE0, 0x59, 0xE1, 0xC0, 0xE3, 0x00,
  0xCC, 0x01, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x22,
  0x00, 0xC6, 0x03, 0x06, 0x1C, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0xC0, 0x0D,
  0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x06, 0x0E, 0x0C, 0x06,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x10, 0x06, 0x18, 0x04, 0x0C, 0x08,
  0x06, 0x30, 0x03, 0xC0, 0x07, 0xE0, 0x0C, 0x30, 0x30, 0x18, 0x20, 0x0C,
  0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18,
  0x70, 0x70, 0x3F, 0xC0, 0x03, 0x80, 0x3F, 0xC3, 0x83, 0x8C, 0x06, 0x60,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x2C, 0x01, 0xB0,
  0x0C, 0x60, 0x71, 0xFF, 0x81, 0xE4, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x1C, 0x00, 0x0C, 0x3C,
  0xF9, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x7C,
  0xF9, 0xE0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x70, 0x38, 0x18, 0x18, 0x0C, 0x0C,
  0x06, 0x02, 0x03, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x7F, 0xFD,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x20, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x1F, 0xC1, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x70, 0x3F, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x7F, 0x80, 0x70, 0x30, 0x18, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x31,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x08, 0xCC, 0x1F, 0xA2, 0x0C, 0x28, 0x82,
  0x06, 0x61, 0x81, 0x98, 0x60, 0x66, 0x18, 0x19, 0x84, 0x04, 0x41, 0x01,
  0x10, 0xC0, 0xC4, 0x30, 0x33, 0x0C, 0x0C, 0xC1, 0x8F, 0x30, 0x7E, 0x8C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x40,
  0x06, 0x80, 0x09, 0x00, 0x33, 0x00, 0x46, 0x01, 0x8C, 0x03, 0x18, 0x04,
  0x10, 0x18, 0x20, 0x20, 0x40, 0xC0, 0x81, 0x01, 0x06, 0x03, 0x0F, 0xFE,
  0x10, 0x0C, 0x60, 0x18, 0x80, 0x13, 0x00, 0x26, 0x00, 0x58, 0x00, 0xB0,
  0x01, 0x80, 0x0F, 0xF8, 0x08, 0x0C, 0x18, 0x06, 0x18, 0x02, 0x18, 0x02,
  0x10, 0x02, 0x10, 0x06, 0x10, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x3F, 0xF0,
  0x3F, 0xF0, 0x20, 0x18, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x04, 0x60, 0x04,
  0x60, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0xC0, 0x30, 0xC1, 0xE0, 0xFF, 0x80,
  0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xC8,
  0x01, 0x90, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x64,
  0x00, 0x8C, 0x03, 0x18, 0x0C, 0x1C, 0x30, 0x1F, 0xC0, 0x0F, 0xF8, 0x10,
  0x38, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x88, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x22, 0x00, 0xC4, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x08, 0xC0, 0x31, 0x00, 0x62, 0x01, 0x8C, 0x06,
  0x18, 0x78, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x84, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x84, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x30,
  0x30, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xC8, 0x01, 0x90, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x7F, 0xB0, 0x02, 0x60,
  0x04, 0xC0, 0x19, 0x80, 0x32, 0x00, 0x64, 0x00, 0x8C, 0x03, 0x18, 0x0C,
  0x1C, 0x30, 0x1F, 0xC0, 0x08, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x02,
  0x18, 0x02, 0x18, 0x06, 0x10, 0x06, 0x10, 0x06, 0x30, 0x06, 0x30, 0x04,
  0x3F, 0xFC, 0x3F, 0xFC, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x08,
  0x60, 0x08, 0x60, 0x08, 0x40, 0x18, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x10, 0x0F, 0xFF, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x20, 0x06, 0x10, 0x03, 0x0C, 0x03, 0x06, 0x03, 0x01, 0xC3, 0x00, 0x7F,
  0x00, 0x08, 0x01, 0x84, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x60, 0x30, 0x30, 0x18, 0x30, 0x0F, 0xF0,
  0x07, 0xF8, 0x02, 0x06, 0x01, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x30, 0x18, 0x10, 0x04, 0x08, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x43,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x1F, 0xFF, 0x80, 0x1C, 0x03, 0x8A, 0x02, 0x85,
  0x01, 0x42, 0x81, 0x63, 0x60, 0xB1, 0x90, 0x98, 0xC8, 0x48, 0x64, 0x44,
  0x22, 0x62, 0x11, 0xA3, 0x08, 0x71, 0x8C, 0x30, 0xC6, 0x18, 0x63, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x01, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x60, 0x0C, 0x03, 0x0C, 0x03,
  0x1E, 0x03, 0x1A, 0x02, 0x1A, 0x02, 0x12, 0x02, 0x13, 0x06, 0x13, 0x06,
  0x31, 0x06, 0x31, 0x04, 0x31, 0x84, 0x21, 0x84, 0x20, 0x8C, 0x20, 0x8C,
  0x60, 0xCC, 0x60, 0xC8, 0x60, 0x48, 0x60, 0x48, 0x40, 0x78, 0x40, 0x78,
  0xC0, 0x78, 0xC0, 0x38, 0xC0, 0x30, 0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x70,
  0xC0, 0x63, 0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0x80, 0x33, 0x00, 0x44, 0x00, 0x88, 0x03, 0x30, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x22, 0x00, 0x44, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x18,
  0x30, 0x1F, 0xC0, 0x0F, 0xFC, 0x04, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x21,
  0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x06, 0x30, 0x03, 0x18, 0x03,
  0x0C, 0x03, 0x07, 0xFF, 0x03, 0xFC, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x60, 0xC0, 0x63,
  0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80,
  0x33, 0x00, 0x44, 0x00, 0x88, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x22, 0x00, 0x44, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x18, 0x70, 0x1F,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0F, 0xFC, 0x08, 0x0E, 0x18, 0x03, 0x18, 0x03, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x1C, 0x3F,
  0xF0, 0x20, 0xC0, 0x20, 0xC0, 0x60, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x08, 0x00,
  0xE0, 0x03, 0xFC, 0x06, 0x06, 0x08, 0x06, 0x18, 0x03, 0x10, 0x03, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0x60, 0x18, 0x70, 0x70, 0x1F, 0xC0, 0xFF,
  0xFF, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x06, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0x44, 0x00, 0x88, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x44, 0x01, 0x88, 0x03, 0x30,
  0x06, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x23, 0x00, 0xC6, 0x01, 0x8C, 0x06,
  0x0C, 0x38, 0x0F, 0xE0, 0x00, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x33, 0x00,
  0x66, 0x00, 0x8C, 0x03, 0x18, 0x04, 0x30, 0x18, 0x60, 0x30, 0x40, 0xC0,
  0x81, 0x81, 0x02, 0x03, 0x0C, 0x06, 0x10, 0x0C, 0x60, 0x18, 0x80, 0x33,
  0x00, 0x26, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x40, 0xC1, 0xE0, 0xE0, 0xF0, 0x50, 0x58, 0x28, 0x2C, 0x34, 0x36,
  0x12, 0x1B, 0x09, 0x09, 0x84, 0x8C, 0xC4, 0x46, 0x62, 0x22, 0x31, 0x11,
  0x19, 0x89, 0x8C, 0x8C, 0xC6, 0x46, 0x43, 0x63, 0x21, 0x21, 0xB0, 0x90,
  0xD0, 0x48, 0x68, 0x28, 0x3C, 0x14, 0x1E, 0x0A, 0x0E, 0x06, 0x05, 0x03,
  0x03, 0x80, 0x0E, 0x00, 0x60, 0xC0, 0x18, 0x08, 0x06, 0x01, 0x80, 0x80,
  0x10, 0x30, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0xD8, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0x20, 0x00,
  0xC6, 0x00, 0x10, 0x40, 0x06, 0x08, 0x01, 0x81, 0x80, 0x20, 0x10, 0x0C,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x04, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x40,
  0x06, 0x40, 0x0C, 0x60, 0x08, 0x20, 0x18, 0x20, 0x30, 0x30, 0x20, 0x10,
  0x60, 0x18, 0xC0, 0x18, 0x80, 0x09, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x40,
  0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x03, 0x01, 0x07, 0xF0, 0x7F, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0x80, 0x38, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0x84, 0x18, 0x63,
  0x06, 0x30, 0x26, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xC3, 0x08, 0x70,
  0x03, 0xE6, 0x1E, 0xEC, 0x70, 0x38, 0xC0, 0x73, 0x00, 0x46, 0x00, 0x88,
  0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0x44, 0x00,
  0x88, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x30, 0xD8, 0x3F, 0x20, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x3E, 0x05, 0xFE, 0x0E,
  0x06, 0x38, 0x0C, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x22, 0x00, 0xC4, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x63, 0x00, 0xCE,
  0x03, 0x1A, 0x0C, 0x33, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x8C,
  0x02, 0x60, 0x0D, 0x80, 0x34, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x1A, 0x00, 0x4C, 0x03, 0x30, 0x18, 0x70, 0xC0,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x03, 0xE6, 0x0F, 0x76, 0x18, 0x0E, 0x18, 0x0E, 0x30, 0x04, 0x30, 0x04,
  0x20, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x08,
  0x40, 0x18, 0x40, 0x18, 0x60, 0x18, 0x60, 0x38, 0x30, 0xD8, 0x1F, 0x90,
  0x07, 0xE0, 0x3F, 0xC1, 0x81, 0x8C, 0x06, 0x60, 0x09, 0x80, 0x24, 0x00,
  0x90, 0x06, 0xFF, 0xFB, 0xFF, 0xEC, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x03, 0x30, 0x18, 0x60, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xCC, 0x7B,
  0xB3, 0x81, 0xCC, 0x07, 0x60, 0x09, 0x80, 0x24, 0x01, 0x90, 0x06, 0xC0,
  0x1B, 0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xC6, 0x0F, 0x1F,
  0xEC, 0x0C, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x0F,
  0xF8, 0x3F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x3E, 0x05, 0xFE, 0x0E, 0x06, 0x38, 0x0C, 0x60, 0x08, 0xC0, 0x11,
  0x80, 0x22, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x08, 0xC0,
  0x11, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x04, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x03, 0x10, 0x06, 0x10, 0x0C, 0x30, 0x0C, 0x30,
  0x18, 0x30, 0x30, 0x30, 0x60, 0x20, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x60,
  0xC0, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x40, 0x30, 0x40, 0x30, 0xC0,
  0x18, 0xC0, 0x1C, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0xC0,
  0x0F, 0xF0, 0x13, 0x8E, 0x0A, 0xEF, 0x86, 0x38, 0x66, 0x08, 0x33, 0x04,
  0x11, 0x86, 0x08, 0xC3, 0x0C, 0x41, 0x86, 0x20, 0x83, 0x30, 0x41, 0x98,
  0x20, 0x8C, 0x30, 0x46, 0x18, 0x22, 0x0C, 0x31, 0x06, 0x18, 0x82, 0x0C,
  0xC1, 0x06, 0x61, 0x82, 0x00, 0x19, 0xF0, 0x2F, 0xF0, 0x50, 0x31, 0xC0,
  0x63, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0x46, 0x00, 0x88, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0x80, 0x20, 0x03, 0xC0, 0x3F, 0xC1, 0x81, 0x8C, 0x06, 0x60, 0x09,
  0x80, 0x24, 0x00, 0x90, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x04,
  0x80, 0x12, 0x00, 0xCC, 0x03, 0x30, 0x18, 0x60, 0xC0, 0xFE, 0x00, 0x0C,
  0xF8, 0x0B, 0xFC, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x02, 0x18, 0x02, 0x18,
  0x02, 0x10, 0x06, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x04, 0x30,
  0x04, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x18, 0x68, 0x30, 0x67, 0xE0, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03,
  0xE6, 0x1E, 0xEC, 0x70, 0x38, 0xC0, 0x73, 0x00, 0x46, 0x00, 0x88, 0x03,
  0x10, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0x44, 0x00, 0x88,
  0x03, 0x18, 0x06, 0x30, 0x1C, 0x30, 0xD8, 0x3F, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x31, 0xE0, 0xDD, 0xE3,
  0x81, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xD8, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x60, 0x31, 0x80, 0x33,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xB0, 0x02, 0x60, 0x0C, 0x70, 0x30,
  0x7F, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x20, 0x0C, 0x80, 0x36,
  0x00, 0xD8, 0x03, 0x60, 0x09, 0x80, 0x24, 0x00, 0x90, 0x06, 0x40, 0x1B,
  0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x02, 0x30, 0x18,
  0x61, 0xC0, 0xFE, 0x00, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x06, 0x40,
  0x31, 0x00, 0xC4, 0x06, 0x18, 0x18, 0x60, 0xC0, 0x83, 0x02, 0x18, 0x08,
  0x60, 0x33, 0x00, 0xC8, 0x01, 0x60, 0x05, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x81, 0x83, 0x81, 0x83, 0x83, 0x82, 0x82, 0x86, 0x82, 0x86, 0x86, 0x84,
  0x84, 0x8C, 0xC4, 0x8C, 0xCC, 0x88, 0xC8, 0x98, 0xC8, 0x98, 0xD8, 0x90,
  0xD0, 0xB0, 0xF0, 0xB0, 0xE0, 0xA0, 0xE0, 0xA0, 0xA0, 0xE0, 0xC0, 0xC0,
  0x18, 0x01, 0x86, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x80, 0x18,
  0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD0, 0x00,
  0x4C, 0x00, 0x42, 0x00, 0x61, 0x80, 0x60, 0x60, 0x60, 0x30, 0x60, 0x0C,
  0x60, 0x06, 0x00, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x02, 0x60, 0x09,
  0x00, 0x64, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x4C, 0x01, 0x30, 0x0C,
  0xC0, 0x33, 0x01, 0xCE, 0x0F, 0x1F, 0xE8, 0x0C, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xFE, 0x3F,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x7C, 0x00, 0x83, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x04, 0x30, 0xC3,
  0x0C, 0x20, 0x86, 0x18, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x30, 0xC2, 0x08,
  0x61, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x08, 0x00, 0x06, 0x00, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC1, 0x00, 0x7E, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x3C,
  0x05, 0x98, 0x1C, 0x30, 0xE0, 0x63, 0x81, 0xFA, 0x01, 0x80,
};

const GFXglyph JetBrainsMono_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 23, 19, 7, -23 },
  { 19, 10, 9, 19, 6, -23 },
  { 31, 18, 23, 19, 1, -23 },
  { 83, 16, 32, 19, 2, -28 },
  { 147, 22, 24, 19, -1, -24 },
  { 213, 17, 24, 19, 1, -24 },
  { 264, 3, 9, 19, 10, -23 },
  { 268, 12, 31, 19, 6, -27 },
  { 315, 12, 31, 19, 2, -27 },
  { 362, 17, 17, 19, 2, -20 },
  { 399, 14, 15, 19, 3, -18 },
  { 426, 7, 10, 19, 4, -5 },
  { 435, 10, 1, 19, 5, -11 },
  { 437, 5, 4, 19, 6, -4 },
  { 440, 18, 31, 19, 1, -27 },
  { 510, 16, 24, 19, 2, -24 },
  { 558, 14, 23, 19, 2, -23 },
  { 599, 16, 24, 19, 2, -24 },
  { 647, 16, 23, 19, 2, -23 },
  { 693, 14, 23, 19, 3, -23 },
  { 734, 16, 23, 19, 2, -23 },
  { 780, 15, 23, 19, 2, -23 },
  { 824, 15, 23, 19, 4, -23 },
  { 868, 16, 24, 19, 2, -24 },
  { 916, 14, 24, 19, 4, -24 },
  { 958, 7, 18, 19, 6, -18 },
  { 974, 9, 23, 19, 4, -18 },
  { 1000, 15, 16, 19, 3, -19 },
  { 1030, 14, 9, 19, 3, -15 },
  { 1046, 15, 16, 19, 2, -19 },
  { 1076, 13, 23, 19, 5, -23 },
  { 1114, 18, 30, 19, 1, -24 },
  { 1182, 15, 23, 19, 1, -23 },
  { 1226, 16, 23, 19, 2, -23 },
  { 1272, 15, 24, 19, 3, -24 },
  { 1317, 15, 23, 19, 2, -23 },
  { 1361, 17, 23, 19, 2, -23 },
  { 1410, 17, 23, 19, 2, -23 },
  { 1459, 15, 24, 19, 3, -24 },
  { 1504, 16, 23, 19, 2, -23 },
  { 1550, 16, 23, 19, 2, -23 },
  { 1596, 17, 23, 19, 1, -23 },
  { 1645, 17, 23, 19, 2, -23 },
  { 1694, 14, 23, 19, 2, -23 },
  { 1735, 17, 23, 19, 2, -23 },
  { 1784, 16, 23, 19, 2, -23 },
  { 1830, 15, 24, 19, 3, -24 },
  { 1875, 17, 23, 19, 2, -23 },
  { 1924, 15, 30, 19, 3, -24 },
  { 1981, 16, 23, 19, 2, -23 },
  { 2027, 16, 24, 19, 2, -24 },
  { 2075, 16, 23, 19, 4, -23 },
  { 2121, 15, 23, 19, 3, -23 },
  { 2165, 15, 23, 19, 4, -23 },
  { 2209, 17, 23, 19, 3, -23 },
  { 2258, 19, 23, 19, 0, -23 },
  { 2313, 16, 23, 19, 4, -23 },
  { 2359, 17, 23, 19, 1, -23 },
  { 2408, 12, 31, 19, 5, -27 },
  { 2455, 8, 31, 19, 6, -27 },
  { 2486, 12, 31, 19, 3, -27 },
  { 2533, 12, 12, 19, 4, -23 },
  { 2551, 16, 1, 19, 0, 1 },
  { 2553, 5, 4, 19, 9, -25 },
  { 2556, 15, 18, 19, 2, -18 },
  { 2590, 15, 23, 19, 2, -23 },
  { 2634, 14, 18, 19, 3, -18 },
  { 2666, 16, 23, 19, 2, -23 },
  { 2712, 14, 18, 19, 3, -18 },
  { 2744, 20, 29, 19, -1, -23 },
  { 2817, 14, 24, 19, 3, -18 },
  { 2859, 15, 23, 19, 2, -23 },
  { 2903, 14, 24, 19, 2, -24 },
  { 2945, 16, 30, 19, 1, -24 },
  { 3005, 16, 23, 19, 2, -23 },
  { 3051, 12, 23, 19, 4, -23 },
  { 3086, 17, 18, 19, 1, -18 },
  { 3125, 15, 18, 19, 2, -18 },
  { 3159, 14, 18, 19, 3, -18 },
  { 3191, 16, 24, 19, 1, -18 },
  { 3239, 15, 24, 19, 2, -18 },
  { 3284, 14, 18, 19, 3, -18 },
  { 3316, 15, 18, 19, 2, -18 },
  { 3350, 15, 22, 19, 3, -22 },
  { 3392, 14, 18, 19, 3, -18 },
  { 3424, 14, 18, 19, 4, -18 },
  { 3456, 16, 18, 19, 3, -18 },
  { 3492, 17, 18, 19, 1, -18 },
  { 3531, 14, 24, 19, 3, -18 },
  { 3573, 15, 18, 19, 2, -18 },
  { 3607, 16, 31, 19, 3, -27 },
  { 3669, 6, 31, 19, 7, -27 },
  { 3693, 16, 31, 19, 1, -27 },
  { 3755, 14, 6, 19, 3, -14 },
};

const GFXfont JetBrainsMono_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_THINITALIC32PT7B_H_
