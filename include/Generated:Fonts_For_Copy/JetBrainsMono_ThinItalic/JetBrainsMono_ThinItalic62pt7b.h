#ifndef _JETBRAINSMONO_THINITALIC62PT7B_H_
#define _JETBRAINSMONO_THINITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C,
  0x01, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70,
  0x07, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF1,
  0x8F, 0x80, 0x0F, 0x87, 0x0F, 0x80, 0x1C, 0x0E, 0x0F, 0x00, 0x70, 0x1C,
  0x0F, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0,
  0x38, 0x1E, 0x01, 0x80, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x07, 0x80, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x87, 0x00, 0x00,
  0x0F, 0x8E, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0x3E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x18, 0x1E, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18,
  0x03, 0x87, 0x00, 0x30, 0x07, 0x0E, 0x00, 0xE0, 0x1E, 0x1C, 0x01, 0xC0,
  0x38, 0x3C, 0x03, 0x80, 0x70, 0x78, 0x06, 0x01, 0xC0, 0x78, 0x0C, 0x07,
  0x80, 0xF0, 0x18, 0x1E, 0x00, 0xF8, 0x30, 0x78, 0x00, 0xFE, 0xE7, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xC0,
  0x1F, 0x0F, 0x00, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x01,
  0x80, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0x70, 0x70, 0x00, 0x01,
  0xC0, 0x78, 0x70, 0x00, 0x00, 0xFD, 0xF8, 0x70, 0x00, 0x00, 0x3F, 0xF8,
  0x70, 0x00, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1F, 0xE0, 0x00, 0x00, 0x38, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x3C, 0x3E,
  0x00, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x06,
  0x00, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xF3, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0x1C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0x0E, 0x03, 0x80, 0x07, 0x0E,
  0x01, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x03, 0x87, 0x80, 0x1C, 0x03, 0x83,
  0x80, 0x0F, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0x01, 0xE1, 0xC0,
  0x70, 0x00, 0x79, 0xC0, 0x78, 0x00, 0x1D, 0xE0, 0x38, 0x00, 0x0F, 0xE0,
  0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x7B,
  0x80, 0x70, 0x00, 0x79, 0xE0, 0x3C, 0x00, 0x78, 0x70, 0x1F, 0x00, 0xF8,
  0x1C, 0x07, 0xE1, 0xF8, 0x0F, 0x01, 0xFF, 0xF0, 0x03, 0x80, 0x7F, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0xF3, 0xDF, 0x79, 0xE7, 0x9E,
  0x7B, 0xEF, 0x3C, 0xF3, 0xCE, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x7C, 0x01, 0xC0, 0x3F, 0xFF, 0x81, 0x81, 0xFF, 0x3F, 0xE1, 0x8F, 0xFC,
  0x0F, 0xF9, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x38, 0x07, 0x83,
  0x80, 0xF8, 0x0F, 0x07, 0x01, 0xF8, 0x1C, 0x0E, 0x03, 0xF0, 0x38, 0x3C,
  0x07, 0xE0, 0x70, 0x78, 0x0F, 0x80, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x01,
  0xF0, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1C,
  0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x78, 0x00, 0xE0,
  0x1E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x0E, 0x1F,
  0xFC, 0x00, 0x73, 0xFF, 0xF8, 0x03, 0xBC, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x01, 0xD8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC7, 0xFC, 0x00, 0x39, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0x80, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x01, 0xF8, 0x07,
  0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x01, 0xFF, 0xFD, 0xC0, 0x07, 0xFF, 0xBC, 0x00, 0x1F, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0xE1, 0xC1,
  0xC0, 0x07, 0xFF, 0x38, 0x38, 0x01, 0xFF, 0xEE, 0x0F, 0x00, 0x78, 0x0F,
  0xC1, 0xC0, 0x1E, 0x00, 0x78, 0x38, 0x03, 0x80, 0x0F, 0x07, 0x00, 0xF0,
  0x01, 0xE0, 0xE0, 0x1C, 0x00, 0x3C, 0x1C, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x03, 0x83,
  0x80, 0x70, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03,
  0xC1, 0xC0, 0x38, 0x00, 0x70, 0x78, 0x07, 0x00, 0x0E, 0x0E, 0x01, 0xE0,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0x38, 0x38, 0x07, 0x00, 0x0F, 0x07, 0x00,
  0xF0, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x1F, 0x07,
  0x00, 0x3F, 0x0E, 0xE0, 0xE0, 0x03, 0xFF, 0x9C, 0x1C, 0x00, 0x3F, 0xE3,
  0x83, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x70, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x01, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x7C, 0x01, 0xC0,
  0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x07, 0xFF,
  0xE0, 0xE0, 0x1F, 0xFF, 0x83, 0x80, 0x7F, 0xFE, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0xC0, 0x6C, 0x00, 0x06, 0xE0, 0x36, 0x00, 0x07, 0x60, 0x3B, 0x80,
  0x03, 0x70, 0x1D, 0xC0, 0x03, 0xB8, 0x0E, 0x60, 0x01, 0x9C, 0x07, 0x30,
  0x01, 0xCE, 0x03, 0x98, 0x00, 0xC7, 0x01, 0xCE, 0x00, 0xE7, 0x01, 0xC7,
  0x00, 0x63, 0x80, 0xE1, 0x80, 0x71, 0xC0, 0x70, 0xC0, 0x30, 0xE0, 0x38,
  0x70, 0x38, 0x70, 0x1C, 0x38, 0x18, 0x38, 0x0E, 0x1C, 0x1C, 0x38, 0x0F,
  0x06, 0x0C, 0x1C, 0x07, 0x03, 0x0E, 0x0E, 0x03, 0x81, 0xCE, 0x07, 0x01,
  0xC0, 0xE7, 0x03, 0x80, 0xE0, 0x37, 0x01, 0xC0, 0x70, 0x1B, 0x01, 0xE0,
  0x38, 0x0F, 0x80, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0x38,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x70, 0x0F,
  0x80, 0x00, 0xE0, 0x1B, 0x80, 0x01, 0xC0, 0x77, 0x00, 0x03, 0x80, 0xEE,
  0x00, 0x07, 0x01, 0xCC, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x38, 0x07, 0x38,
  0x00, 0x70, 0x0E, 0x70, 0x00, 0xE0, 0x38, 0x60, 0x01, 0xC0, 0x70, 0xE0,
  0x03, 0x80, 0xE1, 0xC0, 0x07, 0x01, 0xC3, 0x80, 0x0E, 0x03, 0x87, 0x00,
  0x38, 0x07, 0x06, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x1C, 0x01,
  0xC0, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x30, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0x80, 0xE0,
  0x38, 0x03, 0x81, 0xC0, 0x70, 0x07, 0x03, 0x80, 0xE0, 0x0E, 0x0E, 0x01,
  0xC0, 0x0C, 0x1C, 0x03, 0x80, 0x1C, 0x38, 0x0E, 0x00, 0x38, 0x70, 0x1C,
  0x00, 0x70, 0xE0, 0x38, 0x00, 0xE1, 0xC0, 0x70, 0x00, 0xE7, 0x00, 0xE0,
  0x01, 0xCE, 0x01, 0xC0, 0x03, 0x9C, 0x07, 0x00, 0x07, 0x38, 0x0E, 0x00,
  0x07, 0x70, 0x1C, 0x00, 0x0E, 0xE0, 0x38, 0x00, 0x1D, 0xC0, 0x70, 0x00,
  0x3B, 0x00, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00,
  0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00,
  0x7C, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1D, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x3C, 0x00,
  0x73, 0x80, 0x1F, 0x00, 0x38, 0xE0, 0x06, 0xC0, 0x0E, 0x38, 0x01, 0xB0,
  0x03, 0x8C, 0x00, 0xEC, 0x00, 0xE3, 0x00, 0x3B, 0x00, 0x70, 0xC0, 0x0C,
  0xC0, 0x1C, 0x30, 0x07, 0x30, 0x07, 0x0C, 0x01, 0xCC, 0x03, 0x83, 0x00,
  0x63, 0x00, 0xE0, 0xC0, 0x18, 0xC0, 0x38, 0x70, 0x0E, 0x30, 0x0E, 0x1C,
  0x03, 0x0C, 0x07, 0x07, 0x00, 0xC3, 0x01, 0xC1, 0xC0, 0x71, 0xC0, 0x70,
  0x70, 0x1C, 0x70, 0x18, 0x1C, 0x06, 0x1C, 0x0E, 0x07, 0x03, 0x87, 0x03,
  0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0x30, 0x70, 0x70, 0x1C, 0x0C, 0x1C,
  0x1C, 0x07, 0x07, 0x07, 0x07, 0x01, 0xC1, 0x81, 0xC1, 0x80, 0x70, 0x60,
  0x70, 0xE0, 0x1C, 0x38, 0x1C, 0x38, 0x07, 0x0C, 0x07, 0x0E, 0x01, 0xC3,
  0x01, 0xC3, 0x00, 0x71, 0xC0, 0x61, 0xC0, 0x1C, 0x60, 0x18, 0x70, 0x07,
  0x18, 0x06, 0x18, 0x01, 0xC6, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x63, 0x80,
  0x1C, 0xC0, 0x18, 0xE0, 0x07, 0x30, 0x06, 0x30, 0x01, 0xDC, 0x01, 0x9C,
  0x00, 0x66, 0x00, 0x67, 0x00, 0x19, 0x80, 0x19, 0x80, 0x06, 0xE0, 0x06,
  0xE0, 0x01, 0xB0, 0x01, 0xB8, 0x00, 0xEC, 0x00, 0x6E, 0x00, 0x3B, 0x00,
  0x1B, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x0F,
  0x00, 0x38, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0,
  0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0x87, 0x00, 0xFF, 0xFC, 0x70, 0x1F, 0x01, 0xE7, 0x03, 0xC0,
  0x07, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x78,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x06, 0xE0,
  0x3F, 0x03, 0xCE, 0x01, 0xFF, 0xF8, 0xE0, 0x07, 0xFE, 0x0E, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0xF8, 0x00, 0x78, 0x7F, 0xE0, 0x07, 0x1F, 0xFF, 0x80,
  0x73, 0xC0, 0xFC, 0x07, 0x60, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00,
  0x1E, 0x07, 0x60, 0x03, 0xC0, 0xF7, 0x81, 0xF8, 0x0E, 0x3F, 0xFF, 0x00,
  0xE1, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x83, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0xFF,
  0xFC, 0x70, 0x07, 0xC0, 0x79, 0xC0, 0x3C, 0x00, 0x7F, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x01, 0xF0, 0x1C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xB8, 0x03, 0xF0, 0x3C, 0xE0, 0x07, 0xFF, 0xE3, 0x80, 0x07, 0xFE,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x03, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x87,
  0x00, 0xFF, 0xFC, 0x70, 0x1F, 0x01, 0xE7, 0x03, 0xC0, 0x06, 0xE0, 0x78,
  0x00, 0x3E, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0x70, 0x3E, 0x00, 0x77, 0x01, 0xF8,
  0x3E, 0xF0, 0x0F, 0xFF, 0x8E, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0x78, 0x7F, 0xE0, 0x07, 0x1F, 0xFF, 0x80, 0x73, 0xC0, 0xFC, 0x07,
  0x70, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0xF8, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x70, 0x07, 0x3F, 0xC1, 0xFC,
  0x07, 0x7F, 0xE3, 0xFE, 0x07, 0x61, 0xE6, 0x1F, 0x07, 0x80, 0xF8, 0x0F,
  0x07, 0x80, 0xF8, 0x07, 0x07, 0x00, 0x70, 0x07, 0x07, 0x00, 0x70, 0x07,
  0x0E, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x0E,
  0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E,
  0x1C, 0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x1E,
  0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C,
  0x38, 0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80, 0x3C,
  0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38,
  0x78, 0x03, 0x80, 0x38, 0x70, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00, 0x38,
  0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0xF8, 0x00, 0x78, 0x7F, 0xE0, 0x07, 0x1F, 0xFF, 0x80, 0x73,
  0xC0, 0xFC, 0x07, 0x70, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x1F, 0x03, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x87, 0xFE,
  0x00, 0x1C, 0x7F, 0xFE, 0x00, 0x73, 0xC0, 0xFC, 0x01, 0xD8, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x78, 0x07, 0x60, 0x03, 0xC0, 0x3D, 0xE0, 0x7E, 0x00, 0xE3, 0xFF, 0xF0,
  0x03, 0x87, 0xFF, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0x87, 0x00, 0xFF, 0xFC, 0x70, 0x1F, 0x01, 0xE7,
  0x03, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x38, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x03, 0xC0,
  0x0E, 0xE0, 0x1F, 0x03, 0xCE, 0x01, 0xFF, 0xF8, 0xE0, 0x07, 0xFE, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x7F, 0xF8, 0x01, 0xC7,
  0xFF, 0xE0, 0x0E, 0x78, 0x1F, 0x80, 0x77, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x00,
  0x77, 0x00, 0x7C, 0x00, 0xEE, 0x00, 0xD8, 0x03, 0x9C, 0x01, 0xB0, 0x07,
  0x38, 0x07, 0x60, 0x0E, 0x70, 0x0C, 0xC0, 0x38, 0xE0, 0x19, 0x80, 0x71,
  0xC0, 0x73, 0x00, 0xE3, 0x80, 0xC6, 0x03, 0x87, 0x01, 0x8C, 0x07, 0x0E,
  0x07, 0x18, 0x0E, 0x1C, 0x0C, 0x30, 0x38, 0x38, 0x38, 0x60, 0x70, 0x70,
  0x70, 0xC0, 0xE0, 0xE0, 0xC1, 0x83, 0x81, 0xC3, 0x83, 0x07, 0x03, 0x87,
  0x06, 0x0E, 0x07, 0x0C, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0xE0, 0x38, 0xC0, 0x73, 0x80, 0x73, 0x80, 0xE7, 0x00, 0xE7, 0x01,
  0xCE, 0x01, 0xCC, 0x03, 0xB8, 0x03, 0xB8, 0x07, 0x70, 0x07, 0x60, 0x0E,
  0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x0E, 0xE0,
  0x1F, 0x83, 0xCE, 0x00, 0xFF, 0xF8, 0xE0, 0x07, 0xFE, 0x0E, 0x00, 0x02,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x38, 0x7F, 0x80, 0x01, 0x87, 0xFE, 0x00, 0x1C, 0x78,
  0x78, 0x00, 0xE3, 0x81, 0xE0, 0x07, 0x38, 0x07, 0x80, 0x39, 0xC0, 0x1C,
  0x01, 0xCE, 0x00, 0x70, 0x1C, 0x70, 0x03, 0xC1, 0xE3, 0x00, 0x0F, 0xFE,
  0x38, 0x00, 0x3F, 0xE1, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 12, 45, 37, 13, -45 },
  { 69, 19, 18, 37, 12, -45 },
  { 112, 36, 45, 37, 1, -45 },
  { 315, 31, 63, 37, 4, -54 },
  { 560, 41, 46, 37, -1, -46 },
  { 796, 33, 47, 37, 2, -46 },
  { 990, 6, 18, 37, 19, -45 },
  { 1004, 25, 60, 37, 11, -52 },
  { 1192, 24, 60, 37, 3, -52 },
  { 1372, 32, 32, 37, 4, -38 },
  { 1500, 28, 29, 37, 5, -35 },
  { 1602, 14, 19, 37, 7, -9 },
  { 1636, 20, 3, 37, 9, -22 },
  { 1644, 9, 10, 37, 12, -9 },
  { 1656, 35, 58, 37, 2, -51 },
  { 1910, 31, 47, 37, 4, -46 },
  { 2093, 28, 45, 37, 3, -45 },
  { 2251, 32, 46, 37, 3, -46 },
  { 2435, 30, 46, 37, 4, -45 },
  { 2608, 27, 45, 37, 5, -45 },
  { 2760, 29, 46, 37, 5, -45 },
  { 2927, 28, 46, 37, 4, -45 },
  { 3088, 29, 45, 37, 8, -45 },
  { 3252, 30, 47, 37, 4, -46 },
  { 3429, 28, 46, 37, 7, -46 },
  { 3590, 13, 36, 37, 12, -35 },
  { 3649, 19, 45, 37, 7, -35 },
  { 3756, 29, 31, 37, 6, -36 },
  { 3869, 28, 17, 37, 5, -29 },
  { 3929, 28, 31, 37, 4, -36 },
  { 4038, 24, 45, 37, 10, -45 },
  { 4173, 35, 57, 37, 2, -46 },
  { 4423, 29, 45, 37, 1, -45 },
  { 4587, 30, 45, 37, 4, -45 },
  { 4756, 30, 47, 37, 5, -46 },
  { 4933, 30, 45, 37, 4, -45 },
  { 5102, 31, 45, 37, 5, -45 },
  { 5277, 33, 45, 37, 4, -45 },
  { 5463, 30, 47, 37, 5, -46 },
  { 5640, 31, 45, 37, 4, -45 },
  { 5815, 29, 45, 37, 5, -45 },
  { 5979, 31, 46, 37, 3, -45 },
  { 6158, 33, 45, 37, 4, -45 },
  { 6344, 25, 45, 37, 5, -45 },
  { 6485, 33, 45, 37, 3, -45 },
  { 6671, 31, 45, 37, 4, -45 },
  { 6846, 29, 47, 37, 5, -46 },
  { 7017, 32, 45, 37, 4, -45 },
  { 7197, 29, 57, 37, 5, -46 },
  { 7404, 32, 45, 37, 4, -45 },
  { 7584, 32, 47, 37, 3, -46 },
  { 7772, 30, 45, 37, 8, -45 },
  { 7941, 30, 46, 37, 5, -45 },
  { 8114, 28, 45, 37, 9, -45 },
  { 8272, 34, 45, 37, 5, -45 },
  { 8464, 36, 45, 37, 1, -45 },
  { 8667, 31, 45, 37, 8, -45 },
  { 8842, 32, 45, 37, 3, -45 },
  { 9022, 23, 58, 37, 10, -51 },
  { 9189, 17, 58, 37, 11, -51 },
  { 9313, 23, 58, 37, 6, -51 },
  { 9480, 25, 24, 37, 7, -45 },
  { 9555, 31, 2, 37, 0, 2 },
  { 9563, 8, 9, 37, 18, -49 },
  { 9572, 28, 36, 37, 5, -35 },
  { 9698, 28, 46, 37, 4, -45 },
  { 9859, 28, 36, 37, 5, -35 },
  { 9985, 30, 46, 37, 5, -45 },
  { 10158, 27, 36, 37, 5, -35 },
  { 10280, 39, 56, 37, -2, -45 },
  { 10553, 28, 46, 37, 5, -35 },
  { 10714, 28, 45, 37, 4, -45 },
  { 10872, 28, 47, 37, 3, -47 },
  { 11037, 31, 58, 37, 1, -47 },
  { 11262, 31, 45, 37, 4, -45 },
  { 11437, 24, 45, 37, 7, -45 },
  { 11572, 32, 35, 37, 2, -35 },
  { 11712, 28, 35, 37, 4, -35 },
  { 11835, 27, 36, 37, 5, -35 },
  { 11957, 30, 46, 37, 2, -35 },
  { 12130, 28, 46, 37, 5, -35 },
  { 12291, 29, 35, 37, 5, -35 },
  { 12418, 29, 36, 37, 4, -35 },
  { 12549, 27, 43, 37, 7, -43 },
  { 12695, 28, 35, 37, 5, -34 },
  { 12818, 28, 34, 37, 7, -34 },
  { 12937, 31, 34, 37, 6, -34 },
  { 13069, 33, 34, 37, 2, -34 },
  { 13210, 28, 45, 37, 5, -34 },
  { 13368, 29, 34, 37, 4, -34 },
  { 13492, 29, 58, 37, 7, -51 },
  { 13703, 13, 58, 37, 13, -51 },
  { 13798, 30, 58, 37, 2, -51 },
  { 14016, 29, 12, 37, 5, -28 },
};

const GFXfont JetBrainsMono_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_THINITALIC62PT7B_H_
