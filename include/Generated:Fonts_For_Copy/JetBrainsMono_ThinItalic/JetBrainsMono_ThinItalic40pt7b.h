#ifndef _JETBRAINSMONO_THINITALIC40PT7B_H_
#define _JETBRAINSMONO_THINITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x78, 0xF8, 0x70, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07,
  0x60, 0x66, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xEC, 0x0C, 0xC0, 0xCC, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x1E, 0xDE, 0x03, 0x08, 0x60, 0x60,
  0x87, 0x06, 0x08, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x80, 0x0C,
  0x10, 0x00, 0xC1, 0x00, 0x0E, 0x10, 0x00, 0x73, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x02, 0xF0, 0x00, 0x23, 0x80, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x60, 0x40,
  0xC6, 0x04, 0x0C, 0x60, 0xC1, 0x87, 0x0C, 0x38, 0x38, 0xC7, 0x01, 0xEF,
  0xE0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x73,
  0x80, 0x18, 0x18, 0x10, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x18, 0x08, 0x18, 0x03, 0x03, 0x06, 0x00, 0x60, 0x61, 0x80, 0x0C, 0x0C,
  0x30, 0x01, 0x81, 0x8C, 0x00, 0x30, 0x63, 0x00, 0x03, 0xF8, 0xC0, 0x00,
  0x3E, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0xFC, 0x00, 0x06, 0x3F, 0xC0, 0x01, 0x8C, 0x18, 0x00,
  0x63, 0x03, 0x00, 0x18, 0x60, 0x60, 0x06, 0x0C, 0x0C, 0x00, 0xC1, 0x81,
  0x80, 0x30, 0x20, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x18, 0x30, 0x30, 0x03, 0xFC, 0x0C, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xFC, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0x8C, 0x00, 0x38, 0x70, 0x19, 0x81, 0x81, 0x8C, 0x06, 0x18, 0xE0,
  0x38, 0xC6, 0x00, 0xCC, 0x30, 0x07, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0x60,
  0x60, 0x07, 0x03, 0x00, 0x7C, 0x18, 0x07, 0x70, 0xE0, 0x71, 0x83, 0xDF,
  0x06, 0x0F, 0xE0, 0x38, 0x77, 0x77, 0x66, 0xEE, 0xEC, 0xCC, 0x00, 0x01,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0xC0, 0xFF, 0x86, 0x3F, 0x3F, 0x27, 0xE0, 0x3F, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x19, 0x80, 0x01, 0xCC, 0x00, 0x1C,
  0x70, 0x00, 0xC1, 0x80, 0x0C, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x20, 0x04, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x11, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xE0, 0x0F, 0xBE, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x38, 0x01, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0xC1, 0x9C, 0x3C, 0x33, 0x07, 0x86, 0x60, 0xE1,
  0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03,
  0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x1C, 0x00, 0xE1, 0x80, 0x38,
  0x38, 0x0E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x0E, 0x60, 0x07, 0x18, 0x07, 0x0C, 0x03, 0x83, 0x00, 0x80, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xC1, 0xE0, 0x70, 0x06,
  0x06, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x13, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x30, 0xC0, 0x06, 0x1C, 0x01, 0x81, 0x80, 0x70, 0x1F, 0x7C, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18,
  0x60, 0x06, 0x38, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x7F,
  0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x63, 0xF0, 0x0D, 0xFF,
  0x83, 0x60, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x70,
  0x1F, 0x7C, 0x01, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC0, 0x0D, 0xFE, 0x07, 0xC3,
  0xC3, 0x80, 0x38, 0xC0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0,
  0x07, 0x18, 0x01, 0x87, 0x01, 0xC0, 0xF9, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0x80, 0x03, 0x30, 0x00, 0xEE, 0x00, 0x19, 0xC0,
  0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xF8, 0x01, 0xE1, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0E, 0x00, 0xE0,
  0x60, 0x1C, 0x03, 0x03, 0x80, 0x1C, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x03, 0x8E, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x30, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x70, 0x03, 0x03, 0x80, 0x70, 0x3F, 0x7C, 0x00, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x7F, 0xC0, 0x1E, 0x1C, 0x06, 0x00, 0xC1, 0x80, 0x1C, 0x60,
  0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x00, 0xC1, 0xC0,
  0x78, 0x3F, 0x7E, 0x01, 0xFD, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0x1F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF8, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF,
  0xF8, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x1E, 0x07, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xC3, 0xC0, 0x0C, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x7F, 0x61, 0x81, 0xEE, 0xC6, 0x07, 0x03,
  0x8C, 0x0C, 0x07, 0x18, 0x30, 0x0C, 0x30, 0x60, 0x18, 0x60, 0xC0, 0x30,
  0xC1, 0x80, 0x63, 0x83, 0x00, 0xC6, 0x06, 0x01, 0x8C, 0x18, 0x06, 0x18,
  0x30, 0x0C, 0x30, 0x60, 0x18, 0x60, 0xE0, 0x70, 0xC0, 0xE1, 0x63, 0x01,
  0xFE, 0xC6, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x68, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x04, 0x00, 0x60, 0x80,
  0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x10, 0x06, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x30, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x6C, 0x00, 0x0E, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x30, 0x07, 0x06,
  0x00, 0x60, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x18, 0x01, 0xC3, 0x00, 0x70, 0x7F,
  0xF8, 0x0F, 0xFF, 0x81, 0x80, 0x38, 0x30, 0x03, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x70, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0x1F, 0x03, 0x80, 0x60, 0xE0,
  0x0E, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x67, 0x00, 0x0C, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x18, 0x38, 0x06, 0x03, 0xEF, 0x80, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x30, 0xC0, 0x0E,
  0x18, 0x03, 0x83, 0x00, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0x1F, 0x03,
  0x80, 0x60, 0xE0, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x7F, 0xCC, 0x0F, 0xF9, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00,
  0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x38, 0x06, 0x03, 0xEF,
  0x80, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x0E, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07,
  0x06, 0x00, 0x60, 0x70, 0x1C, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0x0C,
  0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x70, 0x06, 0x03, 0x00, 0x60, 0x38, 0x03, 0x01, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x18, 0x1C,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x38, 0x78, 0x03, 0xC3,
  0xC0, 0x16, 0x1A, 0x01, 0xB0, 0xD0, 0x09, 0x06, 0xC0, 0xD8, 0x66, 0x04,
  0xC3, 0x30, 0x66, 0x18, 0x82, 0x30, 0xC4, 0x31, 0x86, 0x31, 0x0C, 0x31,
  0x98, 0xC1, 0x84, 0x86, 0x18, 0x2C, 0x30, 0xC1, 0x41, 0x86, 0x0E, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x61, 0xC0, 0x0C, 0x3C, 0x01, 0x87, 0x80, 0x30, 0xB0, 0x06, 0x32,
  0x00, 0xC6, 0x60, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC3, 0x10, 0x18, 0x63,
  0x03, 0x18, 0x60, 0x63, 0x0C, 0x08, 0x61, 0x83, 0x0C, 0x10, 0x61, 0x83,
  0x0C, 0x30, 0x61, 0x8C, 0x0C, 0x31, 0x80, 0x86, 0x30, 0x19, 0x86, 0x03,
  0x30, 0xC0, 0x66, 0x18, 0x04, 0xC6, 0x00, 0xD8, 0xC0, 0x1B, 0x18, 0x03,
  0x43, 0x00, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x3F,
  0xE0, 0x0F, 0x0E, 0x03, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x38,
  0x38, 0x0E, 0x03, 0xEF, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x38, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0xE0, 0x0F, 0x1E, 0x03, 0x80, 0xE0, 0xE0, 0x0C, 0x18, 0x01, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x0C, 0x00, 0xC1, 0x80,
  0x38, 0x38, 0x0E, 0x03, 0xEF, 0x80, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C,
  0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x78,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0E, 0x00,
  0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x01, 0xE1, 0xE0, 0x30, 0x06,
  0x06, 0x00, 0x70, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x70, 0x03, 0x83, 0x80, 0x70,
  0x3F, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0xEF, 0x80,
  0x1F, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x18,
  0x03, 0x06, 0x01, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0x20, 0x60, 0x0C, 0x38, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x05,
  0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x0D,
  0x80, 0xE0, 0x36, 0x02, 0x80, 0xD8, 0x0A, 0x06, 0x60, 0x68, 0x19, 0x81,
  0xA0, 0x66, 0x04, 0x83, 0x18, 0x32, 0x0C, 0x60, 0xC8, 0x31, 0x82, 0x20,
  0xC6, 0x19, 0x86, 0x18, 0x66, 0x18, 0x61, 0x18, 0x61, 0x8C, 0x61, 0x06,
  0x31, 0x8C, 0x18, 0x86, 0x30, 0x62, 0x18, 0xC1, 0x98, 0x66, 0x06, 0x41,
  0x98, 0x19, 0x06, 0x60, 0x6C, 0x19, 0x01, 0xB0, 0x6C, 0x04, 0x81, 0xB0,
  0x16, 0x06, 0xC0, 0x58, 0x1E, 0x01, 0x40, 0x78, 0x05, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x17, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x76, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x30, 0x30,
  0x06, 0x01, 0x00, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xFC, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0xD8, 0x00, 0xD8, 0x01, 0x98, 0x03,
  0x8C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x0C, 0x06, 0x1C, 0x06, 0x18,
  0x06, 0x38, 0x07, 0x30, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0xC3, 0x06, 0x1C, 0x03, 0xFC, 0xC1, 0xE7, 0xB0, 0xE0, 0x3C, 0x60,
  0x07, 0x18, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x18, 0x01, 0xC6, 0x00, 0xE1, 0xC0,
  0x78, 0x3C, 0xF6, 0x07, 0xF9, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x67, 0xF8,
  0x1B, 0xCF, 0x07, 0x80, 0xE1, 0xC0, 0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C,
  0xE0, 0x06, 0x38, 0x03, 0x8F, 0x01, 0xC3, 0x79, 0xE0, 0xCF, 0xE0, 0x00,
  0x01, 0xFE, 0x01, 0xF7, 0xC0, 0xE0, 0x38, 0x70, 0x06, 0x18, 0x01, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x0C,
  0xE0, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x61, 0xC0, 0x70, 0x3E, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x1F, 0xE6, 0x07, 0x9E, 0xC1,
  0xC0, 0x78, 0x60, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0x60,
  0x07, 0x0C, 0x01, 0xC1, 0xC0, 0x78, 0x1E, 0x7B, 0x01, 0xFE, 0x60, 0x01,
  0xFE, 0x01, 0xF7, 0xC0, 0xE0, 0x38, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x67, 0xFF, 0xF9,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x01, 0x18, 0x01, 0x86, 0x00, 0x61, 0xC0, 0x70, 0x3E, 0x78, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0xC1, 0xE7, 0xB0, 0xE0,
  0x2C, 0x60, 0x07, 0x18, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x07, 0x0C, 0x02, 0xC3, 0xE7,
  0x60, 0x7F, 0x98, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x63, 0xF8, 0x1B, 0xCF, 0x07, 0x80, 0xE1, 0xC0,
  0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x07, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x07, 0x18,
  0x00, 0xE1, 0x80, 0x1C, 0x18, 0x03, 0x81, 0x80, 0x70, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0xFE, 0x00,
  0x60, 0x60, 0x06, 0x07, 0x00, 0x60, 0x30, 0x06, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00,
  0x70, 0xC0, 0x03, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0D,
  0xF1, 0xF0, 0x59, 0xD1, 0xC7, 0x07, 0x06, 0x38, 0x30, 0x31, 0x81, 0x81,
  0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x63, 0x02, 0x06, 0x18, 0x30, 0x31, 0x81,
  0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x63, 0x03, 0x03, 0x18, 0x18, 0x30,
  0xC1, 0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x63, 0x03, 0x03, 0x18, 0x18,
  0x18, 0xC0, 0xC0, 0x86, 0x04, 0x0C, 0x60, 0x60, 0x60, 0x18, 0xFE, 0x06,
  0xF3, 0xC1, 0xE0, 0x38, 0x70, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x01,
  0xFE, 0x01, 0xF7, 0xC0, 0xE0, 0x38, 0x70, 0x06, 0x18, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0,
  0x03, 0x18, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x70, 0x3E, 0xF8, 0x07, 0xF8,
  0x00, 0x06, 0x7F, 0x80, 0x6F, 0x3C, 0x07, 0x80, 0xE0, 0x70, 0x06, 0x0E,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x80, 0x18, 0x38, 0x03,
  0x83, 0xC0, 0x70, 0x37, 0x9E, 0x03, 0x3F, 0x80, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0xC1, 0xE7, 0xB0, 0xC0, 0x3C, 0x60, 0x07, 0x18,
  0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33,
  0x80, 0x0C, 0xE0, 0x07, 0x18, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x78, 0x3C,
  0xF6, 0x07, 0xF9, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0xFF, 0x01, 0xB9,
  0xF0, 0x68, 0x07, 0x0E, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x03, 0xE3, 0xE1, 0xC0, 0x18, 0x60, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x80, 0x18, 0x7C, 0x3C,
  0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00,
  0xE1, 0xC0, 0x70, 0x3E, 0xF8, 0x07, 0xF8, 0x00, 0xC0, 0x01, 0xF0, 0x00,
  0x6C, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x18, 0x08, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30,
  0x60, 0x0C, 0x18, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x60,
  0x3C, 0x0E, 0x06, 0xC0, 0xE0, 0x6C, 0x1E, 0x06, 0xC1, 0xA0, 0xCC, 0x12,
  0x0C, 0xC3, 0x20, 0xCC, 0x32, 0x18, 0xC2, 0x21, 0x8C, 0x62, 0x18, 0xC6,
  0x23, 0x0C, 0x42, 0x30, 0xCC, 0x23, 0x0C, 0xC2, 0x60, 0xC8, 0x26, 0x0D,
  0x82, 0x60, 0xD0, 0x2C, 0x0D, 0x02, 0xC0, 0xF0, 0x2C, 0x0E, 0x02, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x30, 0x01, 0x80, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x03, 0x0C, 0x00,
  0x18, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x70, 0x03, 0x07, 0x00, 0x18,
  0x70, 0x00, 0x60, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x71, 0x80, 0x1C, 0x60, 0x0E, 0x1C, 0x07, 0x83, 0xCF, 0x60, 0x7F, 0x98,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xF1, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x67, 0xF0, 0x08,
  0xC7, 0x01, 0x30, 0x60, 0x66, 0x06, 0x0C, 0xC0, 0x63, 0x30, 0x0F, 0xE6,
  0x00, 0x30,
};

const GFXglyph JetBrainsMono_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 29, 24, 8, -29 },
  { 30, 12, 12, 24, 8, -29 },
  { 48, 23, 29, 24, 1, -29 },
  { 132, 20, 41, 24, 2, -35 },
  { 235, 27, 29, 24, -1, -29 },
  { 333, 21, 30, 24, 1, -30 },
  { 412, 4, 12, 24, 12, -29 },
  { 418, 16, 39, 24, 7, -34 },
  { 496, 16, 39, 24, 2, -34 },
  { 574, 21, 20, 24, 2, -24 },
  { 627, 18, 19, 24, 3, -23 },
  { 670, 9, 12, 24, 5, -6 },
  { 684, 13, 2, 24, 6, -14 },
  { 688, 6, 6, 24, 8, -6 },
  { 693, 23, 37, 24, 1, -33 },
  { 800, 19, 30, 24, 3, -30 },
  { 872, 18, 29, 24, 2, -29 },
  { 938, 20, 30, 24, 2, -30 },
  { 1013, 19, 29, 24, 3, -29 },
  { 1082, 18, 29, 24, 3, -29 },
  { 1148, 19, 29, 24, 3, -29 },
  { 1217, 18, 29, 24, 3, -29 },
  { 1283, 19, 29, 24, 5, -29 },
  { 1352, 20, 30, 24, 2, -30 },
  { 1427, 19, 30, 24, 4, -30 },
  { 1499, 8, 22, 24, 8, -22 },
  { 1521, 12, 28, 24, 5, -22 },
  { 1563, 18, 20, 24, 4, -23 },
  { 1608, 18, 11, 24, 3, -19 },
  { 1633, 19, 20, 24, 2, -23 },
  { 1681, 15, 29, 24, 7, -29 },
  { 1736, 23, 37, 24, 1, -30 },
  { 1843, 19, 29, 24, 1, -29 },
  { 1912, 19, 29, 24, 3, -29 },
  { 1981, 19, 30, 24, 3, -30 },
  { 2053, 19, 29, 24, 3, -29 },
  { 2122, 20, 29, 24, 3, -29 },
  { 2195, 21, 29, 24, 3, -29 },
  { 2272, 19, 30, 24, 3, -30 },
  { 2344, 19, 29, 24, 3, -29 },
  { 2413, 19, 29, 24, 3, -29 },
  { 2482, 20, 29, 24, 2, -29 },
  { 2555, 21, 29, 24, 3, -29 },
  { 2632, 17, 29, 24, 3, -29 },
  { 2694, 21, 29, 24, 2, -29 },
  { 2771, 19, 29, 24, 3, -29 },
  { 2840, 19, 30, 24, 3, -30 },
  { 2912, 20, 29, 24, 3, -29 },
  { 2985, 19, 37, 24, 3, -30 },
  { 3073, 20, 29, 24, 3, -29 },
  { 3146, 20, 30, 24, 2, -30 },
  { 3221, 19, 29, 24, 5, -29 },
  { 3290, 20, 29, 24, 3, -29 },
  { 3363, 18, 29, 24, 6, -29 },
  { 3429, 22, 29, 24, 3, -29 },
  { 3509, 24, 29, 24, 0, -29 },
  { 3596, 20, 29, 24, 5, -29 },
  { 3669, 21, 29, 24, 2, -29 },
  { 3746, 15, 37, 24, 6, -33 },
  { 3816, 11, 37, 24, 7, -33 },
  { 3867, 15, 37, 24, 4, -33 },
  { 3937, 16, 15, 24, 4, -29 },
  { 3967, 20, 2, 24, 0, 1 },
  { 3972, 6, 5, 24, 11, -31 },
  { 3976, 18, 22, 24, 3, -22 },
  { 4026, 18, 29, 24, 3, -29 },
  { 4092, 18, 22, 24, 3, -22 },
  { 4142, 19, 29, 24, 3, -29 },
  { 4211, 18, 22, 24, 3, -22 },
  { 4261, 25, 36, 24, -1, -29 },
  { 4374, 18, 29, 24, 3, -22 },
  { 4440, 18, 29, 24, 3, -29 },
  { 4506, 18, 31, 24, 2, -31 },
  { 4576, 20, 38, 24, 1, -31 },
  { 4671, 20, 29, 24, 3, -29 },
  { 4744, 15, 29, 24, 5, -29 },
  { 4799, 21, 22, 24, 1, -22 },
  { 4857, 18, 22, 24, 3, -22 },
  { 4907, 18, 22, 24, 3, -22 },
  { 4957, 20, 29, 24, 1, -22 },
  { 5030, 18, 29, 24, 3, -22 },
  { 5096, 19, 22, 24, 3, -22 },
  { 5149, 18, 22, 24, 3, -22 },
  { 5199, 18, 28, 24, 4, -28 },
  { 5262, 18, 22, 24, 3, -22 },
  { 5312, 18, 22, 24, 5, -22 },
  { 5362, 20, 22, 24, 4, -22 },
  { 5417, 21, 22, 24, 1, -22 },
  { 5475, 18, 29, 24, 3, -22 },
  { 5541, 19, 22, 24, 2, -22 },
  { 5594, 19, 37, 24, 4, -33 },
  { 5682, 7, 37, 24, 9, -33 },
  { 5715, 19, 37, 24, 2, -33 },
  { 5803, 19, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_THINITALIC40PT7B_H_
