#ifndef _JETBRAINSMONO_THINITALIC36PT7B_H_
#define _JETBRAINSMONO_THINITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x78, 0x78, 0x70, 0x70, 0x6E, 0x1D, 0xC3, 0xB0, 0x76, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0xC0, 0xD8, 0x13, 0x06, 0x00, 0x00, 0x30, 0x30, 0x03, 0x01,
  0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x03, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x18, 0x0C, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80,
  0x80, 0x0C, 0x0C, 0x07, 0xFF, 0xFE, 0x06, 0x02, 0x00, 0x30, 0x30, 0x01,
  0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x39, 0x38, 0x18, 0xC6, 0x0C, 0x30,
  0xC3, 0x0C, 0x31, 0x82, 0x0C, 0x60, 0x80, 0x18, 0x20, 0x06, 0x18, 0x00,
  0xC6, 0x00, 0x39, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03,
  0x38, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x02, 0x0C, 0xC0, 0x83,
  0x30, 0x20, 0xCC, 0x18, 0x21, 0x86, 0x18, 0x71, 0x8C, 0x0F, 0x5E, 0x01,
  0xFF, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x03, 0xF0, 0x03, 0x06, 0x18, 0x06, 0x04, 0x08, 0x0C, 0x0C, 0x08,
  0x18, 0x0C, 0x08, 0x10, 0x08, 0x18, 0x30, 0x08, 0x18, 0x60, 0x08, 0x18,
  0xC0, 0x08, 0x11, 0x80, 0x0C, 0x33, 0x00, 0x0F, 0xE6, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x63,
  0xF0, 0x00, 0xC6, 0x18, 0x01, 0x8C, 0x18, 0x01, 0x0C, 0x18, 0x03, 0x08,
  0x18, 0x06, 0x08, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x18,
  0x30, 0x60, 0x0C, 0x60, 0xC0, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0xC0,
  0x07, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0x39, 0x80, 0x0C, 0x30, 0x19, 0x83, 0x06, 0x60, 0x60, 0x8C,
  0x06, 0x31, 0x80, 0x6C, 0x30, 0x0D, 0x06, 0x00, 0xE0, 0x80, 0x18, 0x10,
  0x07, 0x83, 0x01, 0x98, 0x60, 0x73, 0x0F, 0x38, 0x30, 0xFE, 0x07, 0x00,
  0x76, 0x66, 0xEE, 0xCC, 0xCC, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x1C, 0x18, 0x3F, 0xE2, 0x3F, 0x1F, 0x5F, 0x00,
  0x7F, 0x00, 0x03, 0x00, 0x00, 0xB0, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x38, 0x0C, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xFF, 0x01, 0xC3, 0xC1, 0x80, 0x61, 0x80, 0x39, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x66, 0x1C, 0x33, 0x0E, 0x19, 0x87, 0x0C, 0xC1, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x30, 0x60, 0x38, 0x3E, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xD8, 0x07, 0x18, 0x0E, 0x18, 0x08, 0x18, 0x10, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x70, 0x38, 0x38, 0x06, 0x0C,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x07, 0xFF, 0xC2, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x61, 0x80, 0x18,
  0x40, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC1, 0xC0, 0x60, 0x3C, 0x70, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x04,
  0xC0, 0x0C, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x0F, 0xFF, 0x84, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x19, 0xFC, 0x0D, 0xCF, 0x07, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x31,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0xC0, 0x70, 0x78, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x3E, 0x01, 0xFF, 0x81, 0xC0, 0xE1, 0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x33, 0x00,
  0x31, 0x80, 0x30, 0xE0, 0x38, 0x3C, 0x78, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xBF, 0xFF, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x33, 0x80,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x38,
  0x38, 0x18, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03,
  0x08, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x70, 0x1C, 0x30, 0x03, 0xB8, 0x00,
  0x78, 0x00, 0x3B, 0x80, 0x38, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x61, 0x80, 0x18,
  0x70, 0x0C, 0x0F, 0x1E, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0xF8, 0x0E,
  0x0E, 0x18, 0x06, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x0E, 0x60, 0x1C, 0x38,
  0x38, 0x1F, 0xD8, 0x02, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x1E, 0x1F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xC0, 0x7C,
  0x1F, 0x83, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x02, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0xE0, 0x83, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xC0, 0x7C, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xF8, 0x01, 0xC1, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x70, 0xC0, 0x03,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x3F,
  0xB3, 0x07, 0x0B, 0x30, 0x60, 0x63, 0x0C, 0x06, 0x30, 0xC0, 0x62, 0x0C,
  0x06, 0x60, 0xC0, 0x66, 0x0C, 0x06, 0x60, 0x80, 0x46, 0x18, 0x0C, 0x61,
  0x80, 0xC4, 0x18, 0x0C, 0xC1, 0xC1, 0xCC, 0x0F, 0xEC, 0xC0, 0x7C, 0x8C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x02, 0x20, 0x03, 0x10, 0x01,
  0x88, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x60,
  0x30, 0x30, 0x18, 0x08, 0x18, 0x04, 0x0C, 0x02, 0x07, 0xFF, 0x86, 0x00,
  0xC2, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0,
  0x01, 0x60, 0x00, 0xC0, 0x0F, 0xFE, 0x03, 0x03, 0xC0, 0xC0, 0x18, 0x30,
  0x06, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0xC1, 0x80, 0x70, 0x40, 0x78, 0x1F, 0xF8, 0x0C, 0x07, 0x83,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x70, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61,
  0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x31, 0x80, 0x18, 0x60, 0x18, 0x1C, 0x78, 0x07, 0xF0,
  0x00, 0x0F, 0xFC, 0x03, 0x07, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x01,
  0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0x40, 0x06, 0x10, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x03, 0x06, 0x01, 0xC1, 0x80, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC2, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x86, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0x40,
  0x06, 0x60, 0x03, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x83, 0xFC, 0xC1, 0xFE, 0x60, 0x02, 0x30, 0x03,
  0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x80,
  0x18, 0x60, 0x18, 0x1C, 0x78, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x1F,
  0xFF, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x10, 0x40, 0x0C, 0x30, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x04, 0x30, 0x03, 0x0C, 0x01, 0xC1, 0x80, 0xE0, 0x78, 0xF0, 0x0F,
  0xF0, 0x00, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x18,
  0x0C, 0x03, 0x80, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x3F, 0xF0, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x20,
  0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0xE1, 0xC0,
  0x3C, 0x68, 0x05, 0x0D, 0x01, 0xA1, 0xA0, 0x2C, 0x36, 0x0D, 0x86, 0x41,
  0x30, 0x88, 0x66, 0x31, 0x08, 0x86, 0x33, 0x10, 0xC6, 0x46, 0x18, 0x58,
  0xC3, 0x0E, 0x18, 0x41, 0x83, 0x08, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x31, 0x80, 0x04,
  0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0xC3, 0x80, 0x30, 0xF0, 0x0C, 0x3C, 0x03, 0x0D, 0x00, 0x82, 0x40, 0x21,
  0x98, 0x18, 0x66, 0x06, 0x19, 0x81, 0x86, 0x20, 0x61, 0x8C, 0x18, 0x43,
  0x04, 0x10, 0xC3, 0x0C, 0x10, 0xC3, 0x06, 0x30, 0xC1, 0x8C, 0x30, 0x63,
  0x08, 0x08, 0x82, 0x02, 0x21, 0x80, 0xD8, 0x60, 0x36, 0x18, 0x05, 0x86,
  0x01, 0x61, 0x80, 0x70, 0x40, 0x1C, 0x30, 0x07, 0x00, 0x00, 0x70, 0x01,
  0xFE, 0x01, 0xC1, 0x81, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x08, 0x40, 0x04,
  0x60, 0x02, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x10,
  0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30,
  0x60, 0x30, 0x3C, 0x70, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0x80, 0xF0,
  0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x01, 0xC1,
  0x01, 0xF0, 0x7F, 0xF8, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xFE, 0x01, 0xC1, 0x81, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x08, 0x40, 0x04,
  0x60, 0x02, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x10,
  0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30,
  0x60, 0x30, 0x3C, 0x70, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x01, 0x81,
  0xF0, 0x30, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x00, 0x86, 0x00,
  0x10, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x08, 0x01,
  0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x30,
  0x06, 0x06, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x20, 0x40, 0x06, 0x18, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x7F, 0xC0, 0x38, 0x38, 0x18, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x21, 0x80, 0x18, 0x70, 0x0C, 0x0F, 0x1E, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x08, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x46,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x02,
  0x30, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x60, 0xC0,
  0x60, 0x38, 0xE0, 0x0F, 0xE0, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x60,
  0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x02, 0x06, 0x01, 0x03, 0x00,
  0xC1, 0x00, 0x61, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60,
  0x03, 0x30, 0x00, 0x90, 0x00, 0x58, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x70, 0x36, 0x07, 0x06, 0x60, 0xF0, 0x64, 0x0F, 0x06,
  0x40, 0xA0, 0x44, 0x0A, 0x0C, 0x41, 0xA0, 0xC4, 0x12, 0x0C, 0x41, 0x20,
  0x84, 0x32, 0x18, 0x42, 0x21, 0x84, 0x22, 0x10, 0x46, 0x23, 0x04, 0x62,
  0x30, 0xC4, 0x23, 0x0C, 0x42, 0x20, 0xCC, 0x26, 0x0C, 0x82, 0x60, 0xC8,
  0x24, 0x0D, 0x82, 0x40, 0xD0, 0x2C, 0x0D, 0x02, 0xC0, 0xF0, 0x28, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x40, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x02,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x80,
  0x00, 0x33, 0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x80, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x60, 0x60, 0x00, 0x83, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x66,
  0x00, 0x18, 0x80, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x81, 0x00, 0xC0, 0x60,
  0x60, 0x18, 0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x06, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC1, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x7F, 0x83, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xC8, 0x03,
  0x30, 0x18, 0xC0, 0xC3, 0x03, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x98,
  0x03, 0x60, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3, 0x0C,
  0x31, 0x80, 0x03, 0xF3, 0x0F, 0x3B, 0x1C, 0x0F, 0x10, 0x07, 0x30, 0x07,
  0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0x60, 0x28, 0x78, 0xF8, 0x3F, 0x98, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x63, 0xF0, 0x37, 0xBC, 0x1E,
  0x07, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x21, 0x00, 0x11, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0x8C, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xE0, 0x38, 0x5C, 0x78, 0x67,
  0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x18, 0x06, 0x30, 0x03,
  0x20, 0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18,
  0x60, 0x38, 0x78, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x0F, 0xCC, 0x1E, 0x76, 0x1C,
  0x0F, 0x0C, 0x03, 0x8C, 0x01, 0xC4, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x02, 0x30, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x70, 0xC0, 0x50, 0x78, 0xF8, 0x1F,
  0xCC, 0x00, 0x03, 0xF8, 0x0F, 0xBC, 0x1C, 0x0E, 0x18, 0x06, 0x30, 0x06,
  0x20, 0x02, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06, 0x7F, 0xFE, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xC0, 0x18,
  0x60, 0x38, 0x78, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF3,
  0x0F, 0x3B, 0x1C, 0x0F, 0x10, 0x07, 0x30, 0x07, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x04, 0xC0, 0x0C,
  0xC0, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x70, 0x6C, 0x3F, 0xC8, 0x02, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0xE0,
  0x7F, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x63, 0xF0, 0x37, 0xBC, 0x1E, 0x07, 0x0E, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0x61, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x04, 0x60, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x3F, 0xE0, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x38, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0xE0, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x06, 0x0C, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x06, 0x18, 0x00,
  0xE0, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x1B,
  0xE7, 0xC3, 0xDD, 0xB8, 0x60, 0xC1, 0x8C, 0x18, 0x31, 0x03, 0x06, 0x20,
  0x40, 0x8C, 0x18, 0x11, 0x83, 0x06, 0x30, 0x60, 0xC6, 0x0C, 0x18, 0xC1,
  0x83, 0x10, 0x20, 0x66, 0x04, 0x08, 0xC1, 0x83, 0x18, 0x30, 0x63, 0x06,
  0x0C, 0x60, 0xC1, 0x88, 0x10, 0x33, 0x02, 0x04, 0x60, 0xC1, 0x80, 0x18,
  0xFC, 0x0D, 0xEF, 0x07, 0x81, 0xC3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x42, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x10, 0x01, 0x18, 0x01, 0x80, 0x03, 0xF8, 0x0F, 0xBC, 0x1C, 0x0E,
  0x18, 0x06, 0x30, 0x06, 0x20, 0x02, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x30, 0x78, 0xE0, 0x1F, 0xC0, 0x0C, 0x7E,
  0x03, 0x7B, 0xC0, 0xF0, 0x38, 0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x21,
  0x80, 0x08, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x10, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06,
  0x0E, 0x03, 0x02, 0xE3, 0xC1, 0x9F, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF3, 0x0F,
  0x3B, 0x18, 0x0F, 0x38, 0x07, 0x30, 0x07, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x04, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x28, 0x78, 0xF8, 0x3F,
  0x98, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x19, 0xFC, 0x0D, 0xCF, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xCF,
  0x83, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0D, 0x80, 0x04, 0x60, 0x06, 0x30, 0x07, 0x0E, 0x07,
  0x03, 0xFE, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x20, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x18, 0x60, 0x30, 0x78, 0xE0, 0x1F, 0xC0, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x20,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30, 0x60, 0x10, 0xC0, 0x10,
  0xC0, 0x19, 0x80, 0x19, 0x80, 0x1B, 0x00, 0x0B, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0xC0, 0xC0, 0x70, 0x30, 0x3C, 0x0C, 0x0F, 0x07, 0x02, 0xC1, 0x41,
  0xB0, 0x50, 0x6C, 0x34, 0x13, 0x09, 0x8C, 0xC6, 0x63, 0x31, 0x98, 0x8C,
  0x46, 0x63, 0x31, 0x98, 0xCC, 0x64, 0x32, 0x1B, 0x05, 0x86, 0xC1, 0x41,
  0xA0, 0x50, 0x78, 0x1C, 0x1E, 0x06, 0x07, 0x01, 0x81, 0xC0, 0x0C, 0x00,
  0x61, 0x80, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0x30, 0x60, 0x02, 0x0C,
  0x00, 0x63, 0x00, 0x04, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01, 0x86, 0x00, 0x60, 0x60,
  0x18, 0x04, 0x06, 0x00, 0xC1, 0xC0, 0x0C, 0x70, 0x01, 0x80, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x20, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x2C, 0x70, 0x68, 0x3F, 0xD8, 0x04, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x06, 0x0C,
  0x10, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x08,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x18,
  0x30, 0x60, 0xC1, 0x80, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0x7F,
  0x01, 0x61, 0x83, 0xC1, 0x83, 0xC0, 0xC3, 0xC0, 0x7E, 0xC0, 0x18,
};

const GFXglyph JetBrainsMono_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 11, 11, 22, 7, -26 },
  { 43, 21, 26, 22, 1, -26 },
  { 112, 18, 36, 22, 2, -31 },
  { 193, 24, 26, 22, -1, -26 },
  { 271, 19, 27, 22, 1, -27 },
  { 336, 4, 11, 22, 11, -26 },
  { 342, 15, 35, 22, 6, -30 },
  { 408, 14, 35, 22, 2, -30 },
  { 470, 19, 18, 22, 2, -22 },
  { 513, 16, 16, 22, 3, -20 },
  { 545, 8, 11, 22, 4, -5 },
  { 556, 12, 2, 22, 5, -13 },
  { 559, 5, 5, 22, 7, -5 },
  { 563, 20, 34, 22, 1, -30 },
  { 648, 17, 27, 22, 3, -27 },
  { 706, 16, 26, 22, 2, -26 },
  { 758, 18, 27, 22, 2, -27 },
  { 819, 18, 26, 22, 2, -26 },
  { 878, 16, 26, 22, 3, -26 },
  { 930, 17, 26, 22, 3, -26 },
  { 986, 17, 26, 22, 2, -26 },
  { 1042, 17, 26, 22, 4, -26 },
  { 1098, 18, 27, 22, 2, -27 },
  { 1159, 16, 27, 22, 4, -27 },
  { 1213, 8, 20, 22, 7, -20 },
  { 1233, 11, 26, 22, 4, -20 },
  { 1269, 17, 18, 22, 3, -21 },
  { 1308, 16, 10, 22, 3, -17 },
  { 1328, 17, 18, 22, 2, -21 },
  { 1367, 14, 26, 22, 6, -26 },
  { 1413, 20, 33, 22, 1, -27 },
  { 1496, 17, 26, 22, 1, -26 },
  { 1552, 18, 26, 22, 2, -26 },
  { 1611, 17, 27, 22, 3, -27 },
  { 1669, 18, 26, 22, 2, -26 },
  { 1728, 18, 26, 22, 3, -26 },
  { 1787, 18, 26, 22, 3, -26 },
  { 1846, 17, 27, 22, 3, -27 },
  { 1904, 18, 26, 22, 2, -26 },
  { 1963, 17, 26, 22, 3, -26 },
  { 2019, 18, 26, 22, 2, -26 },
  { 2078, 20, 26, 22, 2, -26 },
  { 2143, 15, 26, 22, 3, -26 },
  { 2192, 19, 26, 22, 2, -26 },
  { 2254, 18, 26, 22, 2, -26 },
  { 2313, 17, 27, 22, 3, -27 },
  { 2371, 19, 26, 22, 2, -26 },
  { 2433, 17, 33, 22, 3, -27 },
  { 2504, 19, 26, 22, 2, -26 },
  { 2566, 18, 27, 22, 2, -27 },
  { 2627, 18, 26, 22, 4, -26 },
  { 2686, 17, 26, 22, 3, -26 },
  { 2742, 17, 26, 22, 5, -26 },
  { 2798, 20, 26, 22, 3, -26 },
  { 2863, 22, 26, 22, 0, -26 },
  { 2935, 18, 26, 22, 4, -26 },
  { 2994, 18, 26, 22, 2, -26 },
  { 3053, 13, 34, 22, 6, -30 },
  { 3109, 9, 34, 22, 7, -30 },
  { 3148, 14, 34, 22, 3, -30 },
  { 3208, 14, 14, 22, 4, -26 },
  { 3233, 18, 2, 22, 0, 1 },
  { 3238, 5, 5, 22, 10, -28 },
  { 3242, 16, 20, 22, 3, -20 },
  { 3282, 17, 26, 22, 2, -26 },
  { 3338, 16, 20, 22, 3, -20 },
  { 3378, 17, 26, 22, 3, -26 },
  { 3434, 16, 20, 22, 3, -20 },
  { 3474, 22, 32, 22, -1, -26 },
  { 3562, 16, 26, 22, 3, -20 },
  { 3614, 17, 26, 22, 2, -26 },
  { 3670, 16, 28, 22, 2, -28 },
  { 3726, 18, 34, 22, 1, -28 },
  { 3803, 19, 26, 22, 2, -26 },
  { 3865, 14, 26, 22, 4, -26 },
  { 3911, 19, 20, 22, 1, -20 },
  { 3959, 17, 20, 22, 2, -20 },
  { 4002, 16, 20, 22, 3, -20 },
  { 4042, 18, 26, 22, 1, -20 },
  { 4101, 16, 26, 22, 3, -20 },
  { 4153, 17, 20, 22, 3, -20 },
  { 4196, 17, 20, 22, 2, -20 },
  { 4239, 16, 25, 22, 4, -25 },
  { 4289, 16, 20, 22, 3, -20 },
  { 4329, 16, 20, 22, 4, -20 },
  { 4369, 18, 20, 22, 3, -20 },
  { 4414, 19, 20, 22, 1, -20 },
  { 4462, 16, 26, 22, 3, -20 },
  { 4514, 17, 20, 22, 2, -20 },
  { 4557, 17, 34, 22, 4, -30 },
  { 4630, 7, 34, 22, 8, -30 },
  { 4660, 18, 34, 22, 1, -30 },
  { 4737, 16, 7, 22, 3, -16 },
};

const GFXfont JetBrainsMono_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_THINITALIC36PT7B_H_
