#ifndef _JETBRAINSMONO_THINITALIC67PT7B_H_
#define _JETBRAINSMONO_THINITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3E,
  0x1C, 0x3E, 0x00, 0x1F, 0x07, 0x07, 0xC0, 0x0F, 0x01, 0xC0, 0xF0, 0x03,
  0x80, 0x70, 0x1E, 0x01, 0xE0, 0x18, 0x07, 0x80, 0x70, 0x06, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x07,
  0x80, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x00, 0x3E,
  0x18, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0x3F, 0x00, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x00, 0x70, 0x7C,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x07, 0x00,
  0x38, 0x03, 0x83, 0xC0, 0x0E, 0x00, 0xE0, 0xF0, 0x03, 0x00, 0x78, 0x1C,
  0x01, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x7C, 0x07, 0x01, 0xE0, 0x0F, 0x81, 0xC0, 0xF0, 0x01, 0xF0, 0x60, 0xF8,
  0x00, 0x3F, 0xDB, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1E, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC1, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xF3,
  0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0x0F, 0x01, 0xE0, 0x00, 0xE0,
  0xE0, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x80,
  0x38, 0x1C, 0x00, 0x78, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x3C, 0x0E, 0x03, 0x80, 0x01, 0xE1, 0xC0, 0x38, 0x00, 0x0F, 0x3C, 0x03,
  0x80, 0x00, 0xF7, 0x80, 0x38, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x0F, 0x70, 0x07,
  0x80, 0x01, 0xE7, 0x80, 0x78, 0x00, 0x3C, 0x38, 0x07, 0xC0, 0x07, 0x83,
  0xC0, 0x3E, 0x01, 0xF0, 0x1E, 0x03, 0xF8, 0xFE, 0x00, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F,
  0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x03,
  0xC0, 0x01, 0x3C, 0x00, 0x78, 0x00, 0xE7, 0xF0, 0x0E, 0x00, 0xFD, 0xFF,
  0x81, 0xC0, 0xFF, 0xCF, 0xFC, 0x38, 0xFF, 0xE0, 0x3F, 0xE6, 0x7F, 0xE0,
  0x01, 0xFE, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x1E, 0x1C, 0x03, 0xC0, 0x1C, 0x3C, 0x07, 0xE0, 0x1C, 0x3C, 0x07,
  0xF0, 0x3C, 0x3C, 0x07, 0xF0, 0x3C, 0x3C, 0x07, 0xE0, 0x3C, 0x3C, 0x03,
  0xE0, 0x3C, 0x38, 0x01, 0x80, 0x38, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xEE,
  0x00, 0x00, 0x3E, 0x70, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x03, 0xFE, 0x00,
  0x07, 0x0F, 0xFF, 0x80, 0x07, 0x3F, 0xFF, 0xC0, 0x0F, 0x78, 0x07, 0xE0,
  0x0E, 0xE0, 0x03, 0xF0, 0x0E, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x3F, 0xF0, 0x00, 0x39, 0xFF, 0xF8, 0x00, 0xFF, 0xEF,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x8F, 0xDC, 0x00, 0x7F, 0xFF,
  0x70, 0x00, 0x3F, 0xF9, 0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0x01, 0xE0, 0xF0, 0x00, 0x7F, 0xC7,
  0x83, 0xC0, 0x07, 0xFF, 0x9C, 0x0E, 0x00, 0x3F, 0xFF, 0x70, 0x38, 0x01,
  0xF0, 0x0D, 0xC0, 0xE0, 0x07, 0x80, 0x17, 0x03, 0x80, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x70, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x70, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x03, 0x80,
  0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x38, 0x1C,
  0x01, 0xE0, 0x01, 0xE0, 0x70, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x0F, 0x00,
  0x2E, 0x07, 0x00, 0x3E, 0x03, 0xB8, 0x3C, 0x00, 0x7F, 0xFC, 0xE0, 0xF0,
  0x01, 0xFF, 0xE7, 0x03, 0xC0, 0x01, 0xFE, 0x1C, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1C, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x38, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0x80,
  0x00, 0xFC, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x20,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x01, 0xE0, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0x03, 0x80, 0x3F, 0xFF, 0x83, 0xC0, 0x1F, 0xFF,
  0xC1, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x1D, 0xC0, 0x00, 0x7E, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x1D, 0xC0,
  0x00, 0xEE, 0x01, 0xCC, 0x00, 0x1C, 0xE0, 0x1C, 0xC0, 0x01, 0xCE, 0x01,
  0xCE, 0x00, 0x39, 0xE0, 0x3C, 0xE0, 0x03, 0x9C, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x38, 0x60, 0x07, 0x1C, 0x03, 0x86, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x03, 0x87, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x07,
  0x83, 0x03, 0x83, 0x80, 0x70, 0x30, 0x30, 0x38, 0x07, 0x03, 0x87, 0x03,
  0x80, 0x70, 0x38, 0x60, 0x78, 0x07, 0x03, 0x8E, 0x07, 0x80, 0x70, 0x18,
  0xC0, 0x70, 0x0F, 0x01, 0x9C, 0x07, 0x00, 0xF0, 0x1D, 0x80, 0x70, 0x0E,
  0x01, 0xF8, 0x07, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0xE0, 0x0F, 0x80, 0x00, 0x38, 0x03, 0xF0, 0x00, 0x0E, 0x01, 0xFC, 0x00,
  0x03, 0x80, 0x77, 0x00, 0x00, 0xE0, 0x1D, 0xC0, 0x00, 0x78, 0x07, 0x30,
  0x00, 0x1C, 0x01, 0xCE, 0x00, 0x07, 0x00, 0x73, 0x80, 0x01, 0xC0, 0x1C,
  0xE0, 0x00, 0x70, 0x0F, 0x38, 0x00, 0x1C, 0x03, 0x87, 0x00, 0x0F, 0x00,
  0xE1, 0xC0, 0x03, 0xC0, 0x38, 0x70, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x38,
  0x03, 0x83, 0x80, 0x0E, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x70, 0x38, 0x01,
  0xE0, 0x1C, 0x0E, 0x00, 0x78, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0x1C, 0x0E, 0x01,
  0xE0, 0x07, 0x03, 0x80, 0x70, 0x01, 0xC1, 0xE0, 0x1C, 0x00, 0x70, 0x78,
  0x07, 0x00, 0x0E, 0x1C, 0x01, 0xC0, 0x03, 0x87, 0x00, 0x70, 0x00, 0xE1,
  0xC0, 0x3C, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x07, 0x3C, 0x03, 0x80, 0x01,
  0xCF, 0x00, 0xE0, 0x00, 0x73, 0x80, 0x38, 0x00, 0x1C, 0xE0, 0x0E, 0x00,
  0x03, 0xB8, 0x07, 0x80, 0x00, 0xEE, 0x01, 0xE0, 0x00, 0x3B, 0x80, 0x70,
  0x00, 0x0E, 0xE0, 0x1C, 0x00, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x7C, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x5F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x7C, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x77, 0x00, 0x0F, 0x80,
  0x07, 0x70, 0x00, 0xF8, 0x00, 0xF7, 0x00, 0x0D, 0x80, 0x0E, 0x70, 0x00,
  0xD8, 0x00, 0xE7, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x01, 0xD8, 0x01, 0xE7,
  0x00, 0x19, 0x80, 0x1C, 0x70, 0x03, 0xB8, 0x01, 0xC7, 0x00, 0x3B, 0x80,
  0x3C, 0x70, 0x03, 0x38, 0x03, 0x87, 0x00, 0x73, 0x80, 0x38, 0x70, 0x07,
  0x38, 0x03, 0x87, 0x00, 0x63, 0x80, 0x78, 0x70, 0x0E, 0x38, 0x07, 0x07,
  0x00, 0xE3, 0x80, 0x70, 0x70, 0x0E, 0x38, 0x07, 0x07, 0x00, 0xC3, 0x80,
  0xE0, 0x70, 0x1C, 0x38, 0x0E, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x18,
  0x38, 0x1E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x70, 0x38, 0x38, 0x1C, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x07, 0x07, 0x03, 0x83,
  0x80, 0x70, 0x60, 0x38, 0x38, 0x07, 0x06, 0x03, 0x83, 0x80, 0xF0, 0xE0,
  0x38, 0x70, 0x0E, 0x0E, 0x03, 0x07, 0x00, 0xE0, 0xC0, 0x30, 0x70, 0x0E,
  0x1C, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x30, 0xE0, 0x0E, 0x18, 0x03, 0x0E,
  0x00, 0xE3, 0x80, 0x30, 0xE0, 0x0E, 0x38, 0x03, 0x1C, 0x00, 0xE3, 0x00,
  0x31, 0xC0, 0x0E, 0x30, 0x03, 0x1C, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x0E,
  0x60, 0x03, 0x38, 0x00, 0xE6, 0x00, 0x33, 0x80, 0x0E, 0xE0, 0x03, 0x38,
  0x00, 0xEC, 0x00, 0x37, 0x00, 0x0E, 0xC0, 0x03, 0x70, 0x00, 0xFC, 0x00,
  0x37, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0xFF, 0xFC,
  0x78, 0x03, 0xF8, 0xFC, 0xE0, 0x1F, 0x00, 0x3D, 0xC0, 0x3C, 0x00, 0x3B,
  0x80, 0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3F,
  0x80, 0x78, 0x00, 0xEE, 0x00, 0xFE, 0x0F, 0x9C, 0x00, 0xFF, 0xFE, 0x38,
  0x00, 0x7F, 0xF0, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3C, 0x1F, 0xF8, 0x00,
  0x70, 0xFF, 0xFC, 0x00, 0xE7, 0xE3, 0xFC, 0x01, 0xDE, 0x00, 0x78, 0x03,
  0xF0, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1E, 0x07,
  0xE0, 0x00, 0x78, 0x0E, 0xF0, 0x03, 0xE0, 0x1C, 0xF8, 0x3F, 0x80, 0x38,
  0xFF, 0xFC, 0x00, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x47, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x03, 0xC0, 0x00, 0xFF, 0xC1, 0xE0, 0x01, 0xFF, 0xF8, 0xF0,
  0x01, 0xFC, 0x7E, 0x70, 0x03, 0xE0, 0x07, 0xB8, 0x01, 0xE0, 0x01, 0xDC,
  0x01, 0xE0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0xF0, 0x01, 0xDC, 0x00,
  0x7F, 0x07, 0xCE, 0x00, 0x1F, 0xFF, 0xC7, 0x00, 0x03, 0xFF, 0x83, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0xF0, 0x07, 0xFF, 0xE3, 0xC0, 0x3F, 0x8F, 0xCE, 0x03, 0xE0, 0x07, 0xB8,
  0x0F, 0x00, 0x0E, 0xE0, 0x78, 0x00, 0x1B, 0x83, 0xC0, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xB8, 0x0F, 0x80, 0x1C, 0xE0, 0x1F, 0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0x1E,
  0x00, 0x3F, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x3C, 0x1F, 0xF8, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0xE7, 0xE3, 0xFC, 0x01,
  0xDE, 0x00, 0xFC, 0x03, 0xB0, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x08, 0x00, 0x71,
  0xFC, 0x0F, 0xE0, 0x0E, 0x7F, 0xC3, 0xFF, 0x01, 0xDC, 0xFC, 0xE7, 0xE0,
  0x3E, 0x07, 0xB0, 0x3C, 0x0E, 0x80, 0x74, 0x03, 0xC1, 0xE0, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x01, 0xE0, 0xE0, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xF0,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x03, 0x83, 0x80, 0x1C, 0x00, 0xF0,
  0x70, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x00,
  0x70, 0x78, 0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x01, 0xC1, 0xC0, 0x0F,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0xE0, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xC0, 0x0E,
  0x00, 0x70, 0x78, 0x03, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x03, 0xC1, 0xC0,
  0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x01, 0xC1,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x83, 0xFF,
  0x00, 0x0E, 0x1F, 0xFF, 0x80, 0x1C, 0xFC, 0x7F, 0x80, 0x3B, 0xC0, 0x1F,
  0x80, 0x76, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x78, 0x3F, 0xF0, 0x00, 0x38, 0x7F, 0xFE,
  0x00, 0x1C, 0xFC, 0x3F, 0x80, 0x0E, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x00,
  0xF0, 0x07, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0xE0, 0x0F, 0xC0, 0x00, 0xF0, 0x07, 0x78, 0x01, 0xF0,
  0x03, 0x9F, 0x07, 0xF0, 0x01, 0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0xFF, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00,
  0xFF, 0xFC, 0x78, 0x07, 0xF8, 0xFC, 0xE0, 0x1F, 0x00, 0x3D, 0xC0, 0x7C,
  0x00, 0x1B, 0x80, 0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0x78,
  0x00, 0x3F, 0x80, 0x78, 0x00, 0xEE, 0x00, 0xFE, 0x0F, 0x9C, 0x00, 0xFF,
  0xFE, 0x38, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x07, 0xFE,
  0x00, 0x1E, 0x3F, 0xFF, 0x00, 0x39, 0xF8, 0x7F, 0x00, 0x77, 0x80, 0x1F,
  0x00, 0xEC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x3E,
  0x00, 0x3B, 0x80, 0x0D, 0x80, 0x1E, 0xE0, 0x03, 0x60, 0x07, 0x38, 0x01,
  0xD8, 0x01, 0xCE, 0x00, 0x66, 0x00, 0xF3, 0x80, 0x19, 0x80, 0x38, 0xE0,
  0x0E, 0x60, 0x0E, 0x38, 0x03, 0x18, 0x07, 0x8E, 0x00, 0xC6, 0x01, 0xC3,
  0x80, 0x71, 0x80, 0x70, 0xE0, 0x18, 0x60, 0x3C, 0x38, 0x06, 0x18, 0x0E,
  0x0E, 0x03, 0x86, 0x03, 0x83, 0x80, 0xC1, 0x80, 0xE0, 0xE0, 0x70, 0x60,
  0x70, 0x38, 0x1C, 0x18, 0x1C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x83, 0x81,
  0x83, 0x80, 0xE0, 0xE0, 0x60, 0xE0, 0x38, 0x30, 0x18, 0x38, 0x0E, 0x1C,
  0x06, 0x1C, 0x03, 0x87, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x18,
  0xE0, 0x1C, 0xE0, 0x07, 0x38, 0x07, 0x38, 0x01, 0xCC, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x1D, 0xC0, 0x06, 0x60, 0x07, 0x70,
  0x01, 0xB8, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x7E, 0x00, 0x1B, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x6F, 0x01, 0xF0, 0x07, 0xB8, 0x03, 0xFF, 0xF8, 0xE0, 0x07, 0xFF, 0xC3,
  0x80, 0x07, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x3F, 0xE0, 0x00, 0x71,
  0xFF, 0xC0, 0x01, 0xCF, 0x0F, 0x80, 0x07, 0x78, 0x0F, 0x00, 0x1D, 0xC0,
  0x1C, 0x00, 0xE7, 0x00, 0x78, 0x03, 0xB8, 0x00, 0xF0, 0x0E, 0xE0, 0x01,
  0xE0, 0x7B, 0x80, 0x07, 0xC7, 0xCE, 0x00, 0x0F, 0xFE, 0x38, 0x00, 0x0F,
  0xF0, 0xE0, 0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 13, 49, 40, 14, -49 },
  { 81, 21, 20, 40, 13, -49 },
  { 134, 38, 49, 40, 2, -49 },
  { 367, 34, 67, 40, 4, -58 },
  { 652, 46, 49, 40, -2, -49 },
  { 934, 36, 51, 40, 2, -50 },
  { 1164, 7, 20, 40, 20, -49 },
  { 1182, 27, 65, 40, 12, -57 },
  { 1402, 27, 65, 40, 3, -57 },
  { 1622, 35, 34, 40, 4, -41 },
  { 1771, 31, 31, 40, 5, -38 },
  { 1892, 15, 21, 40, 8, -10 },
  { 1932, 22, 3, 40, 10, -24 },
  { 1941, 10, 10, 40, 13, -9 },
  { 1954, 38, 63, 40, 2, -56 },
  { 2254, 32, 51, 40, 5, -50 },
  { 2458, 29, 49, 40, 4, -49 },
  { 2636, 35, 50, 40, 3, -50 },
  { 2855, 33, 50, 40, 4, -49 },
  { 3062, 29, 49, 40, 6, -49 },
  { 3240, 32, 50, 40, 5, -49 },
  { 3440, 31, 50, 40, 4, -49 },
  { 3634, 32, 49, 40, 8, -49 },
  { 3830, 33, 51, 40, 4, -50 },
  { 4041, 31, 50, 40, 7, -50 },
  { 4235, 15, 39, 40, 13, -38 },
  { 4309, 20, 49, 40, 8, -38 },
  { 4432, 31, 34, 40, 6, -39 },
  { 4564, 31, 18, 40, 5, -31 },
  { 4634, 31, 34, 40, 4, -39 },
  { 4766, 26, 49, 40, 11, -49 },
  { 4926, 38, 62, 40, 2, -50 },
  { 5221, 31, 49, 40, 2, -49 },
  { 5411, 33, 49, 40, 4, -49 },
  { 5614, 33, 51, 40, 5, -50 },
  { 5825, 32, 49, 40, 4, -49 },
  { 6021, 34, 49, 40, 5, -49 },
  { 6230, 35, 49, 40, 5, -49 },
  { 6445, 33, 51, 40, 5, -50 },
  { 6656, 34, 49, 40, 4, -49 },
  { 6865, 32, 49, 40, 5, -49 },
  { 7061, 34, 50, 40, 3, -49 },
  { 7274, 36, 49, 40, 4, -49 },
  { 7495, 28, 49, 40, 5, -49 },
  { 7667, 36, 49, 40, 3, -49 },
  { 7888, 34, 49, 40, 4, -49 },
  { 8097, 32, 51, 40, 5, -50 },
  { 8301, 35, 49, 40, 4, -49 },
  { 8516, 32, 62, 40, 5, -50 },
  { 8764, 35, 49, 40, 4, -49 },
  { 8979, 34, 51, 40, 4, -50 },
  { 9196, 33, 49, 40, 8, -49 },
  { 9399, 33, 50, 40, 5, -49 },
  { 9606, 31, 49, 40, 9, -49 },
  { 9796, 36, 49, 40, 6, -49 },
  { 10017, 39, 49, 40, 1, -49 },
  { 10256, 34, 49, 40, 8, -49 },
  { 10465, 35, 49, 40, 3, -49 },
  { 10680, 25, 63, 40, 11, -56 },
  { 10877, 18, 63, 40, 12, -56 },
  { 11019, 25, 63, 40, 6, -56 },
  { 11216, 27, 26, 40, 7, -49 },
  { 11304, 33, 3, 40, 0, 2 },
  { 11317, 9, 10, 40, 19, -53 },
  { 11329, 31, 39, 40, 5, -38 },
  { 11481, 31, 50, 40, 4, -49 },
  { 11675, 30, 39, 40, 5, -38 },
  { 11822, 33, 50, 40, 5, -49 },
  { 12029, 30, 39, 40, 5, -38 },
  { 12176, 42, 61, 40, -2, -49 },
  { 12497, 30, 50, 40, 6, -38 },
  { 12685, 31, 49, 40, 4, -49 },
  { 12875, 30, 51, 40, 3, -51 },
  { 13067, 34, 63, 40, 1, -51 },
  { 13335, 33, 49, 40, 5, -49 },
  { 13538, 26, 49, 40, 8, -49 },
  { 13698, 35, 38, 40, 2, -38 },
  { 13865, 31, 38, 40, 4, -38 },
  { 14013, 30, 39, 40, 5, -38 },
  { 14160, 33, 50, 40, 2, -38 },
  { 14367, 31, 50, 40, 5, -38 },
  { 14561, 31, 38, 40, 6, -38 },
  { 14709, 31, 39, 40, 4, -38 },
  { 14861, 30, 47, 40, 7, -47 },
  { 15038, 31, 38, 40, 5, -37 },
  { 15186, 30, 37, 40, 8, -37 },
  { 15325, 34, 37, 40, 6, -37 },
  { 15483, 35, 37, 40, 2, -37 },
  { 15645, 30, 49, 40, 5, -37 },
  { 15829, 31, 37, 40, 4, -37 },
  { 15973, 32, 63, 40, 7, -56 },
  { 16225, 14, 63, 40, 14, -56 },
  { 16336, 32, 63, 40, 3, -56 },
  { 16588, 30, 13, 40, 6, -30 },
};

const GFXfont JetBrainsMono_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_THINITALIC67PT7B_H_
