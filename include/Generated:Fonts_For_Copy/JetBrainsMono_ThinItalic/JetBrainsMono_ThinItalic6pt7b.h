#ifndef _JETBRAINSMONO_THINITALIC6PT7B_H_
#define _JETBRAINSMONO_THINITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x56, 0xEC, 0x2D, 0x3A, 0x80, 0xD6, 0x7F, 0x6A, 0xF0,
  0x80, 0x6A, 0x90, 0x44, 0x95, 0x00, 0x3D, 0x80, 0x5C, 0xC0, 0xC0, 0x80,
  0x12, 0x24, 0x88, 0x7E, 0xF0, 0x65, 0x70, 0xE5, 0x70, 0x64, 0xF0, 0x2F,
  0x90, 0x6C, 0xF0, 0x6E, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0xF6, 0xA0, 0x30,
  0xE4, 0x7C, 0x6E, 0x00, 0xDA, 0xFF, 0xDA, 0xC0, 0x2D, 0xD0, 0x7E, 0xF0,
  0x72, 0x70, 0x76, 0xF0, 0x7E, 0x70, 0x7E, 0x88, 0x72, 0xF0, 0x7E, 0xD0,
  0x69, 0x70, 0x24, 0xF0, 0x7E, 0xAA, 0x52, 0x70, 0x7E, 0xD0, 0x7E, 0xD0,
  0x76, 0xF0, 0x7E, 0x88, 0x76, 0xF2, 0x7E, 0xD0, 0x68, 0xF0, 0xF2, 0x40,
  0x76, 0xF0, 0xBA, 0x40, 0xB7, 0x60, 0x74, 0x4A, 0xF2, 0x40, 0x65, 0x70,
  0xEA, 0xA0, 0xA9, 0x50, 0xD5, 0xA0, 0x70, 0xE0, 0x80, 0xF7, 0x80, 0x56,
  0xF0, 0xF3, 0x80, 0x76, 0xF0, 0xFB, 0x80, 0x76, 0x44, 0xC0, 0xFF, 0x56,
  0xD0, 0x28, 0xAE, 0x28, 0x93, 0x80, 0x57, 0x50, 0xAB, 0xFF, 0x80, 0xF6,
  0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0x72, 0x00, 0xEF, 0x80, 0xEB,
  0xB7, 0x80, 0xE8, 0xBB, 0x00, 0x6A, 0x80, 0xB5, 0xB0, 0x6B, 0x80, 0x69,
  0x48, 0x80, 0xFC, 0x69, 0xA5, 0x00, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 3, 3, 4, 0, -4 },
  { 20, 3, 2, 4, 0, -3 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 4, 6, 4, 0, -5 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 1, 4, 4, 1, -3 },
  { 48, 2, 3, 4, 1, -3 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 3, 4, 0, -3 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 4, 5, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 3, 5, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 1, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 3, 4, 4, 1, -4 },
  { 100, 3, 4, 4, 1, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 3, 4, 4, 1, -4 },
  { 106, 3, 4, 4, 0, -4 },
  { 108, 2, 6, 4, 1, -5 },
  { 110, 2, 6, 4, 1, -5 },
  { 112, 2, 6, 4, 1, -5 },
  { 114, 2, 2, 4, 1, -4 },
  { 115, 3, 1, 4, 0, 0 },
  { 116, 1, 1, 4, 2, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 4, 5, 4, 0, -4 },
  { 130, 2, 4, 4, 1, -3 },
  { 131, 3, 4, 4, 0, -4 },
  { 133, 3, 5, 4, 0, -5 },
  { 135, 3, 6, 4, 0, -5 },
  { 138, 3, 4, 4, 0, -4 },
  { 140, 2, 4, 4, 1, -4 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -3 },
  { 149, 3, 4, 4, 0, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 3, 4, 0, -3 },
  { 155, 2, 4, 4, 1, -4 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 2, 3, 4, 1, -3 },
  { 159, 3, 3, 4, 1, -3 },
  { 161, 3, 3, 4, 0, -3 },
  { 163, 3, 4, 4, 0, -3 },
  { 165, 3, 3, 4, 0, -3 },
  { 167, 3, 6, 4, 1, -5 },
  { 170, 1, 6, 4, 1, -5 },
  { 171, 3, 6, 4, 0, -5 },
  { 174, 3, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_ThinItalic6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_THINITALIC6PT7B_H_
