#ifndef _JETBRAINSMONO_THINITALIC27PT7B_H_
#define _JETBRAINSMONO_THINITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x21, 0x08, 0x42, 0x20, 0x00, 0x06,
  0x39, 0x80, 0x61, 0xB0, 0x98, 0xCC, 0x64, 0x32, 0x19, 0x09, 0x84, 0x01,
  0x86, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x60, 0x20, 0x80, 0xC1, 0x0F, 0xFF,
  0x82, 0x08, 0x0C, 0x30, 0x10, 0x60, 0x20, 0x80, 0xC3, 0x01, 0x04, 0x1F,
  0xFF, 0x0C, 0x30, 0x10, 0x40, 0x60, 0x80, 0x83, 0x01, 0x04, 0x06, 0x18,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x07, 0xC0, 0xDF, 0x0C, 0x8C, 0xC4,
  0x64, 0x23, 0x21, 0x01, 0x08, 0x0C, 0xC0, 0x34, 0x00, 0xF0, 0x01, 0xE0,
  0x09, 0x80, 0x44, 0x02, 0x20, 0x21, 0xA1, 0x09, 0x08, 0x4C, 0x46, 0x32,
  0x60, 0xFC, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x03, 0x80, 0x61,
  0x98, 0x18, 0x21, 0x06, 0x0C, 0x20, 0x81, 0x04, 0x20, 0x20, 0x88, 0x04,
  0x32, 0x00, 0xC4, 0x80, 0x0F, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x4F, 0x00, 0x13, 0x30, 0x04, 0xC2, 0x01, 0x10, 0x40, 0x62, 0x08, 0x18,
  0x43, 0x06, 0x08, 0x40, 0x81, 0x18, 0x60, 0x1E, 0x00, 0x03, 0xE0, 0x19,
  0xC0, 0xC1, 0x02, 0x06, 0x18, 0x18, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0xF8, 0x02, 0x20, 0x50, 0xC2, 0x41, 0x99, 0x02, 0xCC, 0x0E, 0x30,
  0x18, 0xC0, 0xE3, 0x06, 0x8C, 0x31, 0x1F, 0x86, 0x6D, 0xAD, 0xB6, 0x00,
  0x60, 0x38, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x01, 0xE0, 0x0E, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE2, 0x1D, 0xEB, 0xC0, 0xFC, 0x01,
  0x80, 0x0D, 0x00, 0x66, 0x03, 0x18, 0x18, 0x30, 0x40, 0x40, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xC0, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x1C, 0x61, 0x8C, 0x31, 0x84, 0x30,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x73, 0x86, 0x04, 0x60, 0x32, 0x01,
  0x90, 0x0D, 0x80, 0x6C, 0x02, 0x60, 0x12, 0x38, 0x91, 0xCC, 0x80, 0x6C,
  0x03, 0x60, 0x1B, 0x00, 0x98, 0x04, 0xC0, 0x66, 0x02, 0x18, 0x60, 0x7E,
  0x00, 0x01, 0xC0, 0x70, 0x3A, 0x0C, 0x42, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x7F, 0xF0, 0x03, 0xF0, 0x18, 0x60, 0x80, 0xC4, 0x03,
  0x10, 0x04, 0xC0, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x90, 0x0C, 0x80, 0x46, 0x06, 0x18, 0x60, 0x7E,
  0x00, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x83, 0x30, 0x22, 0x02, 0x40, 0x24, 0x02, 0xFF, 0xE0,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x1F, 0xF8, 0xFF, 0xC4, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0xF8, 0x28, 0xE1, 0x81, 0x18,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0xC0, 0x66, 0x02,
  0x18, 0x60, 0x7E, 0x00, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x17, 0x83, 0xCE, 0x60, 0x64, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x02, 0x80, 0x6C, 0x04, 0x61, 0x83, 0xF0, 0x7F, 0xFB,
  0xFF, 0xD0, 0x04, 0x80, 0x64, 0x02, 0x60, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x61, 0x86, 0x06,
  0x60, 0x33, 0x01, 0x90, 0x0C, 0xC0, 0x42, 0x04, 0x18, 0xC0, 0x38, 0x03,
  0x60, 0x61, 0x86, 0x06, 0x20, 0x13, 0x00, 0x90, 0x04, 0x80, 0x26, 0x03,
  0x18, 0x30, 0x7E, 0x00, 0x07, 0x81, 0x8E, 0x30, 0x26, 0x03, 0x40, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x24, 0x06, 0x61, 0xC3, 0xE8, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x1C, 0xF3,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xF3, 0xCF, 0x00, 0x07, 0x0F,
  0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x40, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x04, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x08, 0x00, 0x3E,
  0x07, 0xF0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x70, 0x78, 0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x30, 0x00, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x30, 0xC0, 0x23, 0x00,
  0x64, 0x00, 0xC8, 0x01, 0x90, 0x7B, 0x61, 0x8C, 0xC6, 0x09, 0x08, 0x12,
  0x10, 0x24, 0x20, 0xC8, 0xC1, 0xB1, 0x82, 0x63, 0x04, 0x86, 0x19, 0x07,
  0xD2, 0x02, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x14, 0x03, 0x40, 0x24, 0x06,
  0x60, 0x46, 0x04, 0x20, 0xC2, 0x08, 0x21, 0x82, 0x10, 0x23, 0xFE, 0x20,
  0x32, 0x03, 0x60, 0x34, 0x01, 0xC0, 0x18, 0x01, 0x1F, 0x80, 0xFF, 0x84,
  0x04, 0x60, 0x33, 0x01, 0x90, 0x0C, 0x80, 0x44, 0x06, 0x20, 0x63, 0xFE,
  0x18, 0x70, 0x80, 0xC4, 0x03, 0x20, 0x19, 0x00, 0xD8, 0x04, 0xC0, 0x26,
  0x02, 0x20, 0x61, 0xFE, 0x00, 0x03, 0xE0, 0x61, 0x86, 0x06, 0x20, 0x33,
  0x00, 0x90, 0x0C, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x04, 0xC0, 0x62, 0x02, 0x18, 0x20,
  0x7E, 0x00, 0x1F, 0x80, 0xFF, 0x04, 0x0C, 0x60, 0x23, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x02, 0x20, 0x13, 0x01, 0x98, 0x0C, 0x80, 0x64, 0x02, 0x20,
  0x11, 0x00, 0x98, 0x0C, 0xC0, 0x46, 0x06, 0x20, 0xE1, 0xFC, 0x00, 0x1F,
  0xFC, 0x7F, 0xF1, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xFF, 0x82, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF1, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xFF, 0xC7, 0xFF, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x61,
  0x86, 0x06, 0x20, 0x33, 0x00, 0x90, 0x0C, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0xFC, 0x87, 0xE4, 0x03, 0x20, 0x19, 0x00, 0x98, 0x04, 0xC0,
  0x62, 0x02, 0x18, 0x20, 0x7E, 0x00, 0x10, 0x08, 0x80, 0x44, 0x06, 0x60,
  0x33, 0x01, 0x90, 0x08, 0x80, 0x44, 0x02, 0x20, 0x13, 0xFF, 0x98, 0x0C,
  0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x02, 0x20,
  0x11, 0x00, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x01, 0xFF, 0x80,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x30, 0x08, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x0F, 0xC0, 0x10,
  0x04, 0x40, 0x21, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x81, 0x82, 0x04, 0x08,
  0x30, 0x21, 0x81, 0xFC, 0x06, 0x10, 0x10, 0x60, 0x41, 0x81, 0x02, 0x04,
  0x0C, 0x30, 0x30, 0xC0, 0x43, 0x01, 0x88, 0x06, 0x20, 0x08, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x7F, 0xF0, 0x18, 0x0E, 0x28, 0x18, 0x50, 0x70, 0xA0, 0xA1, 0x43, 0x42,
  0x85, 0x8C, 0x93, 0x19, 0x26, 0x22, 0x88, 0x45, 0x10, 0x8C, 0x21, 0x00,
  0x46, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0xC6, 0x01, 0x80, 0x18, 0x08, 0xC0, 0x46, 0x02, 0x70, 0x33, 0x41,
  0x92, 0x08, 0x90, 0x44, 0x82, 0x26, 0x13, 0x11, 0x98, 0x8C, 0x84, 0x44,
  0x32, 0x20, 0x91, 0x04, 0x98, 0x2C, 0xC1, 0xE4, 0x06, 0x20, 0x31, 0x01,
  0x80, 0x03, 0xC0, 0x63, 0x86, 0x04, 0x20, 0x33, 0x01, 0x90, 0x08, 0x80,
  0x44, 0x02, 0x60, 0x13, 0x01, 0x98, 0x0C, 0x80, 0x64, 0x02, 0x20, 0x11,
  0x00, 0x98, 0x0C, 0xC0, 0x62, 0x02, 0x18, 0x60, 0x7E, 0x00, 0x1F, 0xC0,
  0x7F, 0xC1, 0x01, 0x8C, 0x02, 0x30, 0x0C, 0x80, 0x32, 0x00, 0x88, 0x02,
  0x20, 0x11, 0x80, 0xC7, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x63,
  0x86, 0x04, 0x20, 0x33, 0x01, 0x90, 0x08, 0x80, 0x44, 0x02, 0x60, 0x13,
  0x01, 0x98, 0x0C, 0x80, 0x64, 0x02, 0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0,
  0x62, 0x02, 0x18, 0x60, 0x7E, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0x01, 0x8C, 0x02, 0x30, 0x08, 0x80,
  0x22, 0x00, 0x88, 0x06, 0x20, 0x31, 0x81, 0x87, 0xFC, 0x10, 0x40, 0x41,
  0x01, 0x06, 0x04, 0x08, 0x30, 0x20, 0xC0, 0xC3, 0x01, 0x08, 0x04, 0x20,
  0x18, 0x03, 0xE0, 0x61, 0x86, 0x06, 0x60, 0x33, 0x01, 0x90, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xD0, 0x04, 0x80, 0x26, 0x03, 0x18, 0x30, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x08, 0x80,
  0x4C, 0x02, 0x60, 0x33, 0x01, 0x90, 0x08, 0x80, 0x44, 0x02, 0x20, 0x13,
  0x01, 0x98, 0x0C, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0,
  0x42, 0x06, 0x18, 0x60, 0x7E, 0x00, 0x80, 0x18, 0x03, 0x80, 0x28, 0x02,
  0xC0, 0x6C, 0x04, 0xC0, 0xC4, 0x08, 0x41, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x62, 0x06, 0x60, 0x64, 0x02, 0xC0, 0x28, 0x02, 0x80, 0x30, 0x03, 0x00,
  0x41, 0x82, 0x83, 0x0D, 0x06, 0x12, 0x14, 0x24, 0x28, 0x48, 0x51, 0x91,
  0x22, 0x22, 0x44, 0x44, 0x98, 0x91, 0x21, 0x22, 0x42, 0x44, 0x84, 0x8B,
  0x0A, 0x14, 0x14, 0x28, 0x68, 0x50, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x06,
  0x06, 0x00, 0x08, 0x01, 0x0C, 0x02, 0x04, 0x06, 0x04, 0x0C, 0x02, 0x08,
  0x02, 0x10, 0x03, 0x30, 0x01, 0x20, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x10, 0x10,
  0x30, 0x18, 0x60, 0x08, 0xC0, 0x0C, 0xC0, 0x0D, 0x00, 0x24, 0x01, 0x18,
  0x0C, 0x20, 0x20, 0x81, 0x03, 0x0C, 0x04, 0x20, 0x11, 0x00, 0x6C, 0x00,
  0xA0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x3F, 0xFC, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x08, 0xFC, 0x00,
  0xC1, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x02,
  0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0x40, 0x81, 0x03, 0x06, 0x1F, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0xFC, 0x00, 0x03, 0x00, 0x60, 0x1C, 0x06, 0xC0,
  0x88, 0x31, 0x04, 0x31, 0x86, 0x60, 0x48, 0x0B, 0x01, 0x80, 0xFF, 0xF8,
  0xC9, 0x90, 0x0F, 0x91, 0x85, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x06, 0x40, 0xC6, 0x1C, 0x3E,
  0x40, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x7C, 0x28, 0x63,
  0x03, 0x20, 0x36, 0x03, 0x60, 0x34, 0x03, 0x40, 0x24, 0x02, 0x40, 0x2C,
  0x06, 0xC0, 0x6C, 0x04, 0xA1, 0x89, 0xF0, 0x07, 0xC1, 0x86, 0x30, 0x32,
  0x01, 0x60, 0x16, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x2C,
  0x06, 0x40, 0x46, 0x18, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x87, 0xC8, 0x61, 0x46, 0x06, 0x20, 0x33, 0x01, 0x98, 0x0C,
  0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0, 0x62, 0x06, 0x18,
  0x70, 0x7C, 0x80, 0x07, 0xC1, 0x86, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03,
  0x40, 0x37, 0xFE, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x06, 0x40, 0x46, 0x18,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x91, 0x85, 0x30,
  0x32, 0x03, 0x60, 0x36, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x64, 0x0E, 0x71, 0x41, 0xE4, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x03,
  0x87, 0xE0, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x7C, 0x28,
  0x63, 0x03, 0x20, 0x36, 0x03, 0x60, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x2C, 0x06, 0xC0, 0x6C, 0x06, 0x80, 0x48, 0x04, 0x00, 0x40, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0xFF, 0xF0, 0x00, 0x10, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x0E, 0x07, 0xC0, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x0C, 0x80, 0x44, 0x04,
  0x20, 0x61, 0x06, 0x18, 0x60, 0xC6, 0x07, 0xE0, 0x21, 0x81, 0x04, 0x08,
  0x30, 0xC0, 0x86, 0x06, 0x20, 0x11, 0x00, 0xC0, 0xFC, 0x1F, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x60, 0x07, 0xF0,
  0x2F, 0x38, 0xC5, 0x32, 0x18, 0xC8, 0x43, 0x21, 0x0D, 0x84, 0x26, 0x10,
  0x90, 0xC2, 0x43, 0x09, 0x08, 0x64, 0x21, 0xB0, 0x84, 0xC2, 0x13, 0x18,
  0x48, 0x61, 0x00, 0x27, 0xC2, 0x86, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x68, 0x04,
  0x80, 0x40, 0x07, 0xC1, 0x86, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x40,
  0x34, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x06, 0x40, 0x46, 0x18, 0x3F,
  0x00, 0x13, 0xE0, 0xA1, 0x86, 0x06, 0x20, 0x33, 0x01, 0x98, 0x0C, 0x80,
  0x64, 0x02, 0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x02, 0x28, 0x61,
  0x3E, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x00, 0x0F, 0x91,
  0x85, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0xC0, 0x6C, 0x06, 0x40, 0xC6, 0x1C, 0x3E, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x17, 0xE1, 0xE1, 0x8C, 0x04, 0x60, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0xE1, 0x83, 0x20, 0x12, 0x01, 0x60,
  0x02, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x02, 0x00, 0x28, 0x02, 0xC0,
  0x6C, 0x0C, 0x7F, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0xFF, 0xF0,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x01, 0x80, 0x1F, 0x80, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x60, 0x36, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0xC0, 0x6C, 0x04, 0x40, 0xC6, 0x18, 0x3F, 0x00, 0xC0, 0x1C, 0x03, 0x40,
  0x24, 0x06, 0x40, 0x46, 0x0C, 0x60, 0x82, 0x18, 0x21, 0x02, 0x30, 0x22,
  0x03, 0x60, 0x14, 0x01, 0xC0, 0x18, 0x00, 0x86, 0x0C, 0x30, 0xE1, 0x85,
  0x14, 0x28, 0xA3, 0x45, 0x12, 0x48, 0x92, 0x4C, 0x92, 0x45, 0x12, 0x28,
  0xB1, 0x45, 0x0C, 0x28, 0x61, 0xC3, 0x0C, 0x00, 0x10, 0x0C, 0x60, 0x60,
  0x83, 0x03, 0x08, 0x04, 0x40, 0x1B, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x12, 0x00, 0x8C, 0x04, 0x10, 0x30, 0x61, 0x80, 0x8C, 0x03, 0x00, 0x20,
  0x12, 0x01, 0x20, 0x36, 0x03, 0x60, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x2C, 0x06, 0xC0, 0x64, 0x0C, 0x71, 0x43, 0xE4, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x03, 0x07, 0xE0, 0x3F, 0xF0, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x08, 0x0F,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x07, 0x80, 0x08, 0xC6, 0x31,
  0x08, 0x42, 0x31, 0x88, 0x42, 0x11, 0x8C, 0x42, 0x10, 0x8C, 0x63, 0x10,
  0x80, 0x0F, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x81, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x03, 0x00, 0xF0, 0x00, 0x3C, 0x1B, 0x30, 0x90, 0x85, 0x86,
  0x6C, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 20, 16, 6, -20 },
  { 14, 9, 8, 16, 5, -20 },
  { 23, 15, 20, 16, 1, -20 },
  { 61, 13, 27, 16, 2, -23 },
  { 105, 19, 20, 16, -1, -20 },
  { 153, 14, 20, 16, 1, -20 },
  { 188, 3, 8, 16, 8, -20 },
  { 191, 11, 26, 16, 5, -23 },
  { 227, 11, 26, 16, 1, -23 },
  { 263, 14, 13, 16, 2, -16 },
  { 286, 13, 12, 16, 2, -15 },
  { 306, 6, 8, 16, 3, -4 },
  { 312, 9, 2, 16, 4, -10 },
  { 315, 4, 4, 16, 5, -4 },
  { 317, 15, 25, 16, 1, -22 },
  { 364, 13, 20, 16, 2, -20 },
  { 397, 11, 20, 16, 2, -20 },
  { 425, 14, 20, 16, 1, -20 },
  { 460, 13, 20, 16, 2, -20 },
  { 493, 12, 20, 16, 2, -20 },
  { 523, 13, 20, 16, 2, -20 },
  { 556, 12, 20, 16, 2, -20 },
  { 586, 13, 20, 16, 3, -20 },
  { 619, 13, 20, 16, 2, -20 },
  { 652, 12, 20, 16, 3, -20 },
  { 682, 6, 15, 16, 5, -15 },
  { 694, 8, 19, 16, 3, -15 },
  { 713, 12, 14, 16, 3, -16 },
  { 734, 12, 8, 16, 2, -13 },
  { 746, 12, 14, 16, 2, -16 },
  { 767, 11, 20, 16, 4, -20 },
  { 795, 15, 25, 16, 1, -20 },
  { 842, 12, 20, 16, 1, -20 },
  { 872, 13, 20, 16, 2, -20 },
  { 905, 13, 20, 16, 2, -20 },
  { 938, 13, 20, 16, 2, -20 },
  { 971, 14, 20, 16, 2, -20 },
  { 1006, 14, 20, 16, 2, -20 },
  { 1041, 13, 20, 16, 2, -20 },
  { 1074, 13, 20, 16, 2, -20 },
  { 1107, 13, 20, 16, 2, -20 },
  { 1140, 14, 20, 16, 1, -20 },
  { 1175, 14, 20, 16, 2, -20 },
  { 1210, 11, 20, 16, 2, -20 },
  { 1238, 15, 20, 16, 1, -20 },
  { 1276, 13, 20, 16, 2, -20 },
  { 1309, 13, 20, 16, 2, -20 },
  { 1342, 14, 20, 16, 2, -20 },
  { 1377, 13, 25, 16, 2, -20 },
  { 1418, 14, 20, 16, 2, -20 },
  { 1453, 13, 20, 16, 2, -20 },
  { 1486, 14, 20, 16, 3, -20 },
  { 1521, 13, 20, 16, 2, -20 },
  { 1554, 12, 20, 16, 4, -20 },
  { 1584, 15, 20, 16, 2, -20 },
  { 1622, 16, 20, 16, 0, -20 },
  { 1662, 14, 20, 16, 3, -20 },
  { 1697, 14, 20, 16, 1, -20 },
  { 1732, 10, 25, 16, 4, -22 },
  { 1764, 7, 25, 16, 5, -22 },
  { 1786, 10, 25, 16, 3, -22 },
  { 1818, 11, 11, 16, 3, -20 },
  { 1834, 13, 1, 16, 0, 1 },
  { 1836, 3, 4, 16, 8, -21 },
  { 1838, 12, 15, 16, 2, -15 },
  { 1861, 12, 20, 16, 2, -20 },
  { 1891, 12, 15, 16, 2, -15 },
  { 1914, 13, 20, 16, 2, -20 },
  { 1947, 12, 15, 16, 2, -15 },
  { 1970, 17, 25, 16, -1, -20 },
  { 2024, 12, 20, 16, 2, -15 },
  { 2054, 12, 20, 16, 2, -20 },
  { 2084, 12, 21, 16, 1, -21 },
  { 2116, 13, 26, 16, 1, -21 },
  { 2159, 13, 20, 16, 2, -20 },
  { 2192, 11, 20, 16, 3, -20 },
  { 2220, 14, 15, 16, 1, -15 },
  { 2247, 12, 15, 16, 2, -15 },
  { 2270, 12, 15, 16, 2, -15 },
  { 2293, 13, 20, 16, 1, -15 },
  { 2326, 12, 20, 16, 2, -15 },
  { 2356, 13, 15, 16, 2, -15 },
  { 2381, 12, 15, 16, 2, -15 },
  { 2404, 12, 19, 16, 3, -19 },
  { 2433, 12, 15, 16, 2, -15 },
  { 2456, 12, 15, 16, 3, -15 },
  { 2479, 13, 15, 16, 3, -15 },
  { 2504, 14, 15, 16, 1, -15 },
  { 2531, 12, 20, 16, 2, -15 },
  { 2561, 12, 15, 16, 2, -15 },
  { 2584, 13, 25, 16, 3, -22 },
  { 2625, 5, 25, 16, 6, -22 },
  { 2641, 13, 25, 16, 1, -22 },
  { 2682, 13, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_THINITALIC27PT7B_H_
