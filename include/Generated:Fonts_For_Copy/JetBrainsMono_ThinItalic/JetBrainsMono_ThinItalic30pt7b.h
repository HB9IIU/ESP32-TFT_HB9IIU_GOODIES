#ifndef _JETBRAINSMONO_THINITALIC30PT7B_H_
#define _JETBRAINSMONO_THINITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC2,
  0x08, 0x00, 0x00, 0x1C, 0xF3, 0x80, 0x61, 0xB0, 0xD8, 0x6C, 0x34, 0x16,
  0x1B, 0x0D, 0x86, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x41, 0x80, 0x60, 0xC0,
  0x20, 0x40, 0x30, 0x60, 0x18, 0x30, 0xFF, 0xFE, 0x7F, 0xFF, 0x06, 0x0C,
  0x02, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0x81, 0x00, 0xC1, 0x83, 0xFF,
  0xF9, 0xFF, 0xFC, 0x30, 0x60, 0x10, 0x20, 0x08, 0x30, 0x0C, 0x18, 0x04,
  0x08, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x3F, 0x01, 0xDB, 0x82, 0x33, 0x0C, 0x42, 0x10, 0x86, 0x61, 0x08, 0xC2,
  0x00, 0x84, 0x01, 0x98, 0x01, 0xA0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0x30,
  0x02, 0x30, 0x0C, 0x60, 0x10, 0x4C, 0x21, 0x98, 0x43, 0x30, 0x84, 0x61,
  0x18, 0x76, 0xE0, 0x7F, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x03, 0xC0, 0x18, 0x23, 0x01, 0x02, 0x08, 0x18, 0x10, 0x41, 0x81,
  0x82, 0x18, 0x0C, 0x11, 0x80, 0x61, 0x88, 0x03, 0x08, 0x80, 0x18, 0xC8,
  0x00, 0x7C, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x4C, 0xC0, 0x04, 0x43, 0x00, 0x44, 0x18, 0x04, 0x20, 0xC0, 0x61, 0x04,
  0x06, 0x08, 0x20, 0x60, 0x41, 0x02, 0x03, 0x10, 0x60, 0x0F, 0x00, 0x01,
  0xF0, 0x03, 0x18, 0x06, 0x0C, 0x0C, 0x04, 0x0C, 0x04, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x31, 0x03, 0x61,
  0x86, 0x40, 0xC4, 0x40, 0xCC, 0x40, 0x78, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x70, 0xC0, 0xD8, 0x61, 0x8C, 0x3E, 0x06, 0x6D, 0xBD, 0xB6, 0xC0, 0x00,
  0x30, 0x0E, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0xC0, 0x10, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x08, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x08, 0x18, 0x3E, 0x23, 0xCF, 0x5F,
  0x07, 0xE0, 0x03, 0x00, 0x09, 0x00, 0x33, 0x00, 0xC6, 0x03, 0x06, 0x0C,
  0x0E, 0x08, 0x08, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x1C, 0x71, 0x8C, 0x31, 0x86, 0x10, 0xC2,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x1E, 0x70, 0x70, 0x30,
  0xC0, 0x23, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x0C, 0xC2,
  0x19, 0x8E, 0x33, 0x1C, 0x66, 0x00, 0x88, 0x01, 0x10, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x23, 0x00, 0xC3, 0x03, 0x07, 0x0E, 0x07, 0xF0, 0x00,
  0x00, 0xE0, 0x0F, 0x01, 0xD8, 0x18, 0x81, 0x04, 0x10, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFC,
  0x03, 0xF0, 0x1C, 0x38, 0x60, 0x30, 0x80, 0x33, 0x00, 0x64, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x20, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x80, 0x07,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0xC0, 0x11, 0x80, 0x63, 0x00, 0xC2, 0x03, 0x06, 0x0C, 0x07, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x20, 0x80, 0x86, 0x06, 0x30, 0x19, 0x80,
  0x64, 0x01, 0x10, 0x04, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x0F, 0xFE, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x37, 0xF0, 0x78, 0x60, 0xC0, 0x61,
  0x80, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x19, 0x80,
  0x23, 0x00, 0xC3, 0x03, 0x07, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x7F, 0x83, 0x87, 0x0C, 0x06, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xB0,
  0x02, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x18, 0x08, 0x70, 0xE0, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x30, 0xC0, 0x21, 0x00,
  0x62, 0x00, 0x84, 0x03, 0x08, 0x04, 0x18, 0x10, 0x1C, 0xC0, 0x0E, 0x00,
  0x76, 0x01, 0x86, 0x06, 0x06, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80,
  0x33, 0x00, 0x46, 0x01, 0x87, 0x0E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x70,
  0xC3, 0x01, 0x88, 0x02, 0x60, 0x0D, 0x00, 0x34, 0x00, 0xD0, 0x02, 0x40,
  0x09, 0x00, 0x66, 0x03, 0x0C, 0x1C, 0x1F, 0xE0, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x18, 0xF3, 0xCF, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C,
  0xF0, 0x07, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x80, 0x00,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x03, 0x81,
  0xE0, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xF0, 0x0E, 0x00, 0x01, 0xFC, 0x03, 0x87, 0x03, 0x00, 0xC1, 0x00,
  0x21, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x22, 0x20, 0xFD, 0x10,
  0xC1, 0x98, 0x60, 0xCC, 0x20, 0x66, 0x10, 0x32, 0x18, 0x11, 0x0C, 0x08,
  0x86, 0x04, 0xC2, 0x06, 0x61, 0x83, 0x30, 0xC3, 0x98, 0x3E, 0x8C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x01, 0xB0, 0x04,
  0xC0, 0x33, 0x00, 0x84, 0x02, 0x10, 0x18, 0x40, 0x41, 0x03, 0x04, 0x08,
  0x18, 0x60, 0x61, 0xFF, 0x87, 0xFE, 0x30, 0x08, 0x80, 0x26, 0x00, 0x90,
  0x02, 0xC0, 0x0B, 0x00, 0x30, 0x1F, 0xF0, 0x30, 0xF0, 0x60, 0x30, 0x80,
  0x21, 0x00, 0x42, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x30, 0x18, 0x40, 0x60,
  0xFF, 0x81, 0x07, 0x86, 0x01, 0x8C, 0x03, 0x18, 0x02, 0x30, 0x04, 0x40,
  0x18, 0x80, 0x31, 0x00, 0x46, 0x01, 0x8C, 0x1E, 0x1F, 0xF0, 0x00, 0x03,
  0xF0, 0x0C, 0x38, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00, 0xCC, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x18, 0x80, 0x31, 0x00, 0x43, 0x01,
  0x83, 0x0E, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x63, 0xC1, 0x81, 0x84, 0x03,
  0x10, 0x0C, 0x40, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00,
  0x88, 0x02, 0x60, 0x09, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x11, 0x00,
  0xC4, 0x02, 0x30, 0x18, 0xC3, 0xC3, 0xFC, 0x00, 0x0F, 0xFE, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x0C, 0x38, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x0F, 0xE6, 0x1F, 0x8C, 0x01,
  0x18, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x31, 0x00, 0x43, 0x01, 0x83,
  0x0E, 0x03, 0xF0, 0x00, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x21,
  0x00, 0x42, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x40, 0x10, 0xFF,
  0xE1, 0x00, 0x46, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x08, 0x40, 0x10,
  0x80, 0x21, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x00, 0x0F, 0xFE,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x40, 0x18, 0x40, 0x18, 0x40, 0x10, 0x60, 0x30, 0x30, 0xE0, 0x1F, 0x80,
  0x18, 0x03, 0x18, 0x06, 0x18, 0x06, 0x10, 0x0C, 0x10, 0x18, 0x10, 0x18,
  0x30, 0x30, 0x30, 0x20, 0x30, 0x60, 0x30, 0xC0, 0x3F, 0x80, 0x20, 0xC0,
  0x60, 0xC0, 0x60, 0x40, 0x60, 0x40, 0x60, 0x60, 0x40, 0x60, 0x40, 0x20,
  0x40, 0x30, 0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x7F, 0xFC, 0x0C, 0x03, 0x0C, 0x07,
  0x0E, 0x05, 0x1A, 0x0F, 0x1A, 0x0B, 0x12, 0x1B, 0x12, 0x12, 0x13, 0x32,
  0x11, 0x22, 0x31, 0x46, 0x31, 0x46, 0x31, 0x86, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0xC0, 0x18, 0x1C, 0x06, 0x38, 0x0C, 0x50, 0x10, 0xA0, 0x21,
  0x60, 0x42, 0xC0, 0x8C, 0x83, 0x19, 0x06, 0x32, 0x0C, 0x46, 0x10, 0x84,
  0x21, 0x08, 0x46, 0x11, 0x8C, 0x33, 0x18, 0x26, 0x20, 0x48, 0x40, 0x90,
  0x81, 0xA1, 0x01, 0x46, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x00, 0x03, 0xF0,
  0x18, 0x60, 0x80, 0xC6, 0x01, 0x10, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03,
  0x20, 0x0C, 0x80, 0x32, 0x00, 0x98, 0x02, 0x60, 0x09, 0x80, 0x66, 0x01,
  0x90, 0x06, 0x40, 0x11, 0x00, 0x44, 0x03, 0x18, 0x18, 0x70, 0xC0, 0x7E,
  0x00, 0x1F, 0xF0, 0x18, 0x3C, 0x18, 0x06, 0x10, 0x06, 0x10, 0x02, 0x10,
  0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x04, 0x20, 0x0C, 0x20, 0x38, 0x3F,
  0xE0, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x18,
  0x60, 0x80, 0xC6, 0x01, 0x10, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x20,
  0x0C, 0x80, 0x32, 0x00, 0x98, 0x02, 0x60, 0x09, 0x80, 0x66, 0x01, 0x90,
  0x06, 0x40, 0x11, 0x00, 0x44, 0x03, 0x18, 0x18, 0x70, 0xC0, 0x7E, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1F, 0xF0, 0x30,
  0xF8, 0x60, 0x30, 0x80, 0x31, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x0C, 0x40, 0x18, 0x80, 0xE1, 0xFF, 0x06, 0x08, 0x0C, 0x10, 0x18,
  0x30, 0x30, 0x20, 0x40, 0x60, 0x80, 0xC1, 0x00, 0x86, 0x01, 0x8C, 0x03,
  0x18, 0x02, 0x00, 0x03, 0xF0, 0x1C, 0x38, 0x20, 0x30, 0xC0, 0x21, 0x00,
  0x66, 0x00, 0x8C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0xC0, 0x19, 0x80,
  0x33, 0x00, 0x46, 0x01, 0x87, 0x0E, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x21, 0x00, 0x42, 0x00, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x0C, 0x40, 0x10, 0x80, 0x21, 0x00, 0x46, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0xC3,
  0x03, 0x03, 0x0C, 0x03, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x90,
  0x06, 0x40, 0x11, 0x00, 0xC4, 0x02, 0x18, 0x18, 0x60, 0x61, 0x81, 0x06,
  0x0C, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x30, 0x08, 0x80, 0x32, 0x00,
  0xD8, 0x03, 0x40, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC1, 0x83, 0xC1,
  0x83, 0xC3, 0x82, 0xC2, 0x82, 0xC2, 0x86, 0xC2, 0x84, 0x84, 0x84, 0x84,
  0x8C, 0x84, 0x8C, 0x8C, 0x88, 0x88, 0x88, 0x88, 0x98, 0x98, 0x90, 0x90,
  0x90, 0x90, 0x90, 0x90, 0xB0, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0C, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x10,
  0x08, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x10, 0x80, 0x06, 0x60, 0x00,
  0xB0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x80, 0x01, 0xA0, 0x00, 0xCC,
  0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x18, 0x02, 0x02, 0x01, 0x00, 0xC0,
  0xC0, 0x10, 0x60, 0x04, 0x30, 0x01, 0x80, 0x80, 0x07, 0x80, 0x1B, 0x00,
  0x62, 0x00, 0x86, 0x03, 0x0C, 0x0C, 0x08, 0x10, 0x18, 0x60, 0x10, 0x80,
  0x22, 0x00, 0x6C, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x0F, 0xE1, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x00,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02,
  0x02, 0x03, 0x03, 0x01, 0x0F, 0xE0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x7F, 0x00, 0x01, 0x80, 0x18, 0x03, 0xC0,
  0x6C, 0x04, 0x40, 0xC6, 0x08, 0x61, 0x86, 0x30, 0x22, 0x03, 0x60, 0x3C,
  0x01, 0xFF, 0xFE, 0xC3, 0x08, 0x61, 0x80, 0x03, 0xCC, 0x3F, 0xB1, 0x81,
  0xCC, 0x07, 0x30, 0x08, 0x80, 0x26, 0x00, 0x98, 0x06, 0x60, 0x19, 0x80,
  0x64, 0x01, 0x10, 0x04, 0x40, 0x31, 0x00, 0xC6, 0x07, 0x1C, 0x3C, 0x3F,
  0x20, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x47, 0x03,
  0x7F, 0x0E, 0x06, 0x30, 0x08, 0xC0, 0x22, 0x00, 0x88, 0x02, 0x60, 0x09,
  0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x11, 0x00, 0x44, 0x03, 0x38, 0x08,
  0xF0, 0xC3, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x30,
  0x0C, 0x80, 0x36, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x02, 0x40, 0x11, 0x00, 0xC6, 0x02, 0x1C, 0x38, 0x1F, 0x80, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x79, 0x83, 0xFB, 0x0C,
  0x0E, 0x30, 0x1C, 0x60, 0x10, 0x80, 0x23, 0x00, 0x46, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x20, 0x08, 0x40, 0x10, 0x80, 0x61, 0x00, 0xC3, 0x03, 0x87,
  0x0F, 0x07, 0xE4, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x30,
  0x08, 0x80, 0x26, 0x00, 0x98, 0x02, 0x7F, 0xF9, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0xC6, 0x02, 0x1C, 0x30, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x98, 0xFE, 0xCC, 0x0E, 0xC0, 0x76, 0x01, 0x20,
  0x0B, 0x00, 0x58, 0x06, 0xC0, 0x36, 0x01, 0xA0, 0x09, 0x00, 0x4C, 0x06,
  0x60, 0x71, 0xFD, 0x83, 0x8C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x7F, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x47, 0x03, 0x7F, 0x0E, 0x06, 0x30, 0x18, 0xC0, 0x22, 0x00, 0x88, 0x02,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x40, 0x11, 0x00, 0x44, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x0E, 0x07, 0xF0,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0xC4, 0x03, 0x18, 0x04, 0x30, 0x18, 0x60, 0x60, 0x81, 0x81, 0x06, 0x02,
  0x18, 0x0F, 0xE0, 0x18, 0x60, 0x30, 0x40, 0x40, 0xC0, 0x80, 0x81, 0x01,
  0x86, 0x01, 0x0C, 0x03, 0x18, 0x03, 0x00, 0x7E, 0x08, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xFF, 0x13, 0x1C, 0x3D, 0xBE, 0x30, 0xC2, 0x30, 0xC2,
  0x20, 0x82, 0x20, 0x82, 0x20, 0x86, 0x21, 0x86, 0x61, 0x86, 0x61, 0x86,
  0x61, 0x04, 0x41, 0x04, 0x41, 0x04, 0x43, 0x0C, 0xC3, 0x0C, 0xC3, 0x0C,
  0xC2, 0x08, 0x11, 0xC0, 0xDF, 0xC3, 0x81, 0x8C, 0x06, 0x30, 0x08, 0x80,
  0x22, 0x00, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x10, 0x04, 0x40,
  0x11, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x30, 0x03, 0xC0, 0x3F, 0xC1,
  0x81, 0x8C, 0x02, 0x30, 0x08, 0x80, 0x26, 0x00, 0x98, 0x02, 0x60, 0x19,
  0x80, 0x64, 0x01, 0x90, 0x04, 0x40, 0x11, 0x00, 0xC6, 0x06, 0x1C, 0x30,
  0x1F, 0x80, 0x08, 0xE0, 0x37, 0xF0, 0x70, 0x30, 0xC0, 0x21, 0x80, 0x42,
  0x00, 0x84, 0x01, 0x18, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00,
  0x42, 0x00, 0x84, 0x03, 0x1C, 0x04, 0x3C, 0x30, 0x6F, 0xC0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0xCC, 0x3F, 0xB1,
  0x81, 0xCC, 0x07, 0x30, 0x08, 0x80, 0x26, 0x00, 0x98, 0x06, 0x60, 0x19,
  0x80, 0x64, 0x01, 0x10, 0x04, 0x40, 0x31, 0x00, 0xC6, 0x07, 0x1C, 0x3C,
  0x3F, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x19,
  0xE0, 0x5F, 0xE1, 0x41, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0x80, 0x8C, 0x03,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x1B, 0x00, 0x4C, 0x03, 0x18, 0x18, 0x3F, 0xC0, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x10, 0x04,
  0xC0, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x08, 0x80, 0x22, 0x00, 0x98, 0x06,
  0x60, 0x19, 0x80, 0x64, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0xC6, 0x06,
  0x0C, 0x30, 0x1F, 0x80, 0x80, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0x6C, 0x06,
  0x20, 0x21, 0x03, 0x08, 0x10, 0x61, 0x83, 0x08, 0x18, 0xC0, 0x44, 0x02,
  0x60, 0x12, 0x00, 0xF0, 0x07, 0x00, 0x18, 0x00, 0x81, 0x07, 0x06, 0x0A,
  0x0C, 0x14, 0x38, 0x68, 0x50, 0x90, 0xA1, 0x23, 0x46, 0x44, 0x8C, 0x89,
  0x11, 0x32, 0x62, 0x44, 0xC4, 0x89, 0x0B, 0x16, 0x14, 0x2C, 0x28, 0x70,
  0x60, 0xE0, 0xC1, 0xC0, 0x18, 0x03, 0x18, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x06, 0x10, 0x02, 0x30, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x06, 0xC0, 0x04, 0x40, 0x08, 0x60, 0x18, 0x30, 0x30, 0x30, 0x60, 0x18,
  0xC0, 0x08, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x40,
  0x31, 0x81, 0xC3, 0xFB, 0x03, 0x88, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC1, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x01,
  0xC0, 0x3F, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x04, 0x10, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0x61,
  0x86, 0x10, 0x41, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x86, 0x18, 0x61, 0x04,
  0x30, 0x07, 0x00, 0x17, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x1C, 0x40, 0x3F, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x07, 0xC0, 0x00, 0x3E, 0x05, 0x8C, 0x14, 0x10, 0xD0,
  0x62, 0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 9, 9, 18, 6, -22 },
  { 29, 17, 22, 18, 1, -22 },
  { 76, 15, 30, 18, 2, -26 },
  { 133, 21, 22, 18, -1, -22 },
  { 191, 16, 22, 18, 1, -22 },
  { 235, 3, 9, 18, 9, -22 },
  { 239, 12, 29, 18, 5, -25 },
  { 283, 11, 29, 18, 2, -25 },
  { 323, 15, 15, 18, 2, -18 },
  { 352, 14, 14, 18, 2, -17 },
  { 377, 6, 10, 18, 4, -5 },
  { 385, 10, 2, 18, 4, -11 },
  { 388, 4, 4, 18, 6, -4 },
  { 390, 17, 28, 18, 1, -25 },
  { 450, 15, 22, 18, 2, -22 },
  { 492, 13, 22, 18, 2, -22 },
  { 528, 15, 22, 18, 2, -22 },
  { 570, 15, 22, 18, 2, -22 },
  { 612, 14, 22, 18, 2, -22 },
  { 651, 15, 22, 18, 2, -22 },
  { 693, 14, 22, 18, 2, -22 },
  { 732, 14, 22, 18, 4, -22 },
  { 771, 15, 22, 18, 2, -22 },
  { 813, 14, 22, 18, 3, -22 },
  { 852, 6, 17, 18, 6, -17 },
  { 865, 8, 22, 18, 4, -17 },
  { 887, 14, 15, 18, 3, -17 },
  { 914, 14, 8, 18, 2, -14 },
  { 928, 14, 15, 18, 2, -17 },
  { 955, 12, 22, 18, 5, -22 },
  { 988, 17, 27, 18, 1, -22 },
  { 1046, 14, 22, 18, 1, -22 },
  { 1085, 15, 22, 18, 2, -22 },
  { 1127, 15, 22, 18, 2, -22 },
  { 1169, 14, 22, 18, 2, -22 },
  { 1208, 15, 22, 18, 2, -22 },
  { 1250, 16, 22, 18, 2, -22 },
  { 1294, 15, 22, 18, 2, -22 },
  { 1336, 15, 22, 18, 2, -22 },
  { 1378, 15, 22, 18, 2, -22 },
  { 1420, 16, 22, 18, 1, -22 },
  { 1464, 16, 22, 18, 2, -22 },
  { 1508, 13, 22, 18, 2, -22 },
  { 1544, 16, 22, 18, 1, -22 },
  { 1588, 15, 22, 18, 2, -22 },
  { 1630, 14, 22, 18, 2, -22 },
  { 1669, 16, 22, 18, 2, -22 },
  { 1713, 14, 27, 18, 2, -22 },
  { 1761, 15, 22, 18, 2, -22 },
  { 1803, 15, 22, 18, 2, -22 },
  { 1845, 14, 22, 18, 4, -22 },
  { 1884, 15, 22, 18, 2, -22 },
  { 1926, 14, 22, 18, 4, -22 },
  { 1965, 16, 22, 18, 3, -22 },
  { 2009, 18, 22, 18, 0, -22 },
  { 2059, 15, 22, 18, 4, -22 },
  { 2101, 16, 22, 18, 1, -22 },
  { 2145, 11, 28, 18, 5, -25 },
  { 2184, 8, 28, 18, 5, -25 },
  { 2212, 11, 28, 18, 3, -25 },
  { 2251, 12, 12, 18, 3, -22 },
  { 2269, 15, 1, 18, 0, 1 },
  { 2271, 5, 5, 18, 8, -24 },
  { 2275, 14, 17, 18, 2, -17 },
  { 2305, 14, 22, 18, 2, -22 },
  { 2344, 14, 17, 18, 2, -17 },
  { 2374, 15, 22, 18, 2, -22 },
  { 2416, 14, 17, 18, 2, -17 },
  { 2446, 19, 27, 18, -1, -22 },
  { 2511, 13, 22, 18, 3, -17 },
  { 2547, 14, 22, 18, 2, -22 },
  { 2586, 13, 23, 18, 2, -23 },
  { 2624, 15, 28, 18, 1, -23 },
  { 2677, 15, 22, 18, 2, -22 },
  { 2719, 12, 22, 18, 3, -22 },
  { 2752, 16, 17, 18, 1, -17 },
  { 2786, 14, 17, 18, 2, -17 },
  { 2816, 14, 17, 18, 2, -17 },
  { 2846, 15, 22, 18, 1, -17 },
  { 2888, 14, 22, 18, 2, -17 },
  { 2927, 14, 17, 18, 2, -17 },
  { 2957, 14, 17, 18, 2, -17 },
  { 2987, 13, 21, 18, 3, -21 },
  { 3022, 14, 17, 18, 2, -17 },
  { 3052, 13, 17, 18, 4, -17 },
  { 3080, 15, 17, 18, 3, -17 },
  { 3112, 16, 17, 18, 1, -17 },
  { 3146, 14, 22, 18, 2, -17 },
  { 3185, 14, 17, 18, 2, -17 },
  { 3215, 15, 28, 18, 3, -25 },
  { 3268, 6, 28, 18, 6, -25 },
  { 3289, 15, 28, 18, 1, -25 },
  { 3342, 14, 5, 18, 2, -13 },
};

const GFXfont JetBrainsMono_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_THINITALIC30PT7B_H_
