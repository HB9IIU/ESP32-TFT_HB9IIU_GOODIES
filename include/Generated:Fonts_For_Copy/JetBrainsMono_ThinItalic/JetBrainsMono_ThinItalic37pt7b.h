#ifndef _JETBRAINSMONO_THINITALIC37PT7B_H_
#define _JETBRAINSMONO_THINITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x04, 0x08, 0x30, 0x60, 0x80, 0x00, 0x00, 0x00, 0x30, 0xF1, 0xE3,
  0x80, 0x30, 0x73, 0x06, 0x70, 0x67, 0x06, 0x70, 0x66, 0x0E, 0x60, 0xE6,
  0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x01, 0x81, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x18, 0x1F, 0xFF, 0xF8, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x20, 0x3F, 0xFF, 0xF0, 0x30, 0x18, 0x01, 0x81,
  0x80, 0x08, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x20, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x00, 0xF5, 0xE0, 0x38, 0x8E,
  0x0E, 0x10, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x0C, 0x18, 0x61, 0x82, 0x00,
  0x38, 0x40, 0x03, 0x08, 0x00, 0x71, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x2F, 0x00, 0x04, 0x70, 0x00, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0xC1, 0x88, 0x10, 0x23, 0x02, 0x0C, 0x30, 0x41, 0x86,
  0x18, 0x60, 0xE3, 0x1C, 0x0F, 0x7F, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01,
  0x81, 0x9C, 0x01, 0x81, 0x82, 0x01, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC1,
  0x80, 0x60, 0x40, 0x80, 0x30, 0x20, 0xC0, 0x10, 0x30, 0xC0, 0x08, 0x18,
  0xC0, 0x06, 0x08, 0xC0, 0x03, 0x9C, 0xC0, 0x00, 0xF8, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x63, 0xE0, 0x00,
  0x63, 0x38, 0x00, 0x63, 0x04, 0x00, 0x63, 0x03, 0x00, 0x21, 0x81, 0x80,
  0x30, 0xC0, 0x80, 0x30, 0x60, 0x40, 0x30, 0x20, 0x60, 0x30, 0x10, 0x30,
  0x30, 0x0C, 0x10, 0x30, 0x07, 0x38, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x1E, 0x78, 0x03, 0x81, 0x80, 0x30, 0x1C, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0x8C, 0x01, 0x30, 0x60, 0x63,
  0x06, 0x04, 0x60, 0x30, 0xC6, 0x03, 0x98, 0x60, 0x1B, 0x06, 0x00, 0xF0,
  0x60, 0x0E, 0x06, 0x00, 0xE0, 0x40, 0x0E, 0x06, 0x01, 0xB0, 0x60, 0x71,
  0x87, 0x9E, 0x18, 0x3F, 0x80, 0xC0, 0x77, 0x76, 0x66, 0x6E, 0xCC, 0xC0,
  0x00, 0x0C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x20, 0x07, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x18, 0x0F, 0xC3,
  0x0F, 0x3E, 0x4F, 0xC1, 0xFB, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x13,
  0x00, 0x06, 0x60, 0x01, 0x8E, 0x00, 0x60, 0xC0, 0x18, 0x0C, 0x07, 0x01,
  0xC0, 0xC0, 0x10, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x07, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0x7B, 0xFF,
  0xFE, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xF7, 0xC0, 0xE0, 0x38, 0x70, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0x61, 0xC3, 0x18, 0x78, 0xC6, 0x1C, 0x31, 0x80, 0x0C, 0xE0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x80, 0x70, 0x60, 0x38, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xC8, 0x03, 0x98, 0x06, 0x18, 0x0C, 0x18, 0x10,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x78, 0xF0, 0x18, 0x07,
  0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x30, 0x70, 0x1C, 0x0F, 0x1E, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x03, 0x0C,
  0x03, 0x1C, 0x02, 0x18, 0x06, 0x30, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x06, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x0F, 0xFF, 0x87, 0xFF, 0xC2, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x78, 0x0C, 0xFF, 0x06, 0x81, 0xC3, 0x80, 0x61, 0x80, 0x38, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x80, 0x38, 0x60, 0x18, 0x3C, 0x78,
  0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xBF, 0x80, 0xB9, 0xE0, 0xE0, 0x38, 0xE0, 0x0C, 0x60,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x30, 0x0C, 0x1F, 0x3C, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x31, 0x80, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x78, 0xF0, 0x1C, 0x07, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x01, 0x82, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x18,
  0x1C, 0x01, 0xCE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xC7, 0x00, 0x60,
  0x70, 0x18, 0x07, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x70, 0x0C, 0x07, 0x8F,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0x8F, 0x07, 0x01, 0xC6, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0xE0, 0xFB, 0xF0,
  0x3F, 0xB0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x1F, 0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0xFC, 0xF8, 0xF8, 0x01,
  0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x7F,
  0xFF, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x03, 0xF8, 0x07, 0xC0, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0x0F, 0x00, 0xE0, 0x18, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x08,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x10, 0x80, 0x7D, 0x8C, 0x0F,
  0xFC, 0x60, 0xE0, 0xE3, 0x06, 0x03, 0x18, 0x20, 0x18, 0xC3, 0x00, 0xC4,
  0x18, 0x04, 0x60, 0xC0, 0x63, 0x06, 0x03, 0x18, 0x30, 0x18, 0xC1, 0x00,
  0xC6, 0x18, 0x06, 0x20, 0x60, 0x63, 0x03, 0x05, 0x18, 0x1F, 0xF8, 0xC0,
  0x7C, 0xC6, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02,
  0x40, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x20, 0x40, 0x30, 0x20, 0x18, 0x10, 0x18, 0x0C, 0x0C, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0xFF, 0xC3, 0x00, 0x61, 0x80, 0x11, 0x80,
  0x08, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x60,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x0E, 0x0C, 0x03, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x0C, 0x03, 0x81,
  0x80, 0x18, 0x30, 0x03, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC6,
  0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x1C, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xE3, 0xC0, 0xE0, 0x38,
  0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x04, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x18, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xC0,
  0x38, 0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30,
  0x60, 0x38, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xE3, 0xC0, 0xE0, 0x38,
  0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x04, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x0F, 0xF1, 0x83, 0xFC, 0x60, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x33,
  0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x18, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x40,
  0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x60, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x18, 0x1F, 0x3C, 0x01, 0xFE, 0x00, 0x06, 0x00,
  0x30, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x18,
  0x1C, 0x01, 0x81, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x30, 0x30, 0x03,
  0x01, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x02, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x07,
  0x06, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0xE1,
  0x40, 0x14, 0x28, 0x07, 0x8D, 0x00, 0xB1, 0xB0, 0x36, 0x36, 0x04, 0xC6,
  0x41, 0x90, 0xC8, 0x26, 0x19, 0x8C, 0xC2, 0x31, 0x18, 0xC6, 0x63, 0x18,
  0x48, 0x63, 0x0B, 0x08, 0x61, 0x43, 0x0C, 0x38, 0x61, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x30, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x43, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x61, 0xE0, 0x0C, 0x3C, 0x01, 0x07, 0x80, 0x60,
  0xD0, 0x0C, 0x1B, 0x01, 0x82, 0x60, 0x30, 0x4C, 0x06, 0x18, 0x80, 0x83,
  0x18, 0x30, 0x63, 0x06, 0x0C, 0x60, 0xC1, 0x84, 0x18, 0x20, 0x83, 0x0C,
  0x18, 0x61, 0x83, 0x08, 0x30, 0x23, 0x06, 0x04, 0x60, 0xC0, 0xCC, 0x10,
  0x19, 0x86, 0x03, 0x30, 0xC0, 0x24, 0x18, 0x07, 0x83, 0x00, 0xF0, 0x60,
  0x1E, 0x08, 0x01, 0xC3, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x03, 0xC7, 0x83,
  0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03,
  0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0xC0, 0x38, 0x60, 0x18,
  0x1C, 0x78, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0C, 0x00,
  0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18,
  0x03, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xC7, 0x83, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18,
  0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00,
  0xC6, 0x00, 0x62, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x23,
  0x00, 0x30, 0xC0, 0x38, 0x60, 0x18, 0x1E, 0x78, 0x07, 0xF0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x30, 0x07, 0x06, 0x00, 0x70,
  0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x70, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x02, 0x00, 0xC0, 0x60, 0x10,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x78, 0xF0,
  0x1C, 0x07, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0x86, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x07, 0xCF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x08, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x38, 0x0F, 0x3C, 0x01,
  0xFC, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xC8, 0x00, 0x66, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x18,
  0x06, 0x04, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xC0,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x10, 0x00, 0x98,
  0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x70, 0x36, 0x07, 0x03, 0x60, 0x50, 0x36, 0x05, 0x02, 0x60, 0xD0,
  0x66, 0x0B, 0x06, 0x60, 0xB0, 0x66, 0x1B, 0x0C, 0x61, 0xB0, 0xC4, 0x13,
  0x0C, 0x43, 0x30, 0x84, 0x33, 0x18, 0x42, 0x31, 0x84, 0x23, 0x18, 0x46,
  0x31, 0x04, 0x43, 0x30, 0x44, 0x33, 0x04, 0xC3, 0x20, 0xC8, 0x36, 0x0C,
  0x83, 0x60, 0xD8, 0x36, 0x0D, 0x03, 0x40, 0xD0, 0x3C, 0x0D, 0x02, 0xC0,
  0xF0, 0x28, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0x30, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x02, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x43, 0x00, 0x01, 0x98, 0x00,
  0x02, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0xC4, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x60, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x6C, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00,
  0x63, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x81, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE6,
  0x01, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x10, 0xE0, 0x31, 0x80, 0x66,
  0x00, 0xDC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x06,
  0x1C, 0x01, 0xE0, 0x03, 0xFC, 0xC3, 0x83, 0x43, 0x00, 0xE3, 0x00, 0x31,
  0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x02, 0x30, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x18, 0xC0,
  0x0C, 0x70, 0x0E, 0x18, 0x0F, 0x0F, 0x1D, 0x81, 0xFC, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0xE0, 0x13, 0xFC, 0x1B, 0x07, 0x0E, 0x01, 0x87, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xE0,
  0x0C, 0x70, 0x0C, 0x3E, 0x3C, 0x31, 0xF8, 0x00, 0x00, 0xE0, 0x03, 0xFE,
  0x03, 0x83, 0x83, 0x00, 0xE3, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x70, 0x06, 0x18, 0x06,
  0x07, 0x9E, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x1E, 0x18, 0x1F, 0xE6, 0x0E,
  0x0D, 0x06, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0x60,
  0x3C, 0x1E, 0x3B, 0x01, 0xFC, 0xC0, 0x00, 0xF0, 0x07, 0xFC, 0x0E, 0x0E,
  0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x7F, 0xFE, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0xE0, 0x0C, 0x60, 0x18, 0x38, 0x70, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0xC3, 0x83, 0x43, 0x00, 0xE3, 0x00,
  0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x02, 0x30, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x31, 0x00, 0x38, 0xC0, 0x18,
  0x60, 0x1C, 0x1C, 0x36, 0x07, 0xF3, 0x00, 0x41, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x1F, 0xF8, 0x0F,
  0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0xC0, 0x13, 0xFC, 0x1B, 0x07, 0x0E, 0x01, 0x87,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x02,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xE0,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x07, 0x30, 0x03, 0x8C,
  0x01, 0xC3, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x02, 0x06,
  0x01, 0x83, 0x00, 0x7F, 0xC0, 0x18, 0x30, 0x06, 0x06, 0x01, 0x81, 0x80,
  0x40, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x0C, 0x30,
  0x03, 0x08, 0x00, 0x60, 0xFF, 0x81, 0xFF, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x01, 0xC1, 0x81, 0xBE, 0x7E,
  0x1C, 0x38, 0x61, 0x83, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x10, 0x30,
  0x63, 0x03, 0x06, 0x30, 0x20, 0x63, 0x06, 0x04, 0x30, 0x60, 0xC3, 0x06,
  0x0C, 0x20, 0x60, 0xC6, 0x06, 0x0C, 0x60, 0x40, 0xC6, 0x0C, 0x0C, 0x60,
  0xC0, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x84, 0x0C, 0x18, 0xC0, 0x81, 0x80,
  0x04, 0x30, 0x04, 0xFF, 0x06, 0xC1, 0xC3, 0x80, 0x61, 0xC0, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x04, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x60, 0x00, 0xF0, 0x07,
  0xFC, 0x0E, 0x0E, 0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xE0, 0x1C, 0x60, 0x18, 0x38,
  0xF0, 0x1F, 0xC0, 0x02, 0x1C, 0x01, 0x3F, 0xC0, 0xD8, 0x38, 0x38, 0x06,
  0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x04, 0x30, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x60, 0xF8, 0xF0,
  0x23, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0xC3, 0x83,
  0x43, 0x00, 0xE3, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x02, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x70, 0x0E, 0x18, 0x0F, 0x0F, 0x1D,
  0x81, 0xFC, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x78, 0x0C, 0xFF, 0x07, 0x81,
  0xC3, 0x80, 0x61, 0x80, 0x38, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x03, 0x98, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x83, 0x80, 0xE1, 0x80, 0x31,
  0x80, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x40, 0x03, 0x30, 0x01, 0x98, 0x01, 0x87, 0x03, 0x81, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x02, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31,
  0x80, 0x18, 0x60, 0x18, 0x30, 0x1C, 0x0F, 0x3C, 0x03, 0xF8, 0x00, 0xC0,
  0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x60,
  0x80, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x08, 0x02, 0x0C,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x33, 0x00, 0x09, 0x00, 0x05,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x78, 0x1C, 0x0B, 0x03,
  0x83, 0x60, 0xF0, 0x6C, 0x16, 0x08, 0x82, 0x43, 0x10, 0xC8, 0x62, 0x11,
  0x08, 0x42, 0x23, 0x08, 0xC4, 0x61, 0x10, 0x88, 0x22, 0x13, 0x04, 0xC2,
  0x60, 0x90, 0x48, 0x16, 0x0B, 0x02, 0xC1, 0x60, 0x50, 0x28, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x60, 0x0C, 0x06,
  0x01, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x0D, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x31, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0x60, 0x70, 0x03, 0x0E, 0x00, 0x38, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C,
  0xE0, 0x1C, 0x60, 0x1C, 0x70, 0x6C, 0x3F, 0xCC, 0x06, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xC0,
  0xFE, 0x00, 0x0F, 0xFF, 0xC4, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xB1, 0xC0,
  0xD8, 0x60, 0x68, 0x18, 0x2C, 0x06, 0x36, 0x01, 0xF0,
};

const GFXglyph JetBrainsMono_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 27, 22, 8, -27 },
  { 25, 12, 11, 22, 7, -27 },
  { 42, 21, 27, 22, 1, -27 },
  { 113, 19, 37, 22, 2, -32 },
  { 201, 25, 27, 22, -1, -27 },
  { 286, 20, 27, 22, 1, -27 },
  { 354, 4, 11, 22, 11, -27 },
  { 360, 14, 36, 22, 7, -31 },
  { 423, 14, 36, 22, 2, -31 },
  { 486, 19, 19, 22, 2, -23 },
  { 532, 17, 17, 22, 3, -21 },
  { 569, 9, 12, 22, 4, -6 },
  { 583, 12, 2, 22, 5, -13 },
  { 586, 6, 5, 22, 7, -5 },
  { 590, 21, 35, 22, 1, -31 },
  { 682, 18, 27, 22, 3, -27 },
  { 743, 16, 27, 22, 2, -27 },
  { 797, 19, 27, 22, 2, -27 },
  { 862, 18, 27, 22, 2, -27 },
  { 923, 16, 27, 22, 3, -27 },
  { 977, 17, 27, 22, 3, -27 },
  { 1035, 17, 27, 22, 2, -27 },
  { 1093, 17, 27, 22, 5, -27 },
  { 1151, 19, 27, 22, 2, -27 },
  { 1216, 17, 27, 22, 4, -27 },
  { 1274, 8, 21, 22, 7, -21 },
  { 1295, 11, 27, 22, 4, -21 },
  { 1333, 17, 18, 22, 4, -21 },
  { 1372, 17, 10, 22, 3, -17 },
  { 1394, 17, 18, 22, 2, -21 },
  { 1433, 15, 27, 22, 6, -27 },
  { 1484, 21, 34, 22, 1, -27 },
  { 1574, 17, 27, 22, 1, -27 },
  { 1632, 19, 27, 22, 2, -27 },
  { 1697, 18, 27, 22, 3, -27 },
  { 1758, 18, 27, 22, 2, -27 },
  { 1819, 19, 27, 22, 3, -27 },
  { 1884, 19, 27, 22, 3, -27 },
  { 1949, 18, 27, 22, 3, -27 },
  { 2010, 19, 27, 22, 2, -27 },
  { 2075, 17, 27, 22, 3, -27 },
  { 2133, 18, 27, 22, 2, -27 },
  { 2194, 20, 27, 22, 2, -27 },
  { 2262, 15, 27, 22, 3, -27 },
  { 2313, 19, 27, 22, 2, -27 },
  { 2378, 19, 27, 22, 2, -27 },
  { 2443, 17, 27, 22, 3, -27 },
  { 2501, 20, 27, 22, 2, -27 },
  { 2569, 17, 34, 22, 3, -27 },
  { 2642, 19, 27, 22, 2, -27 },
  { 2707, 19, 27, 22, 2, -27 },
  { 2772, 18, 27, 22, 5, -27 },
  { 2833, 18, 27, 22, 3, -27 },
  { 2894, 17, 27, 22, 5, -27 },
  { 2952, 20, 27, 22, 3, -27 },
  { 3020, 22, 27, 22, 0, -27 },
  { 3095, 18, 27, 22, 5, -27 },
  { 3156, 19, 27, 22, 2, -27 },
  { 3221, 14, 35, 22, 6, -31 },
  { 3283, 9, 35, 22, 7, -31 },
  { 3323, 14, 35, 22, 3, -31 },
  { 3385, 15, 14, 22, 4, -27 },
  { 3412, 18, 2, 22, 0, 1 },
  { 3417, 6, 5, 22, 10, -29 },
  { 3421, 17, 21, 22, 3, -21 },
  { 3466, 17, 27, 22, 2, -27 },
  { 3524, 17, 21, 22, 3, -21 },
  { 3569, 18, 27, 22, 3, -27 },
  { 3630, 16, 21, 22, 3, -21 },
  { 3672, 23, 34, 22, -1, -27 },
  { 3770, 17, 28, 22, 3, -21 },
  { 3830, 17, 27, 22, 2, -27 },
  { 3888, 16, 28, 22, 2, -28 },
  { 3944, 18, 35, 22, 1, -28 },
  { 4023, 18, 27, 22, 3, -27 },
  { 4084, 15, 27, 22, 4, -27 },
  { 4135, 20, 21, 22, 1, -21 },
  { 4188, 17, 21, 22, 2, -21 },
  { 4233, 16, 21, 22, 3, -21 },
  { 4275, 18, 28, 22, 1, -21 },
  { 4338, 17, 28, 22, 3, -21 },
  { 4398, 17, 21, 22, 3, -21 },
  { 4443, 17, 21, 22, 2, -21 },
  { 4488, 16, 26, 22, 4, -26 },
  { 4540, 17, 20, 22, 3, -20 },
  { 4583, 17, 20, 22, 4, -20 },
  { 4626, 19, 20, 22, 3, -20 },
  { 4674, 20, 20, 22, 1, -20 },
  { 4724, 16, 27, 22, 3, -20 },
  { 4778, 18, 20, 22, 2, -20 },
  { 4823, 18, 35, 22, 4, -31 },
  { 4902, 7, 35, 22, 8, -31 },
  { 4933, 18, 35, 22, 1, -31 },
  { 5012, 17, 6, 22, 3, -16 },
};

const GFXfont JetBrainsMono_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_THINITALIC37PT7B_H_
