#ifndef _JETBRAINSMONO_THINITALIC8PT7B_H_
#define _JETBRAINSMONO_THINITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xFC, 0x29, 0x96, 0xAE, 0x50, 0x11, 0x9A, 0xC3, 0x19, 0x44,
  0x6D, 0x94, 0x66, 0xD8, 0x34, 0x4B, 0x9F, 0xE0, 0x34, 0x44, 0x88, 0x84,
  0x42, 0x11, 0x22, 0x2C, 0x27, 0xC8, 0xA0, 0x4B, 0xA0, 0xE0, 0xE0, 0x40,
  0x08, 0x84, 0x42, 0x21, 0x10, 0x76, 0xFB, 0xC0, 0x25, 0x22, 0x2F, 0x35,
  0x11, 0x6F, 0xE5, 0x1B, 0xC0, 0x29, 0x5E, 0x40, 0xF3, 0x93, 0xC0, 0x2B,
  0x5B, 0xC0, 0xFA, 0x24, 0x48, 0x35, 0x75, 0x97, 0x69, 0x96, 0x48, 0x41,
  0x46, 0x80, 0x2A, 0x30, 0xFC, 0x42, 0x1E, 0x64, 0xA1, 0x00, 0x32, 0x6F,
  0x5A, 0xDB, 0x80, 0x22, 0x55, 0x79, 0xF7, 0xDB, 0xC0, 0x76, 0x4B, 0xC0,
  0xF6, 0xDB, 0x80, 0xF8, 0xE8, 0x8E, 0xF8, 0x8E, 0x88, 0x76, 0x7B, 0xC0,
  0x99, 0xEA, 0xAA, 0xE9, 0x25, 0xC0, 0x31, 0x11, 0x9E, 0x9A, 0xAC, 0xAA,
  0x92, 0x49, 0xC0, 0x4A, 0x9B, 0x29, 0x48, 0x99, 0xEE, 0xAA, 0x76, 0xDB,
  0xC0, 0xE9, 0x9E, 0x88, 0x76, 0xDB, 0x50, 0xE9, 0xBC, 0xAA, 0x32, 0x58,
  0x21, 0x38, 0xF4, 0x44, 0x44, 0x99, 0xAA, 0xAE, 0x99, 0xAA, 0xC4, 0xDD,
  0xAA, 0xAA, 0x4A, 0x88, 0x45, 0x48, 0x9A, 0xA4, 0x44, 0x78, 0x88, 0x44,
  0x78, 0x69, 0x29, 0x26, 0x91, 0x24, 0x89, 0x64, 0x94, 0x96, 0x4E, 0x80,
  0xF0, 0x80, 0xF6, 0xF0, 0x9A, 0xDB, 0xC0, 0xF2, 0x70, 0x15, 0xAA, 0xAE,
  0xFE, 0x70, 0x19, 0x1C, 0x44, 0x23, 0x00, 0xF6, 0xFE, 0x9A, 0xDB, 0x40,
  0x14, 0x22, 0x2F, 0x16, 0x11, 0x12, 0xE0, 0x89, 0xAC, 0xCA, 0xC9, 0x29,
  0xC0, 0x7B, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0, 0x75, 0x9F, 0x80, 0xF6, 0xF2,
  0xF2, 0x40, 0xF8, 0xF0, 0x5D, 0x29, 0xC0, 0xB6, 0xF0, 0xBA, 0xC4, 0xDE,
  0xAC, 0x52, 0x69, 0xB6, 0xFE, 0x72, 0x4F, 0x12, 0x44, 0xC4, 0x46, 0xFF,
  0x62, 0x22, 0x32, 0x4C, 0xBC,
};

const GFXglyph JetBrainsMono_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 3, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 4, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -6 },
  { 20, 4, 8, 5, 1, -7 },
  { 24, 4, 8, 5, 0, -7 },
  { 28, 5, 4, 5, 0, -5 },
  { 31, 3, 4, 5, 1, -5 },
  { 33, 2, 2, 5, 1, -1 },
  { 34, 3, 1, 5, 1, -3 },
  { 35, 2, 1, 5, 1, -1 },
  { 36, 5, 8, 5, 0, -7 },
  { 41, 3, 6, 5, 1, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 4, 6, 5, 1, -6 },
  { 65, 4, 6, 5, 0, -6 },
  { 68, 4, 6, 5, 1, -6 },
  { 71, 2, 4, 5, 1, -4 },
  { 72, 2, 5, 5, 1, -4 },
  { 74, 3, 4, 5, 1, -5 },
  { 76, 3, 2, 5, 1, -4 },
  { 77, 4, 4, 5, 0, -5 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 5, 7, 5, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 4, 6, 5, 0, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 3, 6, 5, 1, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 3, 7, 5, 1, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 4, 6, 5, 1, -6 },
  { 152, 4, 6, 5, 1, -6 },
  { 155, 4, 6, 5, 1, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 3, 8, 5, 1, -7 },
  { 172, 3, 8, 5, 1, -7 },
  { 175, 3, 8, 5, 1, -7 },
  { 178, 3, 3, 5, 1, -6 },
  { 180, 4, 1, 5, 0, 0 },
  { 181, 1, 1, 5, 2, -6 },
  { 182, 3, 4, 5, 1, -4 },
  { 184, 3, 6, 5, 1, -6 },
  { 187, 3, 4, 5, 1, -4 },
  { 189, 4, 6, 5, 1, -6 },
  { 192, 3, 4, 5, 1, -4 },
  { 194, 5, 7, 5, 0, -6 },
  { 199, 3, 5, 5, 1, -4 },
  { 201, 3, 6, 5, 1, -6 },
  { 204, 4, 6, 5, 0, -6 },
  { 207, 4, 7, 5, 0, -6 },
  { 211, 4, 6, 5, 1, -6 },
  { 214, 3, 6, 5, 1, -6 },
  { 217, 4, 4, 5, 0, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 4, 5, 5, 0, -4 },
  { 226, 3, 5, 5, 1, -4 },
  { 228, 3, 4, 5, 1, -4 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 3, 6, 5, 1, -6 },
  { 235, 3, 4, 5, 1, -4 },
  { 237, 4, 4, 5, 1, -4 },
  { 239, 4, 4, 5, 1, -4 },
  { 241, 4, 4, 5, 0, -4 },
  { 243, 3, 5, 5, 1, -4 },
  { 245, 4, 4, 5, 0, -4 },
  { 247, 4, 8, 5, 1, -7 },
  { 251, 1, 8, 5, 2, -7 },
  { 252, 4, 8, 5, 0, -7 },
  { 256, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_THINITALIC8PT7B_H_
