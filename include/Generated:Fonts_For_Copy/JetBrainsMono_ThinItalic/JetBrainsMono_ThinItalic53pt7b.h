#ifndef _JETBRAINSMONO_THINITALIC53PT7B_H_
#define _JETBRAINSMONO_THINITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x70, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0x9B, 0xE0, 0x03, 0x87, 0x1E, 0x00, 0xE0, 0xC1, 0xE0, 0x38,
  0x18, 0x1C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0x60, 0x70, 0x38, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x0F, 0x06, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x1F, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x67, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x86, 0x01, 0x80, 0x60, 0xC0,
  0x30, 0x0C, 0x18, 0x06, 0x03, 0x83, 0x00, 0xC0, 0x70, 0x70, 0x18, 0x1C,
  0x0E, 0x07, 0x07, 0x80, 0xE0, 0xC1, 0xE0, 0x1F, 0x18, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x07, 0xFC,
  0x00, 0x0E, 0x00, 0xF3, 0xC0, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x60, 0x07, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x70, 0x0E, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x0E,
  0x07, 0x00, 0x06, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x0C, 0x1C, 0x00, 0x06,
  0x00, 0xC3, 0x80, 0x00, 0x60, 0x1C, 0x30, 0x00, 0x07, 0x03, 0x86, 0x00,
  0x00, 0x3D, 0xF0, 0xE0, 0x00, 0x03, 0xFE, 0x1C, 0x00, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x87, 0xF0,
  0x00, 0x00, 0x71, 0xFF, 0x80, 0x00, 0x0E, 0x18, 0x1C, 0x00, 0x01, 0xC3,
  0x00, 0xC0, 0x00, 0x38, 0x70, 0x0C, 0x00, 0x03, 0x07, 0x00, 0xC0, 0x00,
  0x60, 0x60, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x60, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x30,
  0x00, 0x70, 0x70, 0x07, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x1E, 0x00, 0x73, 0x80, 0xE0, 0x0E, 0x38, 0x07, 0x01, 0xC3, 0x00, 0x70,
  0x18, 0x70, 0x03, 0x83, 0x87, 0x00, 0x38, 0x70, 0x70, 0x01, 0xCE, 0x07,
  0x00, 0x0E, 0xC0, 0x60, 0x00, 0xFC, 0x06, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xFC, 0x0E, 0x00, 0x1D, 0xC0,
  0xE0, 0x03, 0x8E, 0x07, 0x00, 0x70, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xFF,
  0xC0, 0x38, 0x1F, 0xF0, 0x03, 0x80, 0x10, 0x00, 0x00, 0x39, 0xCE, 0xF7,
  0xBD, 0xCE, 0x73, 0xBD, 0xEE, 0x73, 0x9C, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x67, 0xC0, 0x60, 0x3E, 0xFF, 0x86, 0x1F,
  0xF1, 0xFE, 0x67, 0xF8, 0x03, 0xF7, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x07, 0x81, 0xC3, 0x83, 0xE0, 0x70, 0xE0, 0xF8, 0x1C, 0x30, 0x3E,
  0x06, 0x1C, 0x07, 0x83, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xF3, 0x00, 0x03, 0xCE, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x03, 0xC0, 0x78, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x0C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0xFF, 0x80, 0x19, 0xFF, 0xE0,
  0x1D, 0xC0, 0xF8, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x9F, 0xE0, 0x07, 0x7F, 0xF8, 0x06, 0xE0, 0x7C,
  0x0F, 0x80, 0x1E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x3C, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xC1, 0xF0, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0xF8,
  0x07, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0xC0,
  0x00, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0xE0, 0x0F, 0xF9,
  0x83, 0x00, 0x7F, 0xF6, 0x0C, 0x03, 0xC0, 0xD8, 0x70, 0x0E, 0x01, 0xE1,
  0xC0, 0x70, 0x03, 0x87, 0x01, 0xC0, 0x0E, 0x1C, 0x06, 0x00, 0x38, 0x70,
  0x38, 0x00, 0xC1, 0x80, 0xE0, 0x03, 0x06, 0x03, 0x80, 0x1C, 0x38, 0x0E,
  0x00, 0x70, 0xE0, 0x30, 0x01, 0xC3, 0x80, 0xC0, 0x07, 0x0E, 0x07, 0x00,
  0x18, 0x30, 0x1C, 0x00, 0x60, 0xC0, 0x70, 0x03, 0x87, 0x01, 0xC0, 0x0E,
  0x1C, 0x07, 0x00, 0x78, 0x70, 0x0E, 0x03, 0xE1, 0xC0, 0x3E, 0x3B, 0x07,
  0x00, 0x7F, 0xCC, 0x18, 0x00, 0xFC, 0x30, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x1E, 0x03, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1C,
  0x00, 0xF8, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x03, 0xC0, 0x70, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x83, 0xE0, 0x07,
  0x80, 0x3C, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x03,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0x80, 0x0F, 0x00, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x3F, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0x80, 0x3C,
  0x03, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0x0E, 0x03, 0xFF, 0x83, 0x81,
  0xFF, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x03, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x38,
  0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x70,
  0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xE0,
  0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x80, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x36, 0x06, 0xC0, 0x03, 0x60, 0x66, 0x00, 0x6E, 0x06, 0x60, 0x0E,
  0xE0, 0x66, 0x00, 0xCE, 0x0E, 0x60, 0x1C, 0xC0, 0xE6, 0x01, 0x8C, 0x0E,
  0x30, 0x38, 0xC0, 0xC3, 0x03, 0x1C, 0x0C, 0x30, 0x71, 0xC0, 0xC3, 0x06,
  0x1C, 0x1C, 0x30, 0xE1, 0x81, 0xC1, 0x8C, 0x18, 0x1C, 0x19, 0x81, 0x81,
  0xC1, 0x98, 0x38, 0x18, 0x1B, 0x03, 0x81, 0x81, 0xB0, 0x38, 0x38, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C,
  0x0F, 0x80, 0x03, 0x01, 0xF0, 0x00, 0x60, 0x36, 0x00, 0x0C, 0x06, 0xC0,
  0x03, 0x80, 0xDC, 0x00, 0x70, 0x39, 0x80, 0x0E, 0x07, 0x30, 0x01, 0x80,
  0xE6, 0x00, 0x30, 0x1C, 0xE0, 0x06, 0x03, 0x0C, 0x01, 0xC0, 0x61, 0x80,
  0x38, 0x0C, 0x30, 0x07, 0x03, 0x87, 0x00, 0xE0, 0x70, 0xE0, 0x18, 0x0E,
  0x0C, 0x03, 0x01, 0x81, 0x80, 0xE0, 0x30, 0x38, 0x1C, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x70, 0x38, 0x0C, 0x0C, 0x07, 0x01, 0xC1, 0x80, 0xE0,
  0x38, 0x30, 0x18, 0x03, 0x0E, 0x03, 0x00, 0x61, 0xC0, 0xE0, 0x0C, 0x38,
  0x1C, 0x01, 0xC6, 0x03, 0x80, 0x18, 0xC0, 0x70, 0x03, 0x18, 0x0C, 0x00,
  0x67, 0x01, 0x80, 0x0E, 0xE0, 0x30, 0x01, 0xDC, 0x0E, 0x00, 0x1B, 0x81,
  0xC0, 0x03, 0x60, 0x38, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0x80, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x3E, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x7C,
  0x03, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x78, 0x0C, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x0F,
  0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x7C, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0,
  0x01, 0xE0, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x80, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x70, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x1E,
  0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30,
  0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x0C,
  0x00, 0x0E, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38,
  0x00, 0x70, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x3B, 0x00, 0x38,
  0x01, 0x98, 0x03, 0xC0, 0x1C, 0xC0, 0x1E, 0x00, 0xE6, 0x00, 0xF0, 0x06,
  0x30, 0x0F, 0x80, 0x71, 0x80, 0x6C, 0x03, 0x8C, 0x03, 0x60, 0x18, 0x60,
  0x1B, 0x00, 0xC3, 0x01, 0x98, 0x0E, 0x18, 0x0C, 0xC0, 0x70, 0xC0, 0x66,
  0x03, 0x0E, 0x06, 0x30, 0x18, 0x70, 0x31, 0x81, 0xC3, 0x81, 0x8C, 0x0C,
  0x1C, 0x1C, 0x60, 0x60, 0xE0, 0xC3, 0x07, 0x07, 0x06, 0x18, 0x38, 0x38,
  0x30, 0xC1, 0x81, 0xC3, 0x06, 0x0C, 0x0E, 0x18, 0x30, 0xE0, 0x70, 0xC1,
  0x87, 0x03, 0x8C, 0x0C, 0x30, 0x1C, 0x60, 0x61, 0x80, 0xC3, 0x03, 0x1C,
  0x06, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC6, 0x01, 0x8C, 0x06, 0x70, 0x0C,
  0x60, 0x33, 0x80, 0x66, 0x01, 0x98, 0x03, 0x30, 0x0C, 0xC0, 0x19, 0x80,
  0x6E, 0x00, 0xD8, 0x03, 0x60, 0x06, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0x80,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x01, 0x80, 0x70, 0x0E, 0x07, 0x00, 0x70,
  0x38, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9E, 0x00,
  0x1C, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC7, 0x01, 0xFF, 0xE7, 0x03, 0xC0,
  0x37, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x38, 0x01, 0xB0, 0x3C, 0x07,
  0x70, 0x1F, 0xFE, 0x70, 0x0F, 0xF8, 0x70, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC7, 0xFE, 0x00, 0xEF, 0xFF, 0x80,
  0x6E, 0x01, 0xE0, 0x3E, 0x00, 0x70, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x0F,
  0x80, 0x1E, 0x07, 0x60, 0x1E, 0x03, 0x3F, 0xFE, 0x01, 0x87, 0xFC, 0x01,
  0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xC0, 0x3C, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0xFC, 0x70,
  0x07, 0xFF, 0x9C, 0x03, 0xC0, 0x37, 0x01, 0xC0, 0x07, 0xC0, 0xE0, 0x01,
  0xF0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x78, 0x1C,
  0x00, 0x1E, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x06, 0xC0, 0x3C, 0x07, 0x70,
  0x07, 0xFF, 0x9C, 0x00, 0xFF, 0x87, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0E,
  0x30, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x01,
  0xE0, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC7, 0x01, 0xFF, 0xE7,
  0x03, 0xC0, 0x37, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x0C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x38, 0x00, 0xF8, 0x3C, 0x01, 0xB8, 0x1F, 0x9F, 0x30, 0x0F, 0xFE, 0x30,
  0x03, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC7,
  0xFE, 0x00, 0xEF, 0xFF, 0x80, 0x6E, 0x01, 0xE0, 0x36, 0x00, 0x70, 0x3C,
  0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x07,
  0x00, 0x18, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x1C,
  0x06, 0x01, 0xDF, 0xC3, 0xF8, 0x3F, 0xFC, 0xFF, 0x06, 0x83, 0xB0, 0xF0,
  0xE0, 0x3C, 0x0E, 0x1C, 0x07, 0x01, 0xC3, 0x00, 0xE0, 0x38, 0xE0, 0x18,
  0x07, 0x1C, 0x03, 0x00, 0xE3, 0x80, 0x60, 0x1C, 0x70, 0x1C, 0x03, 0x0C,
  0x03, 0x80, 0x61, 0x80, 0x70, 0x1C, 0x70, 0x0C, 0x03, 0x8E, 0x01, 0x80,
  0x71, 0xC0, 0x30, 0x0E, 0x38, 0x0E, 0x01, 0x86, 0x01, 0xC0, 0x30, 0xC0,
  0x38, 0x0E, 0x18, 0x07, 0x01, 0xC7, 0x00, 0xC0, 0x38, 0xE0, 0x18, 0x07,
  0x1C, 0x07, 0x00, 0xC3, 0x00, 0xE0, 0x18, 0x60, 0x1C, 0x03, 0x0C, 0x03,
  0x80, 0xE3, 0x80, 0x60, 0x1C, 0x70, 0x0C, 0x03, 0x8E, 0x01, 0x80, 0x71,
  0xC0, 0x70, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x8F, 0xFC, 0x01, 0xCF,
  0xFF, 0x00, 0xDC, 0x03, 0xC0, 0x6C, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E,
  0x01, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE6,
  0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xE3, 0xFF, 0x00, 0x3B, 0xFF, 0xE0, 0x0D, 0xC0, 0x3C, 0x03, 0xC0, 0x07,
  0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x03, 0xE0, 0x07, 0x80,
  0xEC, 0x03, 0xC0, 0x33, 0xFF, 0xE0, 0x0C, 0x3F, 0xE0, 0x07, 0x00, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC7,
  0x01, 0xFF, 0xE7, 0x03, 0xC0, 0x37, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x1F,
  0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x38, 0x01, 0xB0, 0x3C, 0x07, 0x70, 0x1F, 0xFE, 0x70, 0x0F, 0xF8, 0x70,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x8F, 0xFC,
  0x01, 0x9F, 0xFF, 0x00, 0xDC, 0x03, 0xC0, 0xF8, 0x00, 0xE0, 0x78, 0x00,
  0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xF0, 0x00,
  0x70, 0x78, 0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E,
  0x60, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x38, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x36,
  0x03, 0xB0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xC0,
  0x66, 0x07, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xE3, 0x03, 0x18, 0x38,
  0xC1, 0x86, 0x0C, 0x30, 0x61, 0x87, 0x0C, 0x18, 0x61, 0xC3, 0x0C, 0x18,
  0x60, 0xC3, 0x06, 0x38, 0x30, 0xC1, 0x8E, 0x0E, 0x60, 0x63, 0x03, 0x98,
  0x19, 0xC0, 0xEE, 0x06, 0x70, 0x3B, 0x01, 0x98, 0x0E, 0xC0, 0x66, 0x03,
  0xF0, 0x1B, 0x80, 0xF8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x06,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xB0, 0x3C,
  0x03, 0x70, 0x1F, 0x9F, 0x70, 0x0F, 0xFC, 0x70, 0x03, 0xF0, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0x87, 0xF0, 0x01, 0xC7,
  0xFC, 0x00, 0xC7, 0x07, 0x00, 0x67, 0x01, 0xC0, 0x33, 0x80, 0xE0, 0x39,
  0x80, 0x38, 0x1C, 0xC0, 0x0E, 0x1C, 0x60, 0x03, 0xFC, 0x70, 0x00, 0xFC,
  0x00,
};

const GFXglyph JetBrainsMono_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 39, 32, 11, -39 },
  { 50, 16, 16, 32, 11, -39 },
  { 82, 31, 39, 32, 1, -39 },
  { 234, 27, 53, 32, 3, -46 },
  { 413, 36, 39, 32, -1, -39 },
  { 589, 28, 40, 32, 2, -39 },
  { 729, 5, 16, 32, 16, -39 },
  { 739, 21, 52, 32, 9, -45 },
  { 876, 20, 52, 32, 3, -45 },
  { 1006, 28, 27, 32, 3, -32 },
  { 1101, 24, 25, 32, 4, -30 },
  { 1176, 12, 16, 32, 6, -8 },
  { 1200, 17, 3, 32, 8, -19 },
  { 1207, 8, 8, 32, 10, -7 },
  { 1215, 29, 50, 32, 2, -44 },
  { 1397, 26, 40, 32, 4, -39 },
  { 1527, 23, 39, 32, 3, -39 },
  { 1640, 27, 39, 32, 3, -39 },
  { 1772, 25, 40, 32, 4, -39 },
  { 1897, 24, 39, 32, 4, -39 },
  { 2014, 25, 40, 32, 4, -39 },
  { 2139, 24, 40, 32, 3, -39 },
  { 2259, 25, 39, 32, 7, -39 },
  { 2381, 26, 40, 32, 3, -39 },
  { 2511, 24, 39, 32, 6, -39 },
  { 2628, 12, 31, 32, 10, -30 },
  { 2675, 16, 38, 32, 6, -30 },
  { 2751, 25, 27, 32, 5, -31 },
  { 2836, 24, 15, 32, 4, -25 },
  { 2881, 25, 27, 32, 3, -31 },
  { 2966, 20, 39, 32, 9, -39 },
  { 3064, 30, 48, 32, 1, -39 },
  { 3244, 25, 39, 32, 1, -39 },
  { 3366, 26, 39, 32, 3, -39 },
  { 3493, 26, 40, 32, 4, -39 },
  { 3623, 26, 39, 32, 3, -39 },
  { 3750, 27, 39, 32, 4, -39 },
  { 3882, 28, 39, 32, 4, -39 },
  { 4019, 26, 40, 32, 4, -39 },
  { 4149, 27, 39, 32, 3, -39 },
  { 4281, 25, 39, 32, 4, -39 },
  { 4403, 27, 40, 32, 2, -39 },
  { 4538, 29, 39, 32, 3, -39 },
  { 4680, 22, 39, 32, 4, -39 },
  { 4788, 28, 39, 32, 3, -39 },
  { 4925, 27, 39, 32, 3, -39 },
  { 5057, 25, 40, 32, 4, -39 },
  { 5182, 28, 39, 32, 3, -39 },
  { 5319, 25, 49, 32, 4, -39 },
  { 5473, 27, 39, 32, 3, -39 },
  { 5605, 27, 40, 32, 3, -39 },
  { 5740, 25, 39, 32, 7, -39 },
  { 5862, 26, 40, 32, 4, -39 },
  { 5992, 25, 39, 32, 7, -39 },
  { 6114, 29, 39, 32, 5, -39 },
  { 6256, 32, 39, 32, 0, -39 },
  { 6412, 27, 39, 32, 6, -39 },
  { 6544, 28, 39, 32, 2, -39 },
  { 6681, 20, 50, 32, 8, -44 },
  { 6806, 14, 50, 32, 10, -44 },
  { 6894, 20, 50, 32, 5, -44 },
  { 7019, 21, 21, 32, 6, -39 },
  { 7075, 26, 3, 32, 0, 1 },
  { 7085, 8, 8, 32, 15, -42 },
  { 7093, 24, 31, 32, 4, -30 },
  { 7186, 25, 40, 32, 3, -39 },
  { 7311, 24, 31, 32, 4, -30 },
  { 7404, 26, 40, 32, 4, -39 },
  { 7534, 23, 31, 32, 4, -30 },
  { 7624, 33, 49, 32, -1, -39 },
  { 7827, 24, 40, 32, 4, -30 },
  { 7947, 25, 39, 32, 3, -39 },
  { 8069, 23, 41, 32, 3, -41 },
  { 8187, 27, 51, 32, 1, -41 },
  { 8360, 26, 39, 32, 4, -39 },
  { 8487, 21, 39, 32, 6, -39 },
  { 8590, 27, 30, 32, 2, -30 },
  { 8692, 25, 30, 32, 3, -30 },
  { 8786, 23, 31, 32, 4, -30 },
  { 8876, 26, 40, 32, 2, -30 },
  { 9006, 24, 40, 32, 4, -30 },
  { 9126, 25, 30, 32, 4, -30 },
  { 9220, 24, 31, 32, 4, -30 },
  { 9313, 23, 37, 32, 6, -37 },
  { 9420, 24, 30, 32, 4, -29 },
  { 9510, 24, 29, 32, 6, -29 },
  { 9597, 26, 29, 32, 5, -29 },
  { 9692, 28, 29, 32, 2, -29 },
  { 9794, 24, 39, 32, 4, -29 },
  { 9911, 25, 29, 32, 3, -29 },
  { 10002, 25, 50, 32, 6, -44 },
  { 10159, 11, 50, 32, 11, -44 },
  { 10228, 25, 50, 32, 2, -44 },
  { 10385, 25, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_THINITALIC53PT7B_H_
