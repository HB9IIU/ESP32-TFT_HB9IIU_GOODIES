#ifndef _JETBRAINSMONO_THINITALIC52PT7B_H_
#define _JETBRAINSMONO_THINITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E,
  0x00, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3E, 0x63, 0xC0, 0x1E, 0x18, 0x78, 0x0E, 0x06, 0x0E, 0x03,
  0x81, 0x81, 0x81, 0xC0, 0x60, 0x70, 0x70, 0x30, 0x1C, 0x18, 0x0C, 0x07,
  0x06, 0x03, 0x01, 0xC1, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C, 0x60, 0x00, 0x07,
  0xD8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x37, 0xE0, 0x00, 0x0C, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x01,
  0x80, 0xE1, 0x80, 0x60, 0x38, 0xE0, 0x18, 0x0E, 0x38, 0x06, 0x03, 0x86,
  0x01, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x0E, 0x0C, 0x1C,
  0x03, 0xE3, 0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xE0, 0x1F, 0xF8, 0x00, 0x38, 0x07, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x70, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x18, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0x38, 0x06, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x70,
  0x00, 0xC0, 0x18, 0x1C, 0x00, 0x18, 0x03, 0x07, 0x00, 0x03, 0x00, 0xE1,
  0xC0, 0x00, 0x60, 0x18, 0x30, 0x00, 0x0E, 0x07, 0x0C, 0x00, 0x01, 0xE1,
  0xC3, 0x80, 0x00, 0x1F, 0xF0, 0xE0, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xC0, 0x00, 0x01, 0xC7,
  0xFE, 0x00, 0x00, 0x71, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x1C, 0x00, 0x07,
  0x0E, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x30, 0x00, 0x30, 0x30, 0x06, 0x00,
  0x0C, 0x06, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x06,
  0x00, 0x38, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x07, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x18, 0x00, 0x78, 0x78, 0x07, 0x00,
  0x07, 0xFE, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x73, 0x80, 0xE0, 0x0C, 0x70, 0x1C, 0x03, 0x8C, 0x01,
  0xC0, 0xE3, 0x80, 0x38, 0x18, 0x70, 0x03, 0x87, 0x0E, 0x00, 0x39, 0xC1,
  0xC0, 0x07, 0x70, 0x30, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0x81, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0xC0, 0xE0, 0x01, 0xDC, 0x1C,
  0x00, 0x73, 0x81, 0xC0, 0x1C, 0x38, 0x3C, 0x0F, 0x03, 0x03, 0xFF, 0xC0,
  0x70, 0x3F, 0xE0, 0x07, 0x00, 0x40, 0x00, 0x00, 0x3B, 0xDE, 0xF7, 0x39,
  0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x06, 0x00, 0x2F, 0x00,
  0xC0, 0x3F, 0xFC, 0x18, 0x3F, 0x9F, 0xE3, 0x3F, 0xE0, 0xFE, 0x5F, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x03, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C,
  0x10, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x01, 0xC0,
  0x78, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0xE1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x1C, 0x06, 0x1C, 0x1F, 0x07, 0x0C, 0x0F, 0x83, 0x8E, 0x07,
  0xC1, 0xC7, 0x03, 0xE0, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x07, 0xC1, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7,
  0x00, 0x07, 0x8E, 0x00, 0x1E, 0x18, 0x00, 0xF0, 0x30, 0x03, 0xC0, 0xE0,
  0x06, 0x01, 0xC0, 0x08, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x00, 0xF8, 0x0F, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0C, 0x07, 0x00, 0x18, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x06, 0x3C, 0x00, 0x0C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0xFE, 0x00,
  0x71, 0xFF, 0x80, 0x3B, 0xE7, 0xF0, 0x1F, 0x80, 0x78, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x8F, 0xC0, 0x03, 0x3F, 0xF0, 0x07, 0xF9, 0xF8,
  0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x06, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E,
  0x60, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x3C, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0xF0,
  0x07, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x38, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE1, 0xE0, 0x01, 0xE0,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x78, 0x01, 0xC1, 0xC0, 0x01, 0xC3,
  0x00, 0x01, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xF8, 0xFE, 0x01, 0xFF, 0xB8,
  0x00, 0xFC, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0xFF, 0x1F, 0xE3, 0xF8,
  0x7F, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x01, 0xFC, 0xE0, 0xC0, 0x1F, 0xFB, 0x83, 0x00, 0xF0, 0x7E,
  0x1C, 0x07, 0x80, 0x70, 0x70, 0x1C, 0x01, 0xC1, 0xC0, 0x60, 0x07, 0x07,
  0x03, 0x80, 0x1C, 0x18, 0x0E, 0x00, 0x70, 0x60, 0x38, 0x01, 0xC1, 0x80,
  0xE0, 0x07, 0x0E, 0x03, 0x00, 0x18, 0x38, 0x0C, 0x00, 0x60, 0xE0, 0x70,
  0x03, 0x83, 0x81, 0xC0, 0x0E, 0x0C, 0x07, 0x00, 0x38, 0x30, 0x1C, 0x00,
  0xE1, 0xC0, 0x70, 0x07, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x07, 0x80, 0xB0,
  0x70, 0x0F, 0x0E, 0xC1, 0x80, 0x3F, 0xF7, 0x06, 0x00, 0x3F, 0x1C, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18,
  0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x0E,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0x07,
  0xE0, 0x0C, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0C, 0x00, 0x3C, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1C, 0x00, 0x7C, 0x07,
  0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0x80, 0x3F, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x7C, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x18, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x78, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xE0, 0x7F, 0x00, 0x60, 0x03, 0xC0, 0x30, 0x00,
  0xF0, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x0C, 0x03,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x38, 0x00,
  0x70, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xFF, 0xC3,
  0x81, 0xFF, 0xE1, 0x80, 0xFF, 0xF0, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18,
  0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x1F, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80,
  0x1C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0x60, 0x01, 0xF0, 0x36, 0x00, 0x3F, 0x03, 0x60, 0x03,
  0x60, 0x36, 0x00, 0x76, 0x07, 0x30, 0x06, 0x60, 0x73, 0x00, 0xCE, 0x07,
  0x30, 0x0C, 0xE0, 0x73, 0x01, 0x8E, 0x06, 0x30, 0x18, 0xE0, 0x61, 0x83,
  0x0C, 0x06, 0x18, 0x30, 0xC0, 0xE1, 0x86, 0x1C, 0x0E, 0x18, 0x61, 0xC0,
  0xE1, 0x8C, 0x1C, 0x0C, 0x0C, 0xC1, 0xC0, 0xC0, 0xD8, 0x18, 0x0C, 0x0D,
  0x81, 0x81, 0xC0, 0xF0, 0x18, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0xC0,
  0xF0, 0x00, 0x70, 0x3E, 0x00, 0x1C, 0x0D, 0x80, 0x07, 0x03, 0x60, 0x01,
  0xC0, 0xD8, 0x00, 0x60, 0x77, 0x00, 0x18, 0x1D, 0xC0, 0x06, 0x07, 0x30,
  0x03, 0x81, 0x8C, 0x00, 0xE0, 0x63, 0x00, 0x38, 0x18, 0xE0, 0x0C, 0x0E,
  0x18, 0x03, 0x03, 0x86, 0x00, 0xC0, 0xE1, 0x80, 0x70, 0x38, 0x70, 0x1C,
  0x0C, 0x0C, 0x07, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x06, 0x0E, 0x07, 0x01, 0x83, 0x81, 0x80, 0x60, 0xE0, 0x60,
  0x1C, 0x38, 0x18, 0x07, 0x0C, 0x0E, 0x00, 0xC3, 0x03, 0x80, 0x30, 0xC0,
  0xE0, 0x0E, 0x70, 0x30, 0x03, 0x9C, 0x0C, 0x00, 0x67, 0x03, 0x00, 0x19,
  0x81, 0xC0, 0x07, 0x60, 0x70, 0x01, 0xD8, 0x1C, 0x00, 0x36, 0x07, 0x00,
  0x0F, 0x81, 0x80, 0x03, 0xE0, 0x60, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x0E,
  0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70,
  0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0E, 0x00, 0xFE, 0x01, 0x80, 0x01, 0xE0, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x01,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0E, 0x01,
  0xFC, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x3C, 0x06, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x0F,
  0x01, 0x80, 0x03, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x18, 0x01, 0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x80, 0xF0, 0x07, 0x80,
  0x1E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x38, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x39, 0x80,
  0x3C, 0x01, 0x8C, 0x01, 0xE0, 0x0C, 0x60, 0x0F, 0x00, 0xE3, 0x00, 0xD8,
  0x07, 0x18, 0x06, 0xC0, 0x30, 0xC0, 0x36, 0x01, 0x86, 0x03, 0xB0, 0x1C,
  0x30, 0x19, 0x80, 0xC3, 0x80, 0xCC, 0x06, 0x1C, 0x06, 0x60, 0x70, 0xE0,
  0x63, 0x03, 0x87, 0x03, 0x18, 0x18, 0x38, 0x18, 0xC0, 0xC1, 0xC1, 0x86,
  0x0E, 0x0E, 0x0C, 0x30, 0x60, 0x70, 0x61, 0x83, 0x03, 0x86, 0x0C, 0x18,
  0x1C, 0x30, 0x61, 0xC0, 0xC1, 0x83, 0x0C, 0x06, 0x0C, 0x18, 0x60, 0x30,
  0xC0, 0xC7, 0x01, 0x86, 0x06, 0x38, 0x0C, 0x30, 0x31, 0x80, 0x63, 0x01,
  0x8C, 0x03, 0x18, 0x0C, 0xE0, 0x18, 0xC0, 0x46, 0x00, 0xCC, 0x02, 0x30,
  0x06, 0x60, 0x13, 0x80, 0x33, 0x00, 0x9C, 0x01, 0x90, 0x04, 0xC0, 0x0D,
  0x80, 0x66, 0x00, 0x6C, 0x03, 0x70, 0x03, 0x60, 0x1B, 0x00, 0x1E, 0x00,
  0xD8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x70, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x03,
  0x81, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x03, 0x00,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x39, 0x80,
  0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x0E, 0x03, 0x80, 0xF0, 0x0C, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x38, 0x00, 0x63, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xE0,
  0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x80, 0x00, 0x3F, 0x87, 0x00, 0xFF, 0xC7,
  0x03, 0xE0, 0xE6, 0x07, 0x80, 0x36, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x3C, 0x07, 0x70, 0x1F, 0xFE, 0x60, 0x0F, 0xF8, 0x60, 0x00, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x0F, 0xE0, 0x06, 0x3F, 0xF8, 0x06, 0x70, 0x7C,
  0x0E, 0xC0, 0x1E, 0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0x6E, 0x03, 0xC0,
  0x67, 0xFF, 0x80, 0xE1, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xC3, 0x80, 0x3F,
  0xF1, 0xC0, 0x7C, 0x1C, 0xC0, 0x78, 0x03, 0x60, 0x70, 0x00, 0xF0, 0x38,
  0x00, 0x78, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00,
  0x78, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0xEE, 0x01, 0xFF, 0xE6, 0x00, 0x7F,
  0xC3, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0x83, 0xE0, 0x3C, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x03, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x31, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0x80, 0xF0, 0x1F, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x00, 0xFF, 0xC7, 0x03, 0xE0,
  0xE6, 0x07, 0x80, 0x36, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x38, 0x00,
  0xB0, 0x3C, 0x03, 0xF0, 0x1F, 0x0F, 0x70, 0x0F, 0xFC, 0x70, 0x03, 0xF0,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x0F, 0xE0, 0x06, 0x3F, 0xF8, 0x06, 0x70, 0x7C, 0x0E, 0xC0,
  0x1E, 0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x78, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x06, 0x00,
  0x78, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x0E, 0x7C, 0x1F, 0x81, 0x9F, 0xC7,
  0xF8, 0x36, 0x3D, 0x8F, 0x07, 0x03, 0xA0, 0xE0, 0xE0, 0x38, 0x0C, 0x18,
  0x06, 0x01, 0x87, 0x00, 0xC0, 0x30, 0xE0, 0x38, 0x06, 0x1C, 0x07, 0x01,
  0xC3, 0x00, 0xE0, 0x38, 0x60, 0x18, 0x07, 0x0C, 0x03, 0x00, 0xE3, 0x80,
  0x60, 0x18, 0x70, 0x1C, 0x03, 0x0E, 0x03, 0x80, 0x61, 0xC0, 0x70, 0x1C,
  0x30, 0x0E, 0x03, 0x86, 0x01, 0x80, 0x71, 0xC0, 0x30, 0x0C, 0x38, 0x06,
  0x01, 0x87, 0x01, 0xC0, 0x30, 0xE0, 0x38, 0x0E, 0x18, 0x07, 0x01, 0xC3,
  0x00, 0xC0, 0x38, 0x60, 0x18, 0x07, 0x1C, 0x03, 0x00, 0xC3, 0x80, 0xE0,
  0x18, 0x70, 0x1C, 0x07, 0x0C, 0x03, 0x80, 0xE0, 0x07, 0x0F, 0xE0, 0x06,
  0x3F, 0xF8, 0x06, 0x70, 0x7C, 0x0E, 0xC0, 0x1E, 0x0F, 0x80, 0x0E, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30,
  0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x30, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x3C, 0x01, 0xC0, 0xF0,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x18, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0xC6, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x18,
  0xE0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C,
  0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xF0,
  0x03, 0x80, 0xF0, 0x1E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x87, 0xF0, 0x01, 0x8F, 0xFE, 0x00, 0xCE, 0x0F, 0x80,
  0xEC, 0x01, 0xE0, 0x7C, 0x00, 0x70, 0x3C, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xF0,
  0x00, 0x70, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x0D,
  0xC0, 0x78, 0x06, 0x7F, 0xF8, 0x07, 0x1F, 0xF8, 0x03, 0x80, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0x01, 0xFF, 0xC7, 0x03, 0xE0, 0xE6, 0x07, 0x80,
  0x36, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x18, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x07, 0x70, 0x1F, 0xFE,
  0x60, 0x0F, 0xF8, 0x60, 0x00, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x0F, 0xE0, 0x06, 0x3F,
  0xF8, 0x0E, 0xF0, 0x7C, 0x0E, 0xC0, 0x1E, 0x0F, 0x80, 0x0E, 0x0F, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x3E, 0x07, 0x80, 0x0F, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x70, 0x00,
  0x18, 0x78, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60,
  0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xE0,
  0x03, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x0C, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00,
  0x6C, 0x01, 0xC0, 0x1B, 0x00, 0xD0, 0x0E, 0xC0, 0x34, 0x03, 0xB0, 0x0D,
  0x00, 0xCC, 0x06, 0x40, 0x73, 0x01, 0x90, 0x1C, 0xC0, 0x64, 0x06, 0x30,
  0x31, 0x03, 0x8C, 0x0C, 0x60, 0xE3, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x1C,
  0x30, 0x61, 0x87, 0x0C, 0x38, 0x61, 0x83, 0x0C, 0x18, 0xE0, 0xC3, 0x06,
  0x38, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x67, 0x03, 0x18, 0x19, 0xC0, 0xCE,
  0x06, 0x60, 0x33, 0x01, 0xB8, 0x0C, 0xC0, 0x6E, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x06, 0xC0, 0x36, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x38, 0x00,
  0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x01,
  0xC6, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C,
  0x00, 0x06, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80,
  0x00, 0xE3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1E, 0x00,
  0x7C, 0x1C, 0x01, 0xB8, 0x3F, 0x1E, 0x70, 0x1F, 0xF8, 0xC0, 0x0F, 0xC1,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x1F, 0xE0, 0x03, 0x38, 0x70, 0x07, 0x30, 0x38, 0x07, 0x70, 0x1C,
  0x06, 0x60, 0x1C, 0x06, 0x60, 0x0E, 0x0E, 0x60, 0x07, 0xFC, 0xE0, 0x03,
  0xF8,
};

const GFXglyph JetBrainsMono_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 10, 38, 31, 11, -38 },
  { 49, 16, 16, 31, 10, -38 },
  { 81, 30, 38, 31, 1, -38 },
  { 224, 26, 52, 31, 3, -45 },
  { 393, 35, 38, 31, -1, -38 },
  { 560, 27, 39, 31, 2, -38 },
  { 692, 5, 16, 31, 16, -38 },
  { 702, 21, 51, 31, 9, -44 },
  { 836, 20, 51, 31, 3, -44 },
  { 964, 27, 27, 31, 3, -32 },
  { 1056, 24, 24, 31, 4, -29 },
  { 1128, 12, 16, 31, 6, -8 },
  { 1152, 17, 2, 31, 8, -18 },
  { 1157, 8, 8, 31, 10, -7 },
  { 1165, 29, 49, 31, 2, -43 },
  { 1343, 25, 39, 31, 4, -38 },
  { 1465, 23, 38, 31, 3, -38 },
  { 1575, 26, 38, 31, 3, -38 },
  { 1699, 26, 39, 31, 3, -38 },
  { 1826, 23, 38, 31, 4, -38 },
  { 1936, 25, 39, 31, 4, -38 },
  { 2058, 24, 39, 31, 3, -38 },
  { 2175, 25, 38, 31, 6, -38 },
  { 2294, 26, 39, 31, 3, -38 },
  { 2421, 23, 38, 31, 6, -38 },
  { 2531, 11, 30, 31, 10, -29 },
  { 2573, 16, 37, 31, 6, -29 },
  { 2647, 24, 26, 31, 5, -30 },
  { 2725, 24, 14, 31, 4, -24 },
  { 2767, 24, 26, 31, 3, -30 },
  { 2845, 20, 38, 31, 9, -38 },
  { 2940, 30, 47, 31, 1, -38 },
  { 3117, 24, 38, 31, 1, -38 },
  { 3231, 26, 38, 31, 3, -38 },
  { 3355, 25, 39, 31, 4, -38 },
  { 3477, 25, 38, 31, 3, -38 },
  { 3596, 26, 38, 31, 4, -38 },
  { 3720, 27, 38, 31, 4, -38 },
  { 3849, 25, 39, 31, 4, -38 },
  { 3971, 26, 38, 31, 3, -38 },
  { 4095, 25, 38, 31, 4, -38 },
  { 4214, 27, 39, 31, 2, -38 },
  { 4346, 28, 38, 31, 3, -38 },
  { 4479, 21, 38, 31, 4, -38 },
  { 4579, 28, 38, 31, 2, -38 },
  { 4712, 26, 38, 31, 3, -38 },
  { 4836, 24, 39, 31, 4, -38 },
  { 4953, 27, 38, 31, 3, -38 },
  { 5082, 24, 47, 31, 4, -38 },
  { 5223, 27, 38, 31, 3, -38 },
  { 5352, 26, 39, 31, 3, -38 },
  { 5479, 26, 38, 31, 6, -38 },
  { 5603, 25, 39, 31, 4, -38 },
  { 5725, 24, 38, 31, 7, -38 },
  { 5839, 29, 38, 31, 4, -38 },
  { 5977, 31, 38, 31, 0, -38 },
  { 6125, 26, 38, 31, 6, -38 },
  { 6249, 27, 38, 31, 2, -38 },
  { 6378, 20, 49, 31, 8, -43 },
  { 6501, 14, 49, 31, 9, -43 },
  { 6587, 19, 49, 31, 5, -43 },
  { 6704, 21, 20, 31, 6, -38 },
  { 6757, 26, 3, 31, 0, 1 },
  { 6767, 7, 7, 31, 15, -41 },
  { 6774, 24, 30, 31, 4, -29 },
  { 6864, 24, 39, 31, 3, -38 },
  { 6981, 24, 30, 31, 4, -29 },
  { 7071, 25, 39, 31, 4, -38 },
  { 7193, 23, 30, 31, 4, -29 },
  { 7280, 32, 47, 31, -1, -38 },
  { 7468, 24, 38, 31, 4, -29 },
  { 7582, 24, 38, 31, 3, -38 },
  { 7696, 23, 40, 31, 3, -40 },
  { 7811, 26, 49, 31, 1, -40 },
  { 7971, 26, 38, 31, 4, -38 },
  { 8095, 20, 38, 31, 6, -38 },
  { 8190, 27, 29, 31, 2, -29 },
  { 8288, 24, 29, 31, 3, -29 },
  { 8375, 23, 30, 31, 4, -29 },
  { 8462, 25, 38, 31, 2, -29 },
  { 8581, 24, 38, 31, 4, -29 },
  { 8695, 24, 29, 31, 4, -29 },
  { 8782, 24, 30, 31, 3, -29 },
  { 8872, 23, 36, 31, 6, -36 },
  { 8976, 24, 30, 31, 4, -29 },
  { 9066, 23, 29, 31, 6, -29 },
  { 9150, 26, 29, 31, 5, -29 },
  { 9245, 27, 29, 31, 2, -29 },
  { 9343, 23, 38, 31, 4, -29 },
  { 9453, 24, 29, 31, 3, -29 },
  { 9540, 25, 49, 31, 6, -43 },
  { 9694, 10, 49, 31, 11, -43 },
  { 9756, 25, 49, 31, 2, -43 },
  { 9910, 24, 9, 31, 4, -23 },
};

const GFXfont JetBrainsMono_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_THINITALIC52PT7B_H_
