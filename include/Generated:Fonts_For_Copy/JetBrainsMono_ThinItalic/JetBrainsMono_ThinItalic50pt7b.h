#ifndef _JETBRAINSMONO_THINITALIC50PT7B_H_
#define _JETBRAINSMONO_THINITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x0F, 0xC3, 0xF0, 0x78, 0x00,
  0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x67, 0x01, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x60, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18,
  0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0E,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x30, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7D, 0xDF, 0x00, 0x78, 0xC3, 0xC0, 0x70, 0x60, 0xE0, 0x30,
  0x30, 0x70, 0x38, 0x18, 0x1C, 0x18, 0x0C, 0x0E, 0x0C, 0x06, 0x07, 0x0E,
  0x06, 0x03, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x3C, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x9E,
  0x00, 0x01, 0x87, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x1C, 0x06,
  0x03, 0x8E, 0x03, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0xE0, 0xE0,
  0x60, 0xE0, 0x78, 0x30, 0xF0, 0x1E, 0x30, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x3F, 0xC0, 0x00, 0xE0, 0x1E, 0x78,
  0x00, 0x70, 0x0E, 0x07, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x70, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x01, 0xC0, 0x06,
  0x01, 0xC0, 0xE0, 0x01, 0x80, 0x60, 0x70, 0x00, 0x60, 0x18, 0x18, 0x00,
  0x18, 0x06, 0x0C, 0x00, 0x06, 0x03, 0x86, 0x00, 0x01, 0x80, 0xC3, 0x00,
  0x00, 0x70, 0xF1, 0xC0, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x01, 0xF8, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0xC3, 0xF8, 0x00, 0x00,
  0xE3, 0xFF, 0x00, 0x00, 0x71, 0xC0, 0xC0, 0x00, 0x18, 0x60, 0x38, 0x00,
  0x0C, 0x38, 0x06, 0x00, 0x06, 0x0C, 0x01, 0x80, 0x03, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0xC0, 0x30, 0x00, 0xE0, 0x30, 0x0C, 0x00, 0x70, 0x0C, 0x03,
  0x00, 0x38, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x70, 0x06, 0x00, 0x70,
  0x18, 0x03, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC7,
  0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0x60, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0x70, 0x07, 0x38, 0x1C, 0x03, 0x8C,
  0x03, 0x80, 0xC7, 0x00, 0xE0, 0x71, 0xC0, 0x1C, 0x38, 0x70, 0x03, 0x8C,
  0x18, 0x00, 0xE7, 0x06, 0x00, 0x1F, 0x81, 0x80, 0x07, 0xC0, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0x03, 0x80, 0x0E, 0xE0, 0xE0,
  0x07, 0x38, 0x3C, 0x03, 0x87, 0x07, 0x81, 0xC0, 0xC0, 0xFF, 0xE0, 0x38,
  0x1F, 0xE0, 0x07, 0x00, 0x80, 0x00, 0x00, 0x39, 0xCE, 0xF7, 0xB9, 0xCE,
  0x73, 0xBD, 0xCE, 0x73, 0x98, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x40, 0x0E, 0x00, 0x9E, 0x03, 0x01, 0xFF, 0xF0, 0xC3, 0xFC, 0xFF,
  0x33, 0xFC, 0x07, 0xEF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x78,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x70, 0x04, 0x00, 0x10, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x18, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0,
  0x1E, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x10, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x38, 0x0C, 0x30,
  0x3C, 0x1C, 0x70, 0x7C, 0x1C, 0x70, 0x7C, 0x1C, 0x70, 0x3C, 0x1C, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0x70, 0x00, 0x79, 0xC0, 0x03, 0x87, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x60,
  0x06, 0x01, 0x80, 0x20, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x3C,
  0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x03,
  0x80, 0x18, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x73,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x3F, 0x80,
  0x1C, 0xFF, 0xE0, 0x19, 0xC3, 0xF0, 0x1B, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xCF, 0xC0, 0x07, 0x7F,
  0xE0, 0x1F, 0xC3, 0xE0, 0x3C, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x01,
  0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0x70,
  0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x1F, 0x00, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x38, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x3C, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7C, 0x3E,
  0x03, 0xC0, 0x1C, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00, 0x01, 0x9C,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB8, 0x00, 0x0C,
  0xE0, 0x00, 0x73, 0xC0, 0x03, 0xC7, 0x00, 0x1E, 0x0F, 0x01, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xEE, 0x00, 0x18, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07,
  0x06, 0x00, 0x7F, 0x38, 0x30, 0x0F, 0xFD, 0xC3, 0x80, 0xF0, 0x7C, 0x1C,
  0x07, 0x00, 0xE0, 0xE0, 0x70, 0x07, 0x06, 0x03, 0x80, 0x38, 0x30, 0x18,
  0x01, 0xC1, 0x80, 0xC0, 0x0E, 0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x70, 0x03,
  0x07, 0x03, 0x80, 0x18, 0x38, 0x1C, 0x00, 0xC1, 0x80, 0xC0, 0x0E, 0x0C,
  0x06, 0x00, 0x70, 0x60, 0x30, 0x03, 0x87, 0x03, 0x80, 0x18, 0x38, 0x0C,
  0x01, 0xC1, 0xC0, 0x70, 0x1E, 0x0C, 0x03, 0xC1, 0xB0, 0x60, 0x0F, 0xFB,
  0x83, 0x00, 0x3F, 0x9C, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x66, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x60,
  0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x60, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x78, 0x0C, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0x80,
  0x7E, 0x01, 0x80, 0x07, 0x80, 0xC0, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x30, 0x00, 0xF0, 0x18, 0x03, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x78, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0x00,
  0x7C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x60, 0x1F, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x7C, 0x03, 0xC0,
  0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x1F,
  0xFC, 0x30, 0x1F, 0xFC, 0x70, 0x1F, 0xFC, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x60, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x01, 0x81, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0x70, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0x81, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x70, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x70,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x30, 0x07, 0x00,
  0x06, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x30, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xA0,
  0x01, 0xF0, 0x36, 0x00, 0x6C, 0x0E, 0xC0, 0x0D, 0x81, 0xD8, 0x03, 0x30,
  0x33, 0x00, 0x6E, 0x06, 0x20, 0x19, 0xC0, 0xC6, 0x07, 0x38, 0x18, 0xC0,
  0xC6, 0x07, 0x18, 0x38, 0xC0, 0xE3, 0x06, 0x18, 0x1C, 0x31, 0x87, 0x03,
  0x06, 0x30, 0xE0, 0x60, 0xCC, 0x1C, 0x0C, 0x19, 0x83, 0x03, 0x83, 0x60,
  0x60, 0x70, 0x2C, 0x0C, 0x0E, 0x07, 0x01, 0x81, 0x80, 0xE0, 0x70, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0x81, 0xE0, 0x00, 0xC0,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x7C, 0x00, 0x30, 0x3F, 0x00, 0x18,
  0x1D, 0x80, 0x0C, 0x0C, 0xC0, 0x06, 0x06, 0x60, 0x07, 0x03, 0x38, 0x03,
  0x83, 0x8C, 0x01, 0xC1, 0xC6, 0x00, 0xC0, 0xE3, 0x00, 0x60, 0x61, 0xC0,
  0x30, 0x30, 0x60, 0x38, 0x18, 0x30, 0x1C, 0x0C, 0x18, 0x0E, 0x0E, 0x0E,
  0x06, 0x07, 0x03, 0x03, 0x03, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0xE0, 0x60, 0x38, 0x70, 0x70, 0x0C, 0x30, 0x38, 0x06, 0x18, 0x1C,
  0x03, 0x0C, 0x0C, 0x01, 0xC6, 0x06, 0x00, 0x67, 0x03, 0x00, 0x33, 0x83,
  0x80, 0x19, 0xC1, 0xC0, 0x0E, 0xC0, 0xE0, 0x03, 0x60, 0x60, 0x01, 0xB0,
  0x30, 0x00, 0xD8, 0x18, 0x00, 0x7C, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xC3, 0xE0, 0x1E, 0x00,
  0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x30, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0xE0, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x07, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xC3,
  0xE0, 0x1E, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x30, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x13, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1E,
  0x07, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x30, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00,
  0x38, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x8C, 0x00, 0x07,
  0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xE0, 0x00, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x18, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x06, 0x07,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00,
  0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x73, 0x00, 0x70,
  0x06, 0x30, 0x0F, 0x00, 0x67, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x00, 0xC7,
  0x00, 0xF0, 0x0C, 0x70, 0x1B, 0x01, 0xC7, 0x01, 0xB0, 0x1C, 0x70, 0x1B,
  0x01, 0x87, 0x03, 0x30, 0x18, 0x60, 0x33, 0x03, 0x86, 0x03, 0x30, 0x30,
  0x60, 0x63, 0x03, 0x06, 0x06, 0x30, 0x30, 0x60, 0x63, 0x07, 0x06, 0x04,
  0x30, 0x60, 0x60, 0xC3, 0x06, 0x06, 0x0C, 0x30, 0xE0, 0x60, 0xC3, 0x0E,
  0x06, 0x18, 0x30, 0xC0, 0x61, 0x83, 0x0C, 0x06, 0x18, 0x31, 0xC0, 0x63,
  0x03, 0x18, 0x06, 0x30, 0x31, 0x80, 0x63, 0x03, 0x18, 0x06, 0x60, 0x33,
  0x80, 0x66, 0x03, 0x30, 0x06, 0x60, 0x33, 0x00, 0x64, 0x03, 0x70, 0x06,
  0xC0, 0x36, 0x00, 0x6C, 0x03, 0x60, 0x0E, 0xC0, 0x36, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x06,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x60,
  0x18, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x41, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xB0, 0x00, 0x39, 0x80,
  0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xC1, 0x80, 0x0E, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0x70, 0x0C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83,
  0x80, 0x0C, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00,
  0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xF0,
  0xE0, 0xE0, 0xC1, 0xC1, 0xC3, 0x80, 0x00, 0x7F, 0x0E, 0x03, 0xFF, 0x9C,
  0x0F, 0x07, 0xB0, 0x38, 0x03, 0x60, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x86,
  0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0x70, 0x03, 0xE0, 0x70, 0x0D, 0xC0, 0xFF, 0xF3, 0x80,
  0x7F, 0xC6, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x1F, 0x80, 0x39,
  0xFF, 0xC0, 0x77, 0x87, 0xC0, 0xF8, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38,
  0x00, 0x38, 0x78, 0x00, 0xE0, 0xD0, 0x03, 0xC1, 0xB8, 0x0F, 0x03, 0x3F,
  0xFC, 0x0E, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3E, 0x3F, 0x01, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x73,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x0E, 0x01, 0xFF,
  0xCE, 0x03, 0xC1, 0xEC, 0x07, 0x00, 0x6C, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xE0, 0x38, 0x06,
  0xE0, 0x3F, 0xFC, 0xE0, 0x0F, 0xF8, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x3E, 0x1F, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38,
  0x70, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x39, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC6, 0x00,
  0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0E, 0x03, 0xFF, 0x1C, 0x0F,
  0x07, 0x30, 0x38, 0x03, 0x60, 0xE0, 0x02, 0xC3, 0x80, 0x07, 0x86, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3,
  0x00, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0xD8, 0x1F,
  0x07, 0x30, 0x1F, 0xFC, 0xE0, 0x0F, 0xE1, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x1F, 0x80, 0x38, 0xFF, 0xC0,
  0x77, 0x87, 0xC0, 0xF8, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xE0,
  0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0xF0,
  0x60, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x78, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x06,
  0x03, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x0C, 0x7C, 0x1E, 0x03,
  0x7F, 0x9F, 0xC0, 0xD0, 0xEC, 0x78, 0x38, 0x1A, 0x0E, 0x1C, 0x07, 0x01,
  0x87, 0x01, 0xC0, 0x61, 0xC0, 0x60, 0x18, 0x60, 0x18, 0x06, 0x18, 0x06,
  0x03, 0x86, 0x01, 0x80, 0xE3, 0x80, 0xE0, 0x38, 0xE0, 0x38, 0x0C, 0x38,
  0x0C, 0x03, 0x0C, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x30, 0xC0, 0x30, 0x1C,
  0x30, 0x1C, 0x07, 0x1C, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x61, 0xC0, 0x60,
  0x18, 0x60, 0x18, 0x06, 0x18, 0x06, 0x03, 0x86, 0x03, 0x80, 0xE3, 0x80,
  0xE0, 0x38, 0xE0, 0x38, 0x0C, 0x38, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0xC3,
  0x00, 0xC0, 0x70, 0x06, 0x0F, 0xC0, 0x1C, 0x7F, 0xE0, 0x3B, 0xC3, 0xE0,
  0x7C, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x06,
  0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0,
  0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3E, 0x1F, 0x01, 0xC0, 0x1C, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x80, 0xE0, 0x1E, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x03, 0x07, 0xE0, 0x07,
  0x3F, 0xF8, 0x07, 0x78, 0x7C, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07,
  0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x34, 0x00, 0xF0, 0x37,
  0x01, 0xE0, 0x73, 0xFF, 0xC0, 0x71, 0xFF, 0x00, 0x70, 0x10, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x0E, 0x03, 0xFF, 0x9C, 0x0F, 0x07, 0xB0, 0x38, 0x03, 0x60, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x03, 0xE0, 0x70,
  0x0D, 0xC0, 0x7F, 0xF3, 0x80, 0x7F, 0xC6, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x1F,
  0xC0, 0x1C, 0xFF, 0xE0, 0x3B, 0x83, 0xE0, 0x7C, 0x01, 0xE0, 0xF0, 0x01,
  0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xF0, 0xE0, 0x00, 0xE1, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x18, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0x78, 0x01, 0xC0, 0xFF, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x86, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x78, 0x0E, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x31, 0x80, 0x01,
  0xC7, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xC0, 0xC0, 0x07, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x60, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80,
  0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xC0, 0x18, 0x03, 0xE0, 0x1C, 0x01, 0xB0, 0x0E, 0x00, 0xD8, 0x07,
  0x80, 0xEC, 0x06, 0xC0, 0x66, 0x03, 0x60, 0x33, 0x01, 0xB0, 0x39, 0x81,
  0x98, 0x18, 0xC0, 0xCC, 0x0C, 0x60, 0x66, 0x0E, 0x30, 0x63, 0x06, 0x18,
  0x31, 0x83, 0x0C, 0x18, 0xC3, 0x86, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC1,
  0x86, 0x18, 0xE0, 0xC6, 0x0C, 0x60, 0x63, 0x06, 0x30, 0x33, 0x83, 0x38,
  0x19, 0x81, 0x98, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x6E, 0x03, 0x60, 0x36,
  0x01, 0xB0, 0x1B, 0x00, 0xF0, 0x0D, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x07,
  0x00, 0x0C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x18,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80,
  0x01, 0xCE, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE1, 0xC0, 0x07,
  0x87, 0x80, 0x3E, 0x0F, 0x87, 0xB8, 0x1F, 0xF8, 0xE0, 0x1F, 0x83, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x3F, 0xC0, 0x0C, 0xE1, 0xC0, 0x3B,
  0x81, 0x80, 0x76, 0x03, 0x80, 0xCC, 0x03, 0x81, 0x98, 0x03, 0x8E, 0x70,
  0x03, 0xFC, 0xE0, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 10, 37, 30, 10, -37 },
  { 48, 15, 16, 30, 10, -37 },
  { 78, 29, 37, 30, 1, -37 },
  { 213, 25, 51, 30, 3, -44 },
  { 373, 34, 37, 30, -1, -37 },
  { 531, 26, 38, 30, 2, -37 },
  { 655, 5, 16, 30, 15, -37 },
  { 665, 20, 48, 30, 9, -42 },
  { 785, 19, 48, 30, 3, -42 },
  { 899, 26, 26, 30, 3, -31 },
  { 984, 23, 23, 30, 4, -28 },
  { 1051, 11, 16, 30, 6, -8 },
  { 1073, 17, 3, 30, 7, -18 },
  { 1080, 8, 8, 30, 9, -7 },
  { 1088, 28, 48, 30, 2, -42 },
  { 1256, 24, 38, 30, 4, -37 },
  { 1370, 22, 37, 30, 3, -37 },
  { 1472, 25, 37, 30, 3, -37 },
  { 1588, 25, 38, 30, 3, -37 },
  { 1707, 22, 36, 30, 4, -36 },
  { 1806, 24, 38, 30, 4, -37 },
  { 1920, 23, 38, 30, 3, -37 },
  { 2030, 24, 37, 30, 6, -37 },
  { 2141, 25, 38, 30, 3, -37 },
  { 2260, 22, 37, 30, 6, -37 },
  { 2362, 12, 29, 30, 9, -28 },
  { 2406, 15, 36, 30, 6, -28 },
  { 2474, 23, 25, 30, 5, -29 },
  { 2546, 23, 13, 30, 4, -23 },
  { 2584, 23, 25, 30, 3, -29 },
  { 2656, 20, 37, 30, 8, -37 },
  { 2749, 29, 46, 30, 1, -37 },
  { 2916, 23, 37, 30, 1, -37 },
  { 3023, 25, 37, 30, 3, -37 },
  { 3139, 24, 38, 30, 4, -37 },
  { 3253, 24, 37, 30, 3, -37 },
  { 3364, 25, 37, 30, 4, -37 },
  { 3480, 26, 37, 30, 4, -37 },
  { 3601, 24, 38, 30, 4, -37 },
  { 3715, 25, 37, 30, 3, -37 },
  { 3831, 24, 37, 30, 4, -37 },
  { 3942, 26, 38, 30, 2, -37 },
  { 4066, 27, 37, 30, 3, -37 },
  { 4191, 20, 37, 30, 4, -37 },
  { 4284, 27, 37, 30, 2, -37 },
  { 4409, 25, 37, 30, 3, -37 },
  { 4525, 23, 38, 30, 4, -37 },
  { 4635, 26, 37, 30, 3, -37 },
  { 4756, 23, 46, 30, 4, -37 },
  { 4889, 26, 37, 30, 3, -37 },
  { 5010, 25, 38, 30, 3, -37 },
  { 5129, 25, 37, 30, 6, -37 },
  { 5245, 24, 38, 30, 4, -37 },
  { 5359, 23, 37, 30, 7, -37 },
  { 5466, 28, 37, 30, 4, -37 },
  { 5596, 30, 37, 30, 0, -37 },
  { 5735, 25, 37, 30, 6, -37 },
  { 5851, 26, 37, 30, 2, -37 },
  { 5972, 19, 48, 30, 8, -42 },
  { 6086, 13, 48, 30, 9, -42 },
  { 6164, 18, 48, 30, 5, -42 },
  { 6272, 21, 20, 30, 5, -37 },
  { 6325, 25, 3, 30, 0, 1 },
  { 6335, 7, 7, 30, 14, -39 },
  { 6342, 23, 29, 30, 4, -28 },
  { 6426, 23, 38, 30, 3, -37 },
  { 6536, 22, 29, 30, 4, -28 },
  { 6616, 24, 38, 30, 4, -37 },
  { 6730, 22, 29, 30, 4, -28 },
  { 6810, 31, 46, 30, -1, -37 },
  { 6989, 23, 37, 30, 4, -28 },
  { 7096, 23, 37, 30, 3, -37 },
  { 7203, 22, 38, 30, 3, -38 },
  { 7308, 25, 47, 30, 1, -38 },
  { 7455, 26, 37, 30, 3, -37 },
  { 7576, 19, 37, 30, 6, -37 },
  { 7664, 26, 28, 30, 2, -28 },
  { 7755, 23, 28, 30, 3, -28 },
  { 7836, 22, 29, 30, 4, -28 },
  { 7916, 24, 37, 30, 2, -28 },
  { 8027, 23, 37, 30, 4, -28 },
  { 8134, 23, 28, 30, 4, -28 },
  { 8215, 23, 29, 30, 3, -28 },
  { 8299, 22, 35, 30, 5, -35 },
  { 8396, 23, 29, 30, 4, -28 },
  { 8480, 22, 28, 30, 6, -28 },
  { 8557, 25, 28, 30, 5, -28 },
  { 8645, 26, 28, 30, 2, -28 },
  { 8736, 22, 37, 30, 4, -28 },
  { 8838, 23, 28, 30, 3, -28 },
  { 8919, 24, 48, 30, 5, -42 },
  { 9063, 10, 48, 30, 11, -42 },
  { 9123, 24, 48, 30, 2, -42 },
  { 9267, 23, 9, 30, 4, -22 },
};

const GFXfont JetBrainsMono_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_THINITALIC50PT7B_H_
