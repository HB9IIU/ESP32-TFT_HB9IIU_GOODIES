#ifndef _JETBRAINSMONO_THINITALIC34PT7B_H_
#define _JETBRAINSMONO_THINITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x00, 0x00, 0x04, 0x3C, 0x78, 0xE0, 0x60,
  0xD8, 0x36, 0x0D, 0x87, 0xE1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x40,
  0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x80,
  0x80, 0x18, 0x18, 0x01, 0x81, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x30,
  0x30, 0x02, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x40, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x18, 0x10, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xB8, 0x0C, 0x46, 0x0C, 0x21, 0x8C, 0x30,
  0xC6, 0x18, 0x63, 0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x71, 0x00, 0x1D,
  0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x2E, 0x00, 0x11, 0x80, 0x08, 0x60,
  0x04, 0x30, 0x06, 0x18, 0x03, 0x0C, 0xC1, 0x06, 0x60, 0x83, 0x30, 0x43,
  0x0C, 0x23, 0x03, 0xB7, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x06, 0x0E, 0xE0, 0x18,
  0x10, 0x40, 0x60, 0x60, 0xC0, 0x80, 0x81, 0x02, 0x01, 0x02, 0x0C, 0x02,
  0x04, 0x30, 0x0C, 0x18, 0xC0, 0x18, 0x33, 0x00, 0x18, 0xCC, 0x00, 0x3F,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0xF8, 0x00, 0x67, 0x38, 0x01, 0x88, 0x30, 0x02, 0x30, 0x60, 0x08, 0x60,
  0xC0, 0x30, 0xC1, 0x80, 0xC1, 0x02, 0x03, 0x02, 0x04, 0x0C, 0x04, 0x18,
  0x30, 0x0C, 0x60, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x73, 0x80, 0x30,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x19, 0x80, 0x0C,
  0x30, 0x36, 0x0C, 0x19, 0x81, 0x8C, 0x60, 0x32, 0x18, 0x0D, 0x84, 0x01,
  0xC1, 0x00, 0x60, 0xC0, 0x1C, 0x30, 0x0D, 0x86, 0x06, 0x61, 0xC7, 0x0C,
  0x3F, 0x03, 0x80, 0x77, 0x66, 0x66, 0x6E, 0xCC, 0x00, 0x04, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x10,
  0x30, 0x1F, 0x0C, 0x3D, 0xF3, 0x3E, 0x0F, 0xBC, 0x00, 0x70, 0x00, 0x14,
  0x00, 0x0D, 0x80, 0x06, 0x60, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0x60,
  0x70, 0x18, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0E,
  0x1C, 0x70, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0x80, 0xFF, 0xFF, 0xFC, 0x39,
  0xE7, 0xDE, 0x78, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0x81, 0xC1, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x38, 0x63, 0x1C, 0x33, 0x0E,
  0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x60, 0x79, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x06, 0xC0, 0x39, 0x80, 0xC3, 0x03, 0x06,
  0x04, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x03, 0xCF, 0x03, 0x80, 0xC3, 0x00, 0x31, 0x80, 0x18, 0x80,
  0x0C, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x18, 0x01,
  0x84, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xC0, 0x70, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x61, 0x80,
  0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0xC0, 0x09, 0x80, 0x33, 0xFF, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x1F,
  0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x33, 0xF0, 0x2C, 0x38, 0x38, 0x1C, 0x70,
  0x0C, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x70, 0xE0, 0x3F,
  0x80, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0D, 0xF0, 0x1F,
  0xFC, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0x40, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x38,
  0x70, 0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x60, 0x03, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0x80, 0xC1,
  0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x30, 0x06, 0x18, 0x02,
  0x06, 0x03, 0x01, 0x86, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x31, 0x80, 0x60,
  0x70, 0x60, 0x18, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x42, 0x00, 0x61, 0x80, 0x60, 0x70, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x1E, 0xF0, 0x60, 0x31, 0x80, 0x26, 0x00, 0x68, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x36, 0x00, 0xC6, 0x03, 0x8F,
  0xBA, 0x07, 0xEC, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0E, 0x1F,
  0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x78, 0x7C, 0x78, 0x78, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x08, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x20, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x3F, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x81, 0xF8, 0x1E, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x38, 0xF0, 0x0C, 0x07,
  0x03, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x07, 0xEC, 0xC1, 0x85, 0x18, 0x60, 0x62, 0x0C, 0x0C,
  0x41, 0x01, 0x98, 0x60, 0x33, 0x0C, 0x06, 0x61, 0x80, 0x8C, 0x30, 0x11,
  0x06, 0x06, 0x20, 0xC0, 0xCC, 0x18, 0x39, 0x83, 0xDB, 0x30, 0x3E, 0x46,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x28, 0x00, 0x68, 0x00, 0x48, 0x00, 0xC8, 0x00, 0x88, 0x01, 0x8C, 0x01,
  0x8C, 0x01, 0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x04, 0x0C, 0x04, 0x1F, 0xFE, 0x1F, 0xFE, 0x10, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x0F, 0xF8, 0x07,
  0xFF, 0x03, 0x01, 0xC1, 0x00, 0x61, 0x80, 0x10, 0xC0, 0x08, 0x60, 0x04,
  0x30, 0x06, 0x18, 0x03, 0x08, 0x03, 0x04, 0x03, 0x87, 0xFF, 0x03, 0xFF,
  0x81, 0x80, 0xE0, 0xC0, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x61, 0x00, 0x61, 0xFF, 0xE0,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xBC, 0x0C, 0x06, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x60,
  0x30, 0x70, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x08, 0x0E, 0x08,
  0x07, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10,
  0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x20,
  0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x18, 0x40, 0x30, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC6,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x3F, 0xFE, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xBC, 0x0C, 0x06, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x61, 0xFE, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x60, 0x30, 0x70, 0xE0, 0x3F, 0xC0,
  0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x31, 0x80, 0x10, 0xC0,
  0x08, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x84, 0x00, 0x87,
  0xFF, 0xC3, 0xFF, 0xE1, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x20, 0x06,
  0x30, 0x02, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00,
  0x31, 0x80, 0x10, 0xC0, 0x18, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x07, 0x01, 0x80,
  0xE1, 0xC0, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18,
  0x20, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x18, 0x04, 0x0C, 0x01, 0x03, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0C, 0x18,
  0x03, 0x02, 0x00, 0x80, 0xC0, 0x20, 0x30, 0x18, 0x04, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x08, 0x18, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0C, 0x01,
  0xC7, 0x00, 0xF1, 0xE0, 0x28, 0x78, 0x1A, 0x12, 0x05, 0x84, 0x83, 0x61,
  0x20, 0x98, 0xCC, 0x66, 0x33, 0x11, 0x0C, 0x4C, 0x43, 0x12, 0x30, 0x85,
  0x8C, 0x21, 0xC3, 0x18, 0x70, 0xC6, 0x00, 0x21, 0x80, 0x08, 0x60, 0x06,
  0x10, 0x01, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x00, 0x0E, 0x01, 0x87, 0x00, 0xC2,
  0x80, 0x61, 0x40, 0x31, 0xB0, 0x10, 0xD8, 0x08, 0x6C, 0x0C, 0x32, 0x06,
  0x19, 0x03, 0x08, 0xC1, 0x84, 0x60, 0x86, 0x10, 0x43, 0x08, 0x61, 0x86,
  0x30, 0xC3, 0x18, 0x40, 0x8C, 0x20, 0x46, 0x30, 0x32, 0x18, 0x19, 0x0C,
  0x05, 0x86, 0x02, 0xC2, 0x01, 0xE1, 0x00, 0xF1, 0x80, 0x70, 0xC0, 0x18,
  0x00, 0x03, 0xF8, 0x07, 0x3C, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30,
  0x02, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xE0, 0x30, 0x70,
  0xE0, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x20, 0x06,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x84,
  0x00, 0x61, 0x00, 0x30, 0xC0, 0x18, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xBC, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02,
  0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xE0, 0x30, 0x70, 0xE0,
  0x3F, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x80, 0x30, 0x20, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x21, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00,
  0x41, 0x00, 0x30, 0xC0, 0x38, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0x06, 0x00,
  0x81, 0x80, 0x20, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x60,
  0x18, 0x18, 0x06, 0x04, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x01,
  0xFC, 0x01, 0xEF, 0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x60,
  0x70, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0,
  0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x30, 0x70, 0xE0, 0x3F,
  0x80, 0x80, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x80, 0x21, 0x80, 0x21, 0x00, 0x23,
  0x00, 0x33, 0x00, 0x36, 0x00, 0x36, 0x00, 0x34, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x40, 0xE0, 0x50, 0x38, 0x34, 0x0E, 0x0D, 0x03, 0x83,
  0x41, 0xE0, 0x90, 0x58, 0x64, 0x16, 0x19, 0x0D, 0x84, 0xC2, 0x61, 0x30,
  0x98, 0xCC, 0x66, 0x33, 0x11, 0x88, 0xC4, 0x66, 0x31, 0x11, 0x8C, 0xC4,
  0x43, 0x21, 0x10, 0xC8, 0x4C, 0x36, 0x13, 0x0D, 0x04, 0x83, 0x41, 0x20,
  0xF0, 0x58, 0x38, 0x14, 0x0E, 0x05, 0x03, 0x81, 0xC0, 0xC0, 0x70, 0x00,
  0x06, 0x00, 0x38, 0x30, 0x01, 0x80, 0x80, 0x18, 0x06, 0x01, 0x80, 0x10,
  0x08, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0xC4, 0x00,
  0x02, 0x60, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x28,
  0x00, 0x03, 0x60, 0x00, 0x31, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01,
  0x81, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0xC0, 0x0C,
  0x0C, 0x00, 0x20, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0xA0, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0xC2, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x20, 0x60, 0x18,
  0x30, 0x0C, 0x30, 0x02, 0x10, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x28, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0xFC, 0x1F, 0xE0, 0xC0, 0x20,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x07, 0xF8,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x83, 0xFC,
  0x1F, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xD0, 0x06, 0xC0, 0x66, 0x03, 0x30,
  0x30, 0x83, 0x06, 0x18, 0x31, 0x81, 0x8C, 0x06, 0xC0, 0x3C, 0x01, 0x80,
  0xFF, 0xFF, 0x80, 0xCC, 0x63, 0x30, 0x03, 0xE6, 0x1E, 0xEC, 0x60, 0x79,
  0x80, 0x72, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x0C, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x1C,
  0xC0, 0x38, 0xE1, 0xA0, 0xFE, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xF8, 0x1B, 0xBC, 0x1C, 0x06,
  0x18, 0x06, 0x18, 0x02, 0x30, 0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06,
  0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x08, 0x70, 0x18, 0xD8, 0x70, 0xCF, 0xC0, 0x03, 0xF0, 0x1F, 0xF0,
  0x60, 0x31, 0x80, 0x62, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x30, 0x06,
  0x60, 0x0C, 0xE0, 0x30, 0xE1, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x03, 0xE6, 0x0F, 0x76,
  0x18, 0x1E, 0x30, 0x0E, 0x20, 0x0C, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C,
  0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0x70, 0xD0, 0x3F, 0xB0, 0x03, 0xF0,
  0x1E, 0xF0, 0x60, 0x31, 0x80, 0x62, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x30,
  0x06, 0x40, 0x0C, 0xFF, 0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x06, 0x60, 0x0C, 0xE0, 0x30, 0xE1, 0xC0, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE6, 0x1E, 0xEC,
  0x60, 0x79, 0x80, 0x72, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x40,
  0x0C, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x18, 0x0E,
  0x38, 0x2C, 0x3F, 0x98, 0x08, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x01, 0xE0, 0xFF, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xF8, 0x1B, 0xBC, 0x1C,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x20, 0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x04, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x00, 0x30, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x30, 0x06, 0x18,
  0x06, 0x0C, 0x03, 0x04, 0x03, 0x06, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x20, 0xC0, 0x10, 0x30, 0x18, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x18, 0xC0, 0x0E, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xFF, 0x07, 0xF8, 0x1B, 0xC7, 0x85, 0xBA, 0xE1, 0x87, 0x0C,
  0x41, 0x83, 0x30, 0x60, 0xCC, 0x18, 0x23, 0x04, 0x08, 0xC1, 0x06, 0x30,
  0x41, 0x88, 0x30, 0x62, 0x0C, 0x19, 0x83, 0x04, 0x60, 0xC1, 0x18, 0x20,
  0xC6, 0x08, 0x31, 0x06, 0x0C, 0x41, 0x83, 0x30, 0x60, 0x8C, 0x18, 0x20,
  0x19, 0xF8, 0x1B, 0xBC, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x02,
  0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x20, 0x06, 0x60, 0x04,
  0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x08,
  0xC0, 0x08, 0x03, 0xF0, 0x1E, 0xF0, 0x60, 0x31, 0x80, 0x62, 0x00, 0x4C,
  0x00, 0x98, 0x01, 0x30, 0x06, 0x40, 0x0C, 0x80, 0x1B, 0x00, 0x36, 0x00,
  0x6C, 0x00, 0x98, 0x03, 0x30, 0x06, 0x60, 0x08, 0xE0, 0x30, 0xE1, 0xC0,
  0xFE, 0x00, 0x0C, 0xFC, 0x06, 0xEF, 0x03, 0x80, 0xC1, 0x80, 0x60, 0xC0,
  0x10, 0xC0, 0x08, 0x60, 0x04, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x84,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08,
  0x38, 0x0C, 0x36, 0x1C, 0x19, 0xF8, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE6, 0x1E, 0xEC,
  0x60, 0x79, 0x80, 0x72, 0x00, 0xCC, 0x00, 0x98, 0x03, 0x30, 0x06, 0x40,
  0x0C, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x1C, 0xE0, 0x38, 0xE1, 0xA0, 0xFE, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x11, 0xF0, 0x17, 0xBC, 0x3C,
  0x0E, 0x38, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x0F,
  0xBE, 0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x60, 0x0C, 0x70, 0x38, 0x3F, 0xF0, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x30, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x98, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0x80, 0x19, 0x00, 0x36, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x18, 0x60, 0x30, 0xE1, 0xC0, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x32, 0x00, 0x64, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x20,
  0x60, 0x40, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x02, 0x30, 0x04, 0xC0,
  0x09, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0xC1, 0xE0, 0xE0,
  0xF0, 0x70, 0x58, 0x38, 0x6C, 0x3C, 0x36, 0x12, 0x13, 0x09, 0x09, 0x8C,
  0x8C, 0xC4, 0x44, 0x62, 0x22, 0x33, 0x13, 0x19, 0x09, 0x0D, 0x84, 0x86,
  0xC2, 0xC3, 0x41, 0x61, 0xE0, 0xA0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18,
  0x00, 0x18, 0x00, 0xC3, 0x00, 0x60, 0x40, 0x30, 0x18, 0x18, 0x02, 0x0C,
  0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x0C, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0xC1, 0x80, 0x60,
  0x20, 0x30, 0x0C, 0x18, 0x01, 0x8E, 0x00, 0x60, 0x30, 0x06, 0x40, 0x0C,
  0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x20, 0x06, 0x40,
  0x0D, 0x80, 0x13, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E,
  0x30, 0x2C, 0x3F, 0x90, 0x18, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x01, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x01,
  0xE0, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x30, 0x60, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0x3C, 0x02, 0xCE, 0x07, 0x0C, 0x1E, 0x0C, 0x3C, 0x0C, 0xD8, 0x0F,
  0x00,
};

const GFXglyph JetBrainsMono_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 25, 20, 7, -25 },
  { 23, 10, 10, 20, 7, -25 },
  { 36, 20, 25, 20, 1, -25 },
  { 99, 17, 35, 20, 2, -30 },
  { 174, 23, 25, 20, -1, -25 },
  { 246, 18, 25, 20, 1, -25 },
  { 303, 4, 10, 20, 10, -25 },
  { 308, 14, 33, 20, 6, -29 },
  { 366, 13, 33, 20, 2, -29 },
  { 420, 18, 18, 20, 2, -21 },
  { 461, 15, 16, 20, 3, -19 },
  { 491, 7, 10, 20, 4, -5 },
  { 500, 11, 2, 20, 5, -12 },
  { 503, 6, 5, 20, 6, -5 },
  { 507, 19, 32, 20, 1, -28 },
  { 583, 17, 25, 20, 2, -25 },
  { 637, 15, 25, 20, 2, -25 },
  { 684, 17, 25, 20, 2, -25 },
  { 738, 17, 25, 20, 2, -25 },
  { 792, 15, 25, 20, 3, -25 },
  { 839, 16, 25, 20, 3, -25 },
  { 889, 16, 25, 20, 2, -25 },
  { 939, 16, 25, 20, 4, -25 },
  { 989, 17, 25, 20, 2, -25 },
  { 1043, 15, 25, 20, 4, -25 },
  { 1090, 8, 19, 20, 6, -19 },
  { 1109, 10, 24, 20, 4, -19 },
  { 1139, 16, 17, 20, 3, -20 },
  { 1173, 15, 9, 20, 3, -16 },
  { 1190, 16, 17, 20, 2, -20 },
  { 1224, 13, 25, 20, 6, -25 },
  { 1265, 19, 31, 20, 1, -25 },
  { 1339, 16, 25, 20, 1, -25 },
  { 1389, 17, 25, 20, 2, -25 },
  { 1443, 16, 25, 20, 3, -25 },
  { 1493, 16, 25, 20, 2, -25 },
  { 1543, 17, 25, 20, 3, -25 },
  { 1597, 18, 25, 20, 2, -25 },
  { 1654, 16, 25, 20, 3, -25 },
  { 1704, 17, 25, 20, 2, -25 },
  { 1758, 16, 25, 20, 3, -25 },
  { 1808, 18, 25, 20, 1, -25 },
  { 1865, 18, 25, 20, 2, -25 },
  { 1922, 14, 25, 20, 3, -25 },
  { 1966, 18, 25, 20, 2, -25 },
  { 2023, 17, 25, 20, 2, -25 },
  { 2077, 16, 25, 20, 3, -25 },
  { 2127, 18, 25, 20, 2, -25 },
  { 2184, 16, 31, 20, 3, -25 },
  { 2246, 18, 25, 20, 2, -25 },
  { 2303, 17, 25, 20, 2, -25 },
  { 2357, 17, 25, 20, 4, -25 },
  { 2411, 16, 25, 20, 3, -25 },
  { 2461, 16, 25, 20, 5, -25 },
  { 2511, 18, 25, 20, 3, -25 },
  { 2568, 21, 25, 20, 0, -25 },
  { 2634, 17, 25, 20, 4, -25 },
  { 2688, 17, 25, 20, 2, -25 },
  { 2742, 13, 32, 20, 5, -28 },
  { 2794, 9, 32, 20, 6, -28 },
  { 2830, 13, 32, 20, 3, -28 },
  { 2882, 13, 13, 20, 4, -25 },
  { 2904, 17, 1, 20, 0, 1 },
  { 2907, 4, 5, 20, 10, -27 },
  { 2910, 15, 19, 20, 3, -19 },
  { 2946, 16, 25, 20, 2, -25 },
  { 2996, 15, 19, 20, 3, -19 },
  { 3032, 16, 25, 20, 3, -25 },
  { 3082, 15, 19, 20, 3, -19 },
  { 3118, 21, 31, 20, -1, -25 },
  { 3200, 15, 25, 20, 3, -19 },
  { 3247, 16, 25, 20, 2, -25 },
  { 3297, 15, 26, 20, 2, -26 },
  { 3346, 17, 32, 20, 1, -26 },
  { 3414, 17, 25, 20, 2, -25 },
  { 3468, 13, 25, 20, 4, -25 },
  { 3509, 18, 19, 20, 1, -19 },
  { 3552, 16, 19, 20, 2, -19 },
  { 3590, 15, 19, 20, 3, -19 },
  { 3626, 17, 25, 20, 1, -19 },
  { 3680, 15, 25, 20, 3, -19 },
  { 3727, 16, 19, 20, 3, -19 },
  { 3765, 16, 19, 20, 2, -19 },
  { 3803, 15, 24, 20, 4, -24 },
  { 3848, 15, 19, 20, 3, -19 },
  { 3884, 15, 19, 20, 4, -19 },
  { 3920, 17, 19, 20, 3, -19 },
  { 3961, 18, 19, 20, 1, -19 },
  { 4004, 15, 25, 20, 3, -19 },
  { 4051, 16, 19, 20, 2, -19 },
  { 4089, 16, 32, 20, 4, -28 },
  { 4153, 7, 32, 20, 7, -28 },
  { 4181, 17, 32, 20, 1, -28 },
  { 4249, 15, 6, 20, 3, -15 },
};

const GFXfont JetBrainsMono_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_THINITALIC34PT7B_H_
