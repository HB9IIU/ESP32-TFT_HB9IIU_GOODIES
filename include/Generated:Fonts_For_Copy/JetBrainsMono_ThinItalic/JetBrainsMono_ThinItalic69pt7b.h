#ifndef _JETBRAINSMONO_THINITALIC69PT7B_H_
#define _JETBRAINSMONO_THINITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFC, 0xE7, 0xF0, 0x00, 0x7C, 0x1C, 0x3E, 0x00, 0x1F, 0x03,
  0x83, 0xE0, 0x03, 0xC0, 0x60, 0x3C, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x3C, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x30, 0x07, 0x80, 0xF0, 0x06, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1F,
  0x03, 0x00, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00,
  0x03, 0xFB, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0E,
  0xFE, 0x00, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x18, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x83, 0x80, 0x0C,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x38, 0x07, 0x80,
  0xF0, 0x06, 0x01, 0xE0, 0x0F, 0x00, 0xC0, 0x7C, 0x01, 0xF0, 0x38, 0x1F,
  0x00, 0x1F, 0x87, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC1, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x81, 0xFF, 0x80, 0x00,
  0x00, 0x0E, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x3E, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x70, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xC0, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x1E, 0x01, 0xE0, 0x01,
  0xE0, 0xE0, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x70, 0x00,
  0xF0, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x01,
  0xE0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x70, 0x00, 0x0F,
  0x38, 0x03, 0x80, 0x00, 0x7B, 0x80, 0x1C, 0x00, 0x01, 0xFC, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x07, 0x80, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0x0F, 0x0E, 0x01,
  0xF0, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xE0, 0x1F, 0xCF, 0xF0,
  0x0F, 0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x7F, 0x00, 0x70, 0x07, 0xFF, 0xFC, 0x07, 0x03, 0xFF, 0x3F, 0xF8,
  0x60, 0xFF, 0xE0, 0xFF, 0xC6, 0x3F, 0xF0, 0x01, 0xFF, 0x6F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x02, 0x03, 0xF0, 0xFF, 0x3F, 0xE7, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0x7F, 0x8F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x07, 0x80, 0x38, 0x3C, 0x07,
  0xE0, 0x3C, 0x1C, 0x03, 0xF0, 0x1E, 0x1E, 0x03, 0xF8, 0x0F, 0x0F, 0x00,
  0xFC, 0x07, 0x87, 0x80, 0x7E, 0x03, 0xC3, 0xC0, 0x1E, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x01, 0xC0, 0x00, 0xF8, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x02, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x80, 0x01, 0xC3, 0xFF, 0xF0, 0x00,
  0xE3, 0xFF, 0xFC, 0x00, 0x73, 0xC0, 0x7F, 0x00, 0x7B, 0x80, 0x0F, 0x80,
  0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xFF, 0x80,
  0x01, 0xE7, 0xFF, 0xE0, 0x01, 0xDF, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xF9, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x03,
  0xDC, 0x00, 0xFF, 0xFF, 0x70, 0x00, 0xFF, 0xF9, 0xE0, 0x00, 0x3F, 0xC7,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x0F, 0xF8, 0xF0, 0x78, 0x00, 0x7F, 0xF9, 0xE0, 0xF0,
  0x01, 0xFF, 0xFB, 0x81, 0xE0, 0x07, 0xC0, 0x37, 0x03, 0x80, 0x1F, 0x00,
  0x2E, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x3C, 0x01, 0xC0,
  0x00, 0xF0, 0x78, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x0F, 0x00, 0x03, 0x81,
  0xC0, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x70,
  0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0x00, 0xE0,
  0x78, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x0F, 0x81, 0xC0, 0x0F,
  0x80, 0x37, 0x03, 0x80, 0x0F, 0x80, 0xEE, 0x0F, 0x00, 0x1F, 0xFF, 0xBC,
  0x1E, 0x00, 0x1F, 0xFE, 0x70, 0x3C, 0x00, 0x0F, 0xF0, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x3C, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x38, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0xFC, 0x01,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x20, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0x07, 0x00, 0x7F, 0xFF, 0x83, 0x80, 0x3F, 0xFF, 0xC1, 0xC0,
  0x1F, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0E, 0xC0, 0x00, 0x77, 0x00,
  0xE7, 0x00, 0x03, 0xB8, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x39, 0xC0, 0x01,
  0xCE, 0x01, 0xCE, 0x00, 0x1C, 0xF0, 0x0E, 0x30, 0x00, 0xC7, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x07, 0x8E, 0x00, 0x61, 0xC0, 0x3C, 0x70, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x30, 0xF0, 0x0E, 0x0C, 0x03, 0x87, 0x80, 0x70, 0x70,
  0x38, 0x3C, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x3C, 0x1C, 0x1C, 0x0E, 0x01,
  0xE0, 0x60, 0xE0, 0x70, 0x0F, 0x03, 0x0E, 0x07, 0x80, 0x70, 0x1C, 0x70,
  0x3C, 0x03, 0x80, 0xE7, 0x01, 0xE0, 0x1C, 0x07, 0x38, 0x0E, 0x00, 0xE0,
  0x1B, 0x80, 0x70, 0x0F, 0x00, 0xDC, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x1C,
  0x03, 0x80, 0x3E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00,
  0xE0, 0x1F, 0x80, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x0E, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0x77, 0x00, 0x00, 0xE0, 0x3D, 0xC0, 0x00, 0x78, 0x0F, 0x70,
  0x00, 0x1E, 0x03, 0x9C, 0x00, 0x07, 0x00, 0xE3, 0x80, 0x01, 0xC0, 0x38,
  0xE0, 0x00, 0x70, 0x0E, 0x38, 0x00, 0x1C, 0x07, 0x8E, 0x00, 0x0F, 0x01,
  0xE3, 0xC0, 0x03, 0xC0, 0x78, 0x70, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x38,
  0x07, 0x07, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x70, 0x38, 0x01,
  0xE0, 0x3C, 0x0E, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x1C, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x01,
  0xC0, 0x0F, 0x03, 0x80, 0xF0, 0x01, 0xC1, 0xE0, 0x3C, 0x00, 0x70, 0x78,
  0x0F, 0x00, 0x1C, 0x1C, 0x03, 0x80, 0x07, 0x87, 0x00, 0xE0, 0x00, 0xE1,
  0xC0, 0x38, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x0E, 0x3C, 0x07, 0x80, 0x03,
  0xCF, 0x01, 0xE0, 0x00, 0x73, 0x80, 0x70, 0x00, 0x1C, 0xE0, 0x1C, 0x00,
  0x07, 0x38, 0x07, 0x00, 0x01, 0xCE, 0x01, 0xC0, 0x00, 0x3B, 0x80, 0xF0,
  0x00, 0x0E, 0xE0, 0x3C, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0xFC, 0x03,
  0x80, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x1C,
  0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF4, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00,
  0x3F, 0x80, 0x1C, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x3F,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x3C, 0xE0, 0x01,
  0xF0, 0x00, 0xE3, 0x80, 0x07, 0xC0, 0x07, 0x8E, 0x00, 0x3F, 0x00, 0x1E,
  0x38, 0x00, 0xFC, 0x00, 0x70, 0xE0, 0x03, 0x70, 0x01, 0xC7, 0x80, 0x1D,
  0xC0, 0x0F, 0x1E, 0x00, 0x77, 0x00, 0x38, 0x70, 0x01, 0xDC, 0x00, 0xE1,
  0xC0, 0x06, 0x70, 0x03, 0x87, 0x00, 0x39, 0xC0, 0x1E, 0x1C, 0x00, 0xE7,
  0x00, 0x70, 0x70, 0x03, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x0F, 0x07,
  0x00, 0x71, 0xC0, 0x38, 0x1C, 0x01, 0x87, 0x00, 0xE0, 0x70, 0x0E, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x70, 0x1E, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0x1C,
  0x03, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x18, 0x0F, 0x01, 0xC0, 0x70, 0x60,
  0x38, 0x07, 0x01, 0x81, 0x80, 0xE0, 0x1C, 0x0E, 0x06, 0x03, 0x80, 0x70,
  0x38, 0x18, 0x1E, 0x01, 0xC0, 0xC0, 0x60, 0x70, 0x07, 0x07, 0x01, 0x81,
  0xC0, 0x1C, 0x1C, 0x06, 0x07, 0x00, 0x70, 0x60, 0x18, 0x38, 0x01, 0xC1,
  0x80, 0x60, 0xE0, 0x07, 0x0E, 0x01, 0x83, 0x80, 0x1C, 0x38, 0x06, 0x1E,
  0x00, 0x70, 0xC0, 0x18, 0x70, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x0F, 0x1C,
  0x01, 0x87, 0x00, 0x3C, 0x60, 0x06, 0x38, 0x00, 0xF3, 0x80, 0x18, 0xE0,
  0x03, 0xCE, 0x00, 0x63, 0x80, 0x0E, 0x30, 0x01, 0x8E, 0x00, 0x39, 0xC0,
  0x06, 0x70, 0x00, 0xE7, 0x00, 0x19, 0xC0, 0x03, 0x98, 0x00, 0x67, 0x00,
  0x0E, 0x60, 0x01, 0xB8, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x00, 0xEC, 0x00,
  0x3B, 0x80, 0x03, 0xB0, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x3F, 0xFF, 0x8F,
  0x00, 0x7F, 0x0F, 0xCE, 0x00, 0xF8, 0x01, 0xEE, 0x01, 0xE0, 0x00, 0xEE,
  0x03, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x3D, 0xC0,
  0x0F, 0xE1, 0xF9, 0xC0, 0x07, 0xFF, 0xE1, 0xC0, 0x03, 0xFF, 0x83, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0xF1, 0xFF, 0xFC, 0x01, 0xE7,
  0xC3, 0xFC, 0x03, 0x9C, 0x00, 0xF8, 0x07, 0x70, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x70, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x78, 0x1F, 0xC0,
  0x01, 0xE0, 0x3D, 0xC0, 0x07, 0xC0, 0x73, 0xF0, 0x7F, 0x00, 0xE3, 0xFF,
  0xF8, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x0F, 0xFF, 0xE3, 0xC0, 0x07, 0xF0, 0xFC,
  0xE0, 0x03, 0xE0, 0x07, 0xB8, 0x01, 0xE0, 0x00, 0xEE, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF8,
  0x01, 0xF0, 0x03, 0xDC, 0x00, 0x3F, 0x07, 0xE7, 0x00, 0x07, 0xFF, 0xE1,
  0xC0, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xC7,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xC7, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x3C, 0x01, 0xFF,
  0xFC, 0x78, 0x07, 0xF0, 0xFC, 0xE0, 0x1F, 0x00, 0x39, 0xC0, 0x78, 0x00,
  0x3B, 0x81, 0xE0, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0x70, 0x1F, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x7B, 0xC0, 0x1F, 0xFF,
  0xE7, 0x80, 0x1F, 0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0xF1,
  0xFF, 0xFC, 0x01, 0xE7, 0xC3, 0xFC, 0x03, 0x9C, 0x00, 0xF8, 0x07, 0x70,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x06, 0x00, 0x38, 0xFF, 0x03,
  0xFC, 0x03, 0x9F, 0xF8, 0xFF, 0xE0, 0x3B, 0xCF, 0xCE, 0x7E, 0x03, 0xA0,
  0x3D, 0x81, 0xF0, 0x3C, 0x03, 0xD0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x70, 0x01, 0xC0,
  0x0F, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0xF0, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x80,
  0x1C, 0x0E, 0x00, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x1E, 0x00,
  0x70, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x03, 0xC1,
  0xC0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x00,
  0x38, 0x3C, 0x00, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0x07, 0x83, 0x80, 0x1E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x07, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC0, 0x07, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0xC0, 0x0E, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x1E, 0x3F, 0xFF, 0x80,
  0x3C, 0xF8, 0x7F, 0x80, 0x73, 0x80, 0x1F, 0x00, 0xEE, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x7F, 0xF0, 0x00, 0x78,
  0xFF, 0xFE, 0x00, 0x3C, 0xF8, 0x7F, 0x80, 0x1C, 0xE0, 0x07, 0xC0, 0x0E,
  0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0xE0,
  0x00, 0xF0, 0x07, 0xB8, 0x00, 0xF8, 0x03, 0x9F, 0x83, 0xF8, 0x01, 0xC7,
  0xFF, 0xF0, 0x00, 0xE0, 0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x7F, 0x0F,
  0xCE, 0x00, 0xF8, 0x01, 0xEE, 0x01, 0xE0, 0x00, 0xEE, 0x03, 0xC0, 0x00,
  0x7E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3D, 0xC0, 0x0F, 0xE1, 0xF9,
  0xC0, 0x07, 0xFF, 0xE1, 0xC0, 0x03, 0xFF, 0x83, 0xC0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0x83, 0xFF, 0xC0, 0x07, 0x8F, 0xFF, 0xE0, 0x07, 0x9F, 0x07,
  0xF0, 0x07, 0xB8, 0x00, 0xF8, 0x07, 0x70, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78,
  0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x3B, 0xC0,
  0x07, 0x80, 0x07, 0x78, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x39,
  0xE0, 0x06, 0xE0, 0x07, 0x3C, 0x00, 0xDC, 0x01, 0xE3, 0x80, 0x3B, 0x80,
  0x38, 0x70, 0x06, 0x70, 0x07, 0x0E, 0x00, 0xCE, 0x00, 0xE1, 0xC0, 0x39,
  0xC0, 0x38, 0x38, 0x06, 0x38, 0x07, 0x07, 0x01, 0xC7, 0x00, 0xE0, 0xE0,
  0x38, 0xE0, 0x38, 0x1C, 0x06, 0x1C, 0x07, 0x03, 0x81, 0xC3, 0x80, 0xE0,
  0x70, 0x38, 0x70, 0x3C, 0x0E, 0x06, 0x06, 0x07, 0x01, 0xC1, 0xC0, 0xC0,
  0xE0, 0x38, 0x38, 0x18, 0x3C, 0x07, 0x06, 0x03, 0x07, 0x00, 0xE1, 0xC0,
  0x60, 0xE0, 0x1C, 0x38, 0x0C, 0x3C, 0x03, 0x86, 0x01, 0x87, 0x00, 0x71,
  0xC0, 0x30, 0xE0, 0x0E, 0x38, 0x06, 0x3C, 0x01, 0xC6, 0x00, 0xC7, 0x00,
  0x39, 0xC0, 0x18, 0xE0, 0x07, 0x38, 0x03, 0x3C, 0x00, 0xEE, 0x00, 0x67,
  0x00, 0x1D, 0xC0, 0x0C, 0xE0, 0x03, 0xB8, 0x01, 0xBC, 0x00, 0x76, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x1C, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xBC,
  0x0F, 0xC0, 0x3C, 0xE0, 0x1F, 0xFF, 0xE3, 0x80, 0x3F, 0xFF, 0x0E, 0x00,
  0x3F, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xBC, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x1F, 0xF0, 0x00, 0x1C,
  0x7F, 0xF0, 0x00, 0x39, 0xF1, 0xF0, 0x00, 0x73, 0x80, 0xF0, 0x00, 0xEF,
  0x00, 0xF0, 0x03, 0xDC, 0x00, 0xE0, 0x07, 0x38, 0x01, 0xE0, 0x0E, 0xF0,
  0x01, 0xE0, 0x3D, 0xC0, 0x01, 0xE0, 0xF3, 0x80, 0x03, 0xFF, 0xC7, 0x00,
  0x01, 0xFF, 0x0E, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 14, 50, 41, 14, -50 },
  { 89, 21, 20, 41, 14, -50 },
  { 142, 40, 50, 41, 2, -50 },
  { 392, 35, 70, 41, 4, -60 },
  { 699, 47, 51, 41, -2, -51 },
  { 999, 37, 52, 41, 2, -51 },
  { 1240, 7, 20, 41, 21, -50 },
  { 1258, 28, 67, 41, 12, -58 },
  { 1493, 26, 67, 41, 4, -58 },
  { 1711, 36, 35, 41, 4, -42 },
  { 1869, 31, 32, 41, 6, -39 },
  { 1993, 15, 21, 41, 8, -10 },
  { 2033, 23, 3, 41, 10, -24 },
  { 2042, 11, 11, 41, 13, -10 },
  { 2058, 39, 65, 41, 2, -57 },
  { 2375, 33, 52, 41, 5, -51 },
  { 2590, 30, 50, 41, 4, -50 },
  { 2778, 35, 51, 41, 4, -51 },
  { 3002, 33, 51, 41, 5, -50 },
  { 3213, 30, 50, 41, 6, -50 },
  { 3401, 33, 51, 41, 5, -50 },
  { 3612, 32, 51, 41, 4, -50 },
  { 3816, 32, 50, 41, 9, -50 },
  { 4016, 34, 52, 41, 4, -51 },
  { 4237, 31, 51, 41, 8, -51 },
  { 4435, 15, 40, 41, 13, -39 },
  { 4510, 21, 50, 41, 8, -39 },
  { 4642, 32, 34, 41, 7, -40 },
  { 4778, 31, 19, 41, 6, -32 },
  { 4852, 32, 34, 41, 4, -40 },
  { 4988, 27, 50, 41, 11, -50 },
  { 5157, 39, 63, 41, 2, -51 },
  { 5465, 32, 50, 41, 2, -50 },
  { 5665, 33, 50, 41, 5, -50 },
  { 5872, 33, 52, 41, 6, -51 },
  { 6087, 32, 50, 41, 5, -50 },
  { 6287, 35, 50, 41, 5, -50 },
  { 6506, 36, 50, 41, 5, -50 },
  { 6731, 33, 52, 41, 6, -51 },
  { 6946, 34, 50, 41, 5, -50 },
  { 7159, 33, 50, 41, 5, -50 },
  { 7366, 35, 51, 41, 3, -50 },
  { 7590, 37, 50, 41, 5, -50 },
  { 7822, 29, 50, 41, 5, -50 },
  { 8004, 37, 50, 41, 3, -50 },
  { 8236, 34, 50, 41, 5, -50 },
  { 8449, 32, 52, 41, 6, -51 },
  { 8657, 35, 50, 41, 5, -50 },
  { 8876, 32, 63, 41, 6, -51 },
  { 9128, 35, 50, 41, 5, -50 },
  { 9347, 35, 52, 41, 4, -51 },
  { 9575, 33, 50, 41, 9, -50 },
  { 9782, 33, 51, 41, 6, -50 },
  { 9993, 32, 50, 41, 10, -50 },
  { 10193, 38, 50, 41, 6, -50 },
  { 10431, 41, 50, 41, 1, -50 },
  { 10688, 35, 50, 41, 8, -50 },
  { 10907, 36, 50, 41, 3, -50 },
  { 11132, 26, 65, 41, 11, -57 },
  { 11344, 18, 65, 41, 13, -57 },
  { 11491, 26, 65, 41, 6, -57 },
  { 11703, 27, 27, 41, 8, -50 },
  { 11795, 34, 3, 41, 0, 2 },
  { 11808, 9, 10, 41, 20, -54 },
  { 11820, 32, 40, 41, 5, -39 },
  { 11980, 31, 51, 41, 5, -50 },
  { 12178, 31, 40, 41, 6, -39 },
  { 12333, 34, 51, 41, 5, -50 },
  { 12550, 30, 40, 41, 6, -39 },
  { 12700, 43, 62, 41, -2, -50 },
  { 13034, 31, 51, 41, 6, -39 },
  { 13232, 31, 50, 41, 5, -50 },
  { 13426, 30, 53, 41, 4, -53 },
  { 13625, 34, 65, 41, 2, -53 },
  { 13902, 34, 50, 41, 5, -50 },
  { 14115, 27, 50, 41, 8, -50 },
  { 14284, 36, 39, 41, 2, -39 },
  { 14460, 31, 39, 41, 5, -39 },
  { 14612, 30, 40, 41, 6, -39 },
  { 14762, 33, 51, 41, 3, -39 },
  { 14973, 32, 51, 41, 5, -39 },
  { 15177, 32, 39, 41, 6, -39 },
  { 15333, 31, 40, 41, 5, -39 },
  { 15488, 31, 48, 41, 7, -48 },
  { 15674, 31, 39, 41, 6, -38 },
  { 15826, 31, 38, 41, 8, -38 },
  { 15974, 35, 38, 41, 6, -38 },
  { 16141, 36, 38, 41, 2, -38 },
  { 16312, 30, 50, 41, 6, -38 },
  { 16500, 32, 38, 41, 4, -38 },
  { 16652, 33, 65, 41, 8, -57 },
  { 16921, 13, 65, 41, 15, -57 },
  { 17027, 33, 65, 41, 3, -57 },
  { 17296, 31, 13, 41, 6, -31 },
};

const GFXfont JetBrainsMono_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_THINITALIC69PT7B_H_
