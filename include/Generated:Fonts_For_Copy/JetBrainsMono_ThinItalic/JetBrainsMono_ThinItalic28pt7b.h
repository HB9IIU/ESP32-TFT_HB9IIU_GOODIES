#ifndef _JETBRAINSMONO_THINITALIC28PT7B_H_
#define _JETBRAINSMONO_THINITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x08, 0x46, 0x31, 0x08, 0x42, 0x10, 0x00, 0x07,
  0x39, 0xC0, 0x63, 0xC3, 0xC3, 0xC2, 0xC2, 0x86, 0x86, 0x86, 0x01, 0x82,
  0x01, 0x06, 0x03, 0x04, 0x02, 0x0C, 0x02, 0x0C, 0x3F, 0xFF, 0x3F, 0xFF,
  0x04, 0x18, 0x0C, 0x10, 0x08, 0x30, 0x08, 0x20, 0x18, 0x20, 0x10, 0x60,
  0xFF, 0xFC, 0x30, 0x40, 0x20, 0xC0, 0x60, 0x80, 0x60, 0x80, 0x41, 0x80,
  0xC1, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x70, 0x0F, 0xF0, 0x62,
  0x61, 0x08, 0x8C, 0x42, 0x31, 0x08, 0xC4, 0x03, 0x10, 0x06, 0x40, 0x1D,
  0x00, 0x1E, 0x00, 0x2E, 0x00, 0x98, 0x02, 0x30, 0x08, 0x40, 0x21, 0x21,
  0x8C, 0x84, 0x33, 0x11, 0x86, 0x4C, 0x0F, 0xE0, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x0C, 0x21, 0x03, 0x04, 0x30,
  0xC1, 0x84, 0x30, 0x20, 0x84, 0x04, 0x11, 0x00, 0x86, 0x40, 0x19, 0x90,
  0x01, 0xC6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x09, 0xF0, 0x02, 0x62,
  0x00, 0x88, 0x60, 0x23, 0x0C, 0x0C, 0x61, 0x03, 0x08, 0x20, 0xC1, 0x04,
  0x10, 0x31, 0x0C, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x10, 0x60, 0x60,
  0x40, 0x80, 0x81, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0xC8, 0x03, 0x18, 0x34, 0x18, 0xC8, 0x33, 0x10, 0x34, 0x60, 0x38, 0xC0,
  0x61, 0x80, 0xC3, 0x02, 0xC3, 0x18, 0xC7, 0xE0, 0x80, 0x6D, 0xB6, 0x96,
  0x00, 0x20, 0x1C, 0x0E, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x01, 0x00, 0x08, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x83, 0x07, 0xCC, 0xF3, 0xEF, 0x00, 0xC0, 0x05, 0x00, 0x36, 0x01,
  0x98, 0x0C, 0x30, 0x60, 0xC1, 0x01, 0x80, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x71, 0x8C, 0x30, 0x86, 0x30, 0xFF,
  0x80, 0x33, 0xFC, 0xE0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0xC1,
  0x81, 0x84, 0x06, 0x30, 0x08, 0x80, 0x22, 0x00, 0x98, 0x02, 0x60, 0x19,
  0x88, 0x66, 0x71, 0x90, 0xC4, 0x40, 0x11, 0x00, 0x4C, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0x8C, 0x06, 0x1C, 0x70, 0x3F, 0x00, 0x01, 0xC0, 0x6C,
  0x0C, 0xC3, 0x08, 0x20, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x00, 0xE0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x21, 0x00,
  0x62, 0x00, 0x88, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x19, 0x00, 0x90, 0x04, 0xC0, 0x66, 0x02,
  0x18, 0x60, 0x7E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x10, 0xC0, 0x8C, 0x0C, 0x40, 0x64,
  0x03, 0x20, 0x13, 0xFF, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0xFC, 0x28, 0x71, 0x81, 0x98, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xD8, 0x04, 0xC0, 0x26, 0x02, 0x18, 0x30, 0x7E, 0x00, 0x00, 0x60,
  0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x17, 0xE3,
  0x86, 0x60, 0x34, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x2C,
  0x06, 0x60, 0xC3, 0xF0, 0x7F, 0xFD, 0x80, 0x24, 0x01, 0x90, 0x04, 0x40,
  0x32, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0x81, 0x84, 0x02, 0x30, 0x08,
  0xC0, 0x23, 0x01, 0x84, 0x04, 0x18, 0x20, 0x33, 0x00, 0x70, 0x07, 0x30,
  0x30, 0x61, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00, 0x8C, 0x06,
  0x18, 0x30, 0x3F, 0x80, 0x03, 0x80, 0x7F, 0x0C, 0x0C, 0x40, 0x26, 0x01,
  0xA0, 0x0F, 0x00, 0x58, 0x02, 0xC0, 0x36, 0x01, 0x98, 0x18, 0xF7, 0x81,
  0xEC, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x0C, 0x38, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x0F, 0x3C, 0x38, 0x03, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x60, 0x60, 0x30,
  0x10, 0x18, 0x18, 0x00, 0x00, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x10, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xDF, 0xFE, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x40, 0x00, 0x3F, 0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x87, 0xE0, 0xF0, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0C,
  0x04, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x22, 0x20,
  0xFA, 0x61, 0x06, 0x63, 0x06, 0x43, 0x06, 0x42, 0x04, 0x42, 0x04, 0x42,
  0x04, 0xC6, 0x0C, 0xC6, 0x0C, 0xC2, 0x1C, 0x83, 0xE8, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x78, 0x02, 0xC0, 0x32, 0x01, 0x10, 0x08, 0x80, 0x84,
  0x04, 0x20, 0x61, 0x02, 0x0C, 0x30, 0x61, 0x03, 0x1F, 0xF8, 0x80, 0x44,
  0x02, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x30, 0x1F, 0xF0, 0x40, 0x61,
  0x01, 0x8C, 0x02, 0x30, 0x08, 0xC0, 0x22, 0x01, 0x88, 0x0C, 0x20, 0x61,
  0xFE, 0x06, 0x06, 0x18, 0x0C, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x0C,
  0xC0, 0x23, 0x01, 0x88, 0x1C, 0x3F, 0xC0, 0x01, 0xC0, 0x1F, 0xC0, 0x81,
  0x84, 0x02, 0x30, 0x0C, 0xC0, 0x22, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x04, 0xC0,
  0x33, 0x00, 0x84, 0x06, 0x18, 0x30, 0x3F, 0x80, 0x1F, 0xE0, 0x81, 0x84,
  0x06, 0x60, 0x33, 0x00, 0x98, 0x0C, 0x80, 0x64, 0x03, 0x20, 0x13, 0x00,
  0x98, 0x04, 0xC0, 0x24, 0x03, 0x20, 0x19, 0x00, 0x88, 0x04, 0xC0, 0x66,
  0x06, 0x20, 0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xFF, 0xC2, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xE1, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0x81, 0x84,
  0x02, 0x30, 0x0C, 0xC0, 0x22, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0xFE, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x33,
  0x00, 0x84, 0x06, 0x18, 0x30, 0x3F, 0x80, 0x18, 0x0C, 0x40, 0x21, 0x00,
  0x8C, 0x02, 0x30, 0x08, 0xC0, 0x62, 0x01, 0x88, 0x04, 0x20, 0x11, 0xFF,
  0xC6, 0x01, 0x18, 0x0C, 0x40, 0x31, 0x00, 0xC4, 0x02, 0x10, 0x08, 0xC0,
  0x23, 0x01, 0x88, 0x06, 0x20, 0x18, 0x1F, 0xF8, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x44, 0x01, 0x30, 0x0C, 0x40, 0x21, 0x01, 0x87, 0x0C,
  0x0F, 0xE0, 0x18, 0x06, 0x20, 0x18, 0x40, 0x61, 0x80, 0x83, 0x03, 0x06,
  0x0C, 0x08, 0x10, 0x10, 0x60, 0x21, 0x80, 0xFF, 0x01, 0x86, 0x03, 0x04,
  0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x61, 0x80, 0x42,
  0x00, 0x84, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0x1C, 0x06,
  0x38, 0x14, 0x50, 0x38, 0xA0, 0xB1, 0x21, 0x42, 0x44, 0x8C, 0x99, 0x19,
  0x22, 0x32, 0xCC, 0x43, 0x18, 0x86, 0x31, 0x00, 0x42, 0x00, 0x8C, 0x01,
  0x18, 0x06, 0x20, 0x0C, 0x40, 0x18, 0x80, 0x21, 0x00, 0x46, 0x00, 0x80,
  0x18, 0x0C, 0x60, 0x21, 0xC0, 0x8D, 0x02, 0x34, 0x08, 0xD0, 0x62, 0x61,
  0x88, 0x84, 0x22, 0x11, 0x88, 0x46, 0x31, 0x18, 0x4C, 0x41, 0x31, 0x04,
  0xC4, 0x1A, 0x10, 0x28, 0xC0, 0xA3, 0x02, 0x88, 0x0E, 0x20, 0x38, 0x01,
  0xC0, 0x3F, 0x82, 0x06, 0x20, 0x33, 0x00, 0x98, 0x04, 0x80, 0x24, 0x03,
  0x20, 0x19, 0x00, 0x98, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00, 0xC8,
  0x06, 0xC0, 0x26, 0x03, 0x10, 0x10, 0xC1, 0x83, 0xF0, 0x00, 0x1F, 0xF0,
  0x40, 0x61, 0x00, 0xCC, 0x01, 0x30, 0x04, 0xC0, 0x12, 0x00, 0xC8, 0x02,
  0x20, 0x19, 0x83, 0xC7, 0xFC, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x3F,
  0x82, 0x06, 0x20, 0x33, 0x00, 0x98, 0x04, 0x80, 0x24, 0x03, 0x20, 0x19,
  0x00, 0x98, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00, 0xC8, 0x06, 0xC0,
  0x26, 0x03, 0x10, 0x10, 0xC1, 0x83, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x1F, 0xF0, 0x40, 0x61, 0x00, 0xCC, 0x03, 0x30,
  0x0C, 0xC0, 0x32, 0x00, 0x88, 0x06, 0x20, 0x31, 0xFF, 0x87, 0xF8, 0x18,
  0x40, 0x41, 0x81, 0x02, 0x04, 0x0C, 0x10, 0x30, 0xC0, 0x43, 0x01, 0x8C,
  0x06, 0x20, 0x0C, 0x01, 0xC0, 0x3F, 0xC1, 0x81, 0x84, 0x02, 0x30, 0x08,
  0xC0, 0x23, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x32, 0x00, 0xCC, 0x06,
  0x18, 0x30, 0x3F, 0x80, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x8C, 0x02, 0x30, 0x08,
  0xC0, 0x62, 0x01, 0x88, 0x06, 0x20, 0x11, 0x80, 0x46, 0x01, 0x18, 0x0C,
  0x40, 0x31, 0x00, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x61, 0x01, 0x06, 0x0C,
  0x0F, 0xC0, 0x80, 0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x20, 0x21,
  0x03, 0x08, 0x10, 0x40, 0x82, 0x0C, 0x18, 0x40, 0xC6, 0x06, 0x20, 0x13,
  0x00, 0x90, 0x04, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x00, 0x41,
  0x83, 0x41, 0x82, 0x41, 0x82, 0x42, 0x86, 0x42, 0x84, 0x42, 0x84, 0x46,
  0x8C, 0x44, 0x88, 0x44, 0x88, 0x44, 0x88, 0x48, 0x98, 0x48, 0x90, 0x48,
  0x90, 0x50, 0xB0, 0x50, 0xA0, 0x50, 0xA0, 0x60, 0xA0, 0xE0, 0xE0, 0xE0,
  0xC0, 0xE0, 0xC0, 0x0C, 0x01, 0x82, 0x01, 0x01, 0x81, 0x80, 0x41, 0x80,
  0x20, 0x80, 0x18, 0xC0, 0x04, 0xC0, 0x03, 0x40, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x10,
  0x20, 0x10, 0x18, 0x18, 0x04, 0x18, 0x02, 0x18, 0x01, 0x80, 0xC0, 0x0D,
  0x00, 0x26, 0x01, 0x08, 0x0C, 0x20, 0x20, 0xC1, 0x81, 0x0C, 0x06, 0x20,
  0x19, 0x80, 0x2C, 0x00, 0xE0, 0x03, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x1F, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xE1, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xC0, 0xC1,
  0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x06,
  0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x0F, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x3F, 0x00, 0x03, 0x80, 0x70, 0x12, 0x06,
  0x40, 0x8C, 0x31, 0x8C, 0x11, 0x82, 0x60, 0x78, 0x0C, 0xFF, 0xFC, 0xC4,
  0x23, 0x03, 0x00, 0x7E, 0xC4, 0x0E, 0x60, 0x22, 0x01, 0x30, 0x09, 0x80,
  0x48, 0x06, 0x40, 0x32, 0x01, 0x90, 0x09, 0x80, 0x4C, 0x06, 0x20, 0x31,
  0x83, 0x87, 0xEC, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x18, 0x1F,
  0xF0, 0xA0, 0xC6, 0x02, 0x20, 0x13, 0x00, 0x98, 0x04, 0xC0, 0x24, 0x03,
  0x20, 0x19, 0x00, 0xC8, 0x04, 0xC0, 0x66, 0x02, 0x28, 0x31, 0x3E, 0x00,
  0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x09, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x6C, 0x02, 0x20, 0x31, 0x83,
  0x07, 0xF0, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0x08, 0x3F,
  0x61, 0x03, 0x8C, 0x04, 0x20, 0x11, 0x80, 0x46, 0x01, 0x10, 0x0C, 0x40,
  0x31, 0x00, 0xC4, 0x02, 0x30, 0x08, 0xC0, 0x61, 0x01, 0x86, 0x0E, 0x0F,
  0xD8, 0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x22, 0x01, 0x30, 0x09, 0x80,
  0x4F, 0xFE, 0x7F, 0xF2, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x02, 0x20, 0x31,
  0x83, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x7E, 0xC4, 0x0E, 0x60, 0x22, 0x01, 0x30, 0x09, 0x80, 0x48,
  0x06, 0x40, 0x32, 0x01, 0x90, 0x08, 0x80, 0xC6, 0x06, 0x1D, 0xF0, 0x79,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x07, 0xF0, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x18, 0x1B, 0xF0, 0xA0, 0xC6, 0x02,
  0x20, 0x13, 0x00, 0x98, 0x04, 0xC0, 0x64, 0x03, 0x20, 0x19, 0x00, 0x88,
  0x04, 0xC0, 0x26, 0x01, 0x30, 0x19, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x07, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x04, 0xC0, 0x62, 0x01, 0x08, 0x08, 0x20, 0x60, 0x83, 0x06, 0x18,
  0x1F, 0xC0, 0x7F, 0x01, 0x04, 0x04, 0x18, 0x10, 0x20, 0xC0, 0xC3, 0x01,
  0x0C, 0x06, 0x20, 0x0C, 0xFE, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x07, 0xF0, 0x06, 0x18, 0x7F, 0xF8,
  0xC6, 0x11, 0x0C, 0x22, 0x18, 0x44, 0x30, 0x98, 0x43, 0x30, 0x86, 0x61,
  0x0C, 0x82, 0x11, 0x0C, 0x22, 0x18, 0x44, 0x20, 0x98, 0x43, 0x30, 0x86,
  0x43, 0x08, 0x01, 0x81, 0xBF, 0x0A, 0x0C, 0x60, 0x22, 0x01, 0x30, 0x09,
  0x80, 0x4C, 0x06, 0x40, 0x32, 0x01, 0x90, 0x08, 0x80, 0x4C, 0x02, 0x60,
  0x13, 0x01, 0x90, 0x0C, 0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x22, 0x01,
  0x30, 0x09, 0x80, 0x48, 0x02, 0x40, 0x32, 0x01, 0x90, 0x0D, 0x80, 0x4C,
  0x06, 0x20, 0x21, 0x83, 0x07, 0xE0, 0x00, 0xC0, 0x7F, 0xC1, 0x41, 0x86,
  0x02, 0x10, 0x08, 0xC0, 0x23, 0x00, 0x8C, 0x02, 0x20, 0x18, 0x80, 0x62,
  0x01, 0x88, 0x04, 0x60, 0x31, 0x80, 0x85, 0x06, 0x13, 0xE0, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x7E, 0xC4, 0x0E,
  0x60, 0x22, 0x01, 0x30, 0x09, 0x80, 0x48, 0x06, 0x40, 0x32, 0x01, 0x90,
  0x09, 0x80, 0x4C, 0x06, 0x20, 0x31, 0x83, 0x87, 0xEC, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0xBF, 0x8E, 0x04, 0x60,
  0x33, 0x01, 0x90, 0x0C, 0x80, 0x64, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x03, 0xC0, 0xFF, 0x8C,
  0x04, 0x40, 0x32, 0x00, 0x10, 0x00, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x68, 0x03, 0x60, 0x13, 0x81, 0x8F, 0xF0, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0xFC, 0x30, 0x19, 0x00, 0xC8, 0x06, 0x40, 0x26, 0x01,
  0x30, 0x09, 0x80, 0xC8, 0x06, 0x40, 0x32, 0x01, 0x10, 0x08, 0x80, 0xC4,
  0x04, 0x30, 0xE0, 0xFC, 0x00, 0xC0, 0x1A, 0x01, 0x90, 0x08, 0x80, 0xC6,
  0x04, 0x30, 0x60, 0x82, 0x04, 0x30, 0x21, 0x01, 0x98, 0x0C, 0x80, 0x2C,
  0x01, 0x40, 0x0E, 0x00, 0x60, 0x00, 0x82, 0x0E, 0x18, 0x28, 0x61, 0xA3,
  0x84, 0x8A, 0x12, 0x24, 0xC9, 0x92, 0x24, 0x48, 0x91, 0x62, 0xC5, 0x0A,
  0x14, 0x28, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x10,
  0x30, 0x30, 0x40, 0x21, 0x00, 0x64, 0x00, 0x58, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x80, 0x09, 0x80, 0x21, 0x00, 0x83, 0x03, 0x02, 0x0C, 0x06, 0x30,
  0x04, 0x00, 0x20, 0x19, 0x00, 0x88, 0x04, 0xC0, 0x26, 0x01, 0x30, 0x19,
  0x00, 0xC8, 0x06, 0x40, 0x22, 0x01, 0x10, 0x18, 0xC1, 0xC7, 0x36, 0x0F,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0xFF, 0x80,
  0x00, 0x78, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x0F, 0xC0, 0x7E, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x0C, 0x20, 0x82, 0x18, 0x61,
  0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41, 0x04,
  0x30, 0xC3, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x1F,
  0x80, 0xFC, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x07, 0x80, 0x00, 0x3C, 0x0A,
  0x30, 0x50, 0xC6, 0x83, 0xEC, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 8, 8, 17, 6, -20 },
  { 22, 16, 20, 17, 1, -20 },
  { 62, 14, 28, 17, 2, -24 },
  { 111, 19, 21, 17, -1, -21 },
  { 161, 15, 21, 17, 1, -21 },
  { 201, 3, 8, 17, 8, -20 },
  { 204, 11, 28, 17, 5, -24 },
  { 243, 11, 28, 17, 1, -24 },
  { 282, 14, 14, 17, 2, -17 },
  { 307, 13, 13, 17, 2, -16 },
  { 329, 6, 8, 17, 3, -4 },
  { 335, 9, 1, 17, 4, -10 },
  { 337, 5, 4, 17, 5, -4 },
  { 340, 16, 26, 17, 1, -23 },
  { 392, 14, 21, 17, 2, -21 },
  { 429, 12, 20, 17, 2, -20 },
  { 459, 15, 21, 17, 1, -21 },
  { 499, 13, 20, 17, 2, -20 },
  { 532, 13, 20, 17, 2, -20 },
  { 565, 13, 20, 17, 2, -20 },
  { 598, 12, 20, 17, 2, -20 },
  { 628, 14, 20, 17, 3, -20 },
  { 663, 14, 21, 17, 2, -21 },
  { 700, 13, 21, 17, 3, -21 },
  { 735, 7, 16, 17, 5, -16 },
  { 749, 9, 20, 17, 3, -16 },
  { 772, 13, 14, 17, 3, -16 },
  { 795, 13, 8, 17, 2, -13 },
  { 808, 13, 14, 17, 2, -16 },
  { 831, 11, 20, 17, 5, -20 },
  { 859, 16, 26, 17, 1, -21 },
  { 911, 13, 20, 17, 1, -20 },
  { 944, 14, 20, 17, 2, -20 },
  { 979, 14, 21, 17, 2, -21 },
  { 1016, 13, 20, 17, 2, -20 },
  { 1049, 14, 20, 17, 2, -20 },
  { 1084, 15, 20, 17, 2, -20 },
  { 1122, 14, 21, 17, 2, -21 },
  { 1159, 14, 20, 17, 2, -20 },
  { 1194, 13, 20, 17, 2, -20 },
  { 1227, 14, 20, 17, 1, -20 },
  { 1262, 15, 20, 17, 2, -20 },
  { 1300, 12, 20, 17, 2, -20 },
  { 1330, 15, 20, 17, 1, -20 },
  { 1368, 14, 20, 17, 2, -20 },
  { 1403, 13, 21, 17, 2, -21 },
  { 1438, 14, 20, 17, 2, -20 },
  { 1473, 13, 26, 17, 2, -21 },
  { 1516, 14, 20, 17, 2, -20 },
  { 1551, 14, 21, 17, 2, -21 },
  { 1588, 14, 20, 17, 3, -20 },
  { 1623, 14, 20, 17, 2, -20 },
  { 1658, 13, 20, 17, 4, -20 },
  { 1691, 16, 20, 17, 2, -20 },
  { 1731, 17, 20, 17, 0, -20 },
  { 1774, 14, 20, 17, 3, -20 },
  { 1809, 15, 20, 17, 1, -20 },
  { 1847, 11, 26, 17, 4, -23 },
  { 1883, 7, 26, 17, 5, -23 },
  { 1906, 10, 26, 17, 3, -23 },
  { 1939, 11, 10, 17, 3, -20 },
  { 1953, 14, 1, 17, 0, 1 },
  { 1955, 4, 4, 17, 8, -22 },
  { 1957, 13, 16, 17, 2, -16 },
  { 1983, 13, 20, 17, 2, -20 },
  { 2016, 13, 16, 17, 2, -16 },
  { 2042, 14, 20, 17, 2, -20 },
  { 2077, 13, 16, 17, 2, -16 },
  { 2103, 18, 25, 17, -1, -20 },
  { 2160, 13, 21, 17, 2, -16 },
  { 2195, 13, 20, 17, 2, -20 },
  { 2228, 13, 21, 17, 1, -21 },
  { 2263, 14, 26, 17, 1, -21 },
  { 2309, 14, 20, 17, 2, -20 },
  { 2344, 11, 20, 17, 3, -20 },
  { 2372, 15, 16, 17, 1, -16 },
  { 2402, 13, 16, 17, 2, -16 },
  { 2428, 13, 16, 17, 2, -16 },
  { 2454, 14, 21, 17, 1, -16 },
  { 2491, 13, 21, 17, 2, -16 },
  { 2526, 13, 16, 17, 2, -16 },
  { 2552, 13, 16, 17, 2, -16 },
  { 2578, 12, 20, 17, 3, -20 },
  { 2608, 13, 15, 17, 2, -15 },
  { 2633, 13, 15, 17, 3, -15 },
  { 2658, 14, 15, 17, 3, -15 },
  { 2685, 15, 15, 17, 1, -15 },
  { 2714, 13, 20, 17, 2, -15 },
  { 2747, 13, 15, 17, 2, -15 },
  { 2772, 13, 26, 17, 3, -23 },
  { 2815, 6, 26, 17, 6, -23 },
  { 2835, 13, 26, 17, 1, -23 },
  { 2878, 13, 5, 17, 2, -12 },
};

const GFXfont JetBrainsMono_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_THINITALIC28PT7B_H_
