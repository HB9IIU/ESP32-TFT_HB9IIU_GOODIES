#ifndef _JETBRAINSMONO_THINITALIC29PT7B_H_
#define _JETBRAINSMONO_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x82,
  0x00, 0x00, 0x06, 0x38, 0xE0, 0x61, 0xB1, 0xB0, 0xD8, 0x6C, 0x36, 0x1B,
  0x09, 0x04, 0x82, 0x00, 0x01, 0x83, 0x01, 0x82, 0x01, 0x06, 0x03, 0x06,
  0x03, 0x04, 0x02, 0x0C, 0x3F, 0xFF, 0x04, 0x08, 0x04, 0x18, 0x0C, 0x18,
  0x08, 0x10, 0x08, 0x30, 0x18, 0x20, 0x10, 0x20, 0xFF, 0xFC, 0x30, 0x40,
  0x20, 0x40, 0x20, 0xC0, 0x60, 0x80, 0x40, 0x80, 0xC1, 0x80, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x07, 0xF0, 0x32, 0x61, 0x88, 0xC4, 0x23,
  0x30, 0x8C, 0xC6, 0x03, 0x10, 0x04, 0x40, 0x19, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xD8, 0x03, 0x30, 0x08, 0x40, 0x21, 0x80, 0x86, 0x82, 0x13, 0x08,
  0xCC, 0x62, 0x19, 0x38, 0x3F, 0x80, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x07, 0xC0, 0x30, 0xC6, 0x04, 0x08, 0x20, 0xC1, 0x82, 0x18, 0x18,
  0x63, 0x01, 0x04, 0x20, 0x10, 0x44, 0x01, 0x8C, 0x80, 0x0F, 0x90, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x9F, 0x80, 0x13, 0x08,
  0x02, 0x20, 0x80, 0x42, 0x08, 0x0C, 0x20, 0x81, 0x86, 0x18, 0x30, 0x61,
  0x02, 0x02, 0x30, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xCC, 0x03, 0x08, 0x34, 0x18, 0xC8, 0x19, 0x10, 0x36, 0x60, 0x38,
  0xC0, 0x21, 0x80, 0xE3, 0x03, 0x63, 0x1C, 0x47, 0xE0, 0xC0, 0x6B, 0x6D,
  0xB4, 0x80, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x02, 0x00, 0x08, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x1C, 0x21, 0xDE, 0x5F, 0x0F, 0xF0, 0x03, 0x00, 0x0A,
  0x00, 0x36, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x0C, 0x10, 0x18, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x1F, 0xFF, 0x80,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x1C, 0xE3,
  0x0C, 0x61, 0x8C, 0x20, 0x80, 0xFF, 0xC0, 0x73, 0xDE, 0xE0, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0xCC, 0x03, 0x30,
  0x0C, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x60, 0x09, 0x8C, 0x26, 0x39, 0x98,
  0xC6, 0x40, 0x19, 0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xC6,
  0x06, 0x1C, 0x30, 0x3F, 0x80, 0x01, 0xC0, 0x34, 0x0E, 0x41, 0x8C, 0x30,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0xFF,
  0xF0, 0x07, 0xF0, 0x30, 0x61, 0x00, 0xCC, 0x03, 0x20, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x18,
  0x30, 0x3F, 0x00, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0xC6, 0x04, 0x60, 0x26, 0x01,
  0x20, 0x09, 0x00, 0xDF, 0xFE, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x1F, 0xFC, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0xF0, 0x3E, 0xF0, 0xC0, 0xC3, 0x01, 0x88, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0xC0, 0x33, 0x00, 0x84, 0x06, 0x18,
  0x30, 0x3F, 0x80, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x1B, 0xC1, 0xFF, 0x0C, 0x0C, 0xC0, 0x34, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x16, 0x01, 0x90, 0x18, 0xC1, 0x83,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x05, 0x80, 0x68, 0x02, 0x40, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x31,
  0x00, 0x86, 0x04, 0x0C, 0x60, 0x1F, 0x00, 0x78, 0x06, 0x18, 0x30, 0x31,
  0x80, 0xC4, 0x01, 0x30, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x02, 0x18, 0x30,
  0x3F, 0x80, 0x0F, 0xE0, 0xC1, 0x8C, 0x06, 0xC0, 0x34, 0x00, 0xA0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x12, 0x01, 0x98, 0x18, 0x7F, 0xC0, 0xCC, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x1E, 0x3C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0F, 0x1E, 0x38, 0x0F, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x80, 0x80,
  0x00, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x10,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x80, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x20, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x01, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x30, 0xF8, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x03, 0xFC, 0x06,
  0x06, 0x0C, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20,
  0x7B, 0x21, 0xC7, 0x61, 0x02, 0x63, 0x02, 0x63, 0x02, 0x43, 0x06, 0x42,
  0x06, 0x42, 0x06, 0xC2, 0x04, 0xC2, 0x0C, 0xC3, 0x0C, 0x83, 0xF4, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F,
  0x80, 0x00, 0x60, 0x05, 0x00, 0x28, 0x03, 0x40, 0x12, 0x01, 0x90, 0x08,
  0x80, 0x46, 0x06, 0x30, 0x21, 0x83, 0x04, 0x10, 0x21, 0x81, 0x08, 0x08,
  0x7F, 0xC6, 0x03, 0x20, 0x1B, 0x00, 0xD0, 0x07, 0x80, 0x18, 0x00, 0x80,
  0x1F, 0xF0, 0x40, 0xE1, 0x00, 0x84, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00,
  0x8C, 0x06, 0x20, 0x30, 0xFF, 0x83, 0xFE, 0x18, 0x0C, 0x60, 0x11, 0x80,
  0x64, 0x01, 0x90, 0x06, 0x40, 0x13, 0x00, 0xCC, 0x06, 0x30, 0x70, 0xFF,
  0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x03, 0x30, 0x04, 0xC0, 0x33,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x04, 0x40, 0x11, 0x00, 0xC6, 0x06, 0x1C, 0x30,
  0x3F, 0x80, 0x1F, 0xE0, 0x40, 0xC1, 0x01, 0x84, 0x02, 0x10, 0x0C, 0xC0,
  0x33, 0x00, 0x8C, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x98, 0x06, 0x60,
  0x11, 0x80, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x33, 0x01, 0x8C, 0x0C, 0x30,
  0xE0, 0xFE, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0xFF, 0xC1,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0xFF, 0xE1, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xF0, 0x30, 0x61, 0x80, 0xC4, 0x03, 0x30, 0x04, 0xC0, 0x33, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0xFE, 0x60, 0x19, 0x00, 0x64,
  0x01, 0x90, 0x04, 0x40, 0x11, 0x00, 0xC6, 0x06, 0x1C, 0x30, 0x3F, 0x80,
  0x18, 0x04, 0x40, 0x11, 0x00, 0xC4, 0x03, 0x10, 0x0C, 0xC0, 0x23, 0x00,
  0x8C, 0x02, 0x20, 0x18, 0xFF, 0xE3, 0xFF, 0x98, 0x04, 0x60, 0x11, 0x80,
  0x44, 0x03, 0x10, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x08, 0x80,
  0x60, 0x1F, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x61,
  0x80, 0x83, 0x86, 0x03, 0xF8, 0x00, 0x18, 0x06, 0x20, 0x08, 0x40, 0x30,
  0x80, 0xC1, 0x01, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x20, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0x04, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x10, 0x20, 0x30,
  0x40, 0x61, 0x80, 0x43, 0x00, 0xC6, 0x01, 0x88, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x0A,
  0x1E, 0x0A, 0x12, 0x12, 0x12, 0x16, 0x12, 0x26, 0x12, 0x26, 0x31, 0x44,
  0x31, 0x44, 0x21, 0x84, 0x21, 0x84, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x08,
  0x60, 0x08, 0x60, 0x08, 0x40, 0x08, 0x40, 0x18, 0x40, 0x18, 0xC0, 0x18,
  0x18, 0x04, 0x70, 0x11, 0x40, 0xC5, 0x03, 0x14, 0x0C, 0xD8, 0x23, 0x20,
  0x88, 0x82, 0x22, 0x08, 0x8C, 0x62, 0x31, 0x98, 0x44, 0x61, 0x11, 0x84,
  0x44, 0x19, 0x10, 0x2C, 0x40, 0xB3, 0x02, 0xCC, 0x0E, 0x30, 0x18, 0x80,
  0x60, 0x07, 0xF0, 0x30, 0x61, 0x80, 0x84, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x11,
  0x00, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x06, 0x18, 0x30,
  0x3F, 0x80, 0x1F, 0xF8, 0x20, 0x38, 0x40, 0x10, 0x80, 0x31, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x18, 0x02, 0x20, 0x0C, 0x40, 0x30, 0xFF, 0xC3, 0xFC,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x30, 0x61, 0x80, 0x84,
  0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x66,
  0x01, 0x98, 0x06, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x31,
  0x00, 0x86, 0x06, 0x1C, 0x30, 0x3F, 0x80, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x1F, 0xF0, 0x20, 0x38, 0x40, 0x30, 0x80, 0x21,
  0x00, 0x46, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x20, 0x08, 0x40, 0x60, 0xFF,
  0x83, 0x0C, 0x06, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x41,
  0x80, 0xC3, 0x00, 0x86, 0x01, 0x08, 0x03, 0x00, 0x07, 0xF0, 0x30, 0x61,
  0x80, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x80, 0x13, 0x00, 0xCC, 0x02, 0x18, 0x38, 0x3F, 0x80, 0xFF, 0xFC, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x18, 0x04,
  0x40, 0x11, 0x00, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x23, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x11, 0x80, 0x44, 0x01,
  0x10, 0x0C, 0x40, 0x31, 0x00, 0x86, 0x06, 0x1C, 0x30, 0x3F, 0x80, 0xC0,
  0x0F, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x06, 0x10,
  0x10, 0x40, 0xC1, 0x82, 0x06, 0x18, 0x18, 0x40, 0x21, 0x00, 0x8C, 0x02,
  0x20, 0x09, 0x80, 0x24, 0x00, 0xB0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0xC1, 0x41, 0xC3, 0x41, 0x43, 0x41, 0x42, 0x43, 0x42, 0x42, 0x46,
  0x42, 0x44, 0x42, 0x44, 0x44, 0xC4, 0x44, 0xCC, 0x44, 0xC8, 0x48, 0x88,
  0x48, 0x98, 0x48, 0x90, 0x58, 0x90, 0x50, 0x90, 0x50, 0xB0, 0x50, 0xA0,
  0x60, 0xA0, 0x60, 0xE0, 0xE0, 0xC0, 0x0C, 0x01, 0xC1, 0x00, 0x40, 0x60,
  0x30, 0x08, 0x18, 0x02, 0x04, 0x00, 0xC2, 0x00, 0x11, 0x80, 0x06, 0xC0,
  0x00, 0xA0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x20, 0x00,
  0x8C, 0x00, 0x61, 0x00, 0x30, 0x40, 0x08, 0x18, 0x04, 0x02, 0x03, 0x00,
  0xC1, 0x80, 0x30, 0xC0, 0x06, 0x00, 0x80, 0x0F, 0x00, 0x6C, 0x01, 0x10,
  0x0C, 0x60, 0x61, 0x81, 0x02, 0x0C, 0x0C, 0x60, 0x31, 0x00, 0x4C, 0x01,
  0xE0, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xC2, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x0F, 0xC0, 0xC0, 0x40, 0x40,
  0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03,
  0x0F, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC3,
  0xF0, 0x00, 0x01, 0x80, 0x38, 0x06, 0x80, 0x4C, 0x0C, 0xC0, 0x84, 0x18,
  0x43, 0x06, 0x30, 0x66, 0x02, 0xC0, 0x30, 0xFF, 0xFC, 0xC6, 0x23, 0x07,
  0xC8, 0xE1, 0x44, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x0C, 0x80, 0x64, 0x02, 0x20, 0x31, 0x82, 0x87,
  0xEC, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x1B, 0xF0, 0xF0,
  0xC6, 0x03, 0x30, 0x19, 0x00, 0xC8, 0x06, 0xC0, 0x36, 0x01, 0x30, 0x09,
  0x00, 0x48, 0x06, 0x40, 0x36, 0x01, 0x38, 0x19, 0xE1, 0x89, 0xF8, 0x00,
  0x07, 0xE0, 0xE1, 0x84, 0x06, 0x60, 0x32, 0x00, 0xB0, 0x09, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x64, 0x03, 0x30, 0x31, 0xC3,
  0x07, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x1F,
  0x21, 0xC2, 0x84, 0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x98, 0x04, 0x60,
  0x11, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x31, 0x00, 0xC4, 0x06, 0x18,
  0x28, 0x3F, 0x60, 0x07, 0xE0, 0xE1, 0x84, 0x06, 0x60, 0x32, 0x01, 0xB0,
  0x0D, 0x80, 0x6F, 0xFE, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x03,
  0x20, 0x31, 0x83, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x3F, 0xFE, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC8, 0xE1, 0x44, 0x06, 0x60, 0x32, 0x01,
  0xB0, 0x0D, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x01, 0x90, 0x0C, 0x80, 0x66,
  0x07, 0x1D, 0xD0, 0x78, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x03,
  0x87, 0xF0, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x1B,
  0xF0, 0xF0, 0xC6, 0x03, 0x30, 0x19, 0x00, 0xC8, 0x06, 0xC0, 0x36, 0x01,
  0x30, 0x09, 0x00, 0x48, 0x06, 0x40, 0x36, 0x01, 0xB0, 0x09, 0x80, 0x48,
  0x02, 0x00, 0x00, 0x70, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x7F, 0xFC, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F,
  0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x01, 0xCC, 0x06, 0x18, 0x08, 0x20, 0x30, 0x40, 0xC0, 0x83, 0x03, 0x0C,
  0x07, 0xF0, 0x0C, 0x20, 0x10, 0x60, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x83,
  0x01, 0x86, 0x01, 0x0C, 0x03, 0x00, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x81,
  0x0F, 0xE0, 0x37, 0xBC, 0x73, 0x8C, 0xC2, 0x19, 0x04, 0x32, 0x08, 0x64,
  0x30, 0xD8, 0x61, 0x30, 0x82, 0x61, 0x04, 0x82, 0x19, 0x04, 0x32, 0x18,
  0x64, 0x30, 0x98, 0x61, 0x30, 0x82, 0x61, 0x0C, 0x37, 0xE1, 0xE1, 0x8C,
  0x06, 0x60, 0x32, 0x01, 0x90, 0x0D, 0x80, 0x6C, 0x02, 0x60, 0x12, 0x00,
  0x90, 0x0C, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x00, 0x90, 0x04, 0x07, 0xE0,
  0xE1, 0x84, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x0C, 0x80, 0x64, 0x02, 0x20, 0x31, 0x83, 0x07, 0xF0,
  0x1B, 0xF0, 0x78, 0x61, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0x40, 0x33, 0x00,
  0xCC, 0x02, 0x30, 0x08, 0x80, 0x22, 0x01, 0x88, 0x06, 0x60, 0x11, 0xC0,
  0xC7, 0x86, 0x13, 0xF0, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x07, 0xC8, 0xE1, 0x44, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80,
  0x4C, 0x02, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x80, 0x64, 0x02, 0x20, 0x31,
  0x82, 0x87, 0xE4, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x13, 0xF0, 0x50, 0xE1, 0x81, 0x8C, 0x02, 0x30, 0x0C, 0xC0, 0x22, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0xC1, 0xCC, 0x06, 0x40, 0x12, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x2C,
  0x03, 0x60, 0x19, 0x81, 0x87, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x0F, 0xFF, 0x82, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x1F, 0x80, 0x30, 0x0C, 0xC0, 0x22, 0x00, 0x88, 0x02, 0x20, 0x18,
  0x80, 0x66, 0x01, 0x98, 0x04, 0x60, 0x11, 0x00, 0x44, 0x03, 0x10, 0x0C,
  0x40, 0x21, 0x81, 0x87, 0x0C, 0x0F, 0xE0, 0xC0, 0x0A, 0x00, 0xD0, 0x04,
  0xC0, 0x66, 0x02, 0x10, 0x30, 0x81, 0x04, 0x18, 0x20, 0x81, 0x8C, 0x0C,
  0x40, 0x26, 0x01, 0x20, 0x0B, 0x00, 0x50, 0x03, 0x80, 0x83, 0x06, 0x0C,
  0x38, 0x50, 0xA1, 0x42, 0x85, 0x1A, 0x24, 0x48, 0x91, 0x22, 0x4C, 0x91,
  0x22, 0x44, 0x8B, 0x16, 0x28, 0x50, 0xA1, 0x43, 0x87, 0x0C, 0x18, 0x30,
  0x60, 0x18, 0x06, 0x10, 0x18, 0x30, 0x60, 0x20, 0x80, 0x62, 0x00, 0x4C,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x43, 0x01,
  0x82, 0x06, 0x06, 0x18, 0x04, 0x60, 0x0C, 0x30, 0x09, 0x00, 0x48, 0x06,
  0x40, 0x36, 0x01, 0xB0, 0x09, 0x80, 0x48, 0x02, 0x40, 0x32, 0x01, 0x90,
  0x0C, 0x80, 0xC6, 0x06, 0x1D, 0xD0, 0x78, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x03, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x0C, 0x30, 0xC2, 0x08,
  0x21, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x18, 0x61,
  0x84, 0x10, 0x43, 0x0C, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x01, 0xF0, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x0F, 0x80, 0x00, 0x1C, 0x0D, 0x98, 0x24, 0x30, 0x90, 0x42,
  0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 21, 17, 6, -21 },
  { 17, 9, 9, 17, 6, -21 },
  { 28, 16, 21, 17, 1, -21 },
  { 70, 14, 29, 17, 2, -25 },
  { 121, 20, 21, 17, -1, -21 },
  { 174, 15, 21, 17, 1, -21 },
  { 214, 3, 9, 17, 9, -21 },
  { 218, 12, 29, 17, 5, -25 },
  { 262, 12, 29, 17, 1, -25 },
  { 306, 15, 15, 17, 2, -18 },
  { 335, 14, 13, 17, 2, -16 },
  { 358, 6, 9, 17, 4, -4 },
  { 365, 10, 1, 17, 4, -10 },
  { 367, 5, 4, 17, 5, -4 },
  { 370, 16, 27, 17, 1, -24 },
  { 424, 14, 21, 17, 2, -21 },
  { 461, 12, 21, 17, 2, -21 },
  { 493, 14, 21, 17, 2, -21 },
  { 530, 14, 21, 17, 2, -21 },
  { 567, 13, 21, 17, 2, -21 },
  { 602, 14, 21, 17, 2, -21 },
  { 639, 13, 21, 17, 2, -21 },
  { 674, 13, 21, 17, 4, -21 },
  { 709, 14, 21, 17, 2, -21 },
  { 746, 13, 21, 17, 3, -21 },
  { 781, 7, 16, 17, 5, -16 },
  { 795, 8, 21, 17, 4, -16 },
  { 816, 13, 15, 17, 3, -17 },
  { 841, 14, 8, 17, 2, -14 },
  { 855, 13, 15, 17, 2, -17 },
  { 880, 11, 21, 17, 5, -21 },
  { 909, 16, 26, 17, 1, -21 },
  { 961, 13, 21, 17, 1, -21 },
  { 996, 14, 21, 17, 2, -21 },
  { 1033, 14, 21, 17, 2, -21 },
  { 1070, 14, 21, 17, 2, -21 },
  { 1107, 15, 21, 17, 2, -21 },
  { 1147, 15, 21, 17, 2, -21 },
  { 1187, 14, 21, 17, 2, -21 },
  { 1224, 14, 21, 17, 2, -21 },
  { 1261, 14, 21, 17, 2, -21 },
  { 1298, 15, 21, 17, 1, -21 },
  { 1338, 15, 21, 17, 2, -21 },
  { 1378, 12, 21, 17, 2, -21 },
  { 1410, 16, 21, 17, 1, -21 },
  { 1452, 14, 21, 17, 2, -21 },
  { 1489, 14, 21, 17, 2, -21 },
  { 1526, 15, 21, 17, 2, -21 },
  { 1566, 14, 26, 17, 2, -21 },
  { 1612, 15, 21, 17, 2, -21 },
  { 1652, 14, 21, 17, 2, -21 },
  { 1689, 14, 21, 17, 4, -21 },
  { 1726, 14, 21, 17, 2, -21 },
  { 1763, 14, 21, 17, 4, -21 },
  { 1800, 16, 21, 17, 2, -21 },
  { 1842, 18, 21, 17, 0, -21 },
  { 1890, 14, 21, 17, 4, -21 },
  { 1927, 15, 21, 17, 1, -21 },
  { 1967, 10, 27, 17, 5, -24 },
  { 2001, 8, 27, 17, 5, -24 },
  { 2028, 11, 27, 17, 3, -24 },
  { 2066, 12, 11, 17, 3, -21 },
  { 2083, 14, 1, 17, 0, 1 },
  { 2085, 4, 4, 17, 8, -23 },
  { 2087, 13, 16, 17, 2, -16 },
  { 2113, 13, 21, 17, 2, -21 },
  { 2148, 13, 16, 17, 2, -16 },
  { 2174, 14, 21, 17, 2, -21 },
  { 2211, 13, 16, 17, 2, -16 },
  { 2237, 18, 26, 17, -1, -21 },
  { 2296, 13, 21, 17, 2, -16 },
  { 2331, 13, 21, 17, 2, -21 },
  { 2366, 13, 22, 17, 1, -22 },
  { 2402, 14, 27, 17, 1, -22 },
  { 2450, 15, 21, 17, 2, -21 },
  { 2490, 12, 21, 17, 3, -21 },
  { 2522, 15, 16, 17, 1, -16 },
  { 2552, 13, 16, 17, 2, -16 },
  { 2578, 13, 16, 17, 2, -16 },
  { 2604, 14, 21, 17, 1, -16 },
  { 2641, 13, 21, 17, 2, -16 },
  { 2676, 14, 16, 17, 2, -16 },
  { 2704, 13, 16, 17, 2, -16 },
  { 2730, 13, 20, 17, 3, -20 },
  { 2763, 14, 16, 17, 2, -16 },
  { 2791, 13, 16, 17, 3, -16 },
  { 2817, 14, 16, 17, 3, -16 },
  { 2845, 15, 16, 17, 1, -16 },
  { 2875, 13, 21, 17, 2, -16 },
  { 2910, 13, 16, 17, 2, -16 },
  { 2936, 14, 27, 17, 3, -24 },
  { 2984, 6, 27, 17, 6, -24 },
  { 3005, 14, 27, 17, 1, -24 },
  { 3053, 14, 5, 17, 2, -13 },
};

const GFXfont JetBrainsMono_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_THINITALIC29PT7B_H_
