#ifndef _JETBRAINSMONO_THINITALIC39PT7B_H_
#define _JETBRAINSMONO_THINITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x70, 0x77, 0x06, 0x60, 0x66, 0x0E, 0x60,
  0xEE, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x31, 0x1F, 0xFF, 0xFC,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x38, 0x9C, 0x07, 0x18, 0xE0, 0x61, 0x86, 0x0C, 0x18, 0x60, 0xC1,
  0x87, 0x0C, 0x10, 0x60, 0xC1, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0E,
  0x30, 0x00, 0x73, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x06, 0x70, 0x00, 0x63, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x04, 0x0C,
  0x00, 0x40, 0xC6, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3,
  0x03, 0x08, 0x60, 0x3E, 0xBC, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x30, 0x30, 0xC0, 0x18, 0x18, 0x30, 0x0C, 0x04, 0x04,
  0x06, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC1, 0x80, 0x30, 0x30, 0x40, 0x0C,
  0x0C, 0x30, 0x03, 0x02, 0x18, 0x00, 0xC1, 0x8C, 0x00, 0x38, 0xC6, 0x00,
  0x07, 0xE3, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0xF8, 0x00, 0x0C, 0x7F, 0x00, 0x06, 0x30, 0xC0, 0x03,
  0x18, 0x18, 0x01, 0x86, 0x06, 0x00, 0xC1, 0x01, 0x80, 0x30, 0x40, 0x40,
  0x18, 0x30, 0x10, 0x0C, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x00, 0xC1,
  0x81, 0x80, 0x1D, 0xE0, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x08, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x73, 0x80, 0x07,
  0x0C, 0x07, 0x30, 0x30, 0x31, 0x81, 0x83, 0x18, 0x06, 0x30, 0xC0, 0x39,
  0x86, 0x00, 0xD8, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60,
  0x0F, 0x03, 0x00, 0xCC, 0x1C, 0x0C, 0x30, 0xFB, 0xC1, 0x83, 0xFC, 0x06,
  0x00, 0x76, 0x66, 0xEE, 0xEC, 0xCC, 0xC0, 0x00, 0x02, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x02, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00,
  0xC0, 0x4F, 0x06, 0x1E, 0xFE, 0x23, 0xF8, 0x7D, 0x7C, 0x00, 0x7F, 0x00,
  0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0xCC, 0x00, 0x1C, 0x60, 0x00, 0xC3,
  0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x20, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x30, 0x60, 0x60, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xFF, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x07, 0x00,
  0xE0, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xE1, 0xC3,
  0x98, 0x78, 0x63, 0x07, 0x0C, 0x60, 0x41, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x70, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x38,
  0xE0, 0x06, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x71, 0x80, 0x70, 0xC0, 0x60,
  0x60, 0x20, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x0E, 0x0C, 0x00,
  0x60, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x06, 0x07,
  0xCF, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x18, 0x60, 0x0C, 0x70, 0x0C,
  0x70, 0x06, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x6F, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xE1, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x0F, 0x00, 0x6F, 0xF8, 0x1B, 0x07, 0x83, 0xC0, 0x30, 0x70,
  0x06, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xE0, 0x0C, 0x0C, 0x03, 0x80, 0xF3, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xBF,
  0x81, 0xFF, 0xE1, 0xE0, 0x38, 0xC0, 0x0C, 0xE0, 0x07, 0x60, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x0C, 0xE0, 0x0E, 0x38, 0x0E, 0x0F, 0x3E, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF6, 0x00, 0x1F, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0E,
  0x06, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x0C, 0x0E, 0x00, 0xC0, 0x60, 0x38, 0x03, 0x8E, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x39, 0xC0, 0x0E, 0x06, 0x01, 0xC0, 0x30, 0x38,
  0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x30, 0x06, 0x03, 0xE7, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xE0, 0x70, 0x70, 0x0E,
  0x38, 0x01, 0x8C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00, 0xC7, 0x00,
  0xF0, 0xF0, 0x78, 0x1F, 0xEC, 0x00, 0xE6, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x07, 0x07, 0xC7,
  0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x8F, 0xC3, 0xC0, 0x01, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x06,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x0F, 0xE0, 0x0F, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x78, 0x86, 0x07, 0xFE, 0x30,
  0x38, 0x38, 0xC0, 0xC0, 0x63, 0x06, 0x01, 0x8C, 0x18, 0x06, 0x30, 0x60,
  0x18, 0xC1, 0x80, 0xC6, 0x0C, 0x03, 0x18, 0x30, 0x0C, 0x60, 0xC0, 0x31,
  0x83, 0x00, 0xC6, 0x0C, 0x07, 0x18, 0x30, 0x18, 0xC0, 0xE0, 0xA3, 0x01,
  0xFD, 0x8C, 0x03, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x58, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC0,
  0xC0, 0x30, 0x10, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xFF, 0xF8,
  0x3F, 0xFE, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0x0F, 0xFF, 0x01, 0x81,
  0xF0, 0x30, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x03,
  0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0C, 0x07, 0x81, 0x80, 0x38, 0x60, 0x03,
  0x0C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x03, 0x83, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x03, 0x00,
  0x60, 0xC0, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0x60, 0x06, 0x0C, 0x00, 0xC1, 0xC0, 0x70, 0x1F, 0x7C, 0x01, 0xFE, 0x00,
  0x0F, 0xFE, 0x03, 0x07, 0xC0, 0xC0, 0x38, 0x60, 0x06, 0x18, 0x01, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x0E, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30,
  0x01, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x86, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x03,
  0xFC, 0x60, 0xFF, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00,
  0xC1, 0xC0, 0x70, 0x1F, 0x7C, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0C, 0x00, 0x61, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x06, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60,
  0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x3C, 0xF8, 0x01, 0xFE, 0x00, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00, 0xC1, 0x80,
  0x18, 0x18, 0x03, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x30, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0x03, 0x00, 0x20, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x78, 0x78, 0x02,
  0x83, 0xC0, 0x3C, 0x1A, 0x01, 0x60, 0x90, 0x1B, 0x0C, 0x80, 0x98, 0x66,
  0x0C, 0xC3, 0x30, 0xCC, 0x18, 0x86, 0x60, 0xC4, 0x63, 0x06, 0x23, 0x18,
  0x61, 0xB0, 0xC3, 0x0D, 0x86, 0x18, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x61,
  0xC0, 0x0C, 0x28, 0x01, 0x0D, 0x80, 0x61, 0xB0, 0x0C, 0x36, 0x01, 0x86,
  0x40, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC6, 0x30, 0x30, 0xC2, 0x06, 0x18,
  0x60, 0xC3, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x10, 0x61, 0x03, 0x18, 0x60,
  0x63, 0x0C, 0x0C, 0x61, 0x81, 0x8C, 0x30, 0x19, 0x86, 0x03, 0x30, 0xC0,
  0x64, 0x30, 0x0D, 0x86, 0x00, 0xB0, 0xC0, 0x1E, 0x18, 0x03, 0xC3, 0x00,
  0x78, 0x60, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x70, 0x38, 0x18,
  0x07, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06,
  0x18, 0x03, 0x07, 0x01, 0xC0, 0xF3, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0xC0, 0x7C, 0x0C, 0x00, 0xE1, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80,
  0x03, 0x18, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0xC3, 0x00, 0x1C, 0x30, 0x03, 0x83, 0x01, 0xF0, 0x3F, 0xFC, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x70, 0x38, 0x18, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x18, 0x60, 0x06, 0x18, 0x03, 0x07, 0x01, 0xC0, 0xF3, 0xE0, 0x1F,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0x01, 0x80, 0xF8, 0x30, 0x03,
  0x0C, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x80,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x06, 0x06, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x86, 0x00, 0x30, 0x70, 0x06, 0x03, 0xE7, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C,
  0x10, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0E, 0x03, 0x00, 0xF3, 0xC0,
  0x0F, 0xF0, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x02, 0x0C, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x01, 0x88, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x40, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x60, 0x38,
  0x1D, 0x80, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x60, 0x58, 0x31,
  0x83, 0x60, 0xC6, 0x0D, 0x83, 0x18, 0x26, 0x08, 0x60, 0x98, 0x61, 0x86,
  0x61, 0x86, 0x19, 0x86, 0x18, 0x46, 0x30, 0x63, 0x18, 0xC1, 0x8C, 0x63,
  0x06, 0x21, 0x08, 0x19, 0x84, 0x60, 0x66, 0x11, 0x81, 0x10, 0x46, 0x04,
  0x41, 0x10, 0x13, 0x04, 0xC0, 0x48, 0x13, 0x01, 0x20, 0x48, 0x05, 0x81,
  0x60, 0x14, 0x05, 0x80, 0xD0, 0x16, 0x03, 0xC0, 0x50, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x07, 0x00, 0x07, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x23, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x74, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x83, 0x00, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0E, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60,
  0xE0, 0x00, 0x70, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x07, 0xFC, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x07, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xD0, 0x01, 0x98,
  0x01, 0x98, 0x03, 0x18, 0x07, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x1C, 0x0C,
  0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC1, 0x87, 0x0C, 0x18, 0x70, 0x00, 0xF0, 0x01, 0xFF,
  0x30, 0xE0, 0x68, 0x70, 0x0E, 0x18, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x20, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x38, 0x01,
  0x86, 0x00, 0xE1, 0xC0, 0x58, 0x3C, 0xF6, 0x07, 0xF3, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x61,
  0xE0, 0x37, 0xFC, 0x1E, 0x07, 0x1E, 0x01, 0x8E, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x19, 0xC0,
  0x0C, 0xE0, 0x0C, 0x78, 0x0E, 0x37, 0x1E, 0x19, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0xE0, 0x70, 0x70, 0x0E, 0x18, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0xC0, 0x03,
  0x18, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x70, 0x3E, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x3C, 0x30, 0x3F, 0xE6, 0x0E, 0x06, 0xC3, 0x80, 0x70,
  0x60, 0x0E, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x63,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x87, 0x00, 0x30, 0x60, 0x0E, 0x0E,
  0x02, 0xC0, 0xF3, 0xD8, 0x0F, 0xE6, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03,
  0x81, 0xC3, 0x80, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x20, 0x01, 0xB0, 0x00, 0xDF, 0xFF, 0xCF, 0xFF, 0xE6, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x18, 0x03, 0x0E,
  0x03, 0x83, 0xC7, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x30, 0xE0, 0x68, 0x70, 0x0E,
  0x18, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x98,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x71, 0x80, 0x18, 0x60, 0x0E, 0x1C, 0x07, 0x83, 0xC7, 0x60, 0x7F, 0x98,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x61, 0xE0,
  0x33, 0xFC, 0x1E, 0x07, 0x1A, 0x01, 0x8E, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x08, 0xC0, 0x06,
  0x18, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x00, 0xC0,
  0x60, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0x81, 0x80, 0x30, 0x38, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x06,
  0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x80,
  0x7F, 0xC0, 0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xE1, 0xE0, 0x5F,
  0x9F, 0x87, 0x8F, 0x0C, 0x38, 0x30, 0x61, 0x81, 0x83, 0x0C, 0x0C, 0x18,
  0x60, 0xC0, 0xC3, 0x06, 0x06, 0x30, 0x30, 0x31, 0x81, 0x81, 0x8C, 0x0C,
  0x18, 0x60, 0x60, 0xC3, 0x02, 0x06, 0x18, 0x30, 0x30, 0x81, 0x81, 0x8C,
  0x0C, 0x0C, 0x60, 0x60, 0x43, 0x03, 0x06, 0x18, 0x10, 0x30, 0xC1, 0x81,
  0x86, 0x0C, 0x0C, 0x60, 0x60, 0x60, 0x00, 0x78, 0x0C, 0xFF, 0x07, 0x81,
  0xC6, 0x80, 0x63, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x30, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0x81, 0xC3,
  0x80, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x20, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0D, 0x80, 0x06, 0xC0, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0E, 0x03, 0x83,
  0xCF, 0x80, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0xDF, 0xF0, 0x1E, 0x07, 0x07,
  0x80, 0x60, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x01, 0x87, 0x00, 0x30, 0xE0,
  0x0C, 0x1E, 0x03, 0x83, 0x71, 0xE0, 0x67, 0xF0, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0x30, 0xE0, 0x68, 0x70, 0x0E, 0x18, 0x03,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x98, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x18, 0xC0, 0x06, 0x38, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x58, 0x3C, 0xF6,
  0x07, 0xF1, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x7C, 0x06, 0x7F, 0xC1,
  0xB0, 0x38, 0x78, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40,
  0x03, 0x30, 0x01, 0xCC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xE0, 0x38, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x63, 0x80, 0x38, 0x78, 0x3C, 0x0F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03,
  0xFF, 0xFE, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x18, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18,
  0x03, 0x07, 0x01, 0x80, 0xF3, 0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0xE0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x30, 0x60, 0x18, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x86, 0x00, 0x43, 0x00, 0x23, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x06,
  0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x70, 0x18, 0x0A, 0x07,
  0x03, 0x40, 0xA0, 0x68, 0x16, 0x0D, 0x06, 0xC3, 0x20, 0x98, 0x64, 0x13,
  0x0C, 0x86, 0x63, 0x10, 0x8C, 0x62, 0x31, 0x8C, 0x46, 0x33, 0x0C, 0x86,
  0x61, 0xB0, 0xCC, 0x36, 0x1B, 0x06, 0x83, 0x60, 0xF0, 0x6C, 0x1E, 0x0F,
  0x02, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x30,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC3, 0x80,
  0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0xE0, 0x03,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x38, 0x70, 0x16, 0x0F, 0x1D, 0x81, 0xFC, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xCC, 0xE0,
  0x36, 0x0C, 0x0D, 0x83, 0x02, 0x40, 0x61, 0xB0, 0x0F, 0xCC, 0x01, 0xE0,
};

const GFXglyph JetBrainsMono_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 8, 28, 23, 8, -28 },
  { 29, 12, 11, 23, 8, -28 },
  { 46, 23, 28, 23, 1, -28 },
  { 127, 20, 39, 23, 2, -34 },
  { 225, 26, 29, 23, -1, -29 },
  { 320, 21, 29, 23, 1, -29 },
  { 397, 4, 11, 23, 12, -28 },
  { 403, 15, 38, 23, 7, -33 },
  { 475, 15, 38, 23, 2, -33 },
  { 547, 21, 20, 23, 2, -24 },
  { 600, 18, 18, 23, 3, -22 },
  { 641, 8, 12, 23, 5, -6 },
  { 653, 12, 2, 23, 6, -14 },
  { 656, 6, 5, 23, 7, -5 },
  { 660, 22, 36, 23, 1, -32 },
  { 759, 19, 29, 23, 3, -29 },
  { 828, 17, 28, 23, 2, -28 },
  { 888, 20, 29, 23, 2, -29 },
  { 961, 18, 28, 23, 3, -28 },
  { 1024, 17, 28, 23, 3, -28 },
  { 1084, 19, 28, 23, 3, -28 },
  { 1151, 17, 28, 23, 3, -28 },
  { 1211, 18, 28, 23, 5, -28 },
  { 1274, 20, 29, 23, 2, -29 },
  { 1347, 18, 29, 23, 4, -29 },
  { 1413, 9, 22, 23, 7, -22 },
  { 1438, 11, 28, 23, 5, -22 },
  { 1477, 18, 20, 23, 4, -23 },
  { 1522, 18, 10, 23, 3, -18 },
  { 1545, 18, 20, 23, 2, -23 },
  { 1590, 16, 28, 23, 6, -28 },
  { 1646, 22, 36, 23, 1, -29 },
  { 1745, 18, 28, 23, 1, -28 },
  { 1808, 19, 28, 23, 3, -28 },
  { 1875, 19, 29, 23, 3, -29 },
  { 1944, 18, 28, 23, 3, -28 },
  { 2007, 20, 28, 23, 3, -28 },
  { 2077, 20, 28, 23, 3, -28 },
  { 2147, 19, 29, 23, 3, -29 },
  { 2216, 19, 28, 23, 3, -28 },
  { 2283, 19, 29, 23, 3, -29 },
  { 2352, 20, 28, 23, 2, -28 },
  { 2422, 20, 29, 23, 3, -29 },
  { 2495, 16, 28, 23, 3, -28 },
  { 2551, 21, 28, 23, 2, -28 },
  { 2625, 19, 28, 23, 3, -28 },
  { 2692, 18, 29, 23, 3, -29 },
  { 2758, 20, 28, 23, 3, -28 },
  { 2828, 18, 36, 23, 3, -29 },
  { 2909, 19, 28, 23, 3, -28 },
  { 2976, 20, 29, 23, 2, -29 },
  { 3049, 19, 28, 23, 5, -28 },
  { 3116, 19, 28, 23, 3, -28 },
  { 3183, 19, 28, 23, 5, -28 },
  { 3250, 22, 28, 23, 3, -28 },
  { 3327, 24, 28, 23, 0, -28 },
  { 3411, 19, 28, 23, 5, -28 },
  { 3478, 20, 28, 23, 2, -28 },
  { 3548, 15, 36, 23, 6, -32 },
  { 3616, 10, 36, 23, 7, -32 },
  { 3661, 14, 36, 23, 4, -32 },
  { 3724, 16, 15, 23, 4, -28 },
  { 3754, 19, 2, 23, 0, 1 },
  { 3759, 6, 6, 23, 11, -31 },
  { 3764, 18, 22, 23, 3, -22 },
  { 3814, 17, 28, 23, 3, -28 },
  { 3874, 18, 22, 23, 3, -22 },
  { 3924, 19, 28, 23, 3, -28 },
  { 3991, 17, 22, 23, 3, -22 },
  { 4038, 24, 35, 23, -1, -28 },
  { 4143, 18, 29, 23, 3, -22 },
  { 4209, 17, 28, 23, 3, -28 },
  { 4269, 17, 30, 23, 2, -30 },
  { 4333, 19, 37, 23, 1, -30 },
  { 4421, 19, 28, 23, 3, -28 },
  { 4488, 16, 28, 23, 4, -28 },
  { 4544, 21, 22, 23, 1, -22 },
  { 4602, 17, 22, 23, 3, -22 },
  { 4649, 17, 22, 23, 3, -22 },
  { 4696, 19, 29, 23, 1, -22 },
  { 4765, 18, 29, 23, 3, -22 },
  { 4831, 18, 22, 23, 3, -22 },
  { 4881, 18, 22, 23, 3, -22 },
  { 4931, 17, 27, 23, 4, -27 },
  { 4989, 18, 21, 23, 3, -21 },
  { 5037, 17, 21, 23, 5, -21 },
  { 5082, 19, 21, 23, 4, -21 },
  { 5132, 21, 21, 23, 1, -21 },
  { 5188, 18, 28, 23, 3, -21 },
  { 5251, 19, 21, 23, 2, -21 },
  { 5301, 19, 36, 23, 4, -32 },
  { 5387, 8, 36, 23, 8, -32 },
  { 5423, 18, 36, 23, 2, -32 },
  { 5504, 18, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_THINITALIC39PT7B_H_
