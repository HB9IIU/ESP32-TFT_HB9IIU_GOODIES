#ifndef _JETBRAINSMONO_THINITALIC61PT7B_H_
#define _JETBRAINSMONO_THINITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x1E, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x83, 0x80, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xF1, 0xC7, 0xC0, 0x07, 0x83, 0x87, 0xC0, 0x1E, 0x06, 0x07,
  0x80, 0x38, 0x0C, 0x07, 0x00, 0xE0, 0x18, 0x0F, 0x01, 0xC0, 0x70, 0x1E,
  0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x78, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x07,
  0xC3, 0x00, 0x00, 0x07, 0xE6, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0x9F, 0x80, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0,
  0x3C, 0x00, 0x01, 0x80, 0x78, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x01,
  0xE1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x07, 0x07, 0x00, 0x70, 0x0E,
  0x0E, 0x00, 0xC0, 0x3C, 0x1E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x01, 0xC0,
  0x3C, 0x0E, 0x07, 0x80, 0x3E, 0x1C, 0x3E, 0x00, 0x3F, 0x39, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0x80, 0x1F, 0xF8, 0x00, 0x03, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x00, 0xE0,
  0x06, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x81,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x80, 0x00, 0x00, 0x70, 0x7F,
  0xE0, 0x00, 0x00, 0x38, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x70, 0x1E, 0x00,
  0x00, 0x38, 0x70, 0x07, 0x00, 0x00, 0x38, 0x38, 0x03, 0x80, 0x00, 0x38,
  0x18, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x18, 0x00,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x00,
  0x60, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x03,
  0x80, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0xC7, 0xC0, 0x0E,
  0x00, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x1E, 0x03,
  0x80, 0x0E, 0x1C, 0x03, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x1C, 0x38, 0x00,
  0xE0, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x38, 0x00, 0x70, 0x70, 0x38, 0x00,
  0x38, 0xE0, 0x70, 0x00, 0x3D, 0xC0, 0x70, 0x00, 0x1F, 0xC0, 0x70, 0x00,
  0x1F, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x70, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x3B, 0xC0, 0x70, 0x00,
  0x79, 0xC0, 0x78, 0x00, 0xF0, 0xE0, 0x78, 0x03, 0xE0, 0xE0, 0x3E, 0x0F,
  0x80, 0x70, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0xFC, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE3, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x07, 0x80, 0x05, 0xE0, 0x0E,
  0x00, 0x7F, 0xF8, 0x1C, 0x07, 0xF7, 0xFC, 0x38, 0x7F, 0xE3, 0xFE, 0x63,
  0xFE, 0x00, 0xFE, 0xDF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x03,
  0x00, 0x01, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7,
  0xF8, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x40, 0x1C, 0x1C, 0x07, 0xC0, 0x70, 0x70, 0x3F, 0x01, 0xC1, 0xC0, 0xFC,
  0x0F, 0x0F, 0x03, 0xF0, 0x3C, 0x3C, 0x07, 0xC0, 0xE0, 0xE0, 0x04, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0x38,
  0x00, 0x0F, 0x87, 0x00, 0x07, 0xC0, 0xE0, 0x01, 0xF0, 0x1C, 0x00, 0x78,
  0x03, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x71, 0xFF, 0xF0, 0x03, 0xBF,
  0xFF, 0xC0, 0x3B, 0x80, 0x3E, 0x01, 0xD8, 0x00, 0x78, 0x0F, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x39,
  0xFF, 0xE0, 0x03, 0xBF, 0xFF, 0x00, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03,
  0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x03,
  0xF0, 0x1F, 0xC7, 0xFC, 0x01, 0xFF, 0xF7, 0x00, 0x0F, 0xF8, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x80, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x0E, 0x00, 0x3F, 0xF3, 0x83, 0x80,
  0x1F, 0xFE, 0xE1, 0xE0, 0x0F, 0x83, 0xB8, 0x70, 0x07, 0x80, 0x2E, 0x1C,
  0x01, 0xC0, 0x0F, 0x07, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x70,
  0x70, 0x0E, 0x00, 0x1C, 0x3C, 0x03, 0x80, 0x07, 0x0E, 0x01, 0xC0, 0x01,
  0xC3, 0x80, 0x70, 0x00, 0xF0, 0xE0, 0x1C, 0x00, 0x38, 0x38, 0x07, 0x00,
  0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x70, 0x00, 0xE1, 0xC0, 0x38,
  0x00, 0x38, 0x70, 0x0E, 0x00, 0x1E, 0x1C, 0x03, 0x80, 0x07, 0x07, 0x00,
  0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0x3C, 0x3C,
  0x03, 0xC0, 0x17, 0x0E, 0x00, 0x7C, 0x1D, 0xC3, 0x80, 0x1F, 0xFE, 0x60,
  0xE0, 0x01, 0xFF, 0x38, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x03, 0xF8, 0x03, 0x80, 0x01, 0xF0, 0x0E,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x7F, 0xC0, 0x1C, 0x00,
  0x0F, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x1E, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0x80, 0x38, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x38, 0x07,
  0xFF, 0xE1, 0xC0, 0x3F, 0xFF, 0x0E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xB0, 0x00, 0x3F, 0x03, 0xB0, 0x00,
  0x37, 0x03, 0xB0, 0x00, 0x77, 0x03, 0xB8, 0x00, 0x66, 0x03, 0x98, 0x00,
  0xEE, 0x03, 0x98, 0x00, 0xCE, 0x03, 0x18, 0x01, 0xCE, 0x07, 0x1C, 0x01,
  0x8E, 0x07, 0x1C, 0x03, 0x8E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x0C, 0x06,
  0x1C, 0x07, 0x0C, 0x0E, 0x1C, 0x07, 0x0E, 0x0C, 0x1C, 0x0E, 0x0E, 0x1C,
  0x1C, 0x0E, 0x06, 0x18, 0x1C, 0x0E, 0x06, 0x38, 0x1C, 0x0E, 0x06, 0x30,
  0x38, 0x0E, 0x07, 0x70, 0x38, 0x0E, 0x07, 0x60, 0x38, 0x1E, 0x03, 0xE0,
  0x38, 0x1C, 0x03, 0xC0, 0x38, 0x1C, 0x03, 0xC0, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x70, 0x1F, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x1C,
  0x0E, 0xC0, 0x00, 0x70, 0x3B, 0x80, 0x03, 0x80, 0xEE, 0x00, 0x0E, 0x03,
  0xB8, 0x00, 0x38, 0x0E, 0x60, 0x00, 0xE0, 0x71, 0xC0, 0x03, 0x81, 0xC7,
  0x00, 0x0E, 0x07, 0x1C, 0x00, 0x70, 0x1C, 0x30, 0x01, 0xC0, 0x70, 0xE0,
  0x07, 0x01, 0xC3, 0x80, 0x1C, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x18, 0x01,
  0xC0, 0xE0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0,
  0x38, 0x0C, 0x03, 0x80, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x1C,
  0x03, 0x80, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x18, 0x1C, 0x07, 0x00,
  0x70, 0x70, 0x1C, 0x01, 0xC1, 0xC0, 0xE0, 0x07, 0x07, 0x03, 0x80, 0x0C,
  0x1C, 0x0E, 0x00, 0x38, 0xE0, 0x38, 0x00, 0xE3, 0x80, 0xE0, 0x03, 0x8E,
  0x03, 0x80, 0x06, 0x38, 0x0C, 0x00, 0x1C, 0xE0, 0x70, 0x00, 0x73, 0x81,
  0xC0, 0x01, 0xCC, 0x07, 0x00, 0x03, 0x70, 0x1C, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x3F, 0x01, 0xC0, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0x38, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x03, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x03, 0xF8, 0x03, 0x80, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E,
  0x01, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C,
  0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xCC, 0x00,
  0x7C, 0x00, 0xE3, 0x00, 0x1F, 0x00, 0x38, 0xC0, 0x07, 0xC0, 0x0E, 0x30,
  0x01, 0xF0, 0x07, 0x0C, 0x00, 0xFC, 0x01, 0xC3, 0x00, 0x37, 0x00, 0x70,
  0xC0, 0x0D, 0xC0, 0x1C, 0x30, 0x07, 0x70, 0x0E, 0x1C, 0x01, 0x9C, 0x03,
  0x87, 0x00, 0x66, 0x00, 0xE1, 0xC0, 0x39, 0x80, 0x30, 0x70, 0x0E, 0x60,
  0x1C, 0x1C, 0x03, 0x18, 0x07, 0x07, 0x00, 0xC6, 0x01, 0xC1, 0xC0, 0x71,
  0x80, 0xE0, 0x70, 0x18, 0x60, 0x38, 0x1C, 0x06, 0x18, 0x0E, 0x07, 0x03,
  0x86, 0x03, 0x01, 0xC0, 0xC1, 0x81, 0xC0, 0x70, 0x30, 0x60, 0x70, 0x1C,
  0x1C, 0x18, 0x1C, 0x07, 0x06, 0x06, 0x06, 0x01, 0xC1, 0x81, 0x83, 0x80,
  0x70, 0x60, 0x60, 0xE0, 0x1C, 0x38, 0x18, 0x30, 0x07, 0x0C, 0x06, 0x1C,
  0x01, 0xC3, 0x01, 0x87, 0x00, 0x71, 0xC0, 0x61, 0xC0, 0x1C, 0x60, 0x18,
  0x60, 0x07, 0x18, 0x06, 0x38, 0x01, 0xCE, 0x01, 0x8E, 0x00, 0x63, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x19, 0xC0, 0x06, 0x30, 0x06, 0x70, 0x01, 0x98,
  0x01, 0x9C, 0x00, 0x66, 0x00, 0x66, 0x00, 0x39, 0x80, 0x1B, 0x80, 0x0E,
  0xE0, 0x06, 0xE0, 0x03, 0xB0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x70, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00,
  0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0x00,
  0x1F, 0xE0, 0xF0, 0x07, 0xFF, 0x8E, 0x01, 0xFE, 0xFC, 0xE0, 0x3E, 0x00,
  0xEE, 0x07, 0x80, 0x06, 0xE0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0xEE, 0x03,
  0xF0, 0x3C, 0xE0, 0x1F, 0xFF, 0x9C, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x3F, 0xC0, 0x07, 0x1F, 0xFF, 0x00,
  0x73, 0xF7, 0xF8, 0x07, 0x70, 0x07, 0xC0, 0x7E, 0x00, 0x3C, 0x07, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x7C, 0x00,
  0x1C, 0x07, 0xE0, 0x03, 0xC0, 0xE7, 0x81, 0xF8, 0x0E, 0x3F, 0xFE, 0x00,
  0xE1, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x38, 0x00, 0x7C,
  0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0xC1, 0xE0, 0x07, 0xFF, 0x8E, 0x00, 0xFF, 0x7E, 0x70, 0x0F, 0x80, 0x3B,
  0x80, 0xF0, 0x00, 0xDC, 0x07, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xE0,
  0x07, 0x70, 0x0F, 0xC0, 0xF3, 0x80, 0x3F, 0xFF, 0x38, 0x00, 0x7F, 0xE1,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x07, 0xFF,
  0x8E, 0x01, 0xFE, 0xFC, 0xE0, 0x3E, 0x00, 0xEE, 0x07, 0x80, 0x06, 0xE0,
  0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xF0, 0x38, 0x00, 0x3E, 0x03, 0xC0, 0x06, 0xE0, 0x1F, 0x03, 0xCE, 0x00,
  0xFF, 0xF8, 0xE0, 0x07, 0xFE, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x3F, 0xC0, 0x07, 0x0F, 0xFF, 0x00, 0x73, 0xF7, 0xF8, 0x07, 0x70, 0x07,
  0xC0, 0x7E, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x03,
  0x80, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0x1F, 0x81, 0xF8,
  0x07, 0x3F, 0xC3, 0xFC, 0x07, 0x77, 0xE7, 0x7E, 0x07, 0xC1, 0xEC, 0x1E,
  0x06, 0x80, 0xE8, 0x0E, 0x07, 0x00, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0x0E,
  0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E,
  0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0x1E,
  0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C,
  0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C,
  0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38,
  0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38,
  0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70,
  0x70, 0x06, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x03, 0xFC, 0x00, 0x70, 0xFF, 0xF0, 0x07, 0x3F, 0x7F, 0x80, 0x77,
  0x00, 0x7C, 0x07, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0xFF, 0x00, 0x07, 0x1F, 0xFF, 0x00, 0x1C, 0xFD, 0xFE, 0x00, 0x77, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x7C,
  0x00, 0x1C, 0x01, 0xF8, 0x00, 0xF0, 0x0E, 0x78, 0x1F, 0x80, 0x38, 0xFF,
  0xF8, 0x00, 0xE1, 0xFF, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0xF0, 0x07, 0xFF, 0x8E, 0x01, 0xFE, 0xFC, 0xE0, 0x3E, 0x00,
  0xEE, 0x07, 0x80, 0x06, 0xE0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0xEE, 0x03,
  0xF0, 0x3C, 0xE0, 0x1F, 0xFF, 0x9C, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x07, 0xFC, 0x00, 0x71, 0xFF, 0xF0, 0x07, 0x3F, 0x7F, 0x80,
  0x77, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x7C, 0x00, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x1F, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF8, 0x03, 0x60, 0x0E, 0xE0, 0x0D,
  0x80, 0x3B, 0x80, 0x36, 0x00, 0xEE, 0x01, 0x98, 0x07, 0x38, 0x06, 0x60,
  0x1C, 0xE0, 0x39, 0x80, 0x73, 0x80, 0xC6, 0x03, 0x8E, 0x03, 0x18, 0x0E,
  0x38, 0x1C, 0x60, 0x38, 0xE0, 0x61, 0x81, 0xC3, 0x81, 0x86, 0x07, 0x0E,
  0x0E, 0x18, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xE0, 0xC1, 0x83, 0x83, 0x87,
  0x06, 0x0E, 0x0E, 0x18, 0x18, 0x70, 0x38, 0x60, 0x61, 0xC0, 0xE3, 0x81,
  0x87, 0x03, 0x8C, 0x06, 0x38, 0x0E, 0x30, 0x18, 0xE0, 0x39, 0xC0, 0x63,
  0x80, 0xE6, 0x01, 0x9C, 0x03, 0xB8, 0x06, 0x70, 0x0E, 0xE0, 0x19, 0xC0,
  0x3B, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xB8, 0x03, 0xF0, 0x06, 0xE0, 0x0F,
  0x80, 0x1B, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0xC1, 0xE0,
  0x01, 0xB8, 0x1E, 0x00, 0x77, 0x03, 0xF0, 0x3C, 0xE0, 0x3F, 0xFF, 0x3C,
  0x01, 0xFF, 0x87, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x71, 0xFF, 0x80, 0x07, 0x3E, 0xFC, 0x00,
  0x73, 0x81, 0xC0, 0x06, 0x70, 0x0E, 0x00, 0x67, 0x00, 0xF0, 0x0E, 0x70,
  0x07, 0x80, 0xE6, 0x00, 0x3C, 0x1C, 0xE0, 0x01, 0xF7, 0xCE, 0x00, 0x0F,
  0xF8, 0xE0, 0x00, 0x7E, 0x00,
};

const GFXglyph JetBrainsMono_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 12, 45, 37, 13, -45 },
  { 69, 19, 19, 37, 12, -45 },
  { 115, 36, 45, 37, 1, -45 },
  { 318, 31, 62, 37, 3, -53 },
  { 559, 41, 45, 37, -1, -45 },
  { 790, 32, 46, 37, 2, -45 },
  { 974, 7, 19, 37, 18, -45 },
  { 991, 24, 60, 37, 11, -52 },
  { 1171, 24, 60, 37, 3, -52 },
  { 1351, 31, 31, 37, 4, -37 },
  { 1472, 28, 28, 37, 5, -34 },
  { 1570, 14, 19, 37, 7, -9 },
  { 1604, 20, 3, 37, 9, -22 },
  { 1612, 10, 9, 37, 11, -8 },
  { 1624, 34, 58, 37, 2, -51 },
  { 1871, 30, 46, 37, 4, -45 },
  { 2044, 27, 45, 37, 3, -45 },
  { 2196, 31, 45, 37, 3, -45 },
  { 2371, 30, 46, 37, 4, -45 },
  { 2544, 27, 44, 37, 5, -44 },
  { 2693, 29, 46, 37, 5, -45 },
  { 2860, 28, 46, 37, 4, -45 },
  { 3021, 28, 45, 37, 8, -45 },
  { 3179, 30, 46, 37, 4, -45 },
  { 3352, 27, 45, 37, 7, -45 },
  { 3504, 14, 35, 37, 11, -34 },
  { 3566, 18, 44, 37, 7, -34 },
  { 3665, 28, 30, 37, 6, -35 },
  { 3770, 28, 16, 37, 5, -28 },
  { 3826, 28, 30, 37, 4, -35 },
  { 3931, 24, 45, 37, 10, -45 },
  { 4066, 34, 56, 37, 2, -45 },
  { 4304, 29, 45, 37, 1, -45 },
  { 4468, 30, 45, 37, 4, -45 },
  { 4637, 29, 46, 37, 5, -45 },
  { 4804, 29, 45, 37, 4, -45 },
  { 4968, 31, 45, 37, 5, -45 },
  { 5143, 32, 45, 37, 4, -45 },
  { 5323, 29, 46, 37, 5, -45 },
  { 5490, 30, 45, 37, 4, -45 },
  { 5659, 29, 45, 37, 5, -45 },
  { 5823, 31, 46, 37, 3, -45 },
  { 6002, 33, 45, 37, 4, -45 },
  { 6188, 25, 45, 37, 5, -45 },
  { 6329, 32, 45, 37, 3, -45 },
  { 6509, 30, 45, 37, 4, -45 },
  { 6678, 28, 46, 37, 5, -45 },
  { 6839, 32, 45, 37, 4, -45 },
  { 7019, 28, 56, 37, 5, -45 },
  { 7215, 31, 45, 37, 4, -45 },
  { 7390, 31, 46, 37, 3, -45 },
  { 7569, 29, 45, 37, 8, -45 },
  { 7733, 29, 46, 37, 5, -45 },
  { 7900, 28, 45, 37, 9, -45 },
  { 8058, 34, 45, 37, 5, -45 },
  { 8250, 36, 45, 37, 1, -45 },
  { 8453, 31, 45, 37, 7, -45 },
  { 8628, 32, 45, 37, 3, -45 },
  { 8808, 22, 58, 37, 10, -51 },
  { 8968, 16, 58, 37, 11, -51 },
  { 9084, 22, 58, 37, 6, -51 },
  { 9244, 24, 24, 37, 7, -45 },
  { 9316, 30, 2, 37, 0, 2 },
  { 9324, 9, 9, 37, 17, -48 },
  { 9335, 28, 35, 37, 5, -34 },
  { 9458, 28, 46, 37, 4, -45 },
  { 9619, 27, 35, 37, 5, -34 },
  { 9738, 29, 46, 37, 5, -45 },
  { 9905, 27, 35, 37, 5, -34 },
  { 10024, 38, 56, 37, -2, -45 },
  { 10290, 28, 45, 37, 5, -34 },
  { 10448, 28, 45, 37, 4, -45 },
  { 10606, 27, 47, 37, 3, -47 },
  { 10765, 31, 58, 37, 1, -47 },
  { 10990, 31, 45, 37, 4, -45 },
  { 11165, 24, 45, 37, 7, -45 },
  { 11300, 32, 34, 37, 2, -34 },
  { 11436, 28, 34, 37, 4, -34 },
  { 11555, 27, 35, 37, 5, -34 },
  { 11674, 30, 45, 37, 2, -34 },
  { 11843, 28, 45, 37, 5, -34 },
  { 12001, 28, 34, 37, 5, -34 },
  { 12120, 28, 35, 37, 4, -34 },
  { 12243, 27, 43, 37, 6, -43 },
  { 12389, 28, 35, 37, 5, -34 },
  { 12512, 28, 34, 37, 7, -34 },
  { 12631, 30, 34, 37, 6, -34 },
  { 12759, 32, 34, 37, 2, -34 },
  { 12895, 27, 45, 37, 5, -34 },
  { 13047, 28, 34, 37, 4, -34 },
  { 13166, 29, 58, 37, 7, -51 },
  { 13377, 12, 58, 37, 13, -51 },
  { 13464, 30, 58, 37, 2, -51 },
  { 13682, 28, 11, 37, 5, -27 },
};

const GFXfont JetBrainsMono_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ThinItalic61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_THINITALIC61PT7B_H_
