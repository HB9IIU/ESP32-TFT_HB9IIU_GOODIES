#ifndef _NOTOSANS_THINITALIC57PT7B_H_
#define _NOTOSANS_THINITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x18, 0xC0, 0x84, 0x04, 0x20, 0x63,
  0x03, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x63, 0x03, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x20, 0x63, 0x02, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x8C, 0x3C,
  0x03, 0x03, 0x01, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x08,
  0x00, 0x18, 0x06, 0x00, 0x04, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x10, 0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x30, 0x20, 0x00, 0x06, 0x08, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x04, 0x70, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x08, 0x06, 0x00,
  0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18, 0x00, 0x10, 0x06,
  0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x30, 0x30, 0x08, 0x38, 0x0F, 0xC2, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0,
  0x61, 0xC0, 0x00, 0x30, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x20, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x06, 0x01, 0x00, 0x18, 0x00, 0x80, 0x60, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x20, 0x01, 0x80, 0x40, 0x0C,
  0x00, 0x20, 0x18, 0x01, 0x80, 0x04, 0x06, 0x00, 0x30, 0x00, 0x81, 0x80,
  0x06, 0x00, 0x30, 0x20, 0x00, 0x80, 0x04, 0x0C, 0x1F, 0x10, 0x00, 0x83,
  0x0F, 0xF2, 0x00, 0x30, 0xC3, 0x03, 0x60, 0x04, 0x10, 0xC0, 0x3C, 0x01,
  0x86, 0x10, 0x07, 0x80, 0x61, 0x86, 0x00, 0x58, 0x18, 0x60, 0x80, 0x0B,
  0x86, 0x08, 0x30, 0x01, 0x1F, 0x83, 0x04, 0x00, 0x20, 0x00, 0xC0, 0x80,
  0x04, 0x00, 0x10, 0x30, 0x00, 0x80, 0x06, 0x06, 0x00, 0x10, 0x01, 0x80,
  0x80, 0x06, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x10, 0x03,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x02, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x10, 0x18, 0x00, 0x10, 0x06, 0x02, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x00,
  0x70, 0x60, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x30, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x04, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x02, 0x18, 0x01,
  0x80, 0x03, 0x18, 0x00, 0x60, 0x01, 0x18, 0x00, 0x10, 0x01, 0x98, 0x00,
  0x0C, 0x00, 0x88, 0x00, 0x03, 0x00, 0xCC, 0x00, 0x00, 0x80, 0xC6, 0x00,
  0x00, 0x60, 0x42, 0x00, 0x00, 0x18, 0x61, 0x00, 0x00, 0x06, 0x60, 0x80,
  0x00, 0x01, 0x60, 0x40, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x68, 0x0C, 0x00, 0x00, 0x66, 0x03, 0x00, 0x00, 0xC1, 0x80,
  0xC0, 0x01, 0xC0, 0x60, 0x38, 0x03, 0x80, 0x10, 0x07, 0xFF, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x10,
  0x84, 0x23, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x08, 0x00, 0xE0, 0x08, 0x00, 0x38, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x07, 0x10, 0x00, 0x01, 0x90, 0x07, 0x00, 0x77, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x88, 0x00, 0x01, 0x08, 0x00, 0x06,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x06, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x07, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x08, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04,
  0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x07, 0xC0, 0x33,
  0x03, 0x88, 0x18, 0x21, 0xC1, 0x8C, 0x06, 0xE0, 0x11, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x08, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x37, 0xFF, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x0C, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x3F,
  0xC0, 0x04, 0x1F, 0x3E, 0x00, 0x8E, 0x00, 0x60, 0x33, 0x00, 0x06, 0x06,
  0xC0, 0x00, 0x60, 0xB0, 0x00, 0x04, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xC1, 0xE0, 0x01,
  0xC0, 0x06, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x04, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x08, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x07, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xD8, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x0C, 0x00, 0x70, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xE0, 0x80, 0x00,
  0x6C, 0x18, 0x00, 0x19, 0x01, 0x80, 0x0E, 0x20, 0x1E, 0x07, 0x0C, 0x00,
  0xFF, 0x81, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x04, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xC1, 0xE0,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x01, 0x06, 0x00, 0x01, 0xF8,
  0x00, 0x20, 0x80, 0x01, 0xFF, 0xF0, 0x06, 0x30, 0x00, 0x60, 0x06, 0x00,
  0xC4, 0x00, 0x38, 0x00, 0x80, 0x19, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x20,
  0x03, 0x00, 0x06, 0x00, 0x6C, 0x00, 0x40, 0x00, 0x80, 0x0D, 0x80, 0x18,
  0x00, 0x10, 0x01, 0xB0, 0x02, 0x00, 0x06, 0x00, 0x34, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x80, 0x10, 0x00, 0x10, 0x00, 0xF0, 0x06, 0x00, 0x02, 0x00,
  0x16, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xD8,
  0x03, 0x00, 0x02, 0x00, 0x13, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x60, 0x0C,
  0x00, 0x18, 0x00, 0x8C, 0x01, 0x80, 0x05, 0x00, 0x31, 0x80, 0x30, 0x01,
  0xA0, 0x0C, 0x30, 0x02, 0x00, 0x64, 0x03, 0x02, 0x00, 0x60, 0x18, 0xC0,
  0xC0, 0x60, 0x07, 0xFE, 0x0F, 0xF0, 0x0C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x07, 0x00, 0x40, 0x00,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0xC0, 0x30, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x40, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x0E, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x70, 0x02, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x03, 0xC0, 0x01,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xE2, 0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x07, 0x00, 0x01, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x0F, 0x00, 0x00,
  0x01, 0x8D, 0x80, 0x00, 0x00, 0xD8, 0x60, 0x00, 0x00, 0x58, 0x30, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00, 0x50, 0x00, 0x00, 0x01,
  0xA0, 0x0A, 0x00, 0x00, 0x00, 0x2C, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80,
  0x6C, 0x00, 0x00, 0x01, 0x20, 0x09, 0x80, 0x00, 0x00, 0x64, 0x01, 0x10,
  0x00, 0x00, 0x19, 0x80, 0x62, 0x00, 0x00, 0x02, 0x30, 0x0C, 0x40, 0x00,
  0x00, 0xC6, 0x01, 0x8C, 0x00, 0x00, 0x10, 0x80, 0x21, 0x80, 0x00, 0x06,
  0x10, 0x04, 0x10, 0x00, 0x01, 0x86, 0x01, 0x82, 0x00, 0x00, 0x20, 0xC0,
  0x30, 0x40, 0x00, 0x0C, 0x10, 0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x81,
  0x80, 0x00, 0x60, 0x40, 0x10, 0x30, 0x00, 0x18, 0x18, 0x06, 0x02, 0x00,
  0x02, 0x03, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x18, 0x08, 0x00, 0x10,
  0x08, 0x02, 0x01, 0x80, 0x06, 0x03, 0x00, 0x40, 0x30, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x40, 0xC0,
  0x04, 0x01, 0x00, 0x08, 0x10, 0x00, 0x80, 0x20, 0x01, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x21, 0x80, 0x06, 0x01, 0x80, 0x06, 0x20, 0x00, 0x80, 0x30,
  0x00, 0xCC, 0x00, 0x10, 0x04, 0x00, 0x09, 0x00, 0x02, 0x00, 0x80, 0x01,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x20, 0x0A, 0x00, 0x00, 0x04, 0x03, 0x60, 0x00, 0x00, 0x80, 0x64,
  0x00, 0x00, 0x30, 0x08, 0xC0, 0x00, 0x06, 0x01, 0x18, 0x00, 0x00, 0x80,
  0x61, 0x00, 0x00, 0x10, 0x0C, 0x30, 0x00, 0x06, 0x01, 0x82, 0x00, 0x00,
  0xC0, 0x20, 0x60, 0x00, 0x18, 0x04, 0x04, 0x00, 0x02, 0x01, 0x80, 0xC0,
  0x00, 0x40, 0x30, 0x18, 0x00, 0x18, 0x06, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x30, 0x00, 0x60, 0x10, 0x02, 0x00, 0x08, 0x06, 0x00, 0x60, 0x01, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x18, 0x01,
  0x00, 0x40, 0x01, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x02,
  0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x08, 0x00, 0x04, 0x04, 0x03, 0x00,
  0x00, 0xC0, 0x80, 0x60, 0x00, 0x18, 0x30, 0x0C, 0x00, 0x01, 0x06, 0x01,
  0x00, 0x00, 0x30, 0xC0, 0x20, 0x00, 0x02, 0x10, 0x0C, 0x00, 0x00, 0x62,
  0x01, 0x80, 0x00, 0x04, 0xC0, 0x30, 0x00, 0x00, 0xD8, 0x04, 0x00, 0x00,
  0x1A, 0x00, 0x80, 0x00, 0x01, 0x40, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x00, 0x01, 0xC0, 0x08, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0xF0,
  0x01, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x40, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x1C, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x00, 0x40, 0x06, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xA0, 0x00, 0x04, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x32, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x62, 0x00, 0x03, 0x04, 0x00, 0x04, 0x20, 0x00,
  0x30, 0x40, 0x00, 0xC2, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x60,
  0x40, 0x01, 0x83, 0x00, 0x04, 0x04, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x40,
  0x03, 0x03, 0x00, 0x08, 0x04, 0x00, 0x30, 0x30, 0x01, 0x80, 0x40, 0x02,
  0x03, 0x00, 0x10, 0x04, 0x00, 0x60, 0x30, 0x03, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x10, 0x04, 0x00, 0x60, 0x10, 0x01, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x10, 0x08, 0x00, 0x60, 0x20, 0x01, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x10, 0x10, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x01, 0x86, 0x00, 0x02, 0x18, 0x00,
  0x18, 0x40, 0x00, 0x21, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x26, 0x00, 0x00, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x02, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x80, 0x08, 0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20,
  0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08,
  0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x03, 0x01, 0x01, 0x01, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x08, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x60, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x03, 0x00, 0x02,
  0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x04, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x81, 0x81,
  0x03, 0x03, 0x02, 0x06, 0x06, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x10,
  0x0E, 0x03, 0x8C, 0x06, 0x00, 0x33, 0x03, 0x00, 0x04, 0x81, 0x80, 0x01,
  0xA0, 0xC0, 0x00, 0x28, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x28, 0x10, 0x00, 0x12, 0x06, 0x00, 0x0D, 0x81, 0x80, 0x06, 0x60,
  0x30, 0x07, 0x10, 0x06, 0x07, 0x04, 0x00, 0xFF, 0x83, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x06, 0x0F, 0xFC,
  0x00, 0x83, 0x01, 0xC0, 0x11, 0x80, 0x0C, 0x06, 0x60, 0x00, 0xC0, 0xD8,
  0x00, 0x18, 0x16, 0x00, 0x01, 0x82, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xA0, 0x00, 0x0C, 0x16, 0x00, 0x03,
  0x02, 0x60, 0x00, 0xC0, 0xC6, 0x00, 0x30, 0x10, 0xE0, 0x1C, 0x02, 0x07,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFC,
  0x03, 0xC0, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x02, 0x01, 0xC0, 0x18, 0x00, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x20, 0x00, 0xFF, 0xC0, 0x80, 0x0E, 0x01, 0xC6, 0x00, 0x60,
  0x01, 0x98, 0x03, 0x00, 0x02, 0x60, 0x18, 0x00, 0x0D, 0x00, 0xC0, 0x00,
  0x14, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x14, 0x03, 0x00, 0x00, 0x90,
  0x06, 0x00, 0x04, 0xC0, 0x18, 0x00, 0x23, 0x00, 0x30, 0x03, 0x08, 0x00,
  0x60, 0x38, 0x20, 0x00, 0xFF, 0x80, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0x80, 0x0E, 0x03, 0x00, 0xE0, 0x06, 0x07, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x40, 0x00, 0x73, 0x00,
  0x07, 0x0C, 0x01, 0xF0, 0x3F, 0xFE, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x40, 0x78, 0x07, 0x00, 0x7F, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x40, 0x0E, 0x01, 0xC2, 0x00, 0xC0, 0x03, 0x30, 0x0C, 0x00,
  0x09, 0x80, 0xC0, 0x00, 0x68, 0x0C, 0x00, 0x01, 0x40, 0xC0, 0x00, 0x0A,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x05, 0x01, 0x80, 0x00, 0x48, 0x06, 0x00, 0x04, 0xC0, 0x30, 0x00, 0x46,
  0x00, 0xC0, 0x0C, 0x20, 0x03, 0x01, 0xC1, 0x00, 0x0F, 0xF8, 0x08, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x06, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xF8, 0x00, 0xC1, 0xFF,
  0x80, 0x20, 0xC0, 0x30, 0x08, 0xE0, 0x06, 0x06, 0x60, 0x00, 0xC1, 0xB0,
  0x00, 0x30, 0x58, 0x00, 0x04, 0x14, 0x00, 0x01, 0x07, 0x00, 0x00, 0x43,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x10, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00,
  0x40, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x10, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x04, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1E, 0x00,
  0x01, 0x19, 0x00, 0x00, 0x90, 0xC0, 0x00, 0xD0, 0x30, 0x00, 0x70, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x10, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x41, 0xFF, 0x80, 0x3F, 0xE0, 0x08, 0x70, 0x38, 0x1C, 0x0E, 0x01, 0x18,
  0x03, 0x06, 0x00, 0x60, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x0D, 0x80, 0x06,
  0x60, 0x00, 0x81, 0x60, 0x00, 0x58, 0x00, 0x18, 0x28, 0x00, 0x0A, 0x00,
  0x03, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x60, 0x00, 0x08, 0x00, 0x02, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x60, 0x00, 0x18, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x00, 0x08, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x81, 0xFF, 0x80,
  0x20, 0xC0, 0x30, 0x08, 0xE0, 0x06, 0x06, 0x60, 0x00, 0xC1, 0xB0, 0x00,
  0x30, 0x58, 0x00, 0x04, 0x14, 0x00, 0x01, 0x07, 0x00, 0x00, 0x43, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x06, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x03,
  0xFF, 0x00, 0x04, 0x18, 0x0E, 0x00, 0x11, 0x80, 0x0C, 0x00, 0xCC, 0x00,
  0x18, 0x03, 0x60, 0x00, 0x60, 0x0B, 0x00, 0x00, 0xC0, 0x28, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x30,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x60, 0x28, 0x00, 0x03, 0x00, 0xB0, 0x00, 0x18, 0x02,
  0x60, 0x00, 0xC0, 0x18, 0xC0, 0x06, 0x00, 0x63, 0x80, 0x70, 0x01, 0x03,
  0xFF, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x04, 0x03, 0x80,
  0x70, 0x80, 0xC0, 0x03, 0x30, 0x30, 0x00, 0x26, 0x0C, 0x00, 0x06, 0x83,
  0x00, 0x00, 0x50, 0xC0, 0x00, 0x0A, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x14, 0x08, 0x00, 0x04, 0x81, 0x80, 0x01, 0xB0, 0x30, 0x00,
  0x66, 0x03, 0x00, 0x30, 0x80, 0x30, 0x1C, 0x10, 0x03, 0xFE, 0x02, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x48, 0x10,
  0x3F, 0x80, 0x87, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00,
  0x16, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0,
  0x38, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x80,
  0x01, 0x83, 0xC0, 0x1C, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x40,
  0x3F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x10,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xA0, 0xC0, 0x00,
  0x68, 0x30, 0x00, 0x32, 0x04, 0x00, 0x19, 0x81, 0x80, 0x0C, 0x60, 0x38,
  0x0C, 0x10, 0x07, 0xFE, 0x04, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88,
  0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0,
  0x01, 0x81, 0x80, 0x06, 0x01, 0x00, 0x08, 0x02, 0x00, 0x30, 0x04, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x60, 0x00, 0x09, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x02, 0xC0, 0x00, 0xE0,
  0x00, 0x6C, 0x00, 0x1A, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0xCC, 0x00,
  0x32, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x01, 0x84, 0x00, 0x62, 0x00, 0x10,
  0x40, 0x04, 0x20, 0x03, 0x04, 0x00, 0xC2, 0x00, 0x20, 0x40, 0x08, 0x30,
  0x06, 0x04, 0x01, 0x83, 0x00, 0x40, 0x40, 0x10, 0x30, 0x0C, 0x04, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x00,
  0x60, 0x40, 0x10, 0x30, 0x06, 0x0C, 0x01, 0x02, 0x00, 0x60, 0x80, 0x10,
  0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x62, 0x00, 0x18, 0x80, 0x02, 0x60, 0x00, 0x98, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x38, 0x04, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x17, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x06, 0x80, 0x01,
  0xFF, 0x00,
};

const GFXglyph NotoSans_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 41, 12, 2, -41 },
  { 53, 13, 15, 18, 6, -41 },
  { 78, 34, 41, 35, 2, -41 },
  { 253, 26, 46, 31, 3, -43 },
  { 403, 35, 42, 43, 5, -41 },
  { 587, 33, 42, 39, 3, -41 },
  { 761, 5, 15, 10, 6, -41 },
  { 771, 16, 50, 14, 2, -41 },
  { 871, 16, 50, 14, -4, -41 },
  { 971, 24, 24, 30, 7, -43 },
  { 1043, 27, 26, 32, 4, -33 },
  { 1131, 8, 14, 10, -3, -7 },
  { 1145, 14, 1, 18, 2, -16 },
  { 1147, 3, 3, 12, 2, -3 },
  { 1149, 24, 41, 17, -2, -41 },
  { 1272, 26, 42, 31, 4, -41 },
  { 1409, 14, 41, 31, 9, -41 },
  { 1481, 28, 41, 31, 1, -41 },
  { 1625, 29, 42, 31, 1, -41 },
  { 1778, 29, 41, 31, 1, -41 },
  { 1927, 29, 42, 31, 2, -41 },
  { 2080, 27, 42, 31, 4, -41 },
  { 2222, 26, 41, 31, 6, -41 },
  { 2356, 27, 42, 31, 3, -41 },
  { 2498, 27, 42, 31, 3, -41 },
  { 2640, 9, 30, 12, 2, -30 },
  { 2674, 14, 37, 12, -3, -30 },
  { 2739, 26, 25, 32, 4, -33 },
  { 2821, 27, 13, 32, 4, -27 },
  { 2865, 26, 25, 32, 4, -33 },
  { 2947, 19, 41, 23, 5, -41 },
  { 3045, 43, 45, 48, 3, -40 },
  { 3287, 31, 41, 31, -3, -41 },
  { 3446, 30, 41, 34, 3, -41 },
  { 3600, 31, 42, 34, 5, -41 },
  { 3763, 33, 41, 39, 3, -41 },
  { 3933, 29, 41, 31, 3, -41 },
  { 4082, 29, 41, 28, 3, -41 },
  { 4231, 33, 42, 39, 5, -41 },
  { 4405, 36, 41, 39, 3, -41 },
  { 4590, 18, 41, 16, 0, -41 },
  { 4683, 23, 51, 13, -10, -41 },
  { 4830, 33, 41, 31, 3, -41 },
  { 5000, 20, 41, 28, 3, -41 },
  { 5103, 43, 41, 46, 3, -41 },
  { 5324, 35, 41, 38, 3, -41 },
  { 5504, 34, 42, 41, 5, -41 },
  { 5683, 29, 41, 32, 3, -41 },
  { 5832, 34, 51, 41, 5, -41 },
  { 6049, 29, 41, 32, 3, -41 },
  { 6198, 28, 42, 28, 1, -41 },
  { 6345, 28, 41, 28, 5, -41 },
  { 6489, 35, 42, 39, 5, -41 },
  { 6673, 29, 41, 31, 6, -41 },
  { 6822, 44, 41, 47, 7, -41 },
  { 7048, 35, 41, 28, -3, -41 },
  { 7228, 28, 41, 28, 5, -41 },
  { 7372, 33, 41, 31, 0, -41 },
  { 7542, 22, 50, 17, -1, -41 },
  { 7680, 8, 41, 17, 6, -41 },
  { 7721, 21, 50, 17, -4, -41 },
  { 7853, 26, 25, 31, 3, -41 },
  { 7935, 22, 2, 21, -5, 6 },
  { 7941, 7, 9, 13, 8, -44 },
  { 7949, 26, 32, 31, 3, -31 },
  { 8053, 27, 44, 32, 2, -43 },
  { 8202, 23, 32, 26, 3, -31 },
  { 8294, 30, 44, 32, 3, -43 },
  { 8459, 22, 32, 28, 4, -31 },
  { 8547, 32, 58, 15, -8, -44 },
  { 8779, 29, 45, 32, 1, -31 },
  { 8943, 26, 43, 32, 2, -43 },
  { 9083, 10, 41, 12, 2, -41 },
  { 9135, 20, 55, 12, -8, -41 },
  { 9273, 25, 43, 25, 2, -43 },
  { 9408, 10, 43, 12, 2, -43 },
  { 9462, 43, 31, 48, 2, -31 },
  { 9629, 26, 31, 32, 2, -31 },
  { 9730, 26, 32, 32, 3, -31 },
  { 9834, 30, 44, 32, -1, -31 },
  { 9999, 27, 44, 32, 3, -31 },
  { 10148, 21, 31, 21, 2, -31 },
  { 10230, 22, 32, 24, 1, -31 },
  { 10318, 16, 39, 18, 3, -38 },
  { 10396, 26, 31, 32, 3, -30 },
  { 10497, 23, 30, 23, 3, -30 },
  { 10584, 36, 30, 37, 3, -30 },
  { 10719, 29, 30, 26, -2, -30 },
  { 10828, 33, 44, 23, -7, -30 },
  { 11010, 26, 30, 25, -1, -30 },
  { 11108, 20, 50, 19, 2, -41 },
  { 11233, 2, 57, 31, 16, -43 },
  { 11248, 20, 50, 19, -3, -41 },
  { 11373, 26, 5, 32, 4, -23 },
};

const GFXfont NotoSans_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_THINITALIC57PT7B_H_
