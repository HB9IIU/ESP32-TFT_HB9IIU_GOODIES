#ifndef _NOTOSANS_THINITALIC16PT7B_H_
#define _NOTOSANS_THINITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x25, 0x24, 0x02, 0x00, 0xB6, 0xD0, 0x11, 0x08, 0x84, 0x8F,
  0xF2, 0x21, 0x20, 0x91, 0xBE, 0x44, 0x24, 0x12, 0x00, 0x08, 0x7D, 0x22,
  0x44, 0x86, 0x06, 0x0A, 0x12, 0x4B, 0xE1, 0x02, 0x00, 0x30, 0x52, 0x24,
  0x8A, 0x24, 0x8A, 0x23, 0x79, 0x65, 0xA9, 0x12, 0x44, 0x92, 0x25, 0x0E,
  0x0C, 0x09, 0x08, 0x44, 0x42, 0x60, 0xC1, 0xA1, 0x11, 0x84, 0xC1, 0xA0,
  0x9F, 0xA0, 0xF0, 0x32, 0x48, 0x88, 0x88, 0x88, 0x88, 0x88, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x24, 0x48, 0x11, 0x21, 0x41, 0xF5, 0x11, 0x02, 0x00,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x56, 0xE0, 0x80, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00, 0x1C, 0x45, 0x0A, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0A, 0x13, 0xC0, 0x7A, 0x22, 0x22, 0x44, 0x44,
  0x80, 0x0E, 0x11, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x18, 0x20, 0x40,
  0xFE, 0x0E, 0x31, 0x01, 0x01, 0x01, 0x02, 0x1E, 0x01, 0x01, 0x01, 0x02,
  0xFC, 0x03, 0x03, 0x05, 0x09, 0x12, 0x22, 0x42, 0xFF, 0x02, 0x04, 0x04,
  0x3F, 0x20, 0x40, 0x40, 0x78, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x0F,
  0x10, 0x20, 0x40, 0x40, 0xBC, 0xC2, 0x82, 0x82, 0x82, 0x84, 0x78, 0xFE,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x00, 0x1C, 0x45, 0x0A,
  0x12, 0x22, 0x9A, 0x42, 0x83, 0x06, 0x13, 0xC0, 0x1C, 0x45, 0x0A, 0x18,
  0x30, 0x51, 0x9D, 0x02, 0x08, 0x27, 0x80, 0x40, 0x00, 0x80, 0x10, 0x00,
  0x00, 0x02, 0x44, 0x80, 0x07, 0x18, 0x60, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x18, 0x04, 0x03, 0x0C, 0x70, 0x80, 0x78, 0x10, 0x41,
  0x04, 0x62, 0x10, 0x40, 0x00, 0x20, 0x1F, 0xC2, 0x02, 0x40, 0x18, 0x79,
  0x88, 0x99, 0x11, 0x91, 0x19, 0x12, 0x97, 0x68, 0x88, 0x40, 0x03, 0xF8,
  0x02, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x7C, 0x41, 0x40, 0xA0, 0x60,
  0x20, 0x3F, 0x21, 0x41, 0x41, 0x72, 0x4E, 0x81, 0x81, 0x81, 0x82, 0xFC,
  0x07, 0x8C, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x07, 0xC0, 0x3F, 0x10, 0x50, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x81,
  0x41, 0x3F, 0x00, 0x3F, 0x20, 0x40, 0x40, 0x7E, 0x40, 0x80, 0x80, 0x80,
  0x80, 0xFC, 0x3F, 0x20, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x0B, 0x84, 0x12, 0x01, 0x00, 0x40, 0x20, 0x08, 0x7A, 0x02, 0x80,
  0xA0, 0x24, 0x10, 0xFC, 0x20, 0x48, 0x14, 0x09, 0x02, 0x7F, 0x90, 0x28,
  0x0A, 0x04, 0x81, 0x20, 0x48, 0x10, 0x38, 0x84, 0x42, 0x10, 0x84, 0x42,
  0x38, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x1C, 0x00, 0x21, 0x91, 0x11, 0x09, 0x05, 0x03, 0x82, 0x21, 0x10, 0x84,
  0x42, 0x20, 0x80, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0F, 0xC0,
  0x20, 0x12, 0x02, 0x50, 0x65, 0x06, 0x50, 0xA5, 0x12, 0x91, 0x28, 0xA4,
  0x8A, 0x48, 0xC4, 0x88, 0x40, 0x20, 0x48, 0x15, 0x09, 0x42, 0x48, 0x92,
  0x28, 0x4A, 0x14, 0x83, 0x20, 0xC8, 0x10, 0x0F, 0x04, 0x22, 0x05, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x24, 0x10, 0xF8, 0x3E, 0x21,
  0x41, 0x41, 0x41, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x04, 0x22,
  0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x24, 0x10, 0xD8,
  0x08, 0x01, 0x00, 0x20, 0x3F, 0x21, 0x41, 0x41, 0x42, 0x7C, 0x88, 0x84,
  0x84, 0x84, 0x82, 0x0F, 0x30, 0x20, 0x20, 0x20, 0x10, 0x0C, 0x02, 0x02,
  0x02, 0x02, 0xFC, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x90, 0x28, 0x0A, 0x02,
  0x81, 0x20, 0x47, 0xE0, 0x81, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90,
  0x60, 0x40, 0x40, 0x84, 0x18, 0x41, 0x8A, 0x28, 0xA2, 0x92, 0x49, 0x24,
  0xA2, 0x8A, 0x28, 0xC3, 0x0C, 0x10, 0x82, 0x00, 0x10, 0x44, 0x20, 0x90,
  0x28, 0x0C, 0x01, 0x00, 0xC0, 0x48, 0x22, 0x10, 0x48, 0x10, 0x83, 0x0A,
  0x24, 0x45, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3F, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x3F, 0x80, 0x3C, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0x80, 0xAA, 0xA5, 0x54, 0x1C,
  0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x23, 0x80, 0x08, 0x10,
  0x51, 0x22, 0x28, 0x60, 0xC1, 0xFC, 0x90, 0x18, 0xCE, 0x0C, 0x18, 0x30,
  0xA1, 0x46, 0xF4, 0x20, 0x81, 0x02, 0xE6, 0x28, 0x60, 0xC1, 0x83, 0x06,
  0x17, 0xC0, 0x19, 0x88, 0x20, 0x82, 0x08, 0x20, 0x78, 0x01, 0x01, 0x01,
  0x1D, 0x62, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0xF4, 0x19, 0x94, 0x61,
  0xFA, 0x08, 0x20, 0x78, 0x07, 0x82, 0x02, 0x03, 0xC0, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x81, 0x80, 0x0E, 0x98,
  0x90, 0x48, 0x24, 0x12, 0x09, 0x08, 0x8C, 0x7A, 0x01, 0x00, 0x80, 0x8F,
  0x80, 0x20, 0x81, 0x02, 0xE6, 0x28, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x20,
  0x40, 0x5A, 0xAA, 0x08, 0x00, 0x00, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10,
  0x98, 0x20, 0x81, 0x02, 0x14, 0x49, 0x24, 0x50, 0xD1, 0x22, 0x24, 0x40,
  0x29, 0x24, 0xA4, 0x92, 0x40, 0x18, 0xE6, 0x51, 0x42, 0x18, 0x21, 0x84,
  0x28, 0x42, 0x84, 0x28, 0x42, 0x88, 0x20, 0x1C, 0xC5, 0x0C, 0x18, 0x30,
  0x61, 0x42, 0x84, 0x1C, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x78, 0x0E,
  0x31, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x1D, 0x62, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0xF4, 0x04, 0x04, 0x08,
  0x08, 0x1B, 0x11, 0x08, 0x42, 0x10, 0x80, 0x3D, 0x04, 0x10, 0x30, 0x20,
  0x41, 0xF8, 0x44, 0xF4, 0x48, 0x88, 0x88, 0xE0, 0x43, 0x06, 0x0C, 0x18,
  0x50, 0xA3, 0x7A, 0x86, 0x28, 0xA4, 0x92, 0x84, 0x10, 0x88, 0x65, 0x29,
  0x4A, 0x94, 0xA5, 0x31, 0x8C, 0x62, 0x10, 0x31, 0x89, 0x05, 0x01, 0x01,
  0x81, 0x20, 0x91, 0x84, 0x10, 0x88, 0x44, 0x42, 0x41, 0x20, 0xA0, 0x20,
  0x10, 0x08, 0x08, 0x08, 0x18, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x7C, 0x0C, 0x41, 0x04, 0x20, 0x8C, 0x08, 0x41, 0x04, 0x10, 0x40, 0x80,
  0xFF, 0xFF, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC4, 0x10, 0x41, 0x08, 0x23,
  0x00, 0xFF,
};

const GFXglyph NotoSans_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 3, 1, -11 },
  { 6, 3, 4, 5, 2, -11 },
  { 8, 9, 11, 10, 1, -11 },
  { 21, 7, 13, 9, 1, -12 },
  { 33, 10, 12, 12, 1, -12 },
  { 48, 9, 12, 11, 1, -12 },
  { 62, 1, 4, 3, 2, -11 },
  { 63, 4, 14, 4, 1, -11 },
  { 70, 4, 14, 4, -1, -11 },
  { 77, 7, 7, 9, 2, -12 },
  { 84, 8, 7, 9, 1, -9 },
  { 91, 2, 4, 3, -1, -2 },
  { 92, 3, 1, 5, 1, -5 },
  { 93, 1, 1, 3, 0, -1 },
  { 94, 7, 11, 5, -1, -11 },
  { 104, 7, 12, 9, 1, -12 },
  { 115, 4, 11, 9, 3, -11 },
  { 121, 8, 12, 9, 0, -12 },
  { 133, 8, 12, 9, 0, -12 },
  { 145, 8, 11, 9, 0, -11 },
  { 156, 8, 11, 9, 1, -11 },
  { 167, 8, 12, 9, 1, -12 },
  { 179, 7, 11, 9, 2, -11 },
  { 189, 7, 12, 9, 1, -12 },
  { 200, 7, 12, 9, 1, -12 },
  { 211, 2, 9, 3, 1, -9 },
  { 214, 4, 11, 3, -1, -9 },
  { 220, 8, 7, 9, 1, -9 },
  { 227, 8, 3, 9, 1, -7 },
  { 230, 8, 7, 9, 1, -9 },
  { 237, 6, 12, 6, 1, -12 },
  { 246, 12, 12, 13, 1, -11 },
  { 264, 9, 11, 9, -1, -11 },
  { 277, 8, 11, 10, 1, -11 },
  { 288, 9, 12, 10, 1, -12 },
  { 302, 9, 11, 11, 1, -11 },
  { 315, 8, 11, 9, 1, -11 },
  { 326, 8, 11, 8, 1, -11 },
  { 337, 10, 12, 11, 1, -12 },
  { 352, 10, 11, 11, 1, -11 },
  { 366, 5, 11, 4, 0, -11 },
  { 373, 7, 14, 4, -3, -11 },
  { 386, 9, 11, 9, 1, -11 },
  { 399, 6, 11, 8, 1, -11 },
  { 408, 12, 11, 13, 1, -11 },
  { 425, 10, 11, 11, 1, -11 },
  { 439, 10, 12, 11, 1, -12 },
  { 454, 8, 11, 9, 1, -11 },
  { 465, 10, 15, 11, 1, -12 },
  { 484, 8, 11, 9, 1, -11 },
  { 495, 8, 12, 8, 0, -12 },
  { 507, 8, 11, 8, 1, -11 },
  { 518, 10, 11, 11, 1, -11 },
  { 532, 8, 11, 9, 2, -11 },
  { 543, 12, 11, 13, 2, -11 },
  { 560, 10, 11, 8, -1, -11 },
  { 574, 7, 11, 8, 2, -11 },
  { 584, 9, 11, 9, 0, -11 },
  { 597, 6, 14, 5, 0, -11 },
  { 608, 2, 11, 5, 2, -11 },
  { 611, 6, 14, 5, -1, -11 },
  { 622, 7, 8, 9, 1, -12 },
  { 629, 6, 1, 6, -1, 1 },
  { 630, 2, 2, 4, 2, -12 },
  { 631, 7, 9, 9, 1, -9 },
  { 639, 7, 12, 9, 1, -12 },
  { 650, 6, 9, 7, 1, -9 },
  { 657, 8, 12, 9, 1, -12 },
  { 669, 6, 9, 8, 1, -9 },
  { 676, 9, 16, 4, -2, -12 },
  { 694, 9, 13, 9, 0, -9 },
  { 709, 7, 12, 9, 1, -12 },
  { 720, 2, 12, 3, 1, -12 },
  { 723, 5, 16, 3, -2, -12 },
  { 733, 7, 12, 7, 1, -12 },
  { 744, 3, 12, 3, 1, -12 },
  { 749, 12, 9, 13, 1, -9 },
  { 763, 7, 9, 9, 1, -9 },
  { 771, 7, 9, 9, 1, -9 },
  { 779, 8, 13, 9, 0, -9 },
  { 792, 8, 13, 9, 1, -9 },
  { 805, 5, 9, 6, 1, -9 },
  { 811, 6, 9, 7, 0, -9 },
  { 818, 4, 11, 5, 1, -11 },
  { 824, 7, 8, 9, 1, -8 },
  { 831, 6, 8, 7, 1, -8 },
  { 837, 10, 8, 10, 1, -8 },
  { 847, 9, 8, 7, -1, -8 },
  { 856, 9, 12, 7, -2, -8 },
  { 870, 7, 8, 7, 0, -8 },
  { 877, 6, 14, 5, 0, -11 },
  { 888, 1, 16, 9, 4, -12 },
  { 890, 6, 14, 5, -1, -11 },
  { 901, 8, 1, 9, 1, -6 },
};

const GFXfont NotoSans_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_THINITALIC16PT7B_H_
