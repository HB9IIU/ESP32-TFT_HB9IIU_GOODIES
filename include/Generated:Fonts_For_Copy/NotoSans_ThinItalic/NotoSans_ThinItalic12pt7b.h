#ifndef _NOTOSANS_THINITALIC12PT7B_H_
#define _NOTOSANS_THINITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0xD0, 0x12, 0x24, 0x53, 0xF2, 0x44,
  0xBE, 0xA4, 0x48, 0x13, 0xE9, 0x46, 0x18, 0xAA, 0xE2, 0x00, 0x62, 0x92,
  0x94, 0x9A, 0xB5, 0x59, 0x29, 0x4A, 0x8E, 0x38, 0x89, 0x22, 0xC6, 0x12,
  0x63, 0x44, 0xF4, 0xF0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x40, 0x21, 0x11,
  0x11, 0x12, 0x24, 0x80, 0x2A, 0x7A, 0x20, 0x21, 0x3E, 0x42, 0x10, 0x58,
  0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x32, 0x63, 0x18,
  0xC6, 0x31, 0xF0, 0x3C, 0x94, 0x92, 0x40, 0x38, 0x10, 0x41, 0x08, 0x42,
  0x10, 0xF8, 0x38, 0x10, 0x41, 0x38, 0x10, 0x41, 0xF8, 0x04, 0x31, 0x45,
  0x25, 0x2F, 0xC2, 0x08, 0x1C, 0x82, 0x10, 0x38, 0x10, 0x41, 0xF8, 0x3D,
  0x04, 0x2C, 0xCA, 0x28, 0xA2, 0xF0, 0x7C, 0x10, 0x84, 0x10, 0x82, 0x10,
  0x80, 0x32, 0x52, 0x97, 0x4E, 0x31, 0xF0, 0x32, 0x63, 0x18, 0xBC, 0x22,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x94, 0x0B, 0xA0, 0xC1, 0x80, 0xF8, 0x3E,
  0xC1, 0x82, 0x6C, 0x00, 0xE1, 0x11, 0x24, 0x80, 0x80, 0x3F, 0x20, 0x67,
  0xB4, 0x9A, 0x4D, 0x2A, 0x69, 0x00, 0x7C, 0x00, 0x04, 0x18, 0x30, 0x91,
  0x27, 0x88, 0xA1, 0x82, 0x79, 0x14, 0x61, 0x7A, 0x18, 0x62, 0xF0, 0x1E,
  0xC1, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0x78, 0x89, 0x0C, 0x18, 0x30,
  0x61, 0x46, 0xF0, 0x7D, 0x04, 0x20, 0x7A, 0x08, 0x20, 0xF0, 0x7D, 0x04,
  0x20, 0xFA, 0x08, 0x20, 0x80, 0x1E, 0xC1, 0x04, 0x08, 0xD0, 0x61, 0x42,
  0x7C, 0x42, 0x85, 0x0C, 0x17, 0xD0, 0xA1, 0x42, 0x84, 0x32, 0x22, 0x44,
  0x44, 0xC0, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x38, 0x42, 0x89, 0x65,
  0x06, 0x14, 0x24, 0x48, 0x88, 0x44, 0x48, 0x88, 0x88, 0xF0, 0x40, 0xA0,
  0x90, 0x54, 0x6A, 0x55, 0x2A, 0xA5, 0x54, 0x92, 0x00, 0x42, 0x85, 0x8D,
  0x19, 0x32, 0xA3, 0x46, 0x84, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC2,
  0x78, 0x79, 0x14, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x3C, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x68, 0x20, 0x20, 0x79, 0x14, 0x61, 0x8B, 0xC9, 0x24,
  0x88, 0x3D, 0x04, 0x10, 0x30, 0x20, 0x42, 0xF8, 0xFC, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x40, 0x42, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42, 0xF8, 0x86,
  0x18, 0x62, 0x91, 0x46, 0x10, 0x40, 0x84, 0x62, 0x18, 0x8A, 0x52, 0x95,
  0x29, 0x4A, 0x63, 0x10, 0x44, 0x00, 0x21, 0x22, 0x14, 0x14, 0x08, 0x18,
  0x28, 0x44, 0x84, 0x86, 0x28, 0x94, 0x61, 0x04, 0x10, 0x40, 0x3E, 0x08,
  0x10, 0x41, 0x04, 0x10, 0x20, 0xF8, 0x32, 0x44, 0x44, 0x88, 0x88, 0xC0,
  0xAA, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x44, 0x21, 0x38, 0x11, 0x8A,
  0x98, 0xC4, 0xF8, 0xC0, 0xFC, 0x63, 0x19, 0x78, 0x20, 0x85, 0x89, 0x45,
  0x14, 0x61, 0xF8, 0xFC, 0x21, 0x08, 0x78, 0x04, 0x13, 0x72, 0x8A, 0x28,
  0xA4, 0xF0, 0x7C, 0x7D, 0x08, 0x78, 0x0E, 0x10, 0x30, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x86, 0x00, 0x7D, 0x18, 0x61, 0x89, 0xE0, 0x82, 0xF0,
  0x20, 0x85, 0x89, 0x45, 0x14, 0x61, 0x88, 0x20, 0x24, 0x94, 0x80, 0x08,
  0x00, 0x21, 0x08, 0x44, 0x21, 0x09, 0x80, 0x20, 0x84, 0x52, 0x51, 0x85,
  0x24, 0x88, 0x25, 0x24, 0x94, 0x80, 0x3F, 0xA2, 0x51, 0x29, 0x18, 0x8C,
  0x44, 0x3D, 0x14, 0x51, 0x86, 0x20, 0xFC, 0x63, 0x18, 0xF8, 0x3D, 0x14,
  0x51, 0x87, 0xE8, 0x20, 0x80, 0xFC, 0x63, 0x19, 0x78, 0x42, 0x10, 0x3A,
  0x10, 0x88, 0x40, 0x7A, 0x08, 0x21, 0x78, 0x5E, 0x49, 0x26, 0x8C, 0x63,
  0x19, 0x78, 0x9C, 0xA9, 0x4C, 0x40, 0x93, 0x67, 0x56, 0xA9, 0x92, 0x00,
  0x4C, 0xC2, 0x14, 0x52, 0x20, 0x46, 0x48, 0xA1, 0x43, 0x04, 0x08, 0x20,
  0x80, 0x78, 0x88, 0x84, 0x78, 0x19, 0x08, 0x42, 0x61, 0x08, 0x44, 0x10,
  0xFF, 0xF0, 0x20, 0x84, 0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 5, 10, 7, 1, -9 },
  { 22, 8, 9, 9, 1, -9 },
  { 31, 7, 9, 8, 1, -9 },
  { 39, 1, 4, 2, 1, -9 },
  { 40, 4, 11, 3, 0, -9 },
  { 46, 4, 11, 3, -1, -9 },
  { 52, 4, 5, 6, 2, -9 },
  { 55, 5, 6, 7, 1, -7 },
  { 59, 2, 3, 2, -1, -1 },
  { 60, 3, 1, 4, 0, -4 },
  { 61, 1, 1, 3, 0, -1 },
  { 62, 6, 9, 4, -1, -9 },
  { 69, 5, 9, 7, 1, -9 },
  { 75, 3, 9, 7, 2, -9 },
  { 79, 6, 9, 7, 0, -9 },
  { 86, 6, 9, 7, 0, -9 },
  { 93, 6, 9, 7, 0, -9 },
  { 100, 6, 9, 7, 0, -9 },
  { 107, 6, 9, 7, 1, -9 },
  { 114, 6, 9, 7, 1, -9 },
  { 121, 5, 9, 7, 1, -9 },
  { 127, 5, 9, 7, 1, -9 },
  { 133, 2, 6, 3, 0, -6 },
  { 135, 3, 8, 3, -1, -6 },
  { 138, 5, 5, 7, 1, -7 },
  { 142, 5, 3, 7, 1, -6 },
  { 144, 5, 5, 7, 1, -7 },
  { 148, 4, 9, 5, 1, -9 },
  { 153, 9, 9, 10, 1, -8 },
  { 164, 7, 9, 7, -1, -9 },
  { 172, 6, 9, 7, 1, -9 },
  { 179, 7, 9, 7, 1, -9 },
  { 187, 7, 9, 8, 1, -9 },
  { 195, 6, 9, 6, 1, -9 },
  { 202, 6, 9, 6, 1, -9 },
  { 209, 7, 9, 8, 1, -9 },
  { 217, 7, 9, 8, 1, -9 },
  { 225, 4, 9, 3, 0, -9 },
  { 230, 5, 11, 3, -2, -9 },
  { 237, 7, 9, 7, 1, -9 },
  { 245, 4, 9, 6, 1, -9 },
  { 250, 9, 9, 10, 1, -9 },
  { 261, 7, 9, 8, 1, -9 },
  { 269, 7, 9, 9, 1, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 7, 11, 9, 1, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 6, 9, 6, 0, -9 },
  { 308, 6, 9, 6, 1, -9 },
  { 315, 7, 9, 8, 1, -9 },
  { 323, 6, 9, 6, 1, -9 },
  { 330, 10, 9, 10, 1, -9 },
  { 342, 8, 9, 6, -1, -9 },
  { 351, 6, 9, 6, 1, -9 },
  { 358, 7, 9, 6, 0, -9 },
  { 366, 4, 11, 4, 0, -9 },
  { 372, 2, 9, 4, 1, -9 },
  { 375, 5, 11, 4, -1, -9 },
  { 382, 5, 6, 7, 1, -9 },
  { 386, 5, 1, 4, -1, 1 },
  { 387, 1, 2, 3, 2, -9 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 6, 9, 7, 0, -9 },
  { 399, 5, 6, 5, 1, -6 },
  { 403, 6, 9, 7, 1, -9 },
  { 410, 5, 6, 6, 1, -6 },
  { 414, 7, 12, 3, -2, -9 },
  { 425, 6, 9, 7, 0, -6 },
  { 432, 6, 9, 7, 0, -9 },
  { 439, 3, 9, 2, 0, -9 },
  { 443, 5, 12, 2, -2, -9 },
  { 451, 6, 9, 5, 0, -9 },
  { 458, 3, 9, 2, 0, -9 },
  { 462, 9, 6, 10, 0, -6 },
  { 469, 6, 6, 7, 0, -6 },
  { 474, 5, 6, 7, 1, -6 },
  { 478, 6, 9, 7, 0, -6 },
  { 485, 5, 9, 7, 1, -6 },
  { 491, 5, 6, 4, 0, -6 },
  { 495, 5, 6, 5, 0, -6 },
  { 499, 3, 8, 4, 1, -8 },
  { 502, 5, 6, 7, 1, -6 },
  { 506, 5, 6, 5, 1, -6 },
  { 510, 7, 6, 8, 1, -6 },
  { 516, 6, 6, 5, 0, -6 },
  { 521, 7, 9, 5, -1, -6 },
  { 529, 5, 6, 5, 0, -6 },
  { 533, 5, 11, 4, 0, -9 },
  { 540, 1, 12, 6, 3, -9 },
  { 542, 5, 11, 4, -1, -9 },
  { 549, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_THINITALIC12PT7B_H_
