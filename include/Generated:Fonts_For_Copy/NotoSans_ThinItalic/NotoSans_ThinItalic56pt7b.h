#ifndef _NOTOSANS_THINITALIC56PT7B_H_
#define _NOTOSANS_THINITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x0E, 0x03, 0x00, 0x18, 0x11, 0x03, 0x10, 0x33, 0x03, 0x30, 0x22, 0x02,
  0x20, 0x62, 0x06, 0x60, 0x44, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x8C, 0x08,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x01, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x04, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x08, 0x1C, 0x07, 0x02, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x10, 0x04, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x74, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x20, 0x10, 0x00, 0x18, 0x04, 0x00, 0x04, 0x01, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x80, 0x20, 0xE0, 0x3F, 0x19, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x18, 0x30, 0x00,
  0x0C, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x20, 0x00, 0x40, 0x30, 0x04,
  0x00, 0x18, 0x0C, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x18, 0x01, 0x80, 0x20,
  0x03, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x08, 0x03, 0x00,
  0x20, 0x01, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x04, 0x06,
  0x00, 0x30, 0x01, 0x81, 0x80, 0x04, 0x00, 0x30, 0x20, 0x00, 0x80, 0x04,
  0x08, 0x00, 0x10, 0x01, 0x83, 0x0F, 0xE2, 0x00, 0x30, 0xC3, 0x86, 0x40,
  0x04, 0x10, 0xC0, 0x6C, 0x01, 0x86, 0x30, 0x05, 0x80, 0x61, 0x86, 0x00,
  0x90, 0x18, 0x61, 0x80, 0x1B, 0x06, 0x08, 0x20, 0x03, 0x3F, 0x83, 0x04,
  0x00, 0x60, 0x80, 0xC1, 0x80, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x20, 0x01, 0x81, 0x80, 0x04, 0x00, 0x60, 0x30, 0x00, 0x80,
  0x18, 0x06, 0x00, 0x30, 0x02, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x10, 0x00,
  0x80, 0x30, 0x02, 0x00, 0x30, 0x04, 0x00, 0x40, 0x06, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x60, 0x01, 0x80, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x02, 0x00,
  0x06, 0x01, 0x00, 0xC0, 0x00, 0x60, 0xE0, 0x30, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x04, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x03, 0x18, 0x00, 0xC0, 0x03, 0x18,
  0x00, 0x30, 0x01, 0x18, 0x00, 0x08, 0x01, 0x88, 0x00, 0x06, 0x00, 0x8C,
  0x00, 0x01, 0x80, 0xC6, 0x00, 0x00, 0x60, 0xC2, 0x00, 0x00, 0x10, 0x41,
  0x00, 0x00, 0x0C, 0x40, 0x80, 0x00, 0x03, 0x60, 0x40, 0x00, 0x00, 0xE0,
  0x20, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xC6,
  0x03, 0x00, 0x00, 0xC1, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x38, 0x03, 0x80,
  0x30, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x84,
  0x63, 0x10, 0x84, 0x62, 0x10, 0x84, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x08, 0x01, 0x00, 0x38, 0x06,
  0x00, 0x1C, 0x08, 0x00, 0x0E, 0x10, 0x00, 0x06, 0x20, 0x00, 0x03, 0x41,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x62, 0x00,
  0x01, 0x84, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xDF, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x18, 0x18, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x88, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x08, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x00, 0x70, 0x18, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x80, 0x72, 0x03, 0x18, 0x38,
  0x61, 0x81, 0x1C, 0x04, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x60, 0x10, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x07,
  0x80, 0x0E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x03, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x80, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0x04, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x07, 0x00, 0x08, 0x1F, 0xF8, 0x02, 0x1C, 0x03,
  0x01, 0x9C, 0x00, 0x60, 0x6C, 0x00, 0x0C, 0x16, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x18, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02,
  0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x04, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x0E,
  0x18, 0x00, 0x06, 0x83, 0x00, 0x03, 0x20, 0x60, 0x01, 0x98, 0x0C, 0x03,
  0xC4, 0x01, 0xFF, 0xC1, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x02, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x01, 0xFF, 0x80, 0xE0, 0x1C, 0x10, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0xC6, 0x00, 0x0E, 0x03,
  0x80, 0x31, 0x00, 0x0E, 0x00, 0x60, 0x04, 0xC0, 0x06, 0x00, 0x18, 0x01,
  0x30, 0x03, 0x00, 0x04, 0x00, 0x48, 0x00, 0x80, 0x01, 0x00, 0x16, 0x00,
  0x60, 0x00, 0xC0, 0x05, 0x80, 0x30, 0x00, 0x20, 0x01, 0x40, 0x0C, 0x00,
  0x08, 0x00, 0xF0, 0x02, 0x00, 0x02, 0x00, 0x3C, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0x00, 0x60, 0x00, 0x40, 0x02, 0xC0, 0x10, 0x00, 0x10, 0x01, 0xB0,
  0x04, 0x00, 0x0C, 0x00, 0x6C, 0x01, 0x00, 0x03, 0x00, 0x13, 0x00, 0x40,
  0x01, 0xC0, 0x0C, 0xC0, 0x10, 0x00, 0xF0, 0x06, 0x30, 0x06, 0x00, 0x2C,
  0x01, 0x8C, 0x01, 0x80, 0x1B, 0x00, 0xC1, 0x00, 0x30, 0x1C, 0x40, 0xE0,
  0x40, 0x07, 0xBC, 0x1C, 0xF0, 0x18, 0x00, 0xFC, 0x03, 0xF0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00,
  0x04, 0x00, 0xFE, 0x00, 0x20, 0x00, 0x38, 0x01, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x01, 0xC0, 0x20, 0x00,
  0x38, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0xE0,
  0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x1C, 0x03, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x01,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xE0, 0x08,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x80, 0x03,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x40, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC4, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x00, 0x01, 0x80, 0x01, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x04, 0x38, 0x00,
  0x00, 0x0C, 0x6C, 0x00, 0x00, 0x0C, 0xCC, 0x00, 0x00, 0x09, 0x86, 0x00,
  0x00, 0x0A, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x40, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x02, 0x80, 0x00, 0x00, 0x1A, 0x01, 0xA0, 0x00, 0x00, 0x05, 0x80,
  0x68, 0x00, 0x00, 0x03, 0x60, 0x13, 0x00, 0x00, 0x00, 0x90, 0x04, 0xC0,
  0x00, 0x00, 0x64, 0x03, 0x30, 0x00, 0x00, 0x31, 0x00, 0xC4, 0x00, 0x00,
  0x08, 0xC0, 0x31, 0x00, 0x00, 0x06, 0x30, 0x08, 0x40, 0x00, 0x01, 0x08,
  0x02, 0x18, 0x00, 0x00, 0xC2, 0x01, 0x86, 0x00, 0x00, 0x60, 0x80, 0x60,
  0x80, 0x00, 0x10, 0x60, 0x10, 0x20, 0x00, 0x0C, 0x18, 0x04, 0x08, 0x00,
  0x02, 0x04, 0x01, 0x02, 0x00, 0x01, 0x81, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x00, 0x20, 0x30, 0x08, 0x04, 0x00, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0x04, 0x02, 0x01, 0x80, 0x40, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x40, 0x18, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40,
  0x30, 0x02, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x02, 0x00,
  0x30, 0x60, 0x02, 0x00, 0x80, 0x04, 0x10, 0x00, 0x80, 0x60, 0x01, 0x0C,
  0x00, 0x20, 0x18, 0x00, 0x46, 0x00, 0x18, 0x04, 0x00, 0x11, 0x00, 0x06,
  0x01, 0x00, 0x06, 0xC0, 0x01, 0x00, 0x40, 0x01, 0xA0, 0x00, 0x40, 0x30,
  0x00, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x01, 0xA0, 0x00, 0x00,
  0xC0, 0x6C, 0x00, 0x00, 0x20, 0x11, 0x00, 0x00, 0x08, 0x04, 0x60, 0x00,
  0x06, 0x03, 0x18, 0x00, 0x01, 0x80, 0xC2, 0x00, 0x00, 0x40, 0x30, 0xC0,
  0x00, 0x10, 0x08, 0x10, 0x00, 0x04, 0x02, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x80, 0x00, 0xC0, 0x60, 0x30, 0x00, 0x20, 0x18, 0x0C, 0x00, 0x08, 0x04,
  0x01, 0x00, 0x06, 0x01, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x08, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x10, 0x08, 0x00, 0x40, 0x04, 0x02, 0x00, 0x18, 0x03,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x30, 0x18, 0x00, 0x30,
  0x08, 0x04, 0x00, 0x04, 0x02, 0x01, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x00,
  0x20, 0x60, 0x30, 0x00, 0x0C, 0x10, 0x0C, 0x00, 0x03, 0x04, 0x02, 0x00,
  0x00, 0x41, 0x00, 0x80, 0x00, 0x18, 0xC0, 0x60, 0x00, 0x02, 0x30, 0x18,
  0x00, 0x00, 0xC8, 0x04, 0x00, 0x00, 0x12, 0x01, 0x00, 0x00, 0x06, 0x80,
  0x40, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x80, 0x03, 0x80, 0x08, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x0E,
  0x00, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x80, 0x01,
  0xC0, 0x08, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x04, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0x08, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x70, 0x0F, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x17, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x04, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x10, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x20, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x80,
  0x01, 0x00, 0x10, 0x00, 0x10, 0x03, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10,
  0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x6C, 0x00, 0x02, 0x30, 0x00, 0x09, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC1, 0x00, 0x02, 0x08, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x04,
  0x00, 0x10, 0x20, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00, 0x30, 0x10, 0x00,
  0x80, 0x80, 0x04, 0x02, 0x00, 0x30, 0x10, 0x01, 0x80, 0x40, 0x04, 0x02,
  0x00, 0x20, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x00, 0x30, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x00,
  0x80, 0x60, 0x06, 0x01, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x00, 0x18, 0x08, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00,
  0x60, 0x40, 0x01, 0x83, 0x00, 0x04, 0x18, 0x00, 0x30, 0x40, 0x00, 0x82,
  0x00, 0x06, 0x18, 0x00, 0x10, 0xC0, 0x00, 0xC2, 0x00, 0x02, 0x10, 0x00,
  0x18, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x26,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x00, 0xB0, 0x00,
  0x04, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x80, 0x00, 0x14,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x60, 0x10, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x20,
  0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xC0,
  0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00, 0x18, 0x08, 0x00, 0x18, 0x04,
  0x00, 0x08, 0x02, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x03, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x09, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x81, 0x81, 0x03, 0x03, 0x02, 0x06, 0x06, 0x00, 0x1F,
  0xC0, 0xC0, 0x1E, 0x1C, 0x20, 0x1C, 0x01, 0x88, 0x0C, 0x00, 0x22, 0x06,
  0x00, 0x05, 0x83, 0x00, 0x01, 0x60, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x02,
  0x83, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x58, 0x10, 0x00, 0x24, 0x06, 0x00,
  0x31, 0x00, 0xC0, 0x18, 0x40, 0x18, 0x1C, 0x30, 0x03, 0xFC, 0x08, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x07, 0xF0, 0x00, 0x83, 0xC3, 0x80, 0x10, 0xC0, 0x18, 0x06, 0x60, 0x01,
  0x80, 0xD8, 0x00, 0x10, 0x12, 0x00, 0x03, 0x02, 0x80, 0x00, 0x20, 0x70,
  0x00, 0x04, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x04, 0x38, 0x00, 0x01, 0x85, 0x00, 0x00, 0x60, 0xA0, 0x00, 0x0C, 0x16,
  0x00, 0x03, 0x02, 0x40, 0x00, 0xC0, 0xCC, 0x00, 0x70, 0x10, 0xE0, 0x38,
  0x02, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x7C, 0x07, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xF0, 0x30, 0x01, 0xE1, 0xE1, 0x80, 0x38, 0x01, 0x88,
  0x03, 0x00, 0x04, 0x40, 0x30, 0x00, 0x16, 0x03, 0x00, 0x00, 0xB0, 0x10,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x28,
  0x0C, 0x00, 0x03, 0x40, 0x60, 0x00, 0x36, 0x01, 0x00, 0x03, 0x20, 0x0C,
  0x00, 0x31, 0x00, 0x30, 0x03, 0x08, 0x00, 0xC0, 0x70, 0x40, 0x03, 0xFE,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xF0,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x61, 0x00, 0x01, 0xC6, 0x00, 0x0E, 0x0C, 0x00, 0xF8, 0x1F, 0xFF,
  0x80, 0x3F, 0x40, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0xE0, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x18, 0x00, 0xF0,
  0xF0, 0xC0, 0x1C, 0x00, 0xC4, 0x01, 0x80, 0x02, 0x20, 0x18, 0x00, 0x09,
  0x01, 0x80, 0x00, 0x58, 0x08, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x14, 0x06, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x1B,
  0x00, 0x80, 0x01, 0x90, 0x06, 0x00, 0x18, 0x80, 0x18, 0x01, 0x84, 0x00,
  0x60, 0x38, 0x60, 0x01, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0xC0,
  0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0x00, 0x20, 0xF1, 0xE0, 0x08, 0x60, 0x0C, 0x06, 0x70,
  0x01, 0x81, 0x90, 0x00, 0x20, 0x48, 0x00, 0x08, 0x14, 0x00, 0x03, 0x07,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x08,
  0x30, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x08, 0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x10, 0x18, 0x00, 0x08, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x02, 0x1E, 0x00, 0x01, 0x19, 0x00, 0x00,
  0x98, 0xC0, 0x00, 0xD0, 0x20, 0x00, 0x70, 0x18, 0x00, 0x30, 0x04, 0x00,
  0x10, 0x03, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x10,
  0x02, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0x40, 0x60, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x00, 0x02, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x87, 0x8F, 0x01, 0xE3,
  0xC0, 0x23, 0x00, 0xC0, 0xC0, 0x38, 0x19, 0x80, 0x18, 0x60, 0x06, 0x04,
  0xC0, 0x02, 0x30, 0x00, 0x81, 0x60, 0x00, 0x98, 0x00, 0x30, 0x50, 0x00,
  0x34, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x00, 0x00, 0x86, 0x00,
  0x01, 0x80, 0x00, 0x61, 0x80, 0x00, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x00, 0x00, 0x86, 0x00, 0x01,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x00, 0x00, 0x43,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x83, 0xC7, 0x80, 0x21,
  0x80, 0x30, 0x19, 0xC0, 0x06, 0x04, 0xC0, 0x00, 0x81, 0x20, 0x00, 0x20,
  0x50, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x02, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02,
  0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x40, 0x00,
  0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x08, 0x20, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x18, 0x60, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x7F, 0x00, 0x01, 0x07, 0x87, 0x00, 0x04, 0x30, 0x06, 0x00, 0x33,
  0x00, 0x0C, 0x00, 0x98, 0x00, 0x10, 0x02, 0x40, 0x00, 0x60, 0x0A, 0x00,
  0x00, 0x80, 0x38, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0xE0, 0x00,
  0x06, 0x02, 0x80, 0x00, 0x30, 0x0A, 0x00, 0x00, 0xC0, 0x2C, 0x00, 0x06,
  0x00, 0x90, 0x00, 0x30, 0x06, 0x60, 0x03, 0x80, 0x18, 0xE0, 0x38, 0x00,
  0x40, 0xFF, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0x0F, 0x0C,
  0x07, 0x00, 0x31, 0x01, 0x80, 0x02, 0x20, 0x60, 0x00, 0x24, 0x18, 0x00,
  0x05, 0x82, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03,
  0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x30, 0x00, 0x05, 0x06, 0x00,
  0x01, 0xA0, 0xC0, 0x00, 0x6C, 0x08, 0x00, 0x19, 0x01, 0x80, 0x06, 0x20,
  0x18, 0x01, 0x84, 0x01, 0x80, 0xE1, 0x80, 0x1F, 0xF0, 0x30, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x03, 0xF0, 0x20, 0xF3,
  0x02, 0x38, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x05, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0x0F, 0xC1, 0xC0, 0x02, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x21, 0x00, 0x03, 0x0F,
  0x00, 0x60, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x02, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0xA0, 0xC0, 0x00, 0x58, 0x30, 0x00, 0x36, 0x04, 0x00, 0x19, 0x01,
  0x80, 0x1C, 0x40, 0x38, 0x1C, 0x10, 0x07, 0xFC, 0x0C, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30,
  0x40, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x01, 0x00, 0x08, 0x02,
  0x00, 0x30, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x06,
  0x00, 0x02, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x09, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x50, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x16,
  0x00, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x00, 0x98, 0x00, 0x46, 0x00,
  0x33, 0x00, 0x18, 0x40, 0x04, 0x20, 0x02, 0x08, 0x01, 0x84, 0x00, 0xC1,
  0x00, 0x20, 0x80, 0x10, 0x20, 0x0C, 0x10, 0x06, 0x04, 0x01, 0x02, 0x00,
  0x80, 0x80, 0x60, 0x40, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x81, 0x80, 0x40, 0x40, 0x30, 0x30, 0x08, 0x18, 0x02, 0x0C, 0x01, 0x82,
  0x00, 0x41, 0x80, 0x30, 0xC0, 0x08, 0x20, 0x06, 0x10, 0x01, 0x0C, 0x00,
  0xC6, 0x00, 0x21, 0x00, 0x18, 0x80, 0x04, 0x60, 0x03, 0x30, 0x00, 0xC8,
  0x00, 0x2C, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x10, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5C, 0x1E, 0x00, 0x1C, 0x00, 0xF0,
  0x1A, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 40, 12, 2, -40 },
  { 51, 12, 14, 17, 6, -40 },
  { 72, 33, 40, 34, 2, -40 },
  { 237, 26, 45, 31, 3, -42 },
  { 384, 35, 42, 43, 5, -41 },
  { 568, 33, 42, 38, 3, -41 },
  { 742, 5, 14, 10, 6, -40 },
  { 751, 15, 49, 14, 2, -40 },
  { 843, 16, 49, 14, -4, -40 },
  { 941, 23, 23, 30, 7, -42 },
  { 1008, 26, 26, 32, 4, -33 },
  { 1093, 8, 14, 10, -3, -7 },
  { 1107, 13, 2, 17, 2, -16 },
  { 1111, 3, 3, 12, 2, -3 },
  { 1113, 24, 40, 17, -2, -40 },
  { 1233, 26, 42, 31, 4, -41 },
  { 1370, 14, 40, 31, 9, -40 },
  { 1440, 27, 41, 31, 1, -41 },
  { 1579, 28, 42, 31, 1, -41 },
  { 1726, 29, 40, 31, 1, -40 },
  { 1871, 28, 41, 31, 2, -40 },
  { 2015, 26, 42, 31, 4, -41 },
  { 2152, 25, 40, 31, 6, -40 },
  { 2277, 27, 42, 31, 3, -41 },
  { 2419, 26, 42, 31, 3, -41 },
  { 2556, 8, 30, 12, 2, -30 },
  { 2586, 13, 37, 12, -3, -30 },
  { 2647, 26, 25, 32, 4, -33 },
  { 2729, 26, 13, 32, 4, -26 },
  { 2772, 26, 25, 32, 4, -33 },
  { 2854, 19, 41, 23, 5, -41 },
  { 2952, 42, 45, 47, 3, -40 },
  { 3189, 31, 40, 31, -3, -40 },
  { 3344, 29, 40, 33, 3, -40 },
  { 3489, 30, 42, 33, 5, -41 },
  { 3647, 33, 40, 38, 3, -40 },
  { 3812, 28, 40, 30, 3, -40 },
  { 3952, 28, 40, 27, 3, -40 },
  { 4092, 32, 42, 39, 5, -41 },
  { 4260, 35, 40, 38, 3, -40 },
  { 4435, 18, 40, 16, 0, -40 },
  { 4525, 23, 50, 13, -10, -40 },
  { 4669, 32, 40, 30, 3, -40 },
  { 4829, 20, 40, 28, 3, -40 },
  { 4929, 42, 40, 45, 3, -40 },
  { 5139, 34, 40, 38, 3, -40 },
  { 5309, 33, 42, 40, 5, -41 },
  { 5483, 28, 40, 31, 3, -40 },
  { 5623, 33, 51, 40, 5, -41 },
  { 5834, 28, 40, 31, 3, -40 },
  { 5974, 28, 42, 28, 1, -41 },
  { 6121, 27, 40, 27, 5, -40 },
  { 6256, 34, 41, 39, 5, -40 },
  { 6431, 28, 40, 30, 6, -40 },
  { 6571, 43, 40, 46, 7, -40 },
  { 6786, 35, 40, 27, -3, -40 },
  { 6961, 27, 40, 27, 5, -40 },
  { 7096, 32, 40, 30, 0, -40 },
  { 7256, 22, 49, 17, -1, -40 },
  { 7391, 9, 40, 17, 5, -40 },
  { 7436, 21, 49, 17, -4, -40 },
  { 7565, 25, 24, 31, 3, -40 },
  { 7640, 21, 2, 21, -5, 6 },
  { 7646, 7, 9, 13, 8, -43 },
  { 7654, 26, 31, 31, 3, -30 },
  { 7755, 27, 44, 32, 2, -43 },
  { 7904, 23, 31, 25, 3, -30 },
  { 7994, 29, 44, 32, 3, -43 },
  { 8154, 23, 31, 28, 3, -30 },
  { 8244, 30, 56, 15, -7, -43 },
  { 8454, 29, 43, 32, 1, -30 },
  { 8610, 26, 43, 31, 2, -43 },
  { 8750, 10, 40, 12, 2, -40 },
  { 8800, 20, 53, 12, -8, -40 },
  { 8933, 25, 43, 25, 2, -43 },
  { 9068, 10, 43, 12, 2, -43 },
  { 9122, 42, 30, 47, 2, -30 },
  { 9280, 26, 30, 31, 2, -30 },
  { 9378, 26, 31, 32, 3, -30 },
  { 9479, 30, 43, 32, -1, -30 },
  { 9641, 27, 43, 32, 3, -30 },
  { 9787, 20, 30, 21, 2, -30 },
  { 9862, 21, 31, 24, 1, -30 },
  { 9944, 15, 38, 17, 3, -37 },
  { 10016, 26, 31, 31, 3, -30 },
  { 10117, 23, 30, 23, 3, -30 },
  { 10204, 35, 30, 36, 3, -30 },
  { 10336, 28, 30, 25, -2, -30 },
  { 10441, 32, 44, 23, -6, -30 },
  { 10617, 25, 30, 24, -1, -30 },
  { 10711, 19, 49, 18, 2, -40 },
  { 10828, 1, 57, 30, 16, -43 },
  { 10836, 20, 49, 18, -3, -40 },
  { 10959, 26, 5, 32, 4, -22 },
};

const GFXfont NotoSans_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_THINITALIC56PT7B_H_
