#ifndef _NOTOSANS_THINITALIC42PT7B_H_
#define _NOTOSANS_THINITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x21, 0xB0, 0x90, 0x48, 0x24,
  0x12, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x04, 0x02, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x10,
  0x00, 0x30, 0x10, 0x07, 0xFF, 0xFF, 0xE0, 0x08, 0x04, 0x00, 0x04, 0x06,
  0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x0F, 0xFF, 0xFF, 0xC8, 0x20,
  0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00,
  0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x38, 0x83, 0x06, 0x08, 0x00,
  0x40, 0x80, 0x08, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00,
  0x08, 0x10, 0x00, 0xC1, 0x00, 0x06, 0x20, 0x00, 0x3A, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x46, 0x00, 0x04, 0x30, 0x00, 0x41, 0x80, 0x04,
  0x08, 0x00, 0x40, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x10, 0x00,
  0x83, 0x08, 0x08, 0x60, 0xF1, 0x18, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x01, 0x06, 0x18,
  0x00, 0x83, 0x02, 0x00, 0x60, 0x80, 0x80, 0x10, 0x60, 0x20, 0x08, 0x10,
  0x0C, 0x04, 0x04, 0x02, 0x03, 0x02, 0x00, 0x80, 0x80, 0x80, 0x20, 0x40,
  0x20, 0x08, 0x20, 0x08, 0x02, 0x18, 0x02, 0x01, 0x84, 0x00, 0x80, 0x42,
  0x1F, 0x20, 0x11, 0x08, 0x28, 0x08, 0xC4, 0x0A, 0x06, 0x22, 0x03, 0xC3,
  0x10, 0x80, 0x5F, 0x8C, 0x40, 0x10, 0x02, 0x10, 0x04, 0x01, 0x04, 0x03,
  0x00, 0x82, 0x00, 0x80, 0x60, 0x80, 0x20, 0x10, 0x20, 0x08, 0x08, 0x08,
  0x02, 0x04, 0x02, 0x01, 0x03, 0x00, 0x80, 0x40, 0x80, 0x20, 0x30, 0x40,
  0x08, 0x08, 0x20, 0x01, 0x04, 0x18, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x30, 0x30, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x02, 0x00,
  0x40, 0x01, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x60, 0x60, 0x00, 0x10,
  0x40, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x88, 0x06, 0x00, 0x88, 0x01, 0x00, 0x48,
  0x00, 0x40, 0x44, 0x00, 0x10, 0x64, 0x00, 0x0C, 0x22, 0x00, 0x02, 0x21,
  0x00, 0x00, 0xA0, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x30, 0x00, 0x24,
  0x0C, 0x00, 0x61, 0x03, 0x00, 0xC0, 0xC0, 0xFF, 0x80, 0x30, 0x2D, 0x24,
  0xA4, 0x92, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x04, 0x04, 0x07, 0x02, 0x00, 0x61, 0x00, 0x09, 0x00,
  0x03, 0x9F, 0x80, 0x70, 0x00, 0xD0, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0x81,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x20, 0x86, 0x10,
  0xC2, 0x08, 0x43, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x30, 0x08, 0x03, 0x02, 0x00,
  0x20, 0x80, 0x06, 0x30, 0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x02, 0x10, 0x00, 0xC1, 0x00, 0x10, 0x30, 0x04, 0x03, 0x03, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x50, 0x6C, 0x32, 0x30, 0x98, 0x28, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x01, 0x80, 0x60,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x0E, 0x01, 0x01, 0x80, 0x04, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x21, 0x00,
  0x06, 0x0C, 0x00, 0x60, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00,
  0x10, 0x80, 0x01, 0x04, 0x00, 0x18, 0x60, 0x01, 0x82, 0x00, 0x18, 0x10,
  0x01, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x08, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x0C,
  0x00, 0x10, 0x7F, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0xBF, 0x80,
  0x0E, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC1, 0x00, 0x0C, 0x0C, 0x01, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x63, 0xFC, 0x04, 0xC0, 0x30, 0x58, 0x01, 0x06, 0x00,
  0x08, 0xE0, 0x00, 0x8C, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80,
  0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x0C,
  0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x40, 0x30, 0x18, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x18, 0x04, 0x03, 0x00, 0x20, 0x20, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x30, 0x40,
  0x02, 0x02, 0x00, 0x40, 0x30, 0x08, 0x01, 0x83, 0x00, 0x05, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0xC0, 0x0C, 0x02, 0x01, 0x00, 0x10, 0x20, 0x00, 0x84,
  0x00, 0x08, 0xC0, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0x40, 0x01, 0x86, 0x00, 0x30, 0x30, 0x0E,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x18, 0x08, 0x02, 0x00, 0x40, 0x40,
  0x02, 0x08, 0x00, 0x21, 0x80, 0x03, 0x10, 0x00, 0x11, 0x00, 0x01, 0x30,
  0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x03, 0x20, 0x00, 0x33,
  0x00, 0x06, 0x10, 0x00, 0xE1, 0x80, 0x1A, 0x0C, 0x03, 0x20, 0x7F, 0xC4,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x0F, 0xF8, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x60, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x02, 0x10, 0x01, 0xFF, 0x03, 0x30, 0x06, 0x02,
  0x01, 0x20, 0x0C, 0x02, 0x01, 0x20, 0x10, 0x02, 0x01, 0x40, 0x30, 0x02,
  0x01, 0x40, 0x20, 0x04, 0x01, 0x40, 0x40, 0x04, 0x01, 0x40, 0x40, 0x04,
  0x03, 0xC0, 0x40, 0x0C, 0x02, 0xC0, 0xC0, 0x08, 0x02, 0x80, 0x80, 0x08,
  0x06, 0x80, 0x80, 0x18, 0x04, 0xC0, 0xC0, 0x18, 0x0C, 0xC0, 0x40, 0x28,
  0x18, 0x40, 0x60, 0xC8, 0x30, 0x40, 0x3F, 0x87, 0xE0, 0x40, 0x04, 0x01,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04,
  0x02, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x02, 0x00,
  0x10, 0x07, 0xFF, 0xE0, 0x10, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x00,
  0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x13, 0x00, 0x00, 0x34, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x03, 0xFF, 0xC0, 0x08, 0x01, 0xC0, 0x20, 0x00, 0x80, 0x80, 0x01, 0x06,
  0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00,
  0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x60,
  0x20, 0x0F, 0x01, 0xFF, 0xF0, 0x04, 0x00, 0x30, 0x10, 0x00, 0x60, 0x40,
  0x00, 0xC1, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84,
  0x00, 0x04, 0x10, 0x00, 0x60, 0xC0, 0x0F, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x70, 0x00, 0x80, 0x06, 0x00,
  0x40, 0x01, 0x80, 0x60, 0x00, 0x60, 0x20, 0x00, 0x10, 0x10, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x10, 0x20, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x08, 0x00, 0x70, 0x0C, 0x01, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xFF, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x07,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x0F, 0xFC, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x10, 0x30, 0x00, 0x20, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC1, 0xFF, 0xFF,
  0xE0, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x20, 0x00,
  0x04, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x03, 0x00,
  0x03, 0x02, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x10, 0x06, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x01, 0x80, 0x04, 0x03, 0x00, 0x04, 0x06,
  0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x08, 0xC0,
  0x00, 0x09, 0xC0, 0x00, 0x1B, 0x20, 0x00, 0x16, 0x20, 0x00, 0x18, 0x10,
  0x00, 0x10, 0x10, 0x00, 0x10, 0x18, 0x00, 0x20, 0x08, 0x00, 0x20, 0x0C,
  0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03,
  0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x00,
  0xC0, 0x80, 0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0E, 0x02, 0x80, 0x00, 0x0A, 0x06, 0x80, 0x00, 0x12, 0x04, 0x80, 0x00,
  0x14, 0x04, 0x80, 0x00, 0x24, 0x04, 0x80, 0x00, 0x64, 0x04, 0x80, 0x00,
  0x44, 0x0C, 0x40, 0x00, 0x84, 0x08, 0x40, 0x00, 0x88, 0x08, 0x40, 0x01,
  0x08, 0x08, 0x40, 0x03, 0x08, 0x08, 0x40, 0x02, 0x08, 0x18, 0x20, 0x04,
  0x18, 0x10, 0x20, 0x04, 0x10, 0x10, 0x20, 0x08, 0x10, 0x10, 0x20, 0x18,
  0x10, 0x10, 0x20, 0x10, 0x10, 0x20, 0x20, 0x20, 0x30, 0x20, 0x10, 0x20,
  0x20, 0x20, 0x10, 0x40, 0x20, 0x20, 0x10, 0xC0, 0x20, 0x60, 0x10, 0x80,
  0x20, 0x40, 0x11, 0x00, 0x40, 0x40, 0x19, 0x00, 0x40, 0x40, 0x0A, 0x00,
  0x40, 0x40, 0x0E, 0x00, 0x40, 0xC0, 0x0C, 0x00, 0x40, 0x80, 0x08, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0A,
  0x00, 0x02, 0x06, 0x80, 0x00, 0x81, 0x30, 0x00, 0x20, 0x44, 0x00, 0x08,
  0x11, 0x00, 0x06, 0x04, 0x20, 0x01, 0x03, 0x08, 0x00, 0x40, 0x81, 0x00,
  0x10, 0x20, 0x40, 0x04, 0x08, 0x18, 0x02, 0x02, 0x02, 0x00, 0x81, 0x80,
  0x80, 0x20, 0x40, 0x10, 0x08, 0x10, 0x04, 0x06, 0x04, 0x00, 0x81, 0x01,
  0x00, 0x20, 0x40, 0x80, 0x0C, 0x10, 0x20, 0x01, 0x04, 0x08, 0x00, 0x43,
  0x02, 0x00, 0x08, 0x81, 0x80, 0x02, 0x20, 0x40, 0x00, 0x48, 0x10, 0x00,
  0x12, 0x04, 0x00, 0x07, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x38, 0x03, 0x00, 0x0C,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x20, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x10, 0x07, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00,
  0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x42,
  0x00, 0x02, 0x10, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x10, 0x60, 0x01,
  0x82, 0x00, 0x30, 0x1F, 0xFE, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x04, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x20, 0x00,
  0x20, 0x30, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x80, 0x10, 0x07,
  0x00, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02,
  0x10, 0x00, 0x30, 0x80, 0x03, 0x04, 0x00, 0x30, 0x60, 0x03, 0x02, 0x03,
  0xE0, 0x1F, 0xF8, 0x00, 0x80, 0x40, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x60, 0x10, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x40, 0x01,
  0x02, 0x00, 0x08, 0x10, 0x00, 0x60, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0x20, 0x00, 0x7F, 0xE0, 0x18, 0x03, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x60,
  0xC0, 0x0C, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x06, 0x20, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x20, 0x40, 0x00, 0x30, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x24,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00,
  0x04, 0x10, 0x00, 0x30, 0x20, 0x00, 0x80, 0x80, 0x04, 0x02, 0x00, 0x10,
  0x08, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x40, 0x04, 0x80, 0x04, 0x40, 0x04, 0x80, 0x08, 0x40, 0x08, 0x80,
  0x08, 0x40, 0x08, 0x80, 0x18, 0x40, 0x10, 0xC0, 0x10, 0x40, 0x10, 0x40,
  0x30, 0x40, 0x30, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x60, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x40, 0x80, 0x40, 0x80, 0x40,
  0x80, 0x41, 0x80, 0x41, 0x00, 0x41, 0x00, 0x41, 0x00, 0x43, 0x00, 0x43,
  0x00, 0x42, 0x00, 0x42, 0x00, 0x42, 0x00, 0x46, 0x00, 0x44, 0x00, 0x44,
  0x00, 0x44, 0x00, 0x44, 0x00, 0x48, 0x00, 0x48, 0x00, 0x48, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x40,
  0x08, 0x00, 0x30, 0x02, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x10, 0x02,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x04, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x20, 0x08, 0x00, 0x10, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x10, 0x03, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x20, 0x20, 0x00, 0x04, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x0C, 0x60, 0x00, 0x82, 0x00, 0x10, 0x20, 0x03,
  0x02, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x10, 0x18, 0x00, 0x81,
  0x00, 0x08, 0x20, 0x00, 0x84, 0x00, 0x0C, 0x40, 0x00, 0x48, 0x00, 0x05,
  0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x00, 0xFF, 0x01,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x01, 0x40, 0x00, 0x68, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00,
  0x82, 0x00, 0x30, 0x40, 0x04, 0x08, 0x01, 0x01, 0x80, 0x60, 0x10, 0x08,
  0x02, 0x02, 0x00, 0x40, 0xC0, 0x04, 0x30, 0x00, 0x84, 0x00, 0x11, 0x00,
  0x02, 0x60, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xC2, 0x18, 0x41, 0x0C,
  0x20, 0x00, 0x10, 0x00, 0x3D, 0xC4, 0x08, 0x0C, 0x86, 0x00, 0xD0, 0x80,
  0x0A, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00,
  0x19, 0x00, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x64, 0x00, 0x08, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x14, 0x20, 0x04,
  0x86, 0x01, 0x20, 0x60, 0x44, 0x07, 0xF0, 0x80, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x30, 0x01, 0x0E,
  0xF0, 0x09, 0x80, 0xC0, 0xD8, 0x02, 0x05, 0x00, 0x08, 0x28, 0x00, 0x41,
  0x80, 0x02, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x20, 0x00,
  0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x10, 0xA0, 0x01, 0x85, 0x00, 0x08,
  0x2C, 0x01, 0x81, 0x30, 0x18, 0x10, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFB,
  0xC0, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x3F, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x40, 0x1E, 0xE1, 0x00, 0x80, 0x64, 0x0C, 0x00, 0x90, 0x20, 0x01, 0xC1,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00,
  0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x0C,
  0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x28, 0x30,
  0x00, 0xA0, 0x40, 0x05, 0x01, 0x80, 0x24, 0x02, 0x03, 0x10, 0x07, 0xF0,
  0x40, 0x00, 0x30, 0x01, 0xDC, 0x06, 0x02, 0x08, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x0C, 0x80, 0x38, 0xFF,
  0xC0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x08, 0x1F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xBC, 0x40, 0x60, 0x32, 0x0C, 0x00, 0x90, 0x40,
  0x02, 0x84, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00,
  0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC3, 0x00, 0x0E, 0x18,
  0x00, 0x50, 0x40, 0x05, 0x03, 0x00, 0x48, 0x08, 0x0C, 0x40, 0x3F, 0x82,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x02, 0x00, 0x20, 0x1C, 0x06, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x60, 0x04, 0x3F, 0xC0, 0x4C, 0x06, 0x0D, 0x80, 0x20,
  0xB0, 0x03, 0x0A, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x31, 0x80, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x20, 0x00,
  0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0xC4, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x8C, 0x00, 0x10, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x01, 0x82, 0x00,
  0x40, 0xC0, 0x10, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x08, 0x10,
  0x03, 0x0C, 0x00, 0x43, 0x00, 0x08, 0xC0, 0x01, 0x38, 0x00, 0x2C, 0x80,
  0x0A, 0x10, 0x01, 0x81, 0x00, 0x20, 0x20, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x10,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x60,
  0x04, 0x7F, 0x81, 0xDC, 0x04, 0xC0, 0x86, 0x06, 0x09, 0x00, 0x4C, 0x03,
  0x0A, 0x00, 0x58, 0x01, 0x0C, 0x00, 0x50, 0x01, 0x0C, 0x00, 0x60, 0x01,
  0x08, 0x00, 0x60, 0x01, 0x18, 0x00, 0x40, 0x03, 0x10, 0x00, 0x40, 0x02,
  0x10, 0x00, 0x40, 0x02, 0x10, 0x00, 0x80, 0x02, 0x10, 0x00, 0x80, 0x02,
  0x20, 0x00, 0x80, 0x04, 0x20, 0x00, 0x80, 0x04, 0x20, 0x01, 0x80, 0x04,
  0x20, 0x01, 0x00, 0x04, 0x60, 0x01, 0x00, 0x04, 0x40, 0x01, 0x00, 0x08,
  0x40, 0x01, 0x00, 0x08, 0x40, 0x02, 0x00, 0x08, 0x40, 0x02, 0x00, 0x08,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x06, 0x00, 0x43, 0xFC, 0x04, 0xC0, 0x60,
  0x98, 0x02, 0x0B, 0x00, 0x30, 0xA0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x03,
  0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x62, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00,
  0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0xC0,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x3D, 0xE0, 0x0C, 0x02, 0x06, 0x00, 0x20,
  0x80, 0x06, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x60, 0x00, 0x28,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0x48, 0x00, 0x11, 0x00, 0x06, 0x20,
  0x00, 0x82, 0x00, 0x20, 0x20, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x02, 0x1D, 0xE0, 0x04, 0xC0, 0x60, 0x13, 0x00, 0x40, 0x2C, 0x00, 0x40,
  0x50, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x00,
  0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x30, 0x00,
  0x20, 0x50, 0x00, 0xC0, 0xA0, 0x01, 0x01, 0x60, 0x0C, 0x02, 0x60, 0x30,
  0x0C, 0x7F, 0x80, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1E,
  0xE1, 0x03, 0x01, 0x90, 0xC0, 0x09, 0x08, 0x00, 0x51, 0x00, 0x06, 0x30,
  0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x44,
  0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08,
  0x80, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x02, 0x84, 0x00, 0x50, 0x60, 0x09,
  0x02, 0x03, 0x10, 0x1F, 0xC1, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x3F, 0x04,
  0xC0, 0x09, 0x80, 0x0A, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xEF, 0x81, 0x00, 0x21,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC6, 0x00, 0xC0, 0xFF, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0xFF, 0xF0, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xE0,
  0x08, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x23, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x18, 0x40,
  0x01, 0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x50, 0xC0, 0x0D, 0x04,
  0x01, 0x90, 0x60, 0x22, 0x03, 0xFC, 0x20, 0x80, 0x00, 0xC0, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x20, 0x80, 0x10,
  0x60, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x0C, 0x02, 0x04, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x22, 0x00, 0x13, 0x00, 0x09, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x04, 0x00, 0x70, 0x01, 0x80,
  0x0B, 0x00, 0x30, 0x02, 0x60, 0x0A, 0x00, 0x44, 0x01, 0x40, 0x10, 0x80,
  0x48, 0x02, 0x10, 0x09, 0x80, 0x82, 0x02, 0x10, 0x10, 0x40, 0xC2, 0x06,
  0x08, 0x10, 0x40, 0x81, 0x06, 0x08, 0x30, 0x20, 0x81, 0x04, 0x04, 0x30,
  0x21, 0x80, 0x84, 0x04, 0x20, 0x11, 0x80, 0x8C, 0x02, 0x20, 0x11, 0x00,
  0x48, 0x01, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x05, 0x00, 0x28, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x00, 0x04, 0x00, 0x18,
  0x30, 0x01, 0x00, 0x80, 0x10, 0x06, 0x01, 0x00, 0x10, 0x18, 0x00, 0x81,
  0x80, 0x02, 0x18, 0x00, 0x11, 0x80, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x20,
  0x00, 0xC1, 0x00, 0x0C, 0x04, 0x00, 0x40, 0x20, 0x04, 0x00, 0x80, 0x40,
  0x04, 0x04, 0x00, 0x10, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x01, 0x01, 0x00,
  0x02, 0x00, 0x80, 0x02, 0x00, 0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x00, 0x80, 0x10, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x20, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x80, 0x00, 0x41,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x22, 0x00, 0x00, 0x22, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x38, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x78, 0x07, 0x01, 0xC1, 0xC0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 9, 11, 13, 5, -30 },
  { 44, 25, 30, 26, 1, -30 },
  { 138, 20, 34, 23, 2, -32 },
  { 223, 26, 31, 32, 4, -30 },
  { 324, 25, 30, 29, 2, -30 },
  { 418, 3, 11, 7, 5, -30 },
  { 423, 12, 37, 10, 1, -30 },
  { 479, 12, 37, 10, -3, -30 },
  { 535, 17, 18, 22, 5, -32 },
  { 574, 19, 19, 24, 3, -24 },
  { 620, 6, 10, 8, -2, -5 },
  { 628, 10, 1, 13, 2, -12 },
  { 630, 3, 2, 9, 1, -2 },
  { 631, 18, 30, 13, -2, -30 },
  { 699, 19, 30, 23, 3, -30 },
  { 771, 10, 30, 23, 7, -30 },
  { 809, 21, 30, 23, 0, -30 },
  { 888, 21, 30, 23, 1, -30 },
  { 967, 21, 30, 23, 1, -30 },
  { 1046, 21, 30, 23, 2, -30 },
  { 1125, 20, 30, 23, 3, -30 },
  { 1200, 19, 30, 23, 5, -30 },
  { 1272, 20, 30, 23, 2, -30 },
  { 1347, 20, 30, 23, 2, -30 },
  { 1422, 7, 22, 9, 1, -22 },
  { 1442, 10, 27, 9, -2, -22 },
  { 1476, 19, 19, 24, 3, -25 },
  { 1522, 19, 10, 24, 3, -20 },
  { 1546, 19, 19, 24, 3, -25 },
  { 1592, 15, 30, 17, 3, -30 },
  { 1649, 32, 34, 35, 2, -30 },
  { 1785, 23, 30, 23, -2, -30 },
  { 1872, 22, 30, 25, 2, -30 },
  { 1955, 23, 30, 25, 4, -30 },
  { 2042, 25, 30, 28, 2, -30 },
  { 2136, 21, 30, 22, 2, -30 },
  { 2215, 22, 30, 20, 2, -30 },
  { 2298, 24, 30, 29, 4, -30 },
  { 2388, 26, 30, 29, 2, -30 },
  { 2486, 13, 30, 12, 0, -30 },
  { 2535, 17, 37, 10, -7, -30 },
  { 2614, 24, 30, 23, 2, -30 },
  { 2704, 15, 30, 21, 2, -30 },
  { 2761, 32, 30, 34, 2, -30 },
  { 2881, 26, 30, 28, 2, -30 },
  { 2979, 24, 30, 30, 4, -30 },
  { 3069, 21, 30, 23, 2, -30 },
  { 3148, 24, 37, 30, 4, -30 },
  { 3259, 21, 30, 24, 2, -30 },
  { 3338, 20, 30, 21, 1, -30 },
  { 3413, 20, 30, 20, 4, -30 },
  { 3488, 25, 30, 29, 4, -30 },
  { 3582, 22, 30, 22, 4, -30 },
  { 3665, 32, 30, 35, 5, -30 },
  { 3785, 26, 30, 21, -2, -30 },
  { 3883, 20, 30, 20, 4, -30 },
  { 3958, 24, 30, 23, 0, -30 },
  { 4048, 16, 37, 13, 0, -30 },
  { 4122, 7, 30, 13, 4, -30 },
  { 4149, 16, 37, 13, -3, -30 },
  { 4223, 19, 18, 23, 2, -30 },
  { 4266, 16, 1, 16, -4, 5 },
  { 4268, 5, 7, 9, 6, -32 },
  { 4273, 19, 23, 23, 2, -23 },
  { 4328, 21, 32, 24, 1, -32 },
  { 4412, 17, 23, 19, 2, -23 },
  { 4461, 22, 32, 24, 2, -32 },
  { 4549, 16, 23, 21, 3, -23 },
  { 4595, 23, 42, 11, -6, -32 },
  { 4716, 21, 33, 24, 1, -23 },
  { 4803, 20, 32, 23, 1, -32 },
  { 4883, 8, 30, 9, 1, -30 },
  { 4913, 15, 40, 9, -6, -30 },
  { 4988, 19, 32, 18, 1, -32 },
  { 5064, 8, 32, 9, 1, -32 },
  { 5096, 32, 23, 35, 1, -23 },
  { 5188, 20, 23, 23, 1, -23 },
  { 5246, 19, 23, 24, 2, -23 },
  { 5301, 23, 33, 24, -1, -23 },
  { 5396, 20, 33, 24, 2, -23 },
  { 5479, 16, 23, 16, 1, -23 },
  { 5525, 17, 23, 18, 0, -23 },
  { 5574, 12, 28, 13, 2, -28 },
  { 5616, 20, 22, 23, 2, -22 },
  { 5671, 17, 22, 17, 2, -22 },
  { 5718, 27, 22, 27, 2, -22 },
  { 5793, 21, 22, 19, -1, -22 },
  { 5851, 24, 32, 17, -5, -22 },
  { 5947, 19, 22, 18, -1, -22 },
  { 6000, 15, 37, 14, 1, -30 },
  { 6070, 1, 42, 22, 12, -32 },
  { 6076, 15, 37, 14, -2, -30 },
  { 6146, 19, 4, 24, 3, -17 },
};

const GFXfont NotoSans_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_THINITALIC42PT7B_H_
