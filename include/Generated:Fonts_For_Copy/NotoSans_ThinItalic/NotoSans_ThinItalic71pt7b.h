#ifndef _NOTOSANS_THINITALIC71PT7B_H_
#define _NOTOSANS_THINITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x10, 0x00, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x08, 0x40, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x08, 0x02, 0x10, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0x42, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x0C, 0x3F,
  0x00, 0x38, 0x0C, 0x03, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x78, 0x40, 0x00, 0x00, 0x1E, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x9F, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x80, 0x0C, 0x07, 0x00, 0xE0, 0x0C, 0x1E, 0x00,
  0xFF, 0x89, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x0F, 0x3C,
  0x00, 0x00, 0x18, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30,
  0x07, 0x00, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x3F, 0x0C,
  0x00, 0x0C, 0x0C, 0x0F, 0xFC, 0xC0, 0x00, 0xC0, 0xC1, 0xC0, 0xEC, 0x00,
  0x18, 0x18, 0x38, 0x06, 0xC0, 0x01, 0x83, 0x07, 0x00, 0x3C, 0x00, 0x30,
  0x60, 0x60, 0x03, 0x60, 0x06, 0x06, 0x0C, 0x00, 0x36, 0x00, 0xE0, 0xC1,
  0x80, 0x03, 0x30, 0x1C, 0x18, 0x18, 0x00, 0x33, 0xEF, 0x83, 0x81, 0x80,
  0x03, 0x0F, 0xE0, 0x30, 0x30, 0x00, 0x30, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x20, 0x00, 0xE0, 0x04, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xC1, 0xC0,
  0x01, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x70, 0x00, 0x0E,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x01,
  0x87, 0x00, 0x00, 0x06, 0x00, 0x61, 0x80, 0x00, 0x01, 0x80, 0x30, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0xC3, 0x03, 0x00, 0x00, 0x00, 0x31, 0x80, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x1C, 0x00,
  0x00, 0x0E, 0x18, 0x03, 0x00, 0x00, 0x07, 0x06, 0x00, 0x60, 0x00, 0x07,
  0x00, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x18, 0x01, 0xF0, 0x0F, 0x80, 0x06,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18,
  0xC6, 0x31, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xE0, 0x03, 0x00, 0x03, 0xC0,
  0x18, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x1C, 0x20,
  0x00, 0x00, 0x39, 0x00, 0x3C, 0x00, 0x78, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x67, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x60, 0x07, 0x30, 0x0E, 0x18, 0x0E, 0x0C, 0x1C, 0x0C, 0x1C, 0x06, 0x38,
  0x03, 0x38, 0x01, 0x90, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x04, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xEF,
  0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x04, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x01, 0xFF, 0x00, 0x03, 0x03, 0xFF, 0xF8, 0x00, 0xC3,
  0xC0, 0x0F, 0x00, 0x31, 0xC0, 0x00, 0xE0, 0x08, 0xC0, 0x00, 0x1C, 0x06,
  0x60, 0x00, 0x03, 0x01, 0xB0, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0x80,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x1E, 0x06, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x07, 0x60, 0x30, 0x00,
  0x03, 0x90, 0x06, 0x00, 0x01, 0xCC, 0x00, 0xE0, 0x01, 0xC3, 0x00, 0x1F,
  0x0F, 0xE0, 0xC0, 0x01, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x38, 0x0F, 0x01, 0xE0, 0x10, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xE3, 0xE0, 0x1C, 0x00, 0x78, 0x10, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x61, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x0C, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x18, 0xC0, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x06, 0x70, 0x00, 0x30, 0x00, 0x08, 0x00, 0x33, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x98, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0D,
  0x80, 0x03, 0x80, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x03, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x1B, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x04, 0x00, 0x07, 0x80, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x1B, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xD8,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x66, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0x30, 0x01, 0x80, 0x00, 0x78,
  0x00, 0x31, 0x80, 0x04, 0x00, 0x03, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00,
  0x36, 0x00, 0x38, 0x60, 0x01, 0x80, 0x03, 0x30, 0x03, 0x83, 0x00, 0x0E,
  0x00, 0x31, 0x80, 0x38, 0x0C, 0x00, 0x38, 0x07, 0x06, 0x03, 0x80, 0x60,
  0x00, 0xF9, 0xF0, 0x3C, 0xF8, 0x03, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x08, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x08,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x00,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0x18, 0x00, 0x00, 0x7F, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x08, 0x3E, 0x00,
  0x00, 0x00, 0x0C, 0x3B, 0x00, 0x00, 0x00, 0x06, 0x39, 0xC0, 0x00, 0x00,
  0x03, 0x38, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x00, 0x00, 0xB0,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x58, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x44, 0x00, 0x00, 0x00, 0x06, 0x60, 0x06, 0x30, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x8C, 0x00, 0xC1, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x06, 0x08, 0x00, 0x00, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x06, 0x02, 0x00, 0x00, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30,
  0x18, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x08, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x08, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x10, 0x01, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x18, 0x00, 0x04, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60,
  0x06, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xC0, 0x06,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x46, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x80, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x30, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x20, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x02, 0x00, 0x00, 0x01, 0x86, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x6C, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xF8, 0x00,
  0x40, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x10, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x04, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x04,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x02, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x20,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x02,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x18, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x38, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xE0, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0x00, 0x3C,
  0x01, 0xC3, 0x00, 0xF0, 0x00, 0xC3, 0x01, 0xC0, 0x00, 0x62, 0x03, 0x80,
  0x00, 0x22, 0x03, 0x00, 0x00, 0x36, 0x06, 0x00, 0x00, 0x16, 0x0C, 0x00,
  0x00, 0x1E, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x01, 0x40, 0xC0, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x0C, 0xC0, 0x60, 0x00,
  0x18, 0xC0, 0x60, 0x00, 0x38, 0x80, 0x30, 0x00, 0x71, 0x80, 0x18, 0x01,
  0xC1, 0x80, 0x0E, 0x07, 0x81, 0x80, 0x07, 0xFE, 0x01, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x1F, 0xE0, 0x00, 0x30, 0x1F, 0xFE, 0x00, 0x0C, 0x1C, 0x01, 0xE0, 0x02,
  0x0C, 0x00, 0x18, 0x01, 0x8E, 0x00, 0x03, 0x00, 0x67, 0x00, 0x00, 0x60,
  0x19, 0x00, 0x00, 0x18, 0x04, 0xC0, 0x00, 0x03, 0x01, 0x60, 0x00, 0x00,
  0xC0, 0xF0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x06, 0x0F, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0xB0, 0x00,
  0x00, 0xE0, 0x66, 0x00, 0x00, 0x30, 0x19, 0x80, 0x00, 0x38, 0x06, 0x30,
  0x00, 0x1C, 0x01, 0x07, 0x00, 0x1E, 0x00, 0x40, 0xF0, 0x1E, 0x00, 0x30,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00,
  0xC0, 0x00, 0x7F, 0xFC, 0x06, 0x00, 0x0F, 0x00, 0x78, 0x60, 0x00, 0xE0,
  0x00, 0xE3, 0x00, 0x1C, 0x00, 0x03, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0xC0,
  0x0C, 0x00, 0x00, 0x24, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x00, 0xD8, 0x03, 0x00, 0x00, 0x0C, 0x80, 0x18, 0x00, 0x00, 0xCC, 0x00,
  0x60, 0x00, 0x0E, 0x60, 0x03, 0x00, 0x00, 0xE3, 0x00, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x01, 0xC0, 0x80, 0x00, 0xE0, 0x3C, 0x0C, 0x00, 0x03,
  0xFF, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x30, 0x00, 0xF0, 0x00, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x1E, 0x03, 0x00,
  0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0x00, 0x0F, 0x00, 0x78, 0x20, 0x01,
  0xC0, 0x01, 0xC6, 0x00, 0x70, 0x00, 0x0C, 0x60, 0x0E, 0x00, 0x00, 0x66,
  0x00, 0xC0, 0x00, 0x02, 0x40, 0x18, 0x00, 0x00, 0x34, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x06, 0xC0,
  0x30, 0x00, 0x00, 0xC8, 0x03, 0x00, 0x00, 0x1D, 0x80, 0x18, 0x00, 0x03,
  0x98, 0x01, 0x80, 0x00, 0x71, 0x80, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x60,
  0x03, 0x83, 0x00, 0x03, 0x80, 0xF0, 0x30, 0x00, 0x1F, 0xFC, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x1F, 0xF0, 0x00, 0x60, 0x3F, 0xFE, 0x00, 0x30, 0x70, 0x03, 0x80,
  0x10, 0x60, 0x00, 0xE0, 0x18, 0xE0, 0x00, 0x30, 0x0C, 0xE0, 0x00, 0x1C,
  0x06, 0x60, 0x00, 0x06, 0x02, 0x60, 0x00, 0x03, 0x01, 0x60, 0x00, 0x01,
  0x81, 0xE0, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x40, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x04, 0x1E, 0x00, 0x00,
  0x0C, 0x3E, 0x00, 0x00, 0x0C, 0x73, 0x00, 0x00, 0x0C, 0xC3, 0x00, 0x00,
  0x09, 0x81, 0x80, 0x00, 0x0B, 0x01, 0x80, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x08, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x21, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x01, 0x8C,
  0x00, 0x1C, 0x18, 0x00, 0x18, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0x1B, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x80, 0x48, 0x00, 0x01, 0x30, 0x00,
  0x02, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x60, 0x3F, 0xFE, 0x00, 0x20, 0x70, 0x03,
  0x80, 0x10, 0x60, 0x00, 0xE0, 0x18, 0xE0, 0x00, 0x30, 0x0C, 0xE0, 0x00,
  0x1C, 0x06, 0x60, 0x00, 0x06, 0x02, 0x60, 0x00, 0x03, 0x01, 0x60, 0x00,
  0x01, 0x81, 0xE0, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x00, 0x04,
  0x0E, 0x00, 0xF0, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x03, 0x1C, 0x00, 0x06,
  0x00, 0x19, 0xC0, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x00, 0xC0, 0x04, 0xC0,
  0x00, 0x03, 0x00, 0x2C, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0xC0,
  0x1E, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0xB0, 0x00, 0x00, 0xE0, 0x0C, 0xC0, 0x00, 0x06, 0x00, 0x66, 0x00,
  0x00, 0xE0, 0x03, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x70, 0x01, 0xE0, 0x00,
  0x81, 0xE0, 0x3C, 0x00, 0x0C, 0x07, 0xFF, 0x80, 0x00, 0x60, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x30, 0x03, 0xC0, 0x1E, 0x08,
  0x01, 0xC0, 0x01, 0xC6, 0x01, 0xC0, 0x00, 0x31, 0x80, 0xE0, 0x00, 0x06,
  0x60, 0x30, 0x00, 0x00, 0x90, 0x18, 0x00, 0x00, 0x34, 0x0C, 0x00, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x00, 0xF0, 0x30, 0x00, 0x00, 0x6C, 0x0C, 0x00, 0x00, 0x32, 0x03, 0x00,
  0x00, 0x1D, 0x80, 0x60, 0x00, 0x0E, 0x60, 0x18, 0x00, 0x07, 0x18, 0x03,
  0x00, 0x03, 0x86, 0x00, 0x60, 0x03, 0x83, 0x00, 0x0E, 0x03, 0xC0, 0xC0,
  0x01, 0xFF, 0xC0, 0x30, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x3F, 0xF0, 0x08, 0x1C, 0x00, 0x02,
  0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x04, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x07, 0xE0, 0x1E, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x36, 0x06, 0x00,
  0x00, 0x12, 0x03, 0x00, 0x00, 0x1B, 0x01, 0x80, 0x00, 0x19, 0x80, 0x60,
  0x00, 0x18, 0xC0, 0x30, 0x00, 0x38, 0x40, 0x0C, 0x00, 0x38, 0x20, 0x03,
  0xC0, 0xF0, 0x30, 0x00, 0xFF, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xA0, 0x00,
  0x04, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x40, 0x00,
  0xC3, 0x00, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x60, 0x40, 0x01, 0x83,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x08, 0x18, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x30, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x26, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x5C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0xE8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 52, 15, 2, -51 },
  { 92, 15, 19, 22, 8, -51 },
  { 128, 42, 51, 44, 2, -51 },
  { 396, 32, 58, 39, 4, -54 },
  { 628, 44, 52, 54, 6, -51 },
  { 914, 42, 52, 48, 3, -51 },
  { 1187, 5, 19, 12, 8, -51 },
  { 1199, 20, 62, 17, 2, -51 },
  { 1354, 19, 62, 17, -4, -51 },
  { 1502, 29, 30, 38, 9, -54 },
  { 1611, 33, 32, 40, 5, -41 },
  { 1743, 9, 17, 13, -3, -8 },
  { 1763, 16, 2, 22, 3, -20 },
  { 1767, 4, 5, 15, 2, -4 },
  { 1770, 31, 51, 22, -3, -51 },
  { 1968, 32, 52, 39, 5, -51 },
  { 2176, 17, 51, 39, 12, -51 },
  { 2285, 35, 51, 39, 1, -51 },
  { 2509, 35, 52, 39, 2, -51 },
  { 2737, 37, 51, 39, 1, -51 },
  { 2973, 35, 52, 39, 3, -51 },
  { 3201, 34, 53, 39, 5, -52 },
  { 3427, 32, 51, 39, 8, -51 },
  { 3631, 35, 52, 39, 3, -51 },
  { 3859, 34, 52, 39, 3, -51 },
  { 4080, 11, 39, 15, 2, -38 },
  { 4134, 16, 47, 15, -3, -38 },
  { 4228, 33, 32, 40, 5, -42 },
  { 4360, 33, 16, 40, 5, -33 },
  { 4426, 33, 32, 40, 5, -42 },
  { 4558, 24, 52, 29, 6, -51 },
  { 4714, 53, 56, 59, 4, -50 },
  { 5085, 39, 51, 39, -4, -51 },
  { 5334, 37, 51, 42, 4, -51 },
  { 5570, 39, 52, 42, 6, -51 },
  { 5824, 41, 51, 48, 4, -51 },
  { 6086, 36, 51, 38, 4, -51 },
  { 6316, 36, 51, 35, 4, -51 },
  { 6546, 41, 52, 49, 6, -51 },
  { 6813, 44, 51, 48, 4, -51 },
  { 7094, 22, 51, 20, 1, -51 },
  { 7235, 28, 63, 16, -12, -51 },
  { 7456, 41, 51, 39, 4, -51 },
  { 7718, 25, 51, 35, 4, -51 },
  { 7878, 53, 51, 57, 4, -51 },
  { 8216, 44, 51, 48, 4, -51 },
  { 8497, 42, 52, 51, 6, -51 },
  { 8770, 36, 51, 40, 4, -51 },
  { 9000, 42, 63, 51, 6, -51 },
  { 9331, 36, 51, 40, 4, -51 },
  { 9561, 35, 52, 35, 1, -51 },
  { 9789, 34, 51, 34, 7, -51 },
  { 10006, 43, 52, 49, 6, -51 },
  { 10286, 35, 51, 38, 8, -51 },
  { 10510, 54, 51, 59, 9, -51 },
  { 10855, 44, 51, 35, -4, -51 },
  { 11136, 34, 51, 34, 7, -51 },
  { 11353, 42, 51, 38, -1, -51 },
  { 11621, 27, 62, 22, -1, -51 },
  { 11831, 11, 51, 22, 7, -51 },
  { 11902, 27, 62, 22, -5, -51 },
  { 12112, 32, 31, 39, 4, -51 },
  { 12236, 27, 2, 26, -6, 8 },
  { 12243, 8, 11, 16, 10, -54 },
  { 12254, 32, 39, 39, 4, -38 },
  { 12410, 34, 55, 40, 2, -54 },
  { 12644, 29, 39, 32, 4, -38 },
  { 12786, 37, 55, 40, 4, -54 },
  { 13041, 29, 39, 35, 4, -38 },
  { 13183, 38, 71, 19, -9, -54 },
  { 13521, 36, 55, 40, 2, -38 },
  { 13769, 33, 54, 39, 2, -54 },
  { 13992, 13, 51, 15, 2, -51 },
  { 14075, 25, 68, 15, -10, -51 },
  { 14288, 32, 54, 31, 2, -54 },
  { 14504, 14, 54, 15, 2, -54 },
  { 14599, 54, 38, 60, 2, -38 },
  { 14856, 33, 38, 39, 2, -38 },
  { 15013, 32, 39, 40, 4, -38 },
  { 15169, 37, 54, 40, -1, -38 },
  { 15419, 34, 54, 40, 4, -38 },
  { 15649, 26, 38, 26, 2, -38 },
  { 15773, 27, 39, 30, 1, -38 },
  { 15905, 19, 48, 22, 4, -47 },
  { 16019, 33, 38, 39, 4, -37 },
  { 16176, 29, 37, 29, 4, -37 },
  { 16311, 44, 37, 46, 4, -37 },
  { 16515, 35, 37, 32, -2, -37 },
  { 16677, 41, 54, 29, -8, -37 },
  { 16954, 32, 37, 31, -1, -37 },
  { 17102, 25, 62, 23, 2, -51 },
  { 17296, 2, 71, 38, 20, -54 },
  { 17314, 26, 62, 23, -4, -51 },
  { 17516, 33, 6, 40, 5, -28 },
};

const GFXfont NotoSans_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_THINITALIC71PT7B_H_
