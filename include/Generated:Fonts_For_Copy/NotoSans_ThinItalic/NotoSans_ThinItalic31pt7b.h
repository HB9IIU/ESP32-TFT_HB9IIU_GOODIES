#ifndef _NOTOSANS_THINITALIC31PT7B_H_
#define _NOTOSANS_THINITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x10, 0x40, 0x00, 0x00, 0x83, 0x00, 0x22, 0x45, 0x0A, 0x24, 0x48, 0x91,
  0x42, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x80, 0x10, 0x40, 0xFF, 0xFF, 0x02, 0x04, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x0F, 0xFF, 0xF0, 0x20,
  0x40, 0x08, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x40,
  0x08, 0x10, 0x00, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0xFC, 0x0C, 0x8C,
  0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x01, 0x10, 0x02, 0x40,
  0x07, 0x00, 0x0B, 0x00, 0x22, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x41,
  0x01, 0x08, 0x04, 0x63, 0x9E, 0x01, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x1F, 0x00, 0x44, 0x20, 0x11, 0x04, 0x04, 0x20, 0x41, 0x08, 0x10,
  0x21, 0x02, 0x08, 0x20, 0x42, 0x04, 0x08, 0x80, 0x81, 0x11, 0x90, 0x44,
  0xCA, 0x09, 0x20, 0xC2, 0x44, 0x14, 0x89, 0x02, 0x62, 0x20, 0x40, 0x84,
  0x08, 0x21, 0x01, 0x04, 0x20, 0x41, 0x04, 0x08, 0x40, 0x81, 0x08, 0x10,
  0x42, 0x02, 0x08, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x60, 0xC0, 0x08,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x01, 0x00, 0x10,
  0x40, 0x02, 0x30, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0x20, 0x01, 0x04,
  0x02, 0x40, 0x40, 0x90, 0x04, 0x22, 0x00, 0x44, 0x80, 0x09, 0x10, 0x00,
  0xC2, 0x00, 0x18, 0x20, 0x05, 0x06, 0x03, 0x10, 0x3F, 0x81, 0x00, 0x25,
  0x24, 0x94, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x00, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x20, 0x30, 0x00, 0x01, 0x00, 0x10, 0x20, 0x81, 0x84, 0x03, 0x20,
  0x05, 0x7C, 0x14, 0x01, 0x40, 0x12, 0x01, 0x08, 0x10, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x12, 0x22, 0x44, 0x88, 0xFF, 0xB0, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x00, 0x03,
  0xF0, 0x10, 0x20, 0x80, 0x44, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x10, 0x10, 0x40, 0xC0,
  0xFC, 0x00, 0x03, 0x0E, 0x12, 0x62, 0x82, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x01, 0xFC, 0x06, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x18, 0x08,
  0x40, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x60, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x88, 0x02, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x22,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x84, 0x01, 0x04, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x08, 0x20, 0x08, 0x40, 0x08, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x03, 0xFF,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x80, 0x20, 0x7F, 0xC0, 0x00, 0x18, 0x01, 0xCC, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x87,
  0x81, 0x30, 0x82, 0x80, 0x8A, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x84, 0x02, 0x04, 0x08, 0x07,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x00, 0x03, 0xF8, 0x08, 0x0C, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x08, 0x06, 0x60, 0x07, 0x00, 0x71,
  0x01, 0x01, 0x04, 0x01, 0x10, 0x02, 0x20, 0x02, 0x80, 0x05, 0x00, 0x09,
  0x00, 0x22, 0x00, 0x42, 0x03, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x08, 0x08,
  0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x40, 0x0C, 0x80, 0x18, 0x80, 0xE0, 0xC6, 0x40, 0x70, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x1F,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x04,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x00, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x08, 0x04, 0x01, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x80, 0xC0,
  0x08, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00, 0x42, 0x00, 0x00, 0x88,
  0x07, 0x80, 0xA0, 0x30, 0xC1, 0x40, 0x80, 0x83, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x10, 0x08, 0x18, 0x20, 0x10, 0x30, 0x40, 0x40, 0xA0, 0x80,
  0x81, 0x41, 0x03, 0x04, 0x82, 0x0A, 0x09, 0x06, 0x36, 0x62, 0x03, 0x83,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x3F, 0xF8,
  0x10, 0x04, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x14, 0x00, 0x0E, 0x00, 0x04, 0x0F, 0xFC, 0x08, 0x02, 0x08, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x20, 0x04, 0x20,
  0x18, 0x3F, 0xE0, 0x20, 0x18, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF,
  0xC0, 0x01, 0xFF, 0x83, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x02, 0x01, 0x80, 0x80, 0x10, 0x40, 0x04, 0x10, 0x00, 0x84,
  0x00, 0x21, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04,
  0x40, 0x03, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x60, 0x80, 0x60, 0x3F,
  0xE0, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xE1, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0x84, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x10, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x01, 0xFC, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x20,
  0x04, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x10, 0xFF, 0xFE, 0x10, 0x00, 0x44, 0x00, 0x10, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x42, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x3E,
  0x00, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0xF8, 0x00, 0x08, 0x00, 0xC2, 0x00, 0xC0, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00,
  0x23, 0x00, 0x09, 0x80, 0x02, 0xA0, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x01, 0x00, 0x40, 0x40, 0x20, 0x08, 0x08, 0x02,
  0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x02, 0x00, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0xFF, 0xC0, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30,
  0xA0, 0x00, 0xA1, 0x40, 0x01, 0x42, 0x40, 0x04, 0x84, 0x80, 0x09, 0x09,
  0x00, 0x24, 0x22, 0x00, 0x88, 0x44, 0x01, 0x10, 0x88, 0x04, 0x21, 0x08,
  0x08, 0x84, 0x10, 0x21, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x84,
  0x08, 0x41, 0x08, 0x21, 0x01, 0x20, 0x42, 0x02, 0x80, 0x84, 0x05, 0x01,
  0x08, 0x0C, 0x02, 0x10, 0x10, 0x08, 0x00, 0x08, 0x00, 0x21, 0x80, 0x08,
  0x30, 0x01, 0x0A, 0x00, 0x21, 0x20, 0x04, 0x24, 0x00, 0x84, 0x40, 0x20,
  0x88, 0x04, 0x20, 0x80, 0x84, 0x10, 0x10, 0x82, 0x02, 0x10, 0x20, 0x84,
  0x04, 0x10, 0x80, 0x42, 0x10, 0x08, 0x42, 0x00, 0x88, 0x40, 0x12, 0x10,
  0x02, 0x42, 0x00, 0x28, 0x40, 0x05, 0x08, 0x00, 0x41, 0x00, 0x08, 0x00,
  0x03, 0xFC, 0x03, 0x00, 0xC1, 0x80, 0x18, 0x40, 0x02, 0x20, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x01, 0x20, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x10, 0x20, 0x18, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x10, 0x08, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x21, 0x03,
  0x83, 0xE8, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x03, 0x00,
  0xC1, 0x80, 0x18, 0x40, 0x02, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00,
  0xC4, 0x00, 0x21, 0x00, 0x10, 0x20, 0x18, 0x07, 0xB8, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x0F, 0xF8, 0x10,
  0x08, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x20, 0x02, 0x40, 0x08, 0x80, 0x61, 0xFF, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x10, 0x01, 0x00, 0x03, 0xFE, 0x18, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x88, 0x06, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x43, 0x00, 0x20,
  0x60, 0x30, 0x07, 0xF0, 0x00, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40,
  0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40,
  0x20, 0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x22,
  0x00, 0x22, 0x00, 0x24, 0x00, 0x14, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x80, 0x10, 0x03, 0x80, 0x30, 0x02, 0x80, 0x30, 0x04, 0x80, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x08, 0x80, 0x48, 0x08,
  0x80, 0x50, 0x09, 0x00, 0x50, 0x09, 0x00, 0x60, 0x0A, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x02, 0x00, 0x20, 0x40, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x10, 0x01, 0x04, 0x00, 0x21, 0x00,
  0x02, 0x40, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x09, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x10, 0x40, 0x04, 0x08, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x04, 0x00, 0x21, 0x80, 0x04, 0x00,
  0x80, 0x07, 0x00, 0x09, 0x00, 0x22, 0x00, 0x84, 0x01, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x40, 0x10, 0x80, 0x22, 0x00, 0x48, 0x00, 0x90, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x03, 0xF0, 0x00, 0x84, 0x20,
  0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x20, 0x84,
  0x07, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x83,
  0xF0, 0x00, 0x00, 0x40, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x10, 0x80, 0x22, 0x00, 0x90, 0x02, 0x80,
  0x0C, 0xFF, 0xF0, 0x91, 0x22, 0x03, 0x80, 0x31, 0x91, 0x01, 0x48, 0x06,
  0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x0C, 0x80, 0x22, 0x01, 0x88, 0x0A, 0x10, 0x48, 0x7E, 0x20, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x78, 0x13, 0x08, 0x28, 0x08, 0x60, 0x09, 0x80, 0x13, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x44, 0x00, 0x94, 0x02, 0x2C, 0x08, 0x4F, 0xE0, 0x03, 0xE0, 0xC1, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x03, 0xC2, 0x0C, 0x24, 0x10, 0x14, 0x20, 0x0C, 0x40, 0x0C, 0x40, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x30, 0x80, 0x30, 0x80, 0x50, 0x41, 0xA0, 0x7E, 0x20, 0x03, 0x80,
  0xC2, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x28, 0x0C, 0xFE, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0x00, 0x0C, 0x40, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0C, 0x24, 0x20, 0x28,
  0x80, 0x32, 0x00, 0x64, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x24, 0x00, 0x44, 0x01, 0x88, 0x03, 0x10, 0x0A, 0x10, 0x68,
  0x3F, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x7F, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x38, 0x13, 0x08, 0x50, 0x11, 0x80, 0x4C, 0x01,
  0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x0C, 0x20, 0x00,
  0x00, 0x01, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x0F, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x01, 0x10, 0x08, 0x40, 0x41,
  0x02, 0x04, 0x10, 0x20, 0x80, 0x8C, 0x02, 0x40, 0x0A, 0x80, 0x52, 0x01,
  0x84, 0x04, 0x10, 0x10, 0x20, 0x40, 0x82, 0x01, 0x08, 0x04, 0x20, 0x08,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x00, 0xC0, 0x38, 0x26, 0x21, 0x88,
  0x50, 0x24, 0x08, 0xC0, 0x50, 0x13, 0x00, 0xC0, 0x26, 0x01, 0x80, 0x48,
  0x02, 0x00, 0x90, 0x04, 0x01, 0x20, 0x08, 0x02, 0x80, 0x20, 0x09, 0x00,
  0x40, 0x12, 0x00, 0x80, 0x24, 0x01, 0x00, 0x48, 0x02, 0x00, 0xA0, 0x08,
  0x02, 0x40, 0x10, 0x04, 0x80, 0x20, 0x08, 0x00, 0xE0, 0x4C, 0x21, 0x40,
  0x46, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80,
  0x10, 0x03, 0xC0, 0x30, 0xC1, 0x00, 0x88, 0x02, 0x40, 0x05, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x48, 0x02, 0x10, 0x10, 0x3F, 0x80, 0x00, 0x3C, 0x02, 0x61, 0x01,
  0x40, 0x40, 0xC0, 0x10, 0x40, 0x08, 0x60, 0x04, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20, 0x80,
  0x10, 0xA0, 0x10, 0x58, 0x10, 0x27, 0xF0, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x30, 0x91, 0x01, 0x48, 0x03, 0x40, 0x0D, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0xC8, 0x05,
  0x10, 0x68, 0x3E, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xE2, 0x60, 0x50, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x00, 0x01, 0x80, 0xC3, 0x10, 0x01, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x48, 0x04, 0x7F, 0x80, 0x10, 0x10, 0x10, 0x20, 0xFF, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xF8, 0x20, 0x04, 0x80, 0x14, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80,
  0x62, 0x02, 0x88, 0x12, 0x1F, 0x88, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x88, 0x08, 0x41, 0x04, 0x10, 0x42, 0x04, 0x20, 0x44, 0x04, 0x80,
  0x48, 0x03, 0x00, 0x30, 0x02, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A, 0x05,
  0x01, 0x40, 0xA0, 0x48, 0x24, 0x09, 0x04, 0x82, 0x21, 0x08, 0x44, 0x21,
  0x10, 0x88, 0x22, 0x11, 0x04, 0x82, 0x40, 0x90, 0x48, 0x12, 0x0A, 0x02,
  0x81, 0x40, 0x50, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x08, 0x03, 0x04, 0x04,
  0x04, 0x08, 0x04, 0x10, 0x02, 0x20, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x10, 0x80, 0x10, 0x02, 0x00, 0x40, 0x80, 0x20, 0x20, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x09, 0x80, 0x01, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x3F, 0xF8, 0x00, 0xE0, 0x60, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0xC0, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03, 0x03, 0x80, 0x00, 0x7E, 0x03,
  0x03, 0xF8,
};

const GFXglyph NotoSans_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 7, 8, 10, 3, -22 },
  { 25, 18, 22, 19, 1, -22 },
  { 75, 14, 26, 17, 2, -24 },
  { 121, 19, 22, 24, 3, -22 },
  { 174, 19, 22, 21, 1, -22 },
  { 227, 3, 8, 5, 3, -22 },
  { 230, 9, 27, 8, 1, -22 },
  { 261, 9, 27, 8, -2, -22 },
  { 292, 13, 13, 16, 4, -23 },
  { 314, 15, 14, 18, 2, -18 },
  { 341, 4, 8, 6, -1, -4 },
  { 345, 8, 1, 10, 1, -9 },
  { 346, 2, 2, 7, 1, -2 },
  { 347, 13, 22, 9, -1, -22 },
  { 383, 14, 22, 17, 2, -22 },
  { 422, 8, 22, 17, 5, -22 },
  { 444, 16, 22, 17, 0, -22 },
  { 488, 15, 22, 17, 1, -22 },
  { 530, 16, 22, 17, 0, -22 },
  { 574, 16, 22, 17, 1, -22 },
  { 618, 15, 23, 17, 2, -23 },
  { 662, 13, 22, 17, 4, -22 },
  { 698, 15, 22, 17, 1, -22 },
  { 740, 15, 22, 17, 1, -22 },
  { 782, 5, 16, 7, 1, -16 },
  { 792, 7, 20, 7, -1, -16 },
  { 810, 15, 14, 18, 2, -18 },
  { 837, 15, 7, 18, 2, -14 },
  { 851, 15, 14, 18, 2, -18 },
  { 878, 10, 22, 13, 3, -22 },
  { 906, 23, 25, 26, 2, -22 },
  { 978, 17, 22, 17, -2, -22 },
  { 1025, 16, 22, 19, 2, -22 },
  { 1069, 17, 22, 18, 3, -22 },
  { 1116, 18, 22, 21, 2, -22 },
  { 1166, 15, 22, 17, 2, -22 },
  { 1208, 15, 22, 15, 2, -22 },
  { 1250, 18, 22, 21, 3, -22 },
  { 1300, 19, 22, 21, 2, -22 },
  { 1353, 10, 22, 9, 0, -22 },
  { 1381, 12, 27, 7, -5, -22 },
  { 1422, 18, 22, 17, 2, -22 },
  { 1472, 11, 22, 15, 2, -22 },
  { 1503, 23, 22, 25, 2, -22 },
  { 1567, 19, 22, 21, 2, -22 },
  { 1620, 18, 22, 22, 3, -22 },
  { 1670, 15, 22, 17, 2, -22 },
  { 1712, 18, 27, 22, 3, -22 },
  { 1773, 15, 22, 17, 2, -22 },
  { 1815, 15, 22, 15, 1, -22 },
  { 1857, 15, 22, 15, 3, -22 },
  { 1899, 18, 22, 21, 3, -22 },
  { 1949, 16, 22, 17, 3, -22 },
  { 1993, 24, 22, 26, 4, -22 },
  { 2059, 19, 22, 15, -2, -22 },
  { 2112, 15, 22, 15, 3, -22 },
  { 2154, 18, 22, 17, 0, -22 },
  { 2204, 11, 27, 9, 0, -22 },
  { 2242, 5, 22, 9, 3, -22 },
  { 2256, 11, 27, 9, -2, -22 },
  { 2294, 14, 13, 17, 2, -22 },
  { 2317, 12, 1, 12, -3, 3 },
  { 2319, 3, 5, 7, 5, -24 },
  { 2321, 14, 17, 17, 2, -17 },
  { 2351, 15, 24, 18, 1, -24 },
  { 2396, 12, 17, 14, 2, -17 },
  { 2422, 16, 24, 18, 2, -24 },
  { 2470, 12, 17, 15, 2, -17 },
  { 2496, 17, 31, 8, -4, -24 },
  { 2562, 15, 24, 18, 1, -17 },
  { 2607, 14, 24, 17, 1, -24 },
  { 2649, 6, 22, 6, 1, -22 },
  { 2666, 11, 29, 6, -4, -22 },
  { 2706, 14, 24, 14, 1, -24 },
  { 2748, 6, 24, 6, 1, -24 },
  { 2766, 23, 17, 26, 1, -17 },
  { 2815, 14, 17, 17, 1, -17 },
  { 2845, 14, 17, 18, 2, -17 },
  { 2875, 17, 24, 18, -1, -17 },
  { 2926, 14, 24, 18, 2, -17 },
  { 2968, 11, 17, 11, 1, -17 },
  { 2992, 12, 17, 13, 0, -17 },
  { 3018, 8, 20, 10, 2, -20 },
  { 3038, 14, 16, 17, 2, -16 },
  { 3066, 12, 16, 13, 2, -16 },
  { 3090, 19, 16, 20, 2, -16 },
  { 3128, 16, 16, 14, -1, -16 },
  { 3160, 18, 24, 13, -4, -16 },
  { 3214, 14, 16, 14, 0, -16 },
  { 3242, 11, 27, 10, 1, -22 },
  { 3280, 1, 31, 17, 9, -24 },
  { 3284, 11, 27, 10, -2, -22 },
  { 3322, 15, 2, 18, 2, -12 },
};

const GFXfont NotoSans_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_THINITALIC31PT7B_H_
