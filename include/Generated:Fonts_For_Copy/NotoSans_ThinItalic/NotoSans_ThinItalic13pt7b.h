#ifndef _NOTOSANS_THINITALIC13PT7B_H_
#define _NOTOSANS_THINITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0x80, 0x12, 0x12, 0x7B, 0x14, 0x24,
  0xFE, 0x24, 0x48, 0x48, 0x10, 0xF5, 0x24, 0x60, 0x42, 0x8A, 0x3B, 0x04,
  0x00, 0x71, 0x92, 0x94, 0x9B, 0xAD, 0x59, 0x29, 0x49, 0x4E, 0x3C, 0x89,
  0x11, 0xC5, 0x12, 0x62, 0xC2, 0xFA, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x40, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x25, 0x16, 0xCA, 0x08, 0x20,
  0x82, 0x3F, 0x20, 0x80, 0x56, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x7D, 0x18, 0x61, 0x86, 0x18, 0xA2, 0xF0, 0x74, 0x92, 0x92,
  0x40, 0x3E, 0x04, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x3E, 0x04, 0x08,
  0x23, 0x80, 0x81, 0x02, 0xF8, 0x06, 0x14, 0x51, 0x22, 0x48, 0xAE, 0x84,
  0x08, 0x3E, 0x40, 0x83, 0xC0, 0x40, 0x81, 0x02, 0xF8, 0x3D, 0x08, 0x3C,
  0x8A, 0x18, 0x62, 0xF0, 0x7C, 0x10, 0x84, 0x10, 0x82, 0x10, 0x80, 0x7D,
  0x14, 0x4A, 0x52, 0x28, 0xA2, 0xF0, 0x7E, 0x18, 0x61, 0x89, 0xE0, 0x84,
  0xE0, 0x40, 0x08, 0x20, 0x00, 0x92, 0x80, 0x04, 0x66, 0x30, 0x30, 0x30,
  0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x83, 0x33, 0x00, 0x71, 0x11, 0x24, 0x80,
  0x80, 0x3F, 0x20, 0x63, 0x32, 0x5A, 0x2D, 0x16, 0x93, 0x36, 0x80, 0x3F,
  0x00, 0x04, 0x14, 0x28, 0x91, 0x25, 0xD0, 0xA1, 0x82, 0x7C, 0x85, 0x0C,
  0x2F, 0x90, 0xA1, 0x42, 0xF8, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x7C, 0x7C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF8, 0x7D, 0x04, 0x20,
  0xFA, 0x08, 0x20, 0xF0, 0x7D, 0x04, 0x20, 0x7A, 0x08, 0x20, 0x80, 0x3F,
  0x40, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x82, 0x7C, 0x41, 0x41, 0x41, 0x82,
  0xFE, 0x82, 0x82, 0x84, 0x84, 0x32, 0x22, 0x24, 0x44, 0xC0, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x21, 0x38, 0x46, 0x91, 0x45, 0x06, 0x12, 0x24, 0x44,
  0x88, 0x44, 0x48, 0x88, 0x88, 0xF0, 0x40, 0xA0, 0xD8, 0x74, 0x5A, 0x2D,
  0x26, 0x65, 0x32, 0x91, 0x00, 0x41, 0x61, 0x62, 0x92, 0x92, 0x8A, 0x8A,
  0x84, 0x84, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x7D,
  0x14, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x6C, 0x10, 0x08, 0x7D, 0x14, 0x61, 0xFA, 0x48, 0xA2, 0x88,
  0x3E, 0x81, 0x01, 0x01, 0x80, 0x81, 0x02, 0xF8, 0xFC, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x40, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78,
  0x83, 0x0A, 0x12, 0x44, 0x8A, 0x14, 0x30, 0x40, 0x88, 0x66, 0x29, 0x8A,
  0xA4, 0xA9, 0x32, 0x8C, 0x42, 0x10, 0x84, 0x00, 0x21, 0x12, 0x14, 0x08,
  0x08, 0x18, 0x24, 0x44, 0x82, 0x87, 0x09, 0x22, 0x86, 0x04, 0x10, 0x20,
  0x40, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0xFC, 0x39, 0x10, 0x84,
  0x21, 0x10, 0x84, 0x30, 0xA9, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x38, 0x10, 0xA4, 0x92, 0x84, 0xF8, 0xC0, 0x7E, 0x28, 0xA2, 0x8A,
  0x6E, 0x80, 0x20, 0x40, 0x82, 0xE6, 0x28, 0x50, 0xA1, 0x85, 0xF0, 0x7C,
  0x21, 0x08, 0x43, 0xC0, 0x02, 0x04, 0x13, 0xE8, 0x50, 0xA1, 0x44, 0x89,
  0xF0, 0x7C, 0x63, 0xE8, 0x43, 0xC0, 0x06, 0x10, 0x20, 0xE1, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x0C, 0x00, 0x3E, 0x85, 0x0C, 0x18, 0x50, 0x9F,
  0x02, 0x09, 0xE0, 0x20, 0x82, 0x17, 0x65, 0x14, 0x51, 0x86, 0x10, 0x21,
  0x24, 0x94, 0x80, 0x08, 0x04, 0x21, 0x08, 0x44, 0x21, 0x09, 0x80, 0x20,
  0x82, 0x11, 0x49, 0x46, 0x14, 0x8A, 0x20, 0x24, 0xA4, 0x92, 0x90, 0x5D,
  0xD8, 0x94, 0x45, 0x11, 0x44, 0x61, 0x18, 0x84, 0x5D, 0x94, 0x51, 0x46,
  0x18, 0x40, 0x7A, 0x18, 0x61, 0x86, 0x2F, 0x00, 0x5C, 0xC5, 0x0A, 0x14,
  0x30, 0xBE, 0x40, 0x81, 0x00, 0x7E, 0x18, 0x61, 0x8A, 0x2F, 0x82, 0x10,
  0x40, 0x5B, 0x10, 0x84, 0x42, 0x00, 0x7A, 0x10, 0x60, 0x87, 0xC0, 0x4A,
  0xC9, 0x24, 0xC0, 0x86, 0x18, 0x62, 0x8A, 0x2F, 0x80, 0x8C, 0xA5, 0x4A,
  0x62, 0x00, 0x91, 0x91, 0xB2, 0xAA, 0xCC, 0x88, 0x88, 0x45, 0x23, 0x08,
  0x51, 0x48, 0x80, 0x42, 0x44, 0x91, 0x42, 0x86, 0x08, 0x10, 0x21, 0x80,
  0x7C, 0x21, 0x08, 0x41, 0x0F, 0x00, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42,
  0x18, 0xFF, 0xF8, 0x18, 0x44, 0x21, 0x04, 0x44, 0x21, 0x30, 0xFC,
};

const GFXglyph NotoSans_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 11, 7, 1, -10 },
  { 25, 8, 9, 10, 1, -9 },
  { 34, 7, 9, 9, 1, -9 },
  { 42, 1, 3, 2, 1, -9 },
  { 43, 4, 11, 3, 0, -9 },
  { 49, 4, 11, 3, -1, -9 },
  { 55, 5, 6, 7, 2, -10 },
  { 59, 6, 6, 7, 1, -8 },
  { 64, 2, 4, 2, -1, -2 },
  { 65, 4, 1, 4, 0, -4 },
  { 66, 1, 1, 3, 0, -1 },
  { 67, 6, 9, 4, -1, -9 },
  { 74, 6, 9, 7, 1, -9 },
  { 81, 3, 9, 7, 2, -9 },
  { 85, 7, 9, 7, 0, -9 },
  { 93, 7, 9, 7, 0, -9 },
  { 101, 7, 9, 7, 0, -9 },
  { 109, 7, 9, 7, 0, -9 },
  { 117, 6, 9, 7, 1, -9 },
  { 124, 6, 9, 7, 1, -9 },
  { 131, 6, 9, 7, 1, -9 },
  { 138, 6, 9, 7, 1, -9 },
  { 145, 2, 7, 3, 0, -7 },
  { 147, 3, 9, 3, -1, -7 },
  { 151, 6, 6, 7, 1, -8 },
  { 156, 6, 3, 7, 1, -6 },
  { 159, 6, 6, 7, 1, -8 },
  { 164, 4, 9, 5, 1, -9 },
  { 169, 9, 10, 11, 1, -9 },
  { 181, 7, 9, 7, -1, -9 },
  { 189, 7, 9, 8, 1, -9 },
  { 197, 7, 9, 8, 1, -9 },
  { 205, 7, 9, 9, 1, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 6, 9, 6, 1, -9 },
  { 227, 8, 9, 9, 1, -9 },
  { 236, 8, 9, 9, 1, -9 },
  { 245, 4, 9, 4, 0, -9 },
  { 250, 5, 11, 3, -2, -9 },
  { 257, 7, 9, 7, 1, -9 },
  { 265, 4, 9, 6, 1, -9 },
  { 270, 9, 9, 10, 1, -9 },
  { 281, 8, 9, 9, 1, -9 },
  { 290, 8, 9, 9, 1, -9 },
  { 299, 6, 9, 7, 1, -9 },
  { 306, 8, 11, 9, 1, -9 },
  { 317, 6, 9, 7, 1, -9 },
  { 324, 7, 9, 6, 0, -9 },
  { 332, 6, 9, 6, 1, -9 },
  { 339, 8, 9, 9, 1, -9 },
  { 348, 7, 9, 7, 1, -9 },
  { 356, 10, 9, 11, 2, -9 },
  { 368, 8, 9, 6, -1, -9 },
  { 377, 7, 9, 6, 1, -9 },
  { 385, 7, 9, 7, 0, -9 },
  { 393, 5, 11, 4, 0, -9 },
  { 400, 2, 9, 4, 1, -9 },
  { 403, 5, 11, 4, -1, -9 },
  { 410, 6, 5, 7, 1, -9 },
  { 414, 5, 1, 5, -1, 1 },
  { 415, 1, 2, 3, 2, -10 },
  { 416, 6, 7, 7, 1, -7 },
  { 422, 7, 10, 7, 0, -10 },
  { 431, 5, 7, 6, 1, -7 },
  { 436, 7, 10, 7, 1, -10 },
  { 445, 5, 7, 6, 1, -7 },
  { 450, 7, 13, 3, -2, -10 },
  { 462, 7, 10, 7, 0, -7 },
  { 471, 6, 10, 7, 0, -10 },
  { 479, 3, 9, 3, 0, -9 },
  { 483, 5, 12, 3, -2, -9 },
  { 491, 6, 10, 6, 0, -10 },
  { 499, 3, 10, 3, 0, -10 },
  { 503, 10, 7, 11, 0, -7 },
  { 512, 6, 7, 7, 0, -7 },
  { 518, 6, 7, 7, 1, -7 },
  { 524, 7, 10, 7, 0, -7 },
  { 533, 6, 10, 7, 1, -7 },
  { 541, 5, 7, 5, 0, -7 },
  { 546, 5, 7, 6, 0, -7 },
  { 551, 3, 9, 4, 1, -9 },
  { 555, 6, 7, 7, 1, -7 },
  { 561, 5, 7, 5, 1, -7 },
  { 566, 8, 7, 8, 1, -7 },
  { 573, 6, 7, 6, 0, -7 },
  { 579, 7, 10, 5, -1, -7 },
  { 588, 6, 7, 6, 0, -7 },
  { 594, 5, 11, 4, 0, -9 },
  { 601, 1, 13, 7, 3, -10 },
  { 603, 5, 11, 4, -1, -9 },
  { 610, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_THINITALIC13PT7B_H_
