#ifndef _NOTOSANS_THINITALIC38PT7B_H_
#define _NOTOSANS_THINITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x00, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84, 0x00,
  0x10, 0x10, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x02,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x1F, 0xFF,
  0xFE, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x02, 0x02, 0x01,
  0xFF, 0xFF, 0xE0, 0x18, 0x08, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x00,
  0x80, 0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x20,
  0x10, 0x00, 0x40, 0x40, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xF0, 0x01, 0xD7, 0x81, 0x84, 0x10, 0xC1, 0x00, 0x20, 0x80, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x61, 0x00, 0x08, 0x40, 0x01, 0x90,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x98, 0x00, 0x21, 0x00, 0x08, 0x20,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01,
  0x0C, 0x30, 0x8C, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x18, 0x60, 0x0C,
  0x10, 0x20, 0x08, 0x20, 0x20, 0x10, 0x20, 0x20, 0x20, 0x40, 0x20, 0x60,
  0x40, 0x20, 0x40, 0x40, 0x20, 0x80, 0x40, 0x21, 0x00, 0x80, 0x43, 0x00,
  0x80, 0x42, 0x08, 0x80, 0x44, 0x66, 0x80, 0x88, 0x82, 0xC0, 0x89, 0x81,
  0x41, 0x11, 0x01, 0x76, 0x23, 0x01, 0x08, 0x42, 0x01, 0x00, 0x42, 0x01,
  0x00, 0x82, 0x01, 0x01, 0x04, 0x02, 0x03, 0x04, 0x02, 0x02, 0x04, 0x02,
  0x04, 0x04, 0x06, 0x08, 0x04, 0x04, 0x18, 0x04, 0x0C, 0x10, 0x02, 0x08,
  0x20, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x01, 0xDC, 0x00, 0x18, 0x18, 0x00,
  0x40, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x02, 0x00, 0x80, 0x08, 0x04, 0x00, 0x10, 0x60, 0x00, 0x42, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x66, 0x00, 0x02, 0x08, 0x00, 0x30,
  0x10, 0x05, 0x80, 0x20, 0x24, 0x00, 0x80, 0xA0, 0x01, 0x04, 0x80, 0x02,
  0x22, 0x00, 0x0C, 0x88, 0x00, 0x14, 0x20, 0x00, 0x20, 0x80, 0x03, 0x41,
  0x00, 0x11, 0x06, 0x01, 0x82, 0x07, 0xF8, 0x04, 0x24, 0xA4, 0x92, 0x90,
  0x00, 0x60, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x08,
  0x08, 0x0C, 0x20, 0x06, 0x40, 0x02, 0x87, 0x03, 0xF0, 0x0E, 0x00, 0x22,
  0x00, 0x84, 0x02, 0x04, 0x08, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x44, 0x22, 0x11, 0x08, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0xEE, 0x01, 0x80,
  0x81, 0x80, 0x20, 0x80, 0x10, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x20,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80, 0x18, 0x20,
  0x08, 0x18, 0x18, 0x03, 0xF0, 0x00, 0x00, 0x81, 0xC1, 0x23, 0x12, 0x1E,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0x70, 0x06, 0x01, 0x01, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x1E,
  0xE0, 0x0C, 0x03, 0x06, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC3, 0x00, 0x30,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x20, 0x06, 0x04, 0x01, 0x80, 0x80, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10,
  0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xE0, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFC,
  0x00, 0x80, 0x60, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x18, 0x03, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x1E, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x07, 0x00, 0x46, 0x18, 0x16, 0x01, 0x0A, 0x00, 0x23, 0x00,
  0x08, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02,
  0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0x80, 0x0C, 0x10, 0x06, 0x02,
  0x03, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x7B, 0xC0, 0x30, 0x18, 0x10, 0x03, 0x04,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x43, 0x00,
  0x20, 0x40, 0x10, 0x08, 0x18, 0x01, 0x0C, 0x00, 0x3C, 0x00, 0x3B, 0x00,
  0x30, 0x20, 0x30, 0x04, 0x18, 0x00, 0x84, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x10, 0x01,
  0x02, 0x01, 0x80, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x77, 0x80, 0x20, 0x10,
  0x10, 0x06, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00,
  0x61, 0x00, 0x28, 0x60, 0x12, 0x0F, 0x79, 0x00, 0x20, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x80, 0x00, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x01, 0xFF, 0x08, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x07, 0xF8, 0x11, 0x00, 0xC0, 0x40,
  0x48, 0x0C, 0x02, 0x02, 0x80, 0xC0, 0x20, 0x14, 0x04, 0x01, 0x00, 0xA0,
  0x40, 0x08, 0x0E, 0x02, 0x00, 0x40, 0x50, 0x10, 0x04, 0x02, 0x81, 0x00,
  0x20, 0x14, 0x08, 0x01, 0x01, 0x20, 0x40, 0x18, 0x09, 0x02, 0x01, 0x40,
  0x88, 0x08, 0x0A, 0x0C, 0x60, 0x61, 0x98, 0xC1, 0x00, 0xF0, 0x78, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10,
  0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x03, 0xFF, 0xE0, 0x10, 0x00,
  0x81, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x02,
  0x07, 0xFF, 0x80, 0x40, 0x0C, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x10, 0x00, 0x41, 0x00, 0x18, 0x1F, 0xFE, 0x01, 0x00, 0x60, 0x10,
  0x01, 0x82, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x44,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x03, 0x08, 0x00, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x01,
  0xEF, 0x80, 0x30, 0x02, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x40, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x10, 0x07, 0x00, 0x40, 0x06, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00,
  0x11, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x01, 0x98, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x80, 0x06, 0x02, 0x00, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x02, 0x07, 0xFF, 0x81, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xF7, 0xE0, 0x0C, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xA0, 0x03, 0xFC, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x21, 0x00, 0x00, 0x84,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x20, 0x00, 0x60, 0x40, 0x01, 0x00, 0xC0,
  0x0C, 0x01, 0xFF, 0xC0, 0x06, 0x00, 0x01, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x1F, 0xFF, 0xF8, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x80, 0x00,
  0x40, 0x03, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x8C, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x0C, 0x10, 0x00, 0x40, 0x40, 0x06, 0x01, 0x00, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x08, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x08, 0x10, 0x00, 0x21,
  0x80, 0x01, 0x0C, 0x00, 0x04, 0x60, 0x00, 0x12, 0x80, 0x00, 0x51, 0x00,
  0x01, 0x84, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80, 0x40, 0x02,
  0x01, 0x00, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x04, 0x00,
  0x40, 0x10, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x05, 0x00, 0x00, 0x50,
  0x50, 0x00, 0x05, 0x05, 0x00, 0x00, 0xA0, 0x90, 0x00, 0x1A, 0x09, 0x00,
  0x01, 0x20, 0x90, 0x00, 0x22, 0x08, 0x80, 0x02, 0x20, 0x88, 0x00, 0x44,
  0x10, 0x80, 0x0C, 0x41, 0x08, 0x00, 0x84, 0x10, 0x80, 0x10, 0x41, 0x04,
  0x01, 0x04, 0x10, 0x40, 0x20, 0x82, 0x04, 0x06, 0x08, 0x20, 0x40, 0x40,
  0x82, 0x04, 0x08, 0x08, 0x20, 0x40, 0x81, 0x84, 0x02, 0x10, 0x10, 0x40,
  0x21, 0x01, 0x04, 0x02, 0x20, 0x10, 0x40, 0x24, 0x01, 0x04, 0x02, 0x40,
  0x20, 0x80, 0x28, 0x02, 0x08, 0x01, 0x80, 0x20, 0x80, 0x10, 0x02, 0x00,
  0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x28, 0x00, 0x10,
  0x50, 0x00, 0x41, 0x10, 0x00, 0x82, 0x20, 0x01, 0x04, 0x20, 0x02, 0x08,
  0x40, 0x04, 0x10, 0x80, 0x10, 0x40, 0x80, 0x20, 0x81, 0x00, 0x41, 0x01,
  0x00, 0x82, 0x02, 0x01, 0x04, 0x02, 0x04, 0x10, 0x04, 0x08, 0x20, 0x08,
  0x10, 0x40, 0x08, 0x20, 0x80, 0x10, 0xC2, 0x00, 0x11, 0x04, 0x00, 0x22,
  0x08, 0x00, 0x24, 0x10, 0x00, 0x48, 0x20, 0x00, 0xA0, 0x80, 0x00, 0xC1,
  0x00, 0x01, 0x82, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE7, 0x80,
  0x06, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0x40, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10, 0x00, 0x0C,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x40, 0x20, 0x01, 0x00, 0x20, 0x0C, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x80, 0x30, 0x10, 0x01, 0x02, 0x00,
  0x30, 0x40, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x06,
  0x07, 0xFF, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xE7, 0x80, 0x06, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x20, 0x00, 0x10, 0x20, 0x00, 0x40, 0x20, 0x01, 0x00, 0x20,
  0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE,
  0x00, 0x80, 0x30, 0x10, 0x01, 0x02, 0x00, 0x10, 0x40, 0x02, 0x10, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x01,
  0x08, 0x00, 0x61, 0x00, 0x18, 0x20, 0x1C, 0x07, 0xFE, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x30, 0x04, 0x04, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x62,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x7D, 0xE0, 0x30, 0x04, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x08, 0x01, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x11, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x30, 0x20, 0x00, 0x40, 0x20, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x3F, 0xE0,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x20, 0x20, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x08,
  0x01, 0x01, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0x80,
  0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xA0, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x48, 0x00, 0xA0, 0x02,
  0x40, 0x09, 0x00, 0x22, 0x00, 0x48, 0x01, 0x10, 0x04, 0x40, 0x10, 0x80,
  0x22, 0x00, 0x84, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x41, 0x01, 0x02,
  0x06, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x04, 0x10,
  0x10, 0x40, 0x20, 0x80, 0x42, 0x01, 0x08, 0x02, 0x20, 0x08, 0x40, 0x11,
  0x00, 0x44, 0x00, 0x98, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x2C, 0x00,
  0x90, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x40,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x03, 0x00, 0x02, 0x02,
  0x00, 0x08, 0x04, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x03, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x20, 0x40, 0x00, 0x21, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x48, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x10, 0x00, 0x40, 0x10, 0x01, 0x80, 0x20, 0x02,
  0x00, 0x60, 0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x00, 0x82, 0x00,
  0x01, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x11, 0x00, 0x08, 0x40,
  0x06, 0x10, 0x01, 0x02, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x04, 0x08,
  0x01, 0x04, 0x00, 0x43, 0x00, 0x18, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xFE, 0x00, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20,
  0xC0, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x08, 0x80,
  0x0C, 0x40, 0x04, 0x20, 0x04, 0x08, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01,
  0x02, 0x00, 0x43, 0x00, 0x21, 0x00, 0x11, 0x00, 0x09, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xFC, 0x88, 0x46, 0x21, 0x03, 0xF8, 0x82, 0x02, 0x42, 0x00,
  0xA2, 0x00, 0x52, 0x00, 0x11, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32,
  0x00, 0x11, 0x00, 0x18, 0x80, 0x14, 0x20, 0x12, 0x18, 0x11, 0x07, 0xF1,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x0F,
  0xE0, 0x26, 0x06, 0x05, 0x00, 0x60, 0xC0, 0x04, 0x28, 0x00, 0x86, 0x00,
  0x10, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x23, 0x00, 0x04, 0x60, 0x01,
  0x0C, 0x00, 0x61, 0x40, 0x18, 0x44, 0x06, 0x08, 0x7F, 0x00, 0x03, 0xFE,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x7F, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x3F,
  0xC4, 0x04, 0x02, 0x40, 0x80, 0x14, 0x10, 0x01, 0x82, 0x00, 0x18, 0x20,
  0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x60,
  0x80, 0x0E, 0x08, 0x00, 0xA0, 0x40, 0x12, 0x06, 0x06, 0x40, 0x3F, 0x84,
  0x00, 0x01, 0xFC, 0x0C, 0x0C, 0x20, 0x08, 0xC0, 0x13, 0x00, 0x24, 0x00,
  0x58, 0x01, 0xA0, 0x06, 0x40, 0x38, 0xFF, 0x83, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x20, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x20, 0x60, 0x24,
  0x10, 0x02, 0x84, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x38, 0x40, 0x05, 0x04,
  0x01, 0x40, 0xC0, 0xC8, 0x0F, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x60,
  0x30, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x1F, 0xC0, 0x98, 0x08, 0x2C, 0x02, 0x0E, 0x00, 0x45, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0xC2, 0x00, 0x81, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08,
  0xC0, 0x04, 0x90, 0x02, 0x88, 0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x08, 0x10, 0x04, 0x08, 0x01, 0x08, 0x00, 0xC0, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x00, 0x08, 0xFE, 0x07, 0xE0, 0x4C, 0x18, 0xC0, 0x82, 0x80, 0x48, 0x04,
  0x18, 0x02, 0xC0, 0x11, 0x40, 0x14, 0x00, 0x8C, 0x00, 0xC0, 0x04, 0x40,
  0x06, 0x00, 0x22, 0x00, 0x20, 0x02, 0x10, 0x01, 0x00, 0x11, 0x00, 0x08,
  0x00, 0x88, 0x00, 0x80, 0x04, 0x40, 0x04, 0x00, 0x42, 0x00, 0x20, 0x02,
  0x10, 0x01, 0x00, 0x11, 0x00, 0x08, 0x00, 0x88, 0x00, 0x80, 0x04, 0x40,
  0x04, 0x00, 0x42, 0x00, 0x20, 0x02, 0x10, 0x01, 0x00, 0x11, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x7F, 0x02, 0x60, 0x20, 0xB0, 0x08, 0x38, 0x01, 0x14,
  0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x03,
  0xFC, 0x03, 0x01, 0x02, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x80, 0x04, 0x40, 0x06, 0x30,
  0x06, 0x0C, 0x06, 0x03, 0xFC, 0x00, 0x02, 0x1F, 0xC0, 0x13, 0x03, 0x00,
  0xB0, 0x0C, 0x07, 0x00, 0x20, 0x50, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00,
  0x60, 0x80, 0x02, 0x04, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x10, 0x60, 0x00, 0x83, 0x00, 0x08,
  0x18, 0x00, 0xC0, 0xA0, 0x0C, 0x04, 0x80, 0xC0, 0x43, 0xF8, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x41, 0x80, 0x90, 0x80, 0x14, 0x40, 0x06, 0x20, 0x01, 0x88, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x38, 0x80,
  0x0A, 0x10, 0x05, 0x06, 0x06, 0x40, 0xFE, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x7C, 0x26, 0x00, 0xA0, 0x03, 0x00,
  0x14, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x18, 0x04, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x23, 0x00, 0xC1, 0xFE, 0x00, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x01, 0xFF, 0xC4, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x7E, 0x00, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01,
  0x88, 0x00, 0x62, 0x00, 0x30, 0x80, 0x14, 0x30, 0x0D, 0x04, 0x04, 0x40,
  0xFE, 0x10, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x44, 0x00, 0x88,
  0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x80, 0x80, 0x82, 0x01, 0x04,
  0x02, 0x10, 0x04, 0x60, 0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x80, 0x10, 0x01, 0x80, 0x10, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88,
  0x08, 0x40, 0x88, 0x10, 0x41, 0x08, 0x10, 0x41, 0x08, 0x20, 0x42, 0x08,
  0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x58, 0x05, 0x00, 0x50, 0x05, 0x00, 0x70, 0x05, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x80, 0x10, 0x18, 0x06, 0x01,
  0x01, 0x80, 0x30, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x04, 0x80, 0x00,
  0xA0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x90, 0x00, 0x32, 0x00, 0x0C,
  0x20, 0x01, 0x04, 0x00, 0x40, 0x40, 0x10, 0x08, 0x04, 0x00, 0x81, 0x00,
  0x10, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x04,
  0x04, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x10, 0x01, 0x00, 0x80, 0x08, 0x08, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0xE0, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x06, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xE0, 0xE0, 0x60,
  0x1F, 0xC0,
};

const GFXglyph NotoSans_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 8, 10, 12, 4, -27 },
  { 35, 23, 27, 23, 1, -27 },
  { 113, 18, 31, 21, 2, -29 },
  { 183, 24, 28, 29, 3, -28 },
  { 267, 22, 28, 26, 2, -28 },
  { 344, 3, 10, 7, 4, -27 },
  { 348, 11, 33, 9, 1, -27 },
  { 394, 10, 33, 9, -2, -27 },
  { 436, 15, 16, 20, 5, -29 },
  { 466, 17, 17, 22, 3, -22 },
  { 503, 5, 9, 7, -2, -4 },
  { 509, 9, 1, 12, 1, -11 },
  { 511, 2, 2, 8, 1, -2 },
  { 512, 17, 27, 12, -2, -27 },
  { 570, 17, 28, 21, 3, -28 },
  { 630, 9, 27, 21, 6, -27 },
  { 661, 19, 28, 21, 0, -28 },
  { 728, 19, 28, 21, 1, -28 },
  { 795, 19, 27, 21, 1, -27 },
  { 860, 19, 27, 21, 1, -27 },
  { 925, 18, 28, 21, 3, -28 },
  { 988, 17, 27, 21, 4, -27 },
  { 1046, 18, 28, 21, 2, -28 },
  { 1109, 18, 28, 21, 2, -28 },
  { 1172, 6, 20, 8, 1, -20 },
  { 1187, 9, 25, 8, -2, -20 },
  { 1216, 17, 17, 22, 3, -22 },
  { 1253, 17, 9, 22, 3, -18 },
  { 1273, 17, 17, 22, 3, -22 },
  { 1310, 13, 28, 15, 3, -28 },
  { 1356, 29, 30, 32, 2, -27 },
  { 1465, 21, 27, 21, -2, -27 },
  { 1536, 20, 27, 23, 2, -27 },
  { 1604, 21, 28, 23, 3, -28 },
  { 1678, 22, 27, 26, 2, -27 },
  { 1753, 19, 27, 20, 2, -27 },
  { 1818, 19, 27, 19, 2, -27 },
  { 1883, 22, 28, 26, 3, -28 },
  { 1960, 24, 27, 26, 2, -27 },
  { 2041, 12, 27, 11, 0, -27 },
  { 2082, 15, 34, 9, -6, -27 },
  { 2146, 22, 27, 21, 2, -27 },
  { 2221, 14, 27, 19, 2, -27 },
  { 2269, 28, 27, 31, 2, -27 },
  { 2364, 23, 27, 26, 2, -27 },
  { 2442, 23, 28, 27, 3, -28 },
  { 2523, 19, 27, 21, 2, -27 },
  { 2588, 23, 34, 27, 3, -28 },
  { 2686, 19, 27, 21, 2, -27 },
  { 2751, 18, 28, 19, 1, -28 },
  { 2814, 18, 27, 18, 4, -27 },
  { 2875, 23, 27, 26, 3, -27 },
  { 2953, 19, 27, 20, 4, -27 },
  { 3018, 29, 27, 31, 5, -27 },
  { 3116, 23, 27, 19, -2, -27 },
  { 3194, 18, 27, 18, 4, -27 },
  { 3255, 22, 27, 20, 0, -27 },
  { 3330, 14, 33, 12, 0, -27 },
  { 3388, 6, 27, 12, 4, -27 },
  { 3409, 15, 33, 12, -3, -27 },
  { 3471, 17, 16, 21, 2, -27 },
  { 3505, 14, 1, 14, -3, 4 },
  { 3507, 4, 6, 9, 6, -29 },
  { 3510, 17, 20, 21, 2, -20 },
  { 3553, 19, 29, 22, 1, -29 },
  { 3622, 15, 20, 17, 2, -20 },
  { 3660, 20, 29, 22, 2, -29 },
  { 3733, 15, 20, 19, 2, -20 },
  { 3771, 21, 38, 10, -5, -29 },
  { 3871, 19, 29, 22, 1, -20 },
  { 3940, 18, 29, 21, 1, -29 },
  { 4006, 7, 27, 8, 1, -27 },
  { 4030, 13, 36, 8, -5, -27 },
  { 4089, 17, 29, 17, 1, -29 },
  { 4151, 7, 29, 8, 1, -29 },
  { 4177, 29, 20, 32, 1, -20 },
  { 4250, 18, 20, 21, 1, -20 },
  { 4295, 17, 20, 21, 2, -20 },
  { 4338, 21, 29, 22, -1, -20 },
  { 4415, 18, 29, 22, 2, -20 },
  { 4481, 14, 20, 14, 1, -20 },
  { 4516, 15, 20, 16, 0, -20 },
  { 4554, 11, 25, 12, 2, -25 },
  { 4589, 18, 20, 21, 2, -20 },
  { 4634, 15, 20, 16, 2, -20 },
  { 4672, 24, 20, 25, 2, -20 },
  { 4732, 19, 20, 17, -1, -20 },
  { 4780, 21, 29, 16, -4, -20 },
  { 4857, 18, 20, 17, -1, -20 },
  { 4902, 14, 33, 12, 1, -27 },
  { 4960, 1, 38, 20, 11, -29 },
  { 4965, 14, 33, 12, -2, -27 },
  { 5023, 17, 3, 22, 3, -15 },
};

const GFXfont NotoSans_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_THINITALIC38PT7B_H_
