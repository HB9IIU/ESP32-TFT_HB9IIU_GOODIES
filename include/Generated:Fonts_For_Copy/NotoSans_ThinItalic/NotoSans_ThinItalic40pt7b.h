#ifndef _NOTOSANS_THINITALIC40PT7B_H_
#define _NOTOSANS_THINITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x30, 0x90, 0x48, 0x24, 0x22, 0x12,
  0x09, 0x04, 0x82, 0x42, 0x21, 0x20, 0x80, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x40, 0x1F, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80,
  0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x01, 0x00, 0x01, 0x01,
  0x00, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xF8, 0x02, 0x02, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x02, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x08, 0x04,
  0x00, 0x08, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x38, 0x8E, 0x0C, 0x20,
  0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x03, 0x02, 0x00, 0x60, 0x80,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x0C, 0x40, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x58, 0x00, 0x08, 0xC0, 0x01, 0x08, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x02, 0x00, 0x20, 0x83,
  0x84, 0x60, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0xC0, 0x01, 0x06, 0x30, 0x01, 0x06, 0x08, 0x01, 0x82,
  0x02, 0x00, 0x82, 0x01, 0x00, 0x81, 0x00, 0x80, 0x81, 0x80, 0x40, 0xC0,
  0x80, 0x20, 0x40, 0x40, 0x20, 0x40, 0x20, 0x10, 0x40, 0x10, 0x08, 0x60,
  0x18, 0x04, 0x20, 0x0C, 0x04, 0x23, 0xF6, 0x02, 0x23, 0x0D, 0x03, 0x31,
  0x02, 0x81, 0x11, 0x01, 0x63, 0x10, 0x80, 0x9F, 0x18, 0x80, 0x40, 0x08,
  0x40, 0x20, 0x08, 0x20, 0x10, 0x08, 0x20, 0x08, 0x0C, 0x10, 0x04, 0x04,
  0x08, 0x04, 0x04, 0x04, 0x02, 0x04, 0x02, 0x01, 0x06, 0x01, 0x01, 0x02,
  0x00, 0x80, 0x82, 0x00, 0x20, 0x82, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x80, 0x40, 0x01, 0x00, 0x40, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x01, 0x00, 0x80, 0x01, 0x03, 0x00, 0x00, 0x84, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x10, 0x01, 0x18, 0x10, 0x02,
  0x20, 0x08, 0x02, 0x40, 0x04, 0x04, 0x40, 0x06, 0x04, 0x80, 0x02, 0x08,
  0x80, 0x01, 0x10, 0x80, 0x00, 0xB0, 0x80, 0x00, 0xE0, 0x80, 0x00, 0xC0,
  0xC0, 0x01, 0x20, 0x40, 0x02, 0x30, 0x30, 0x0C, 0x10, 0x1F, 0xF0, 0x08,
  0x32, 0x22, 0x24, 0x44, 0x44, 0x80, 0x00, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0xC0, 0x80, 0x30, 0x80,
  0x08, 0x80, 0x06, 0x9F, 0x01, 0xE0, 0x02, 0x80, 0x04, 0x80, 0x08, 0x40,
  0x30, 0x40, 0x60, 0x20, 0x40, 0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x20, 0x84, 0x10, 0xC2, 0x18, 0x43, 0x00, 0xFF, 0x80, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x60,
  0x18, 0x10, 0x02, 0x08, 0x00, 0xC4, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x58, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x18,
  0x80, 0x04, 0x30, 0x02, 0x04, 0x01, 0x80, 0x80, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x80, 0xC1, 0xA1, 0x13, 0x12, 0x0A, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x00, 0x00, 0x1F, 0x80,
  0x06, 0x0C, 0x01, 0x80, 0x20, 0x10, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x1C, 0x0C, 0x07, 0x00, 0x20, 0x40, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x0C, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00, 0x03, 0x40,
  0x00, 0x64, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x02, 0x08,
  0x00, 0x40, 0x80, 0x08, 0x08, 0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00,
  0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xE0, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x7F, 0x80, 0x30, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x40, 0x0C, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x0E, 0x04, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x20, 0x04, 0x7B, 0xC0, 0x90, 0x0C, 0x14, 0x00, 0xC5, 0x00, 0x08, 0xC0,
  0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x08, 0x00, 0x81, 0x00,
  0x30, 0x18, 0x08, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x30, 0x0C, 0x01, 0x03, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x43, 0x00,
  0x08, 0x40, 0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x10, 0x02, 0x01, 0x00,
  0x80, 0x18, 0x60, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x30, 0x60, 0x18, 0x06,
  0x04, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x18, 0x00, 0x21, 0x00, 0x08,
  0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x60, 0x08, 0x02,
  0x02, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x32, 0x00, 0x06,
  0x40, 0x01, 0x84, 0x00, 0x70, 0xC0, 0x1A, 0x0C, 0x0C, 0xC0, 0x7E, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x0F,
  0xF8, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0xE0, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01,
  0x10, 0x03, 0xFC, 0x04, 0x80, 0x30, 0x10, 0x12, 0x01, 0x80, 0x40, 0x58,
  0x0C, 0x01, 0x01, 0x40, 0x60, 0x08, 0x05, 0x01, 0x00, 0x20, 0x14, 0x04,
  0x00, 0x80, 0x70, 0x20, 0x02, 0x01, 0x80, 0x80, 0x10, 0x0E, 0x02, 0x00,
  0x40, 0x28, 0x08, 0x03, 0x00, 0xA0, 0x20, 0x0C, 0x04, 0x80, 0x80, 0x50,
  0x33, 0x03, 0x02, 0x41, 0x84, 0x06, 0x71, 0x9C, 0x10, 0x07, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x42, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x10, 0x07, 0xFF, 0xC0, 0x20, 0x01, 0x00, 0x80,
  0x06, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x02,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x26, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x03, 0xFC, 0x00, 0x10, 0x1F, 0x00, 0x80, 0x0C, 0x08, 0x00,
  0x30, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x08,
  0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x41, 0x80, 0x0C,
  0x0F, 0xFF, 0x80, 0x40, 0x7C, 0x02, 0x00, 0x30, 0x10, 0x00, 0x41, 0x80,
  0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11,
  0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x1C, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xC0,
  0x70, 0x0C, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20,
  0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x1F, 0x80, 0x08, 0x01, 0x80,
  0x20, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x80, 0x00, 0x81, 0x00, 0x01, 0x82,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x84, 0x00, 0x01, 0x10, 0x00, 0x04, 0x20, 0x00, 0x10,
  0x40, 0x00, 0x40, 0x80, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xF8, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF8, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x1F, 0x00,
  0xC0, 0x02, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x07, 0xFC, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x10, 0x20, 0x00, 0x10, 0x30, 0x00, 0x10, 0x18,
  0x00, 0x20, 0x0C, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x08, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x60, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00,
  0x04, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x41, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x83,
  0x00, 0xFC, 0x00, 0x02, 0x00, 0x02, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x20, 0x01, 0x80, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x40, 0x02,
  0x01, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x42,
  0x00, 0x01, 0x88, 0x00, 0x02, 0x28, 0x00, 0x05, 0x90, 0x00, 0x0E, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x40,
  0x02, 0x00, 0x80, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x01, 0x00,
  0x40, 0x02, 0x00, 0x80, 0x06, 0x01, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x41, 0x40, 0x00, 0x06, 0x05, 0x00, 0x00,
  0x28, 0x14, 0x00, 0x01, 0xA0, 0x48, 0x00, 0x04, 0x81, 0x20, 0x00, 0x26,
  0x08, 0x80, 0x00, 0x90, 0x22, 0x00, 0x04, 0x40, 0x88, 0x00, 0x31, 0x02,
  0x30, 0x00, 0x84, 0x18, 0x40, 0x04, 0x30, 0x41, 0x00, 0x10, 0x81, 0x04,
  0x00, 0x82, 0x04, 0x10, 0x06, 0x08, 0x10, 0x40, 0x10, 0x20, 0xC0, 0x80,
  0x81, 0x02, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0xC0,
  0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10, 0x08, 0x10, 0x04, 0x40, 0x20,
  0x40, 0x12, 0x00, 0x81, 0x00, 0x58, 0x02, 0x04, 0x01, 0x40, 0x18, 0x20,
  0x06, 0x00, 0x40, 0x80, 0x18, 0x01, 0x00, 0x02, 0x00, 0x00, 0x81, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x40, 0xA0, 0x00, 0x20, 0x58, 0x00, 0x10, 0x24,
  0x00, 0x08, 0x12, 0x00, 0x08, 0x08, 0x80, 0x04, 0x08, 0x40, 0x02, 0x04,
  0x10, 0x01, 0x02, 0x08, 0x00, 0x81, 0x06, 0x00, 0x81, 0x81, 0x00, 0x40,
  0x80, 0x80, 0x20, 0x40, 0x20, 0x10, 0x20, 0x10, 0x08, 0x10, 0x04, 0x08,
  0x18, 0x02, 0x04, 0x08, 0x01, 0x82, 0x04, 0x00, 0x41, 0x02, 0x00, 0x21,
  0x81, 0x00, 0x08, 0x81, 0x00, 0x04, 0x40, 0x80, 0x01, 0x20, 0x40, 0x00,
  0x90, 0x20, 0x00, 0x70, 0x10, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x30, 0x01, 0x00, 0x08, 0x02,
  0x00, 0x04, 0x04, 0x00, 0x06, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x18, 0x20, 0x00, 0x10, 0x30, 0x00, 0x20, 0x18, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x78, 0x02, 0x00,
  0x60, 0x40, 0x02, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x18,
  0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x81, 0x00, 0x70, 0x1F, 0xF8, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x30,
  0x01, 0x00, 0x08, 0x02, 0x00, 0x04, 0x04, 0x00, 0x06, 0x08, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x10, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01,
  0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x20, 0x00, 0x10, 0x30, 0x00, 0x20,
  0x18, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x03, 0xF0, 0x00, 0x20, 0xF8, 0x02,
  0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02,
  0x18, 0x00, 0x61, 0x00, 0x0C, 0x10, 0x03, 0x81, 0xFF, 0xC0, 0x10, 0x18,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x20, 0x04, 0x02, 0x00,
  0x40, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x38, 0x1C,
  0x08, 0x00, 0x82, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x40,
  0x0C, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x40, 0x80, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x40, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18,
  0x40, 0x01, 0x04, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x02,
  0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x01, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0A, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00, 0x48, 0x00, 0x50, 0x00,
  0x90, 0x01, 0xA0, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40, 0x0C, 0x80, 0x10,
  0x80, 0x11, 0x00, 0x21, 0x00, 0x22, 0x00, 0xC2, 0x00, 0x82, 0x01, 0x02,
  0x01, 0x04, 0x06, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x20, 0x40, 0x40, 0x80, 0x41, 0x00, 0x82, 0x00, 0x82,
  0x01, 0x04, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x04, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x08, 0x80, 0x11, 0x00, 0x12, 0x00, 0x26, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x50, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x02,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x10, 0x40, 0x00, 0x04, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x23, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x10, 0x00, 0x10, 0x08, 0x00, 0x10, 0x06, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x20, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0B, 0x00, 0x03,
  0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x04, 0x08, 0x01, 0x81, 0x00, 0x20,
  0x20, 0x08, 0x02, 0x03, 0x00, 0x40, 0x40, 0x08, 0x10, 0x00, 0x84, 0x00,
  0x11, 0x80, 0x02, 0x20, 0x00, 0x68, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x82, 0x08, 0x20, 0x41,
  0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x41, 0x04, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0x90, 0x00, 0x62, 0x00,
  0x10, 0x80, 0x08, 0x20, 0x06, 0x08, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x10, 0x30, 0x04, 0x08, 0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x01,
  0x40, 0x00, 0x70, 0x00, 0x10, 0xFF, 0xFE, 0x8C, 0x46, 0x21, 0x10, 0x00,
  0x20, 0x00, 0x7F, 0x10, 0x60, 0x24, 0x30, 0x05, 0x18, 0x01, 0x44, 0x00,
  0x62, 0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80,
  0x06, 0x20, 0x02, 0x84, 0x00, 0xA1, 0x00, 0xC8, 0x20, 0x64, 0x07, 0xE1,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x04, 0x00,
  0x47, 0xF8, 0x08, 0x80, 0xC0, 0x90, 0x04, 0x0A, 0x00, 0x20, 0xC0, 0x02,
  0x08, 0x00, 0x21, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x60, 0x00, 0x86, 0x00, 0x08, 0x50, 0x01, 0x05, 0x00, 0x20, 0x48,
  0x0C, 0x08, 0x7F, 0x80, 0x00, 0x10, 0x01, 0xFF, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x08, 0x0F, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x30, 0x20,
  0x0F, 0xF1, 0x01, 0x80, 0xC8, 0x18, 0x02, 0x41, 0x80, 0x0C, 0x08, 0x00,
  0x60, 0x80, 0x03, 0x04, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10,
  0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04,
  0x10, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x28, 0x10, 0x02, 0x40, 0x80,
  0x24, 0x02, 0x02, 0x20, 0x0F, 0xE1, 0x00, 0x00, 0x10, 0x01, 0xFE, 0x02,
  0x03, 0x0C, 0x01, 0x08, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x03, 0x60,
  0x02, 0x40, 0x0C, 0x40, 0xF0, 0x7E, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18,
  0x08, 0x0F, 0xF8, 0x00, 0x00, 0x24, 0x00, 0x07, 0x20, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x26, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F,
  0xF1, 0x03, 0x01, 0x90, 0x60, 0x09, 0x0C, 0x00, 0x50, 0x80, 0x06, 0x10,
  0x00, 0x61, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x44,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18,
  0x40, 0x01, 0x84, 0x00, 0x28, 0x20, 0x04, 0x82, 0x00, 0x90, 0x10, 0x11,
  0x00, 0xFE, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x08, 0x01, 0x00, 0xF9,
  0xE0, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x04, 0x00, 0x8F, 0xF0, 0x22, 0x03, 0x04, 0x80, 0x20, 0xA0, 0x02, 0x18,
  0x00, 0x43, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x18, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00,
  0x11, 0x00, 0x06, 0x00, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x1B, 0x80, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x30, 0x80, 0x10,
  0x20, 0x08, 0x08, 0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x10,
  0x40, 0x04, 0x20, 0x01, 0x38, 0x00, 0x9A, 0x00, 0x2C, 0xC0, 0x0E, 0x10,
  0x02, 0x06, 0x00, 0x80, 0x80, 0x40, 0x30, 0x10, 0x04, 0x04, 0x01, 0x81,
  0x00, 0x20, 0x40, 0x0C, 0x20, 0x01, 0x00, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x00, 0x08, 0x00, 0x40, 0x11, 0xFC, 0x0F, 0xE0, 0x98, 0x18, 0xC0,
  0xC2, 0xC0, 0x26, 0x01, 0x0A, 0x00, 0xB0, 0x04, 0x30, 0x02, 0x80, 0x10,
  0x80, 0x0C, 0x00, 0x46, 0x00, 0x30, 0x01, 0x10, 0x00, 0x80, 0x04, 0x40,
  0x02, 0x00, 0x11, 0x00, 0x08, 0x00, 0xCC, 0x00, 0x40, 0x02, 0x20, 0x01,
  0x00, 0x08, 0x80, 0x04, 0x00, 0x22, 0x00, 0x10, 0x00, 0x88, 0x00, 0x40,
  0x04, 0x40, 0x02, 0x00, 0x11, 0x00, 0x08, 0x00, 0x44, 0x00, 0x20, 0x01,
  0x10, 0x00, 0x80, 0x04, 0x40, 0x04, 0x00, 0x22, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x8F, 0xF0, 0x22, 0x03, 0x04, 0x80, 0x20, 0xA0, 0x02,
  0x18, 0x00, 0x43, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x11, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x60, 0x10,
  0x30, 0x02, 0x18, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x90, 0x00, 0x44, 0x00, 0x21,
  0x80, 0x10, 0x30, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x04, 0x7F,
  0x80, 0x23, 0x03, 0x00, 0x90, 0x04, 0x02, 0x80, 0x08, 0x0C, 0x00, 0x20,
  0x30, 0x00, 0x81, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40,
  0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x18, 0x00, 0x20, 0x60, 0x00, 0x81, 0x40, 0x04, 0x05,
  0x00, 0x20, 0x12, 0x03, 0x00, 0x87, 0xF8, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xC4, 0x18, 0x0C, 0x86, 0x00, 0x91, 0x80, 0x0A, 0x20, 0x01, 0x88,
  0x00, 0x31, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80,
  0x03, 0x10, 0x00, 0xA1, 0x00, 0x24, 0x20, 0x09, 0x02, 0x02, 0x20, 0x3F,
  0x84, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x04,
  0x7E, 0x11, 0x00, 0x24, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x0C, 0x01, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x10, 0x3F, 0xE0, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x81, 0xFF, 0xC4, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0F, 0xC0, 0x10,
  0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x20, 0x00, 0xC4, 0x00,
  0x30, 0x80, 0x06, 0x10, 0x01, 0x41, 0x00, 0x48, 0x30, 0x31, 0x03, 0xF8,
  0x40, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x20, 0x60, 0x20, 0x20, 0x40, 0x20,
  0xC0, 0x20, 0x80, 0x21, 0x00, 0x21, 0x00, 0x22, 0x00, 0x12, 0x00, 0x14,
  0x00, 0x14, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xA0, 0x06, 0x00, 0x50, 0x05, 0x00, 0x68, 0x02, 0x40, 0x22, 0x02,
  0x20, 0x31, 0x01, 0x10, 0x10, 0x81, 0x08, 0x08, 0x40, 0x84, 0x08, 0x20,
  0x82, 0x04, 0x10, 0x41, 0x04, 0x08, 0x40, 0x82, 0x04, 0x20, 0x42, 0x02,
  0x20, 0x11, 0x01, 0x10, 0x09, 0x00, 0x90, 0x04, 0x80, 0x48, 0x02, 0x80,
  0x28, 0x01, 0x40, 0x14, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x30, 0x40, 0x04, 0x02, 0x00, 0x80, 0x20, 0x18, 0x01,
  0x03, 0x00, 0x10, 0x60, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0xD0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00,
  0x06, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x06,
  0x04, 0x00, 0x20, 0x80, 0x03, 0x00, 0x01, 0x00, 0x02, 0x02, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x0C, 0x00, 0x40, 0x10, 0x00, 0x80, 0x60, 0x00, 0x80, 0x80, 0x01,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10,
  0x80, 0x00, 0x13, 0x00, 0x00, 0x24, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x11, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0xF0, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x03, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x07, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x70, 0x03, 0x80, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x18,
  0x70, 0x18, 0x07, 0x98, 0x00, 0x18,
};

const GFXglyph NotoSans_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 29, 8, 1, -29 },
  { 30, 9, 11, 12, 4, -29 },
  { 43, 24, 29, 25, 1, -29 },
  { 130, 19, 32, 22, 2, -30 },
  { 206, 25, 29, 31, 3, -29 },
  { 297, 24, 29, 27, 2, -29 },
  { 384, 4, 11, 7, 4, -29 },
  { 390, 11, 35, 10, 1, -29 },
  { 439, 12, 35, 10, -3, -29 },
  { 492, 16, 16, 21, 5, -30 },
  { 524, 18, 18, 23, 3, -23 },
  { 565, 6, 10, 7, -2, -5 },
  { 573, 9, 1, 12, 2, -11 },
  { 575, 2, 2, 8, 1, -2 },
  { 576, 18, 29, 12, -2, -29 },
  { 642, 18, 29, 22, 3, -29 },
  { 708, 9, 29, 22, 7, -29 },
  { 741, 20, 29, 22, 0, -29 },
  { 814, 20, 29, 22, 1, -29 },
  { 887, 20, 29, 22, 1, -29 },
  { 960, 19, 29, 22, 2, -29 },
  { 1029, 19, 29, 22, 3, -29 },
  { 1098, 17, 29, 22, 5, -29 },
  { 1160, 19, 29, 22, 2, -29 },
  { 1229, 19, 29, 22, 2, -29 },
  { 1298, 6, 21, 8, 1, -21 },
  { 1314, 9, 26, 8, -2, -21 },
  { 1344, 18, 17, 23, 3, -23 },
  { 1383, 18, 9, 23, 3, -19 },
  { 1404, 18, 17, 23, 3, -23 },
  { 1443, 14, 29, 16, 3, -29 },
  { 1494, 30, 32, 33, 2, -28 },
  { 1614, 22, 29, 22, -2, -29 },
  { 1694, 21, 29, 24, 2, -29 },
  { 1771, 22, 29, 24, 3, -29 },
  { 1851, 23, 29, 27, 2, -29 },
  { 1935, 20, 29, 21, 2, -29 },
  { 2008, 20, 29, 19, 2, -29 },
  { 2081, 24, 29, 28, 3, -29 },
  { 2168, 25, 29, 27, 2, -29 },
  { 2259, 13, 29, 11, 0, -29 },
  { 2307, 16, 36, 9, -7, -29 },
  { 2379, 23, 29, 22, 2, -29 },
  { 2463, 14, 29, 20, 2, -29 },
  { 2514, 30, 29, 32, 2, -29 },
  { 2623, 25, 29, 27, 2, -29 },
  { 2714, 24, 29, 29, 3, -29 },
  { 2801, 20, 29, 22, 2, -29 },
  { 2874, 24, 36, 29, 3, -29 },
  { 2982, 20, 29, 22, 2, -29 },
  { 3055, 19, 29, 20, 1, -29 },
  { 3124, 19, 29, 19, 4, -29 },
  { 3193, 24, 29, 28, 4, -29 },
  { 3280, 20, 29, 21, 4, -29 },
  { 3353, 31, 29, 33, 5, -29 },
  { 3466, 25, 29, 20, -2, -29 },
  { 3557, 19, 29, 19, 4, -29 },
  { 3626, 23, 29, 22, 0, -29 },
  { 3710, 15, 35, 12, 0, -29 },
  { 3776, 6, 29, 12, 4, -29 },
  { 3798, 15, 35, 12, -3, -29 },
  { 3864, 18, 18, 22, 2, -29 },
  { 3905, 15, 1, 15, -3, 4 },
  { 3907, 4, 7, 9, 6, -31 },
  { 3911, 18, 22, 22, 2, -22 },
  { 3961, 20, 30, 23, 1, -30 },
  { 4036, 16, 22, 18, 2, -22 },
  { 4080, 21, 30, 23, 2, -30 },
  { 4159, 16, 22, 20, 2, -22 },
  { 4203, 22, 41, 11, -5, -31 },
  { 4316, 20, 32, 23, 1, -22 },
  { 4396, 19, 30, 22, 1, -30 },
  { 4468, 8, 29, 8, 1, -29 },
  { 4497, 15, 39, 8, -6, -29 },
  { 4571, 18, 30, 18, 1, -30 },
  { 4639, 8, 30, 8, 1, -30 },
  { 4669, 30, 22, 34, 1, -22 },
  { 4752, 19, 22, 22, 1, -22 },
  { 4805, 18, 22, 23, 2, -22 },
  { 4855, 22, 31, 23, -1, -22 },
  { 4941, 19, 31, 23, 2, -22 },
  { 5015, 15, 21, 15, 1, -21 },
  { 5055, 16, 22, 17, 0, -22 },
  { 5099, 11, 26, 12, 2, -26 },
  { 5135, 19, 21, 22, 2, -21 },
  { 5185, 16, 21, 16, 2, -21 },
  { 5227, 25, 21, 26, 2, -21 },
  { 5293, 20, 21, 18, -1, -21 },
  { 5346, 23, 31, 16, -5, -21 },
  { 5436, 18, 21, 17, -1, -21 },
  { 5484, 14, 35, 13, 1, -29 },
  { 5546, 1, 40, 21, 11, -30 },
  { 5551, 14, 35, 13, -2, -29 },
  { 5613, 18, 4, 23, 3, -16 },
};

const GFXfont NotoSans_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_THINITALIC40PT7B_H_
