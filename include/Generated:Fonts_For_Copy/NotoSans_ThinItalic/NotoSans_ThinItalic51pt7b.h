#ifndef _NOTOSANS_THINITALIC51PT7B_H_
#define _NOTOSANS_THINITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x18, 0x00, 0x30, 0x64, 0x08, 0x81, 0x30, 0x66,
  0x0C, 0x81, 0x10, 0x22, 0x04, 0xC1, 0x90, 0x22, 0x04, 0x40, 0x88, 0x10,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x01, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0x40, 0x00, 0x18,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x38, 0xC3, 0x81,
  0xC1, 0x01, 0x06, 0x02, 0x00, 0x08, 0x04, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x06, 0x06,
  0x00, 0x04, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x0E, 0x20, 0x00, 0x07, 0x40,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x60, 0x00, 0x08, 0x70,
  0x00, 0x10, 0x20, 0x00, 0x60, 0x60, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80,
  0x02, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x10, 0x00,
  0x40, 0x40, 0x00, 0x83, 0x03, 0x83, 0x1C, 0x03, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x03, 0xB8, 0x00, 0x0C,
  0x04, 0x0C, 0x00, 0x08, 0x08, 0x04, 0x00, 0x10, 0x18, 0x06, 0x00, 0x30,
  0x10, 0x06, 0x00, 0x60, 0x30, 0x06, 0x00, 0x40, 0x20, 0x06, 0x00, 0x80,
  0x20, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x40, 0x06, 0x02, 0x00,
  0x40, 0x04, 0x04, 0x00, 0x40, 0x04, 0x0C, 0x00, 0x40, 0x04, 0x18, 0x00,
  0xC0, 0x0C, 0x10, 0x00, 0xC0, 0x08, 0x30, 0xFC, 0xC0, 0x18, 0x61, 0x86,
  0xC0, 0x10, 0x42, 0x02, 0x40, 0x30, 0x86, 0x03, 0x40, 0x21, 0x8C, 0x01,
  0x60, 0x63, 0x08, 0x01, 0x39, 0x82, 0x18, 0x01, 0x1F, 0x04, 0x10, 0x01,
  0x00, 0x0C, 0x10, 0x01, 0x00, 0x18, 0x30, 0x03, 0x00, 0x10, 0x30, 0x03,
  0x00, 0x20, 0x20, 0x03, 0x00, 0x60, 0x20, 0x02, 0x00, 0xC0, 0x20, 0x02,
  0x00, 0x80, 0x20, 0x06, 0x01, 0x00, 0x20, 0x04, 0x03, 0x00, 0x20, 0x04,
  0x06, 0x00, 0x20, 0x0C, 0x04, 0x00, 0x20, 0x08, 0x0C, 0x00, 0x30, 0x10,
  0x18, 0x00, 0x18, 0x30, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x10, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0x61, 0x80, 0x30,
  0x00, 0x86, 0x00, 0x20, 0x03, 0x18, 0x00, 0x20, 0x04, 0x60, 0x00, 0x60,
  0x10, 0xC0, 0x00, 0x60, 0x61, 0x00, 0x00, 0x40, 0x82, 0x00, 0x00, 0x42,
  0x0C, 0x00, 0x00, 0xCC, 0x18, 0x00, 0x00, 0xB0, 0x30, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x03, 0x80, 0x40, 0x00, 0x0D, 0x80, 0xC0, 0x00, 0x61, 0x00,
  0xC0, 0x01, 0x81, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x7F, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x32, 0x26, 0x64, 0x44, 0xC8, 0x88, 0x80, 0x00,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x20, 0x08,
  0x03, 0x80, 0x40, 0x07, 0x02, 0x00, 0x0C, 0x20, 0x00, 0x19, 0x00, 0x00,
  0x38, 0xFE, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x00, 0xC8, 0x00, 0x0C, 0x40,
  0x00, 0xC1, 0x00, 0x0C, 0x08, 0x00, 0x80, 0x60, 0x08, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x04, 0x10, 0xC2, 0x18, 0x61, 0x0C, 0x21, 0x84,
  0x30, 0x80, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x70, 0x00, 0x60, 0x18, 0x00, 0x80, 0x04, 0x01, 0x00, 0x06, 0x02,
  0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x20,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x03, 0x80, 0x64, 0x06, 0x20, 0xC3, 0x0C, 0x1B,
  0x80, 0x88, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x1C, 0x01, 0x80, 0x38,
  0x00, 0x60, 0x08, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC7, 0x80, 0x0F, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x06, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x40, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x88, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x80, 0x30, 0x00, 0x40, 0x08, 0x00, 0x20, 0x02, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x04,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x30, 0x10, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x11, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x04, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x60,
  0x3C, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0xFF, 0x80,
  0x21, 0xC0, 0x60, 0x13, 0x00, 0x18, 0x0B, 0x00, 0x06, 0x0F, 0x00, 0x01,
  0x07, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x3E, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x10, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x10, 0x00, 0x20, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x20,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x60, 0x00, 0x18,
  0x10, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x38, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x38,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x10, 0x00, 0x18, 0x18,
  0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x04, 0x00, 0x02,
  0x83, 0x00, 0x03, 0xC0, 0x80, 0x03, 0x40, 0x60, 0x06, 0x20, 0x0E, 0x1E,
  0x30, 0x03, 0xF8, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x10, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0x83, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x9E, 0x0C, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x00, 0x21, 0x80, 0x01,
  0xF8, 0x00, 0xC4, 0x00, 0x1F, 0xFC, 0x03, 0x30, 0x01, 0xC0, 0x10, 0x04,
  0x80, 0x0C, 0x00, 0xC0, 0x16, 0x00, 0x60, 0x02, 0x00, 0x58, 0x03, 0x00,
  0x08, 0x01, 0x40, 0x08, 0x00, 0x60, 0x05, 0x00, 0x40, 0x01, 0x80, 0x1C,
  0x01, 0x00, 0x04, 0x00, 0xF0, 0x0C, 0x00, 0x10, 0x03, 0x80, 0x20, 0x00,
  0xC0, 0x0A, 0x00, 0x80, 0x02, 0x00, 0x28, 0x02, 0x00, 0x08, 0x01, 0xA0,
  0x18, 0x00, 0x60, 0x04, 0x80, 0x60, 0x01, 0x80, 0x32, 0x00, 0x80, 0x0A,
  0x00, 0x88, 0x02, 0x00, 0x68, 0x06, 0x30, 0x0C, 0x03, 0x20, 0x30, 0xC0,
  0x18, 0x18, 0xC1, 0x81, 0x00, 0x3F, 0xC1, 0xFC, 0x04, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x30, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x06, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xC0, 0x0C, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x01,
  0xFF, 0xFC, 0x00, 0x20, 0x00, 0xE0, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x10,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x18, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x80, 0x40, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0xFE, 0x00,
  0x60, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x1C, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x40, 0x00,
  0xE0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x70, 0x04, 0x00, 0x0F, 0x00, 0x20, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0xC0, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x01, 0xEF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x08, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x08,
  0xD0, 0x00, 0x00, 0xC8, 0xC0, 0x00, 0x07, 0x82, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x20, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x30, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x02, 0x80,
  0xD0, 0x00, 0x00, 0x1A, 0x03, 0x40, 0x00, 0x00, 0x58, 0x09, 0x00, 0x00,
  0x03, 0x60, 0x24, 0x00, 0x00, 0x09, 0x00, 0x98, 0x00, 0x00, 0x44, 0x06,
  0x60, 0x00, 0x03, 0x10, 0x18, 0x80, 0x00, 0x08, 0xC0, 0x42, 0x00, 0x00,
  0x63, 0x01, 0x08, 0x00, 0x01, 0x08, 0x04, 0x20, 0x00, 0x08, 0x20, 0x30,
  0xC0, 0x00, 0x60, 0x80, 0x81, 0x00, 0x01, 0x06, 0x02, 0x04, 0x00, 0x0C,
  0x18, 0x08, 0x10, 0x00, 0x20, 0x40, 0x60, 0x40, 0x01, 0x01, 0x01, 0x81,
  0x80, 0x0C, 0x04, 0x04, 0x06, 0x00, 0x20, 0x30, 0x10, 0x08, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x04, 0x02, 0x03, 0x00, 0x80, 0x20, 0x08, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x20, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x30, 0x30, 0x04,
  0x02, 0x00, 0x40, 0x80, 0x10, 0x18, 0x01, 0x04, 0x00, 0x40, 0x60, 0x04,
  0x30, 0x03, 0x01, 0x00, 0x10, 0x80, 0x0C, 0x04, 0x00, 0x66, 0x00, 0x20,
  0x30, 0x00, 0x90, 0x00, 0x80, 0xC0, 0x02, 0x80, 0x02, 0x02, 0x00, 0x0E,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x1E, 0x00, 0x00, 0x20, 0x34, 0x00, 0x00, 0x40, 0x4C, 0x00, 0x00, 0x80,
  0x88, 0x00, 0x03, 0x01, 0x18, 0x00, 0x04, 0x06, 0x10, 0x00, 0x08, 0x0C,
  0x20, 0x00, 0x10, 0x10, 0x60, 0x00, 0x60, 0x20, 0x40, 0x00, 0xC0, 0x40,
  0xC0, 0x01, 0x01, 0x80, 0x80, 0x02, 0x02, 0x01, 0x80, 0x04, 0x04, 0x01,
  0x00, 0x18, 0x08, 0x02, 0x00, 0x30, 0x30, 0x06, 0x00, 0x40, 0x60, 0x04,
  0x00, 0x80, 0x80, 0x0C, 0x01, 0x01, 0x00, 0x08, 0x06, 0x02, 0x00, 0x18,
  0x0C, 0x0C, 0x00, 0x10, 0x10, 0x18, 0x00, 0x20, 0x20, 0x20, 0x00, 0x60,
  0xC0, 0x40, 0x00, 0x41, 0x80, 0x80, 0x00, 0xC2, 0x03, 0x00, 0x00, 0x84,
  0x06, 0x00, 0x01, 0x88, 0x08, 0x00, 0x01, 0x30, 0x10, 0x00, 0x02, 0x60,
  0x60, 0x00, 0x06, 0x80, 0xC0, 0x00, 0x05, 0x01, 0x00, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x10, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x80,
  0x0E, 0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xE0, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x0F, 0x00,
  0x40, 0x01, 0xC0, 0x60, 0x00, 0x20, 0x30, 0x00, 0x18, 0x10, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x0C, 0x00,
  0x1C, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x20, 0x00, 0x80, 0x10,
  0x00, 0x40, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x40, 0x00, 0x08, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x38, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x20, 0x08, 0x00, 0x18, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x40,
  0x08, 0x00, 0x10, 0x06, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x20, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00, 0x03, 0x40,
  0x00, 0x64, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x19, 0x00, 0x03, 0x10,
  0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x44, 0x00, 0x18, 0x40, 0x01, 0x08,
  0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0xC1, 0x00, 0x0C, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x08, 0x00, 0x81,
  0x80, 0x10, 0x10, 0x03, 0x03, 0x00, 0x60, 0x20, 0x04, 0x06, 0x00, 0x80,
  0x40, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x80, 0xC0,
  0x10, 0x18, 0x03, 0x01, 0x00, 0x20, 0x20, 0x06, 0x06, 0x00, 0x40, 0xC0,
  0x0C, 0x08, 0x00, 0x81, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x10, 0x40,
  0x02, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x10, 0x00, 0x42, 0x00, 0x08, 0x60,
  0x00, 0x8C, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x23, 0x00, 0x02, 0x60,
  0x00, 0x64, 0x00, 0x04, 0x80, 0x00, 0xD8, 0x00, 0x09, 0x00, 0x01, 0xA0,
  0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x20, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x08, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x18, 0x01, 0x80, 0x08,
  0x03, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x04, 0x10, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02,
  0x40, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x00, 0x7F,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x18, 0x30, 0x00,
  0x20, 0x20, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x80, 0x04, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x60, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x08, 0x30, 0x00, 0x10, 0x40, 0x00, 0x31, 0x80, 0x00, 0x26, 0x00, 0x00,
  0x58, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xE0, 0xC1, 0x82,
  0x0C, 0x10, 0x20, 0xC1, 0x00, 0x7F, 0x82, 0x03, 0x81, 0x84, 0x0C, 0x01,
  0x98, 0x30, 0x01, 0xA0, 0xC0, 0x01, 0x43, 0x00, 0x02, 0x84, 0x00, 0x07,
  0x10, 0x00, 0x0C, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00,
  0x03, 0x08, 0x00, 0x0A, 0x10, 0x00, 0x3C, 0x30, 0x00, 0xD0, 0x20, 0x03,
  0x20, 0x60, 0x0C, 0x40, 0x60, 0x70, 0x80, 0x7F, 0x82, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x0F, 0xF0, 0x04, 0x38, 0x18, 0x04, 0x60, 0x0C, 0x04, 0x80,
  0x06, 0x0D, 0x00, 0x02, 0x0A, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x08, 0x70, 0x00, 0x18, 0x50, 0x00, 0x30, 0xD8, 0x00,
  0x60, 0x88, 0x00, 0xC0, 0x86, 0x03, 0x80, 0x83, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0xF0, 0x1C, 0x01, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x10, 0x03, 0x80, 0xC6, 0x00, 0xC0,
  0x0C, 0xC0, 0x30, 0x00, 0xD0, 0x0C, 0x00, 0x0A, 0x03, 0x00, 0x01, 0x40,
  0xC0, 0x00, 0x38, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x80, 0x80,
  0x00, 0x50, 0x10, 0x00, 0x16, 0x03, 0x00, 0x06, 0x80, 0x20, 0x01, 0x90,
  0x06, 0x00, 0x62, 0x00, 0x60, 0x30, 0x40, 0x07, 0xFC, 0x10, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0C, 0x06, 0x03, 0x00, 0x30, 0x60, 0x01,
  0x0C, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00,
  0x36, 0x00, 0x06, 0x60, 0x00, 0xC4, 0x00, 0x78, 0x40, 0xFE, 0x0F, 0xFC,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x40, 0x1C, 0x06, 0x10, 0x0C, 0x00, 0xCC, 0x06, 0x00, 0x1A,
  0x03, 0x00, 0x02, 0x81, 0x80, 0x00, 0xA0, 0xC0, 0x00, 0x38, 0x20, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x70, 0x20, 0x00, 0x14, 0x08, 0x00, 0x0B, 0x03, 0x00,
  0x06, 0x80, 0x40, 0x03, 0x20, 0x18, 0x01, 0x88, 0x03, 0x01, 0x86, 0x00,
  0x7F, 0xC1, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x87, 0x03, 0x81, 0x18,
  0x01, 0x02, 0x60, 0x03, 0x0D, 0x00, 0x02, 0x16, 0x00, 0x04, 0x38, 0x00,
  0x08, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x31,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x30,
  0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x80, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x02, 0x18, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x40,
  0x03, 0x01, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x20,
  0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40, 0x01, 0x02, 0x00, 0x04,
  0x30, 0x00, 0x11, 0xC0, 0x00, 0xCD, 0x80, 0x03, 0x62, 0x00, 0x0B, 0x0C,
  0x00, 0x38, 0x10, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x40, 0x04, 0x01, 0x00, 0x18, 0x04, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x80,
  0x01, 0x02, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x02, 0x00, 0x04, 0x1F, 0xE0, 0x1F, 0xE0, 0x10, 0xC0, 0xC0,
  0xC0, 0xC0, 0x4C, 0x01, 0x86, 0x01, 0x81, 0x60, 0x06, 0x20, 0x03, 0x0D,
  0x00, 0x09, 0x00, 0x0C, 0x28, 0x00, 0x2C, 0x00, 0x10, 0xE0, 0x00, 0xA0,
  0x00, 0x43, 0x00, 0x03, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x60,
  0x00, 0x20, 0x00, 0x21, 0x80, 0x00, 0x80, 0x00, 0x84, 0x00, 0x06, 0x00,
  0x02, 0x10, 0x00, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x40, 0x00, 0x63, 0x00,
  0x01, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x80, 0x00, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x00, 0x03, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x40, 0x00, 0x60, 0x00, 0x21, 0x00, 0x01, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x00, 0x06, 0x30, 0x00, 0x10, 0x00, 0x18, 0xC0, 0x00,
  0x40, 0x00, 0x42, 0x00, 0x03, 0x00, 0x01, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x0F, 0xF0, 0x08, 0x70, 0x38, 0x11, 0x80, 0x10, 0x26, 0x00,
  0x30, 0xD0, 0x00, 0x21, 0x60, 0x00, 0x43, 0x80, 0x00, 0x86, 0x00, 0x01,
  0x0C, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x00, 0x00, 0x42, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0x80,
  0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x3F, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x81, 0xFE, 0x00, 0x10, 0xE0, 0x60, 0x02,
  0x30, 0x06, 0x00, 0x48, 0x00, 0x60, 0x1A, 0x00, 0x04, 0x02, 0xC0, 0x00,
  0xC0, 0x50, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x10, 0x1C, 0x00, 0x06, 0x02, 0x80, 0x01, 0x80, 0xD8, 0x00,
  0x60, 0x19, 0x00, 0x18, 0x02, 0x18, 0x0E, 0x00, 0x41, 0xFF, 0x00, 0x08,
  0x02, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0x01, 0xC0, 0x61, 0x03, 0x00,
  0x33, 0x06, 0x00, 0x1A, 0x0C, 0x00, 0x0A, 0x18, 0x00, 0x0A, 0x30, 0x00,
  0x0E, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x70, 0x80, 0x00, 0x50, 0x80, 0x00, 0xB0, 0xC0, 0x01,
  0xA0, 0x40, 0x03, 0x20, 0x60, 0x06, 0x20, 0x30, 0x18, 0x60, 0x1F, 0xF0,
  0x40, 0x03, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x04, 0x0F, 0xC1, 0x0C, 0x00, 0x46, 0x00, 0x12, 0x00, 0x0D, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x0C, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x80,
  0x06, 0x1C, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x3F, 0xFF, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x46, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x0A, 0x10,
  0x00, 0x34, 0x20, 0x00, 0x58, 0x60, 0x01, 0x20, 0x40, 0x0C, 0x40, 0xE0,
  0x70, 0x80, 0x7F, 0x83, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x28, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x40,
  0x01, 0x84, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x60, 0x40, 0x04, 0x06,
  0x00, 0xC0, 0x60, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10, 0x02, 0x02, 0x00,
  0x20, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x01, 0x00, 0x03, 0x80, 0x03, 0x00, 0x02,
  0x80, 0x03, 0x00, 0x06, 0x80, 0x07, 0x80, 0x04, 0x80, 0x05, 0x80, 0x0C,
  0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x10,
  0xC0, 0x10, 0x80, 0x30, 0xC0, 0x30, 0x80, 0x20, 0xC0, 0x20, 0x80, 0x60,
  0xC0, 0x60, 0x80, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0xC0, 0x80,
  0x40, 0x80, 0xC1, 0x80, 0x41, 0x80, 0x41, 0x00, 0x41, 0x00, 0x41, 0x00,
  0x43, 0x00, 0x42, 0x00, 0x42, 0x00, 0x42, 0x00, 0x46, 0x00, 0x46, 0x00,
  0x44, 0x00, 0x44, 0x00, 0x48, 0x00, 0x4C, 0x00, 0x48, 0x00, 0x68, 0x00,
  0x50, 0x00, 0x78, 0x00, 0x50, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x08,
  0x00, 0x30, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x06, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x02, 0x00, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00,
  0x30, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x08,
  0x02, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xC0, 0x02, 0xC0, 0xE0, 0x06, 0x00, 0x78, 0x34, 0x00, 0x3F,
  0xC0,
};

const GFXglyph NotoSans_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 36, 11, 2, -36 },
  { 42, 11, 13, 16, 6, -36 },
  { 60, 30, 36, 31, 2, -36 },
  { 195, 23, 42, 28, 3, -39 },
  { 316, 32, 38, 39, 4, -37 },
  { 468, 31, 38, 35, 2, -37 },
  { 616, 4, 13, 9, 6, -36 },
  { 623, 14, 44, 12, 2, -36 },
  { 700, 14, 44, 12, -3, -36 },
  { 777, 21, 22, 27, 6, -39 },
  { 835, 23, 24, 29, 4, -30 },
  { 904, 6, 13, 9, -2, -6 },
  { 914, 12, 1, 16, 2, -14 },
  { 916, 2, 3, 11, 2, -3 },
  { 917, 22, 36, 16, -2, -36 },
  { 1016, 24, 38, 28, 3, -37 },
  { 1130, 13, 36, 28, 8, -36 },
  { 1189, 25, 37, 28, 1, -37 },
  { 1305, 26, 38, 28, 1, -37 },
  { 1429, 26, 37, 28, 1, -37 },
  { 1550, 25, 37, 28, 2, -36 },
  { 1666, 25, 38, 28, 3, -37 },
  { 1785, 23, 36, 28, 6, -36 },
  { 1889, 25, 38, 28, 2, -37 },
  { 2008, 25, 38, 28, 2, -37 },
  { 2127, 7, 27, 11, 2, -27 },
  { 2151, 11, 34, 11, -2, -27 },
  { 2198, 23, 23, 29, 4, -30 },
  { 2265, 23, 12, 29, 4, -24 },
  { 2300, 23, 23, 29, 4, -30 },
  { 2367, 17, 37, 21, 4, -37 },
  { 2446, 38, 41, 43, 3, -36 },
  { 2641, 28, 37, 28, -3, -37 },
  { 2771, 27, 36, 31, 3, -36 },
  { 2893, 28, 38, 30, 4, -37 },
  { 3026, 29, 36, 35, 3, -36 },
  { 3157, 26, 36, 27, 3, -36 },
  { 3274, 26, 36, 25, 3, -36 },
  { 3391, 30, 38, 35, 4, -37 },
  { 3534, 31, 36, 35, 3, -36 },
  { 3674, 16, 36, 14, 0, -36 },
  { 3746, 21, 45, 12, -9, -36 },
  { 3865, 29, 36, 28, 3, -36 },
  { 3996, 18, 36, 25, 3, -36 },
  { 4077, 38, 36, 41, 3, -36 },
  { 4248, 31, 36, 34, 3, -36 },
  { 4388, 30, 38, 37, 4, -37 },
  { 4531, 25, 36, 28, 3, -36 },
  { 4644, 30, 46, 37, 4, -37 },
  { 4817, 25, 36, 29, 3, -36 },
  { 4930, 25, 38, 25, 1, -37 },
  { 5049, 24, 36, 25, 5, -36 },
  { 5157, 31, 37, 35, 4, -36 },
  { 5301, 26, 36, 27, 5, -36 },
  { 5418, 39, 36, 42, 6, -36 },
  { 5594, 32, 36, 25, -3, -36 },
  { 5738, 24, 36, 25, 5, -36 },
  { 5846, 29, 36, 27, 0, -36 },
  { 5977, 19, 44, 15, 0, -36 },
  { 6082, 8, 36, 16, 5, -36 },
  { 6118, 20, 44, 15, -4, -36 },
  { 6228, 23, 23, 28, 3, -37 },
  { 6295, 19, 1, 19, -4, 6 },
  { 6298, 6, 8, 12, 7, -39 },
  { 6304, 23, 28, 28, 3, -27 },
  { 6385, 24, 40, 29, 2, -39 },
  { 6505, 20, 28, 23, 3, -27 },
  { 6575, 27, 40, 29, 3, -39 },
  { 6710, 20, 28, 25, 3, -27 },
  { 6780, 28, 51, 13, -7, -39 },
  { 6959, 26, 39, 29, 1, -27 },
  { 7086, 23, 39, 28, 2, -39 },
  { 7199, 9, 37, 11, 2, -37 },
  { 7241, 18, 49, 11, -7, -37 },
  { 7352, 22, 39, 22, 2, -39 },
  { 7460, 9, 39, 11, 2, -39 },
  { 7504, 38, 27, 43, 2, -27 },
  { 7633, 23, 27, 28, 2, -27 },
  { 7711, 23, 28, 29, 3, -27 },
  { 7792, 27, 39, 29, -1, -27 },
  { 7924, 24, 39, 29, 3, -27 },
  { 8041, 18, 27, 19, 2, -27 },
  { 8102, 19, 28, 22, 1, -27 },
  { 8169, 14, 35, 16, 3, -34 },
  { 8231, 23, 28, 28, 3, -27 },
  { 8312, 20, 27, 21, 3, -27 },
  { 8380, 32, 27, 33, 3, -27 },
  { 8488, 26, 27, 23, -2, -27 },
  { 8576, 29, 39, 21, -6, -27 },
  { 8718, 23, 27, 22, -1, -27 },
  { 8796, 18, 44, 17, 1, -36 },
  { 8895, 2, 51, 27, 14, -39 },
  { 8908, 19, 44, 17, -3, -36 },
  { 9013, 23, 4, 29, 4, -20 },
};

const GFXfont NotoSans_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_THINITALIC51PT7B_H_
