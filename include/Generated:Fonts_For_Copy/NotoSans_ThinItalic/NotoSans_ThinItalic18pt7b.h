#ifndef _NOTOSANS_THINITALIC18PT7B_H_
#define _NOTOSANS_THINITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x90, 0x08, 0x59, 0x9A, 0xA0, 0x08, 0x82, 0x20,
  0x90, 0x44, 0x7F, 0xC4, 0x41, 0x20, 0x88, 0xFF, 0x88, 0x84, 0x41, 0x10,
  0x44, 0x00, 0x04, 0x04, 0x1F, 0x24, 0x48, 0x48, 0x28, 0x18, 0x0E, 0x12,
  0x12, 0x12, 0xDC, 0x20, 0x20, 0x70, 0x51, 0x12, 0x22, 0x44, 0x88, 0xA1,
  0x29, 0xA5, 0x4F, 0x51, 0x12, 0x22, 0x84, 0x91, 0x22, 0x28, 0x38, 0x0E,
  0x02, 0x20, 0x82, 0x10, 0x81, 0x20, 0x28, 0x0E, 0x02, 0x21, 0x82, 0x50,
  0x52, 0x04, 0x41, 0x47, 0xCC, 0xF8, 0x18, 0x88, 0x84, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22,
  0x11, 0x10, 0x08, 0x08, 0xC8, 0x33, 0x1C, 0x28, 0x48, 0x04, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x29, 0x40, 0xF0,
  0x80, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x80, 0x1E, 0x10, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x02, 0x81,
  0x40, 0xA0, 0x90, 0x47, 0xC0, 0x17, 0x91, 0x12, 0x22, 0x22, 0x44, 0x40,
  0x0F, 0x08, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x0F, 0xF0, 0x1F, 0x10, 0x40, 0x20, 0x10, 0x08, 0x08, 0x78, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x2F, 0xE0, 0x00, 0x80, 0x60, 0x28, 0x12, 0x09,
  0x04, 0x41, 0x10, 0x84, 0x41, 0x3F, 0xF0, 0x20, 0x08, 0x02, 0x00, 0x1F,
  0x90, 0x08, 0x04, 0x04, 0x03, 0xE0, 0x08, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x4F, 0xC0, 0x0F, 0x88, 0x08, 0x08, 0x04, 0x03, 0xF3, 0x05, 0x02, 0x81,
  0x40, 0xA0, 0x50, 0x47, 0xC0, 0xFF, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x10,
  0x90, 0xF0, 0x84, 0x81, 0x40, 0xA0, 0x50, 0x47, 0xC0, 0x1E, 0x21, 0x41,
  0x41, 0x41, 0x41, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x04, 0xF8, 0x50, 0x00,
  0x20, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x00, 0x81, 0x83, 0x06, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x00, 0x7C, 0x04,
  0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0x80, 0x00, 0x08, 0x00, 0x07, 0xE0,
  0x60, 0x42, 0x00, 0x90, 0x02, 0x47, 0xC6, 0x21, 0x18, 0x84, 0x64, 0x21,
  0x90, 0x8A, 0x42, 0x28, 0xFF, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x01, 0x00, 0x40, 0x28, 0x12, 0x04, 0x82, 0x20, 0x88, 0x7E, 0x20,
  0x48, 0x14, 0x05, 0x01, 0x80, 0x40, 0x1F, 0x10, 0x48, 0x24, 0x14, 0x0A,
  0x09, 0xF8, 0x82, 0x40, 0xC0, 0x60, 0x50, 0x2F, 0xE0, 0x1F, 0x90, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x07, 0xE0,
  0x1F, 0x08, 0x22, 0x04, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x0A, 0x0C, 0xFC, 0x00, 0x1F, 0x90, 0x08, 0x04, 0x04, 0x02, 0x01,
  0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x0F, 0xC0, 0x1F, 0x90, 0x08, 0x04,
  0x04, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x00, 0x1F,
  0xC8, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x72, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x04, 0x7F, 0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14, 0x04, 0x80,
  0x9F, 0xF2, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40, 0x48, 0x08, 0x1C, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0xE0, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x70, 0x20, 0x48,
  0x22, 0x10, 0x88, 0x4C, 0x14, 0x06, 0x81, 0x20, 0x44, 0x21, 0x08, 0x22,
  0x08, 0x81, 0x00, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0xFC, 0x20, 0x09, 0x80, 0x4C, 0x06, 0x60, 0x55, 0x02, 0xA4, 0x25, 0x21,
  0x49, 0x12, 0x49, 0x14, 0x48, 0xA2, 0x89, 0x08, 0x48, 0x42, 0x00, 0x20,
  0x26, 0x04, 0xC0, 0x94, 0x14, 0x84, 0x90, 0x91, 0x12, 0x22, 0x42, 0x50,
  0x52, 0x06, 0x40, 0xC8, 0x08, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x7E, 0x00, 0x1F, 0x10,
  0x48, 0x24, 0x14, 0x0A, 0x05, 0x0C, 0xF8, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x00, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x28, 0x0A, 0x04, 0x76, 0x02, 0x00, 0x40, 0x18, 0x1F, 0x10, 0x48,
  0x24, 0x14, 0x0A, 0x05, 0x0C, 0xF8, 0x44, 0x41, 0x20, 0x90, 0x48, 0x10,
  0x0F, 0x98, 0x08, 0x04, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x4F, 0xC0, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x08, 0x7C, 0x00, 0x80, 0xC0, 0xA0,
  0x50, 0x48, 0x24, 0x22, 0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x04, 0x00,
  0x81, 0x06, 0x08, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x92,
  0x24, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x14, 0x10, 0x20, 0x40, 0x80, 0x10,
  0x22, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0C, 0x01, 0x00, 0x50, 0x12, 0x02,
  0x20, 0x84, 0x20, 0x88, 0x08, 0x81, 0x81, 0x82, 0x84, 0x48, 0x48, 0x50,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x1F, 0xC0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xFF, 0x00, 0x1E,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x70, 0x92, 0x49, 0x12, 0x49, 0x12, 0x1E, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x70, 0x04, 0x0A, 0x0A, 0x12,
  0x22, 0x41, 0x41, 0x81, 0xFE, 0xA4, 0x1D, 0x23, 0x41, 0x81, 0x81, 0x82,
  0x82, 0x82, 0x86, 0x7A, 0x20, 0x20, 0x20, 0x20, 0x4E, 0x71, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x1E, 0x41, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0xF8, 0x00, 0x80, 0x40, 0x20, 0x11, 0xC9, 0x15, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x90, 0x48, 0x63, 0xD0, 0x1C, 0x45, 0x0C, 0x18, 0xDE,
  0x20, 0x40, 0x80, 0xF8, 0x03, 0x82, 0x01, 0x00, 0x81, 0x60, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x60,
  0x00, 0x0E, 0x44, 0x52, 0x09, 0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0x43,
  0x0F, 0x40, 0x10, 0x08, 0x02, 0x3F, 0x00, 0x20, 0x20, 0x20, 0x20, 0x4E,
  0x71, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x20, 0x24, 0x94,
  0x92, 0x48, 0x02, 0x00, 0x00, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0xE0, 0x20, 0x20, 0x20, 0x20, 0x41, 0x42, 0x44,
  0x48, 0xB0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x24, 0x94, 0x92, 0x92, 0x49,
  0x00, 0x5C, 0x73, 0x14, 0x50, 0xC2, 0x82, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0x42, 0x84, 0x14, 0x20, 0x80, 0x4E, 0x71, 0x41, 0x41, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x7C, 0x27, 0x1C, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41,
  0x5F, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1C, 0x91, 0x50, 0x50, 0x28, 0x14,
  0x0A, 0x09, 0x04, 0x86, 0x3D, 0x00, 0x80, 0x80, 0x40, 0x20, 0x4D, 0xC4,
  0x10, 0x82, 0x08, 0x20, 0x82, 0x00, 0x1E, 0x41, 0x02, 0x03, 0x01, 0x01,
  0x02, 0x05, 0xF0, 0x22, 0x2E, 0x84, 0x22, 0x10, 0x84, 0x21, 0xE0, 0x41,
  0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x86, 0xFA, 0x83, 0x06, 0x14,
  0x28, 0x91, 0x14, 0x30, 0x60, 0x80, 0x84, 0x30, 0x86, 0x30, 0xC6, 0x29,
  0x45, 0x25, 0x28, 0xA5, 0x18, 0xC2, 0x10, 0x40, 0x20, 0x88, 0x44, 0x41,
  0x40, 0xC0, 0x40, 0x50, 0x44, 0x42, 0x60, 0x80, 0x10, 0x44, 0x11, 0x08,
  0x42, 0x11, 0x04, 0x40, 0xA0, 0x28, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x38, 0x00, 0x3F, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0xFC,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0xE0, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x10, 0x41, 0x04, 0x20, 0x83, 0x08,
  0x21, 0x04, 0x10, 0x42, 0x30, 0xFF, 0x80,
};

const GFXglyph NotoSans_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 4, 1, -13 },
  { 6, 4, 5, 6, 2, -13 },
  { 9, 10, 13, 11, 1, -13 },
  { 26, 8, 15, 10, 1, -14 },
  { 41, 11, 13, 14, 2, -13 },
  { 59, 11, 13, 12, 1, -13 },
  { 77, 1, 5, 3, 2, -13 },
  { 78, 5, 16, 4, 1, -13 },
  { 88, 5, 16, 4, -1, -13 },
  { 98, 8, 8, 10, 2, -14 },
  { 106, 9, 9, 10, 1, -11 },
  { 117, 3, 4, 3, -1, -2 },
  { 119, 4, 1, 6, 1, -5 },
  { 120, 1, 1, 4, 1, -1 },
  { 121, 8, 13, 6, -1, -13 },
  { 134, 9, 13, 10, 1, -13 },
  { 149, 4, 13, 10, 3, -13 },
  { 156, 9, 13, 10, 0, -13 },
  { 171, 9, 13, 10, 0, -13 },
  { 186, 10, 13, 10, 0, -13 },
  { 203, 9, 13, 10, 1, -13 },
  { 218, 9, 13, 10, 1, -13 },
  { 233, 8, 13, 10, 2, -13 },
  { 246, 9, 13, 10, 1, -13 },
  { 261, 8, 13, 10, 1, -13 },
  { 274, 2, 10, 4, 1, -10 },
  { 277, 4, 12, 4, -1, -10 },
  { 283, 9, 9, 10, 1, -11 },
  { 294, 9, 4, 10, 1, -8 },
  { 299, 9, 9, 10, 1, -11 },
  { 310, 7, 13, 7, 1, -13 },
  { 322, 14, 15, 15, 1, -13 },
  { 349, 10, 13, 10, -1, -13 },
  { 366, 9, 13, 11, 1, -13 },
  { 381, 9, 13, 11, 2, -13 },
  { 396, 10, 13, 12, 1, -13 },
  { 413, 9, 13, 10, 1, -13 },
  { 428, 9, 13, 9, 1, -13 },
  { 443, 10, 13, 12, 2, -13 },
  { 460, 11, 13, 12, 1, -13 },
  { 478, 6, 13, 5, 0, -13 },
  { 488, 7, 16, 4, -3, -13 },
  { 502, 10, 13, 10, 1, -13 },
  { 519, 6, 13, 9, 1, -13 },
  { 529, 13, 13, 15, 1, -13 },
  { 551, 11, 13, 12, 1, -13 },
  { 569, 10, 13, 13, 2, -13 },
  { 586, 9, 13, 10, 1, -13 },
  { 601, 10, 16, 13, 2, -13 },
  { 621, 9, 13, 10, 1, -13 },
  { 636, 9, 13, 9, 0, -13 },
  { 651, 8, 13, 9, 2, -13 },
  { 664, 10, 13, 12, 2, -13 },
  { 681, 9, 13, 10, 2, -13 },
  { 696, 14, 13, 15, 2, -13 },
  { 719, 11, 13, 9, -1, -13 },
  { 737, 8, 13, 9, 2, -13 },
  { 750, 10, 13, 10, 0, -13 },
  { 767, 7, 16, 5, 0, -13 },
  { 781, 3, 13, 6, 2, -13 },
  { 786, 7, 16, 5, -1, -13 },
  { 800, 8, 8, 10, 1, -13 },
  { 808, 7, 1, 7, -2, 2 },
  { 809, 2, 3, 4, 3, -14 },
  { 810, 8, 10, 10, 1, -10 },
  { 820, 8, 14, 10, 1, -14 },
  { 834, 7, 10, 8, 1, -10 },
  { 843, 9, 14, 10, 1, -14 },
  { 859, 7, 10, 9, 1, -10 },
  { 868, 9, 18, 5, -2, -14 },
  { 889, 10, 14, 10, 0, -10 },
  { 907, 8, 14, 10, 1, -14 },
  { 921, 3, 13, 4, 1, -13 },
  { 926, 7, 17, 4, -3, -13 },
  { 941, 8, 14, 8, 1, -14 },
  { 955, 3, 14, 4, 1, -14 },
  { 961, 13, 10, 15, 1, -10 },
  { 978, 8, 10, 10, 1, -10 },
  { 988, 8, 10, 10, 1, -10 },
  { 998, 9, 14, 10, 0, -10 },
  { 1014, 9, 14, 10, 1, -10 },
  { 1030, 6, 10, 7, 1, -10 },
  { 1038, 7, 10, 8, 0, -10 },
  { 1047, 5, 12, 6, 1, -12 },
  { 1055, 8, 10, 10, 1, -10 },
  { 1065, 7, 10, 7, 1, -10 },
  { 1074, 11, 10, 12, 1, -10 },
  { 1088, 9, 10, 8, -1, -10 },
  { 1100, 10, 14, 7, -2, -10 },
  { 1118, 8, 10, 8, 0, -10 },
  { 1128, 7, 16, 6, 0, -13 },
  { 1142, 1, 18, 10, 5, -14 },
  { 1145, 6, 16, 6, -1, -13 },
  { 1157, 9, 1, 10, 1, -7 },
};

const GFXfont NotoSans_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_THINITALIC18PT7B_H_
