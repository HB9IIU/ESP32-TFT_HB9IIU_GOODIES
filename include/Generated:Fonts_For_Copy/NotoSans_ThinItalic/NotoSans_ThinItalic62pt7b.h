#ifndef _NOTOSANS_THINITALIC62PT7B_H_
#define _NOTOSANS_THINITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x18, 0x18, 0x80,
  0xCC, 0x06, 0x60, 0x23, 0x01, 0x10, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x23,
  0x01, 0x10, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x22, 0x01, 0x10, 0x18, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0x86, 0x0F, 0x00, 0x70, 0x20, 0x10, 0x06, 0x01, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x8E,
  0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x20, 0x70, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0xC0,
  0x80, 0x18, 0x1C, 0x07, 0x80, 0x83, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x30, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x10, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x06, 0x00,
  0x10, 0x00, 0x20, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0x80, 0x02, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x0F,
  0x86, 0x00, 0x18, 0x30, 0x7F, 0xCC, 0x00, 0x20, 0x41, 0x81, 0xD8, 0x00,
  0xC1, 0x86, 0x01, 0x90, 0x01, 0x06, 0x18, 0x01, 0x30, 0x06, 0x18, 0x30,
  0x03, 0x60, 0x18, 0x20, 0xC0, 0x06, 0x60, 0x60, 0xC1, 0x00, 0x0C, 0x7F,
  0x83, 0x06, 0x00, 0x18, 0x7C, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x10,
  0x00, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x00, 0x30, 0x04,
  0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x01, 0x80, 0x03, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x40, 0x00,
  0x0C, 0x0C, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x08, 0x30, 0x03, 0x00,
  0x00, 0x83, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x43, 0x00,
  0x00, 0x80, 0x06, 0x30, 0x00, 0x06, 0x00, 0x61, 0x80, 0x00, 0x18, 0x03,
  0x08, 0x00, 0x00, 0x60, 0x30, 0xC0, 0x00, 0x03, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x10, 0x30, 0x00, 0x00, 0x31, 0x81, 0x80, 0x00, 0x00, 0x98, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x00, 0x39, 0x00, 0x60, 0x00, 0x03, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x06,
  0x00, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x8C,
  0x63, 0x10, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x10, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0xC0, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x06, 0x04, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x39, 0x00, 0x30,
  0x06, 0x8F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x90, 0x00,
  0x01, 0x84, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x40,
  0x01, 0x80, 0x30, 0x03, 0x80, 0x08, 0x00, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xA0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x01, 0xD8, 0x07, 0x20, 0x38, 0x40, 0xE1, 0x87, 0x03,
  0x1C, 0x06, 0xE0, 0x08, 0x80, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x10, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x01, 0xFF, 0x00, 0x0C, 0x1F, 0x0F,
  0x00, 0x31, 0xC0, 0x06, 0x00, 0x8C, 0x00, 0x0C, 0x02, 0x60, 0x00, 0x18,
  0x1B, 0x00, 0x00, 0x20, 0x78, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x10, 0x01, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x70, 0x80, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x03, 0x40, 0xC0, 0x00, 0x36, 0x03, 0x00, 0x07,
  0x30, 0x0C, 0x00, 0xE1, 0x00, 0x3F, 0xFC, 0x18, 0x00, 0x7F, 0x80, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x3C, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0x70, 0x20, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xC3, 0x00,
  0x03, 0xE0, 0x78, 0x01, 0x8C, 0x00, 0x0E, 0x00, 0x20, 0x03, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x06, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x32, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x6C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xD8, 0x00, 0x80,
  0x00, 0x60, 0x01, 0xB0, 0x03, 0x00, 0x00, 0x80, 0x03, 0x40, 0x06, 0x00,
  0x03, 0x00, 0x04, 0x80, 0x08, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x36, 0x00, 0x60, 0x00, 0x30, 0x00, 0x6C, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0x98, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x30, 0x03, 0x00, 0x03,
  0x80, 0x0C, 0x60, 0x06, 0x00, 0x0F, 0x00, 0x18, 0x40, 0x04, 0x00, 0x36,
  0x00, 0x60, 0x80, 0x0C, 0x00, 0xC4, 0x01, 0x81, 0x80, 0x1C, 0x03, 0x8C,
  0x0E, 0x03, 0x00, 0x1E, 0x1C, 0x1C, 0x78, 0x06, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x20, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x04, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFC, 0xC0,
  0x00, 0x1F, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x20,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x08, 0x07, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00,
  0x20, 0x70, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x61, 0xE0, 0x00,
  0x00, 0x06, 0x33, 0x00, 0x00, 0x00, 0x66, 0x30, 0x00, 0x00, 0x04, 0xC1,
  0x80, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x01, 0x40, 0x00, 0x00, 0x00, 0xD0, 0x02, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x1B, 0x00, 0x00, 0x00,
  0x09, 0x00, 0x36, 0x00, 0x00, 0x00, 0x32, 0x00, 0x44, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x88, 0x00, 0x00, 0x01, 0x98, 0x03, 0x18, 0x00, 0x00, 0x06,
  0x30, 0x06, 0x30, 0x00, 0x00, 0x08, 0x40, 0x0C, 0x60, 0x00, 0x00, 0x30,
  0x80, 0x10, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x00, 0x01, 0x86,
  0x00, 0xC1, 0x00, 0x00, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x00, 0x08, 0x10,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x18, 0x08, 0x00, 0x01, 0x81, 0x80, 0x30, 0x10, 0x00, 0x06, 0x02, 0x00,
  0x60, 0x20, 0x00, 0x08, 0x04, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x01,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x06, 0x00,
  0x20, 0x08, 0x00, 0x40, 0x08, 0x00, 0x40, 0x30, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x81, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x06, 0x00, 0x08, 0x01, 0x80, 0x02, 0x08, 0x00, 0x30, 0x02, 0x00, 0x04,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x19,
  0x80, 0x01, 0x00, 0x30, 0x00, 0x36, 0x00, 0x02, 0x00, 0x60, 0x00, 0x68,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x14, 0x00, 0x00, 0x03, 0x00, 0xD8, 0x00, 0x00, 0x08, 0x03, 0x60, 0x00,
  0x00, 0x20, 0x0C, 0xC0, 0x00, 0x01, 0x80, 0x23, 0x00, 0x00, 0x06, 0x00,
  0x84, 0x00, 0x00, 0x18, 0x06, 0x18, 0x00, 0x00, 0x40, 0x18, 0x20, 0x00,
  0x01, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x01, 0x03, 0x00, 0x00, 0x30, 0x04,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x20, 0x00,
  0x18, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x01, 0x00, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x18, 0x00, 0x10, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x80, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x01, 0x80, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x00, 0x60, 0x00, 0x08, 0x04, 0x01, 0x80, 0x00, 0x30, 0x30,
  0x04, 0x00, 0x00, 0x40, 0xC0, 0x10, 0x00, 0x01, 0x83, 0x00, 0xC0, 0x00,
  0x06, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x60, 0x0C, 0x00, 0x00, 0x31, 0x80,
  0x20, 0x00, 0x00, 0x46, 0x01, 0x80, 0x00, 0x01, 0x98, 0x06, 0x00, 0x00,
  0x02, 0x40, 0x18, 0x00, 0x00, 0x0D, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x01,
  0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xE0, 0x04, 0x00, 0x03, 0x80, 0x0C, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x40, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xC0,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x20, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0x58, 0x00, 0x01,
  0x98, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x02, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x21,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x82, 0x00, 0x01, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20,
  0x00, 0xC0, 0x40, 0x01, 0x80, 0x40, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80,
  0x06, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x02, 0x00,
  0x30, 0x06, 0x00, 0x20, 0x04, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0x60, 0x08, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x03, 0x03, 0x00,
  0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x30, 0x00, 0x10, 0x20, 0x00, 0x30, 0x40, 0x00,
  0x20, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xC0, 0xC1,
  0x81, 0x81, 0x03, 0x03, 0x02, 0x06, 0x00, 0x0F, 0xF8, 0x18, 0x01, 0xE0,
  0xE0, 0x80, 0x38, 0x01, 0x84, 0x03, 0x80, 0x06, 0x20, 0x30, 0x00, 0x13,
  0x03, 0x00, 0x00, 0xD8, 0x18, 0x00, 0x02, 0x81, 0x80, 0x00, 0x14, 0x18,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0F,
  0x06, 0x00, 0x00, 0x50, 0x10, 0x00, 0x06, 0x80, 0xC0, 0x00, 0x6C, 0x06,
  0x00, 0x06, 0x60, 0x18, 0x00, 0x62, 0x00, 0xE0, 0x0E, 0x10, 0x03, 0x81,
  0xE0, 0x80, 0x07, 0xFC, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x1F, 0xF0, 0x00, 0x40, 0xE0, 0xF0, 0x03, 0x0E,
  0x00, 0xE0, 0x0C, 0x60, 0x00, 0xC0, 0x33, 0x00, 0x03, 0x00, 0x98, 0x00,
  0x06, 0x02, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x20, 0x70, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x30, 0x78, 0x00, 0x01, 0x81, 0xA0, 0x00, 0x06, 0x04,
  0xC0, 0x00, 0x30, 0x11, 0x00, 0x01, 0x80, 0x47, 0x00, 0x1C, 0x03, 0x0F,
  0x01, 0xC0, 0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0x03, 0xC0, 0x1C, 0x00, 0x20, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x0F,
  0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x30, 0x00,
  0x78, 0x3C, 0x18, 0x00, 0xE0, 0x03, 0x08, 0x00, 0xE0, 0x00, 0xC4, 0x00,
  0xE0, 0x00, 0x36, 0x00, 0xC0, 0x00, 0x0B, 0x00, 0x60, 0x00, 0x05, 0x80,
  0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x0B, 0x00, 0x40, 0x00, 0x0D, 0x00, 0x30, 0x00,
  0x0C, 0x80, 0x18, 0x00, 0x0C, 0xC0, 0x06, 0x00, 0x0C, 0x60, 0x03, 0x80,
  0x1C, 0x30, 0x00, 0xE0, 0x38, 0x10, 0x00, 0x1F, 0xF8, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x06,
  0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x38, 0x40, 0x01, 0xE0,
  0xC1, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x10,
  0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x06, 0x00, 0x3C, 0x1E, 0x0C, 0x01, 0xC0, 0x06, 0x10, 0x07, 0x00, 0x06,
  0x20, 0x18, 0x00, 0x06, 0x40, 0x70, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x0B,
  0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x05, 0x80, 0x80, 0x00, 0x1A, 0x01, 0x80, 0x00, 0x64, 0x03, 0x00, 0x01,
  0x98, 0x03, 0x00, 0x06, 0x30, 0x07, 0x00, 0x38, 0x60, 0x07, 0x01, 0xC0,
  0x80, 0x03, 0xFF, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x08,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x20, 0x70,
  0x78, 0x03, 0x0E, 0x00, 0x60, 0x18, 0xC0, 0x01, 0x80, 0xCC, 0x00, 0x0C,
  0x04, 0xC0, 0x00, 0x20, 0x2C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x07, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x70,
  0x10, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x87, 0x80, 0x00, 0x18, 0xC8, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x1B,
  0x04, 0x00, 0x01, 0x60, 0x60, 0x00, 0x1C, 0x02, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x04, 0x1C, 0x3C,
  0x01, 0xC3, 0xC0, 0x31, 0xC0, 0x18, 0x1C, 0x01, 0x80, 0xCE, 0x00, 0x30,
  0xC0, 0x03, 0x02, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x09, 0x00, 0x03, 0x30,
  0x00, 0x10, 0x2C, 0x00, 0x04, 0x80, 0x00, 0x41, 0xE0, 0x00, 0x16, 0x00,
  0x01, 0x07, 0x00, 0x00, 0x50, 0x00, 0x04, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x00, 0x02, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x40, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0xFF, 0x80, 0x08, 0x1C, 0x1E, 0x00, 0xC3, 0x80, 0x18,
  0x06, 0x30, 0x00, 0x60, 0x23, 0x00, 0x03, 0x01, 0x30, 0x00, 0x08, 0x0B,
  0x00, 0x00, 0x60, 0xF0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xE0, 0x00, 0x10, 0x78,
  0x3C, 0x00, 0x18, 0x70, 0x07, 0x00, 0x0C, 0x60, 0x00, 0xC0, 0x04, 0x60,
  0x00, 0x60, 0x02, 0x60, 0x00, 0x18, 0x01, 0x60, 0x00, 0x0C, 0x01, 0xE0,
  0x00, 0x02, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x0C, 0x01, 0xA0, 0x00, 0x06,
  0x00, 0xD8, 0x00, 0x06, 0x00, 0x44, 0x00, 0x06, 0x00, 0x23, 0x80, 0x0E,
  0x00, 0x30, 0xF0, 0x1C, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0C, 0x00,
  0xF0, 0x78, 0x30, 0x0E, 0x00, 0x30, 0x80, 0x70, 0x00, 0x62, 0x03, 0x00,
  0x00, 0xC8, 0x1C, 0x00, 0x01, 0x60, 0x60, 0x00, 0x05, 0x83, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x16, 0x04, 0x00, 0x00, 0xD0,
  0x18, 0x00, 0x06, 0x40, 0x60, 0x00, 0x33, 0x00, 0xC0, 0x01, 0x8C, 0x01,
  0x80, 0x1C, 0x30, 0x07, 0x01, 0xC0, 0x80, 0x07, 0xFE, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x01, 0xFC, 0x04, 0x1E, 0x10, 0x30, 0xE0,
  0x00, 0xC6, 0x00, 0x02, 0x30, 0x00, 0x09, 0x80, 0x00, 0x2C, 0x00, 0x01,
  0xA0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0x80, 0x02, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xF8, 0x03, 0x80, 0x3F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xE0, 0x40, 0x3F, 0xE0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x78, 0x30, 0x00, 0x06,
  0x80, 0x80, 0x00, 0x64, 0x06, 0x00, 0x06, 0x20, 0x30, 0x00, 0x63, 0x00,
  0xC0, 0x06, 0x18, 0x07, 0x80, 0xE0, 0x80, 0x0F, 0xFC, 0x04, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x10, 0x00, 0x18, 0x08, 0x00,
  0x0C, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x03, 0x00, 0x08, 0x01, 0x00, 0x04,
  0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x20, 0x60, 0x00, 0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x32, 0x00, 0x03, 0xC0, 0x00, 0x64, 0x00, 0x07, 0x80, 0x00, 0x88,
  0x00, 0x1B, 0x00, 0x03, 0x10, 0x00, 0x36, 0x00, 0x04, 0x20, 0x00, 0xC4,
  0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x20, 0xC0, 0x06, 0x10, 0x00, 0xC1,
  0x80, 0x0C, 0x20, 0x01, 0x03, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x40,
  0xC0, 0x08, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x18, 0x02, 0x03, 0x00, 0x40,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x60,
  0x08, 0x0C, 0x01, 0x80, 0x80, 0x10, 0x18, 0x01, 0x03, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x20,
  0x01, 0x86, 0x00, 0x10, 0xC0, 0x03, 0x18, 0x00, 0x21, 0x00, 0x06, 0x30,
  0x00, 0x46, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x09, 0x80, 0x01, 0xB0,
  0x00, 0x12, 0x00, 0x03, 0x40, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0x50,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x70,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x06, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xF0,
};

const GFXglyph NotoSans_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 45, 13, 2, -44 },
  { 69, 13, 16, 19, 7, -44 },
  { 95, 37, 44, 38, 2, -44 },
  { 299, 29, 51, 34, 3, -47 },
  { 484, 39, 46, 47, 5, -45 },
  { 709, 37, 46, 42, 3, -45 },
  { 922, 5, 16, 11, 7, -44 },
  { 932, 17, 54, 15, 2, -44 },
  { 1047, 17, 54, 15, -4, -44 },
  { 1162, 25, 26, 33, 8, -47 },
  { 1244, 28, 28, 35, 5, -36 },
  { 1342, 8, 15, 11, -3, -7 },
  { 1357, 15, 2, 19, 2, -18 },
  { 1361, 3, 4, 13, 2, -3 },
  { 1363, 27, 44, 19, -3, -44 },
  { 1512, 29, 46, 34, 4, -45 },
  { 1679, 15, 44, 34, 10, -44 },
  { 1762, 30, 45, 34, 1, -45 },
  { 1931, 32, 46, 34, 1, -45 },
  { 2115, 32, 45, 34, 1, -45 },
  { 2295, 31, 45, 34, 2, -44 },
  { 2470, 30, 46, 34, 4, -45 },
  { 2643, 28, 44, 34, 7, -44 },
  { 2797, 30, 46, 34, 3, -45 },
  { 2970, 29, 46, 34, 3, -45 },
  { 3137, 10, 34, 13, 2, -33 },
  { 3180, 14, 41, 13, -3, -33 },
  { 3252, 28, 27, 35, 5, -36 },
  { 3347, 28, 14, 35, 5, -29 },
  { 3396, 28, 27, 35, 5, -36 },
  { 3491, 21, 46, 25, 5, -45 },
  { 3612, 47, 50, 52, 3, -44 },
  { 3906, 34, 44, 34, -3, -44 },
  { 4093, 33, 44, 37, 3, -44 },
  { 4275, 34, 46, 37, 5, -45 },
  { 4471, 37, 44, 42, 3, -44 },
  { 4675, 32, 44, 33, 3, -44 },
  { 4851, 32, 44, 30, 3, -44 },
  { 5027, 36, 46, 43, 5, -45 },
  { 5234, 39, 44, 42, 3, -44 },
  { 5449, 20, 44, 17, 0, -44 },
  { 5559, 25, 55, 14, -11, -44 },
  { 5731, 36, 44, 34, 3, -44 },
  { 5929, 22, 44, 30, 3, -44 },
  { 6050, 47, 44, 50, 3, -44 },
  { 6309, 38, 44, 42, 3, -44 },
  { 6518, 37, 46, 44, 5, -45 },
  { 6731, 32, 44, 35, 3, -44 },
  { 6907, 37, 56, 44, 5, -45 },
  { 7166, 32, 44, 35, 3, -44 },
  { 7342, 31, 46, 31, 1, -45 },
  { 7521, 30, 44, 30, 6, -44 },
  { 7686, 38, 45, 43, 5, -44 },
  { 7900, 31, 44, 33, 7, -44 },
  { 8071, 47, 44, 51, 8, -44 },
  { 8330, 39, 44, 30, -4, -44 },
  { 8545, 30, 44, 30, 6, -44 },
  { 8710, 36, 44, 33, -1, -44 },
  { 8908, 24, 54, 19, -1, -44 },
  { 9070, 10, 44, 19, 6, -44 },
  { 9125, 23, 54, 19, -4, -44 },
  { 9281, 28, 28, 34, 3, -45 },
  { 9379, 23, 1, 23, -5, 7 },
  { 9382, 7, 9, 14, 9, -47 },
  { 9390, 29, 34, 34, 3, -33 },
  { 9514, 30, 48, 35, 2, -47 },
  { 9694, 25, 34, 28, 3, -33 },
  { 9801, 33, 48, 35, 3, -47 },
  { 9999, 24, 34, 30, 4, -33 },
  { 10101, 34, 62, 16, -8, -47 },
  { 10365, 31, 48, 35, 2, -33 },
  { 10551, 29, 47, 34, 2, -47 },
  { 10722, 12, 45, 13, 2, -45 },
  { 10790, 23, 60, 13, -9, -45 },
  { 10963, 28, 47, 27, 2, -47 },
  { 11128, 12, 47, 13, 2, -47 },
  { 11199, 46, 33, 52, 2, -33 },
  { 11389, 29, 33, 34, 2, -33 },
  { 11509, 29, 34, 35, 3, -33 },
  { 11633, 33, 47, 35, -1, -33 },
  { 11827, 30, 47, 35, 3, -33 },
  { 12004, 22, 33, 23, 2, -33 },
  { 12095, 24, 34, 26, 1, -33 },
  { 12197, 17, 42, 19, 3, -41 },
  { 12287, 29, 34, 34, 3, -33 },
  { 12411, 25, 33, 25, 3, -33 },
  { 12515, 39, 33, 40, 3, -33 },
  { 12676, 31, 33, 28, -2, -33 },
  { 12804, 35, 48, 25, -7, -33 },
  { 13014, 28, 33, 27, -1, -33 },
  { 13130, 22, 54, 20, 2, -44 },
  { 13279, 2, 62, 33, 17, -47 },
  { 13295, 22, 54, 20, -3, -44 },
  { 13444, 28, 6, 35, 5, -25 },
};

const GFXfont NotoSans_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_THINITALIC62PT7B_H_
