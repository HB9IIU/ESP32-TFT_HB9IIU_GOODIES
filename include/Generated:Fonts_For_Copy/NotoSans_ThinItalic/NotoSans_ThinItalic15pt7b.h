#ifndef _NOTOSANS_THINITALIC15PT7B_H_
#define _NOTOSANS_THINITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0xFB,
  0x24, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x88, 0x08, 0x7D, 0x22, 0x85, 0x06,
  0x07, 0x12, 0x25, 0x71, 0x81, 0x00, 0x30, 0x92, 0x28, 0x92, 0x28, 0x95,
  0xA5, 0x96, 0xA4, 0x51, 0x24, 0x49, 0x24, 0x78, 0x1C, 0x11, 0x08, 0x84,
  0x42, 0xC1, 0x83, 0x23, 0x0A, 0x86, 0x43, 0x3E, 0x40, 0xF0, 0x08, 0x88,
  0x44, 0x22, 0x10, 0x84, 0x21, 0x04, 0x00, 0x11, 0x11, 0x11, 0x11, 0x12,
  0x24, 0xC0, 0x12, 0x47, 0xC8, 0xD0, 0x40, 0x10, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x00, 0x56, 0xE0, 0x80, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x40, 0x82, 0x00, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x09,
  0xE0, 0x17, 0x91, 0x12, 0x22, 0x24, 0x40, 0x1E, 0x21, 0x01, 0x01, 0x02,
  0x02, 0x04, 0x18, 0x20, 0x40, 0xFC, 0x1E, 0x21, 0x01, 0x01, 0x02, 0x1C,
  0x02, 0x02, 0x02, 0x02, 0xFC, 0x01, 0x02, 0x06, 0x0A, 0x12, 0x22, 0x42,
  0xFF, 0x04, 0x04, 0x04, 0x3E, 0x41, 0x02, 0x07, 0x01, 0x81, 0x02, 0x04,
  0x0B, 0xE0, 0x1E, 0x41, 0x02, 0x0B, 0x98, 0xA0, 0xC1, 0x85, 0x09, 0xE0,
  0xFC, 0x10, 0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x00, 0x3C, 0x85, 0x0A,
  0x12, 0x47, 0x11, 0x42, 0x85, 0x0B, 0xE0, 0x3C, 0x85, 0x0C, 0x18, 0x30,
  0xDE, 0x82, 0x04, 0x13, 0xC0, 0x20, 0x00, 0x04, 0x10, 0x00, 0x00, 0x24,
  0x48, 0x02, 0x19, 0xC4, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x03, 0xF8, 0x80,
  0xE0, 0x30, 0x10, 0xC6, 0x30, 0x00, 0x70, 0x42, 0x10, 0x99, 0x08, 0x00,
  0x20, 0x0F, 0x86, 0x09, 0x00, 0xA3, 0x18, 0x93, 0x22, 0x68, 0x4D, 0x11,
  0x96, 0x51, 0x32, 0x00, 0x3F, 0x80, 0x02, 0x06, 0x05, 0x09, 0x09, 0x11,
  0x1F, 0x21, 0x41, 0x41, 0x81, 0x3E, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x82,
  0x82, 0x82, 0x82, 0xFC, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x0F, 0x80, 0x3E, 0x20, 0x90, 0x48, 0x14, 0x0A, 0x06,
  0x03, 0x02, 0x81, 0x43, 0x3E, 0x00, 0x3E, 0x81, 0x02, 0x04, 0x0F, 0xA0,
  0x40, 0x81, 0x03, 0xE0, 0x3E, 0x81, 0x02, 0x04, 0x0F, 0xA0, 0x40, 0x81,
  0x02, 0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x32, 0x05, 0x02, 0x81,
  0x20, 0x8F, 0x80, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0B, 0xFA, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x80, 0x38, 0x84, 0x42, 0x10, 0x84, 0x42, 0x38, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x13, 0x80, 0x21, 0x42,
  0x44, 0x48, 0x50, 0x70, 0x90, 0x88, 0x88, 0x84, 0x84, 0x22, 0x10, 0x84,
  0x22, 0x10, 0x84, 0x3E, 0x20, 0x24, 0x05, 0x81, 0xB0, 0x55, 0x0C, 0xA2,
  0xA4, 0x94, 0x92, 0x94, 0x51, 0x12, 0x22, 0x00, 0x20, 0x90, 0x54, 0x2A,
  0x15, 0x12, 0x4A, 0x25, 0x0A, 0x85, 0x41, 0x20, 0x80, 0x1F, 0x10, 0x50,
  0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x20, 0x8F, 0x80, 0x3C, 0x85,
  0x0A, 0x14, 0x28, 0xAE, 0x40, 0x81, 0x02, 0x00, 0x1F, 0x10, 0x50, 0x28,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x20, 0x8D, 0x81, 0x00, 0x40, 0x20,
  0x3C, 0x85, 0x0A, 0x14, 0x28, 0xAE, 0x44, 0x85, 0x0A, 0x10, 0x1F, 0x20,
  0x40, 0x40, 0x20, 0x18, 0x04, 0x02, 0x02, 0x04, 0xF8, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0xA0, 0x50, 0x28,
  0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x41, 0x1F, 0x00, 0x83, 0x06, 0x14,
  0x28, 0x91, 0x24, 0x50, 0xA1, 0x81, 0x00, 0x84, 0x30, 0x86, 0x30, 0xC6,
  0x29, 0x45, 0x29, 0x28, 0xA5, 0x18, 0xC3, 0x10, 0x42, 0x08, 0x00, 0x10,
  0x88, 0x44, 0x41, 0x40, 0xC0, 0x40, 0x30, 0x28, 0x22, 0x21, 0x20, 0x40,
  0x81, 0x42, 0x44, 0x44, 0x48, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x3F,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x3F, 0x80,
  0x1C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0xE0, 0x91, 0x24,
  0x92, 0x24, 0x80, 0x1C, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08,
  0xE0, 0x08, 0x30, 0x51, 0x24, 0x50, 0x60, 0x80, 0xF8, 0x90, 0x3A, 0x8A,
  0x14, 0x28, 0x50, 0xA2, 0x7C, 0x20, 0x20, 0x20, 0x3E, 0x21, 0x41, 0x41,
  0x41, 0x42, 0x42, 0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x1E, 0x01, 0x01,
  0x02, 0x3E, 0x42, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x3D, 0x18, 0x7E,
  0x82, 0x08, 0x1E, 0x07, 0x08, 0x08, 0x1E, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x80, 0x1F, 0x21, 0x41, 0x41, 0x42, 0x82,
  0x46, 0x7A, 0x04, 0x04, 0x88, 0x70, 0x20, 0x40, 0x81, 0xF2, 0x28, 0x50,
  0xA1, 0x43, 0x06, 0x08, 0x20, 0x12, 0x92, 0x52, 0x00, 0x08, 0x00, 0x10,
  0x88, 0x42, 0x11, 0x08, 0x42, 0x13, 0x00, 0x20, 0x40, 0x81, 0x12, 0x49,
  0x14, 0x38, 0x49, 0x12, 0x10, 0x24, 0x92, 0x92, 0x52, 0x00, 0x3E, 0xE2,
  0x31, 0x42, 0x14, 0x21, 0x42, 0x14, 0x22, 0x84, 0x28, 0x42, 0x3E, 0x45,
  0x0A, 0x14, 0x28, 0x60, 0xC1, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x3C,
  0x3E, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x3E,
  0x86, 0x0C, 0x18, 0x50, 0xA3, 0x7A, 0x08, 0x10, 0x20, 0x3C, 0x84, 0x10,
  0x41, 0x08, 0x20, 0x3D, 0x04, 0x08, 0x18, 0x20, 0xBE, 0x44, 0xF8, 0x88,
  0x88, 0x8C, 0x43, 0x06, 0x0C, 0x28, 0x50, 0xA2, 0x7C, 0x86, 0x28, 0xA4,
  0x92, 0x8C, 0x10, 0x88, 0xC4, 0x66, 0x55, 0x2A, 0xA6, 0x32, 0x11, 0x08,
  0x21, 0x12, 0x14, 0x08, 0x18, 0x24, 0x24, 0xC2, 0x10, 0x88, 0x84, 0x42,
  0x41, 0x20, 0xA0, 0x20, 0x10, 0x10, 0x08, 0x08, 0x18, 0x00, 0x3E, 0x08,
  0x20, 0x82, 0x08, 0x10, 0x7C, 0x0C, 0x41, 0x08, 0x20, 0x8C, 0x10, 0x41,
  0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x20, 0x82, 0x08, 0x20, 0xC4, 0x10,
  0x42, 0x08, 0xE0, 0xFE,
};

const GFXglyph NotoSans_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 5, 2, -11 },
  { 8, 8, 11, 9, 1, -11 },
  { 19, 7, 12, 8, 1, -11 },
  { 30, 10, 11, 11, 1, -11 },
  { 44, 9, 11, 10, 1, -11 },
  { 57, 1, 4, 3, 2, -11 },
  { 58, 5, 13, 4, 0, -11 },
  { 67, 4, 13, 4, -1, -11 },
  { 74, 6, 6, 8, 2, -11 },
  { 79, 7, 7, 9, 1, -9 },
  { 86, 2, 4, 3, -1, -2 },
  { 87, 3, 1, 5, 1, -5 },
  { 88, 1, 1, 3, 0, -1 },
  { 89, 7, 11, 5, -1, -11 },
  { 99, 7, 11, 8, 1, -11 },
  { 109, 4, 11, 8, 2, -11 },
  { 115, 8, 11, 8, 0, -11 },
  { 126, 8, 11, 8, 0, -11 },
  { 137, 8, 11, 8, 0, -11 },
  { 148, 7, 11, 8, 1, -11 },
  { 158, 7, 11, 8, 1, -11 },
  { 168, 6, 11, 8, 2, -11 },
  { 177, 7, 11, 8, 1, -11 },
  { 187, 7, 11, 8, 1, -11 },
  { 197, 3, 8, 3, 0, -8 },
  { 200, 4, 10, 3, -1, -8 },
  { 205, 7, 7, 9, 1, -9 },
  { 212, 7, 3, 9, 1, -7 },
  { 215, 7, 7, 9, 1, -9 },
  { 222, 5, 11, 6, 1, -11 },
  { 229, 11, 12, 13, 1, -11 },
  { 246, 8, 11, 8, -1, -11 },
  { 257, 8, 11, 9, 1, -11 },
  { 268, 9, 11, 9, 1, -11 },
  { 281, 9, 11, 10, 1, -11 },
  { 294, 7, 11, 8, 1, -11 },
  { 304, 7, 11, 7, 1, -11 },
  { 314, 9, 11, 10, 1, -11 },
  { 327, 9, 11, 10, 1, -11 },
  { 340, 5, 11, 4, 0, -11 },
  { 347, 6, 14, 3, -3, -11 },
  { 358, 8, 11, 8, 1, -11 },
  { 369, 5, 11, 7, 1, -11 },
  { 376, 11, 11, 12, 1, -11 },
  { 392, 9, 11, 10, 1, -11 },
  { 405, 9, 11, 11, 1, -11 },
  { 418, 7, 11, 8, 1, -11 },
  { 428, 9, 14, 11, 1, -11 },
  { 444, 7, 11, 8, 1, -11 },
  { 454, 8, 11, 7, 0, -11 },
  { 465, 8, 11, 7, 1, -11 },
  { 476, 9, 11, 10, 1, -11 },
  { 489, 7, 11, 8, 2, -11 },
  { 499, 11, 11, 12, 2, -11 },
  { 515, 9, 11, 7, -1, -11 },
  { 528, 8, 11, 7, 1, -11 },
  { 539, 9, 11, 8, 0, -11 },
  { 552, 6, 13, 5, 0, -11 },
  { 562, 3, 11, 5, 1, -11 },
  { 567, 6, 13, 5, -1, -11 },
  { 577, 7, 7, 8, 1, -11 },
  { 584, 5, 1, 6, -1, 1 },
  { 585, 2, 2, 3, 2, -11 },
  { 586, 7, 8, 8, 1, -8 },
  { 593, 8, 11, 9, 0, -11 },
  { 604, 6, 8, 7, 1, -8 },
  { 610, 8, 11, 9, 1, -11 },
  { 621, 6, 8, 7, 1, -8 },
  { 627, 8, 15, 4, -2, -11 },
  { 642, 8, 12, 9, 0, -8 },
  { 654, 7, 11, 8, 0, -11 },
  { 664, 3, 11, 3, 0, -11 },
  { 669, 5, 15, 3, -2, -11 },
  { 679, 7, 11, 7, 0, -11 },
  { 689, 3, 11, 3, 0, -11 },
  { 694, 12, 8, 13, 0, -8 },
  { 706, 7, 8, 8, 0, -8 },
  { 713, 7, 8, 8, 1, -8 },
  { 720, 8, 11, 9, 0, -8 },
  { 731, 7, 11, 9, 1, -8 },
  { 741, 6, 8, 6, 0, -8 },
  { 747, 6, 8, 6, 0, -8 },
  { 753, 4, 10, 5, 1, -10 },
  { 758, 7, 8, 8, 1, -8 },
  { 765, 6, 8, 6, 1, -8 },
  { 771, 9, 8, 10, 1, -8 },
  { 780, 8, 8, 7, -1, -8 },
  { 788, 9, 12, 6, -2, -8 },
  { 802, 7, 8, 7, 0, -8 },
  { 809, 6, 13, 5, 0, -11 },
  { 819, 1, 15, 8, 4, -11 },
  { 821, 6, 13, 5, -1, -11 },
  { 831, 7, 1, 9, 1, -6 },
};

const GFXfont NotoSans_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_THINITALIC15PT7B_H_
