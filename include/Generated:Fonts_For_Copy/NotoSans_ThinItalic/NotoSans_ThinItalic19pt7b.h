#ifndef _NOTOSANS_THINITALIC19PT7B_H_
#define _NOTOSANS_THINITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x52, 0x01, 0x00, 0x55, 0x99, 0x90, 0x04, 0x41,
  0x10, 0x22, 0x04, 0x46, 0xEE, 0x22, 0x04, 0x40, 0x88, 0x22, 0x1F, 0xF8,
  0x88, 0x21, 0x04, 0x40, 0x88, 0x00, 0x04, 0x0F, 0xC9, 0x08, 0x84, 0x41,
  0x40, 0x60, 0x18, 0x0A, 0x04, 0x84, 0x42, 0x4F, 0xC0, 0x80, 0x80, 0x30,
  0x29, 0x0A, 0x21, 0x44, 0x48, 0x91, 0x14, 0xA4, 0xAC, 0xA9, 0x6A, 0x22,
  0x44, 0x48, 0x91, 0x14, 0x23, 0x07, 0x80, 0x0F, 0x02, 0x10, 0x42, 0x08,
  0x41, 0x10, 0x24, 0x03, 0x01, 0xA0, 0x44, 0x30, 0x4A, 0x05, 0x40, 0x48,
  0x18, 0xFC, 0x80, 0x5A, 0x80, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x80, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21,
  0x10, 0x88, 0x80, 0x08, 0x88, 0x68, 0x17, 0x18, 0x28, 0x44, 0x04, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x29, 0x40,
  0xF0, 0x80, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x80, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x0A, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xA0, 0x50, 0x28, 0x23, 0xE0, 0x09, 0xD3, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x20, 0x07, 0x06, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x3F, 0xC0, 0x0F,
  0x84, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0xF0, 0x44, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x3F, 0x80, 0x00, 0x40, 0x20, 0x18, 0x0A, 0x04, 0x82,
  0x21, 0x08, 0x84, 0x41, 0x10, 0x4B, 0xFC, 0x04, 0x02, 0x00, 0x80, 0x1F,
  0x88, 0x08, 0x04, 0x02, 0x02, 0x01, 0xF8, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x27, 0xE0, 0x07, 0x84, 0x04, 0x04, 0x04, 0x02, 0x61, 0xC8, 0x82,
  0x80, 0xC0, 0x60, 0x50, 0x24, 0x21, 0xE0, 0xFF, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x00, 0x0F,
  0x08, 0x48, 0x24, 0x12, 0x09, 0x08, 0x78, 0x6C, 0x41, 0x40, 0xA0, 0x50,
  0x28, 0x13, 0xF0, 0x0E, 0x18, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x86,
  0x3D, 0x00, 0x80, 0x40, 0x40, 0x47, 0xC0, 0x20, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x22, 0x11, 0x00, 0x01, 0x83, 0x06, 0x0C, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xC0, 0x18, 0x03,
  0x80, 0x20, 0x18, 0x30, 0x61, 0xC0, 0x7A, 0x10, 0x41, 0x04, 0x21, 0x08,
  0x42, 0x08, 0x00, 0x02, 0x00, 0x0F, 0xF0, 0x40, 0x22, 0x00, 0x50, 0x71,
  0x46, 0x26, 0x21, 0x18, 0x84, 0x62, 0x11, 0x90, 0x46, 0x22, 0x28, 0xF7,
  0x20, 0x00, 0x40, 0x00, 0xC1, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x60, 0x18,
  0x0A, 0x04, 0x81, 0x20, 0x84, 0x21, 0x1F, 0xC8, 0x12, 0x05, 0x01, 0x40,
  0x60, 0x10, 0x1F, 0x08, 0x32, 0x04, 0x81, 0x20, 0x50, 0x27, 0xF1, 0x04,
  0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x80, 0x0F, 0xC4, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x1F, 0xC0, 0x1F, 0x04, 0x10, 0x81, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x28, 0x06, 0x01, 0x40, 0x48, 0x11, 0xFC, 0x00, 0x1F, 0xC8,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x3F, 0x80, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xC2,
  0x04, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x3E, 0x80, 0x50, 0x0A,
  0x02, 0x40, 0x48, 0x08, 0xFE, 0x00, 0x10, 0x12, 0x01, 0x20, 0x12, 0x02,
  0x20, 0x24, 0x02, 0x7F, 0xE4, 0x02, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x1C, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x43, 0x80, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x08, 0xF0, 0x10, 0x24, 0x08, 0x82, 0x10, 0x82, 0x60,
  0x90, 0x16, 0x03, 0x40, 0x44, 0x08, 0x82, 0x08, 0x41, 0x08, 0x11, 0x02,
  0x00, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x1F, 0xC0, 0x10, 0x04, 0x40, 0x13, 0x00, 0xCC, 0x05, 0x28, 0x15, 0x20,
  0xA4, 0x82, 0x92, 0x12, 0x48, 0x89, 0x22, 0x28, 0x51, 0x21, 0x44, 0x86,
  0x12, 0x10, 0x40, 0x20, 0x11, 0x01, 0x30, 0x12, 0x82, 0x28, 0x24, 0x42,
  0x44, 0x24, 0x44, 0x42, 0x44, 0x24, 0x81, 0x48, 0x14, 0x80, 0x88, 0x08,
  0x0F, 0x06, 0x19, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0A, 0x01, 0x40, 0x48, 0x18, 0xFC, 0x00, 0x1F, 0x08, 0x22, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x09, 0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x0F, 0x06, 0x19, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x18, 0xEC, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x1F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x24, 0x09, 0xFC,
  0x44, 0x10, 0x88, 0x22, 0x08, 0x81, 0x20, 0x40, 0x0F, 0x84, 0x12, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x3F, 0x80, 0xFF, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x48, 0x10,
  0xFC, 0x00, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x84, 0x21, 0x10,
  0x48, 0x12, 0x05, 0x01, 0x40, 0x20, 0x08, 0x00, 0x81, 0x03, 0x02, 0x06,
  0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0x91, 0x22, 0x24, 0x44, 0x48, 0x90,
  0xA0, 0xA1, 0x41, 0x82, 0x83, 0x06, 0x04, 0x08, 0x08, 0x10, 0x00, 0x10,
  0x11, 0x02, 0x08, 0x40, 0x88, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60, 0x0A,
  0x01, 0x10, 0x11, 0x02, 0x10, 0x40, 0x88, 0x08, 0x80, 0xC0, 0xA0, 0x48,
  0x44, 0x42, 0x21, 0x20, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00,
  0x1F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0xFE, 0x00, 0x1E, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0, 0x92,
  0x49, 0x12, 0x49, 0x12, 0x40, 0x1E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xE0, 0x02, 0x03, 0x02, 0x82,
  0x41, 0x11, 0x09, 0x04, 0x81, 0x80, 0x80, 0xFF, 0xA4, 0x3E, 0xA0, 0x90,
  0x50, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x86, 0x3D, 0x00, 0x20, 0x10, 0x08,
  0x04, 0x05, 0xF3, 0x05, 0x02, 0x81, 0x40, 0xC0, 0x60, 0x50, 0x28, 0x27,
  0xE0, 0x1F, 0x60, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x3E, 0x90, 0x64, 0x0A, 0x02, 0x81, 0x20, 0x48,
  0x12, 0x08, 0x85, 0x1E, 0x80, 0x1E, 0x21, 0x41, 0x82, 0xFC, 0x80, 0x80,
  0x80, 0x80, 0x7C, 0x00, 0xE0, 0x20, 0x08, 0x01, 0x00, 0x20, 0x1F, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x70, 0x00, 0x1F, 0x48, 0x32, 0x05, 0x01,
  0x40, 0x90, 0x24, 0x09, 0x04, 0x42, 0x8F, 0x40, 0x10, 0x04, 0x02, 0x21,
  0x07, 0x80, 0x20, 0x20, 0x20, 0x20, 0x5F, 0x61, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x20, 0x04, 0x92, 0x52, 0x49, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x43, 0x00, 0x20, 0x20, 0x20, 0x20, 0x41, 0x42, 0x44, 0x58, 0x70,
  0xD0, 0x88, 0x88, 0x84, 0x84, 0x24, 0x94, 0x92, 0x52, 0x49, 0x00, 0x5E,
  0x79, 0x86, 0x14, 0x10, 0x50, 0x41, 0x41, 0x06, 0x08, 0x18, 0x20, 0xA0,
  0x82, 0x82, 0x0A, 0x08, 0x20, 0x5F, 0x61, 0x41, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x02,
  0x82, 0x3E, 0x00, 0x2F, 0x8C, 0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09,
  0x02, 0x41, 0x2F, 0x88, 0x02, 0x00, 0x80, 0x20, 0x00, 0x3E, 0xA0, 0xD0,
  0x30, 0x18, 0x14, 0x0A, 0x05, 0x04, 0x85, 0x3D, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x5E, 0xC1, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3F, 0x40,
  0x40, 0x20, 0x10, 0x0C, 0x02, 0x02, 0x02, 0xFC, 0x21, 0x09, 0xB4, 0x21,
  0x10, 0x84, 0x21, 0x0F, 0x00, 0x40, 0xA0, 0x50, 0x28, 0x28, 0x14, 0x0A,
  0x05, 0x04, 0x86, 0x3D, 0x00, 0x81, 0x82, 0x84, 0x84, 0x88, 0x48, 0x50,
  0x50, 0x60, 0x40, 0x84, 0x18, 0x42, 0x8A, 0x28, 0xA4, 0x92, 0x49, 0x24,
  0xA2, 0x8A, 0x28, 0x41, 0x08, 0x10, 0x10, 0x44, 0x20, 0x90, 0x28, 0x04,
  0x03, 0x01, 0x20, 0x88, 0x41, 0x30, 0x40, 0x10, 0x22, 0x08, 0x41, 0x08,
  0x41, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x30, 0x00, 0x3F, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0xFC, 0x04, 0x61, 0x08, 0x20, 0x82, 0x10, 0x81, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x60, 0xFF, 0xFF, 0xE0, 0x18, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0xC0, 0x70, 0x47, 0xC0,
};

const GFXglyph NotoSans_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 4, 1, -14 },
  { 7, 4, 5, 6, 2, -14 },
  { 10, 11, 14, 12, 1, -14 },
  { 30, 9, 15, 10, 1, -14 },
  { 47, 11, 14, 15, 2, -14 },
  { 67, 11, 14, 13, 1, -14 },
  { 87, 2, 5, 3, 2, -14 },
  { 89, 5, 17, 5, 1, -14 },
  { 100, 5, 17, 5, -1, -14 },
  { 111, 8, 8, 10, 2, -14 },
  { 119, 9, 9, 11, 1, -11 },
  { 130, 3, 4, 3, -1, -2 },
  { 132, 4, 1, 6, 1, -6 },
  { 133, 1, 1, 4, 1, -1 },
  { 134, 8, 14, 6, -1, -14 },
  { 148, 9, 14, 10, 1, -14 },
  { 164, 5, 14, 10, 3, -14 },
  { 173, 10, 14, 10, 0, -14 },
  { 191, 10, 14, 10, 0, -14 },
  { 209, 10, 14, 10, 0, -14 },
  { 227, 9, 14, 10, 1, -14 },
  { 243, 9, 14, 10, 1, -14 },
  { 259, 9, 14, 10, 2, -14 },
  { 275, 9, 14, 10, 1, -14 },
  { 291, 9, 14, 10, 1, -14 },
  { 307, 3, 10, 4, 1, -10 },
  { 311, 5, 12, 4, -1, -10 },
  { 319, 9, 8, 11, 1, -11 },
  { 328, 9, 4, 11, 1, -9 },
  { 333, 9, 8, 11, 1, -11 },
  { 342, 6, 14, 8, 2, -14 },
  { 353, 14, 15, 16, 1, -13 },
  { 380, 10, 14, 10, -1, -14 },
  { 398, 10, 14, 11, 1, -14 },
  { 416, 10, 14, 11, 2, -14 },
  { 434, 11, 14, 13, 1, -14 },
  { 454, 10, 14, 10, 1, -14 },
  { 472, 10, 14, 9, 1, -14 },
  { 490, 11, 14, 13, 2, -14 },
  { 510, 12, 14, 13, 1, -14 },
  { 531, 6, 14, 5, 0, -14 },
  { 542, 7, 17, 4, -3, -14 },
  { 557, 11, 14, 10, 1, -14 },
  { 577, 7, 14, 9, 1, -14 },
  { 590, 14, 14, 15, 1, -14 },
  { 615, 12, 14, 13, 1, -14 },
  { 636, 11, 14, 14, 2, -14 },
  { 656, 10, 14, 11, 1, -14 },
  { 674, 11, 17, 14, 2, -14 },
  { 698, 10, 14, 11, 1, -14 },
  { 716, 10, 14, 9, 0, -14 },
  { 734, 9, 14, 9, 2, -14 },
  { 750, 11, 14, 13, 2, -14 },
  { 770, 10, 14, 10, 2, -14 },
  { 788, 15, 14, 16, 2, -14 },
  { 815, 12, 14, 9, -1, -14 },
  { 836, 9, 14, 9, 2, -14 },
  { 852, 11, 14, 10, 0, -14 },
  { 872, 7, 17, 6, 0, -14 },
  { 887, 3, 14, 6, 2, -14 },
  { 893, 7, 17, 6, -1, -14 },
  { 908, 9, 9, 10, 1, -14 },
  { 919, 8, 1, 7, -2, 2 },
  { 920, 2, 3, 4, 3, -15 },
  { 921, 9, 10, 10, 1, -10 },
  { 933, 9, 14, 11, 1, -14 },
  { 949, 8, 10, 9, 1, -10 },
  { 959, 10, 14, 11, 1, -14 },
  { 977, 8, 10, 9, 1, -10 },
  { 987, 11, 20, 5, -3, -15 },
  { 1015, 10, 15, 11, 0, -10 },
  { 1034, 8, 14, 11, 1, -14 },
  { 1048, 3, 14, 4, 1, -14 },
  { 1054, 7, 19, 4, -3, -14 },
  { 1071, 8, 14, 8, 1, -14 },
  { 1085, 3, 14, 4, 1, -14 },
  { 1091, 14, 10, 16, 1, -10 },
  { 1109, 8, 10, 11, 1, -10 },
  { 1119, 9, 10, 11, 1, -10 },
  { 1131, 10, 14, 11, 0, -10 },
  { 1149, 9, 14, 11, 1, -10 },
  { 1165, 7, 10, 7, 1, -10 },
  { 1174, 8, 10, 8, 0, -10 },
  { 1184, 5, 13, 6, 1, -13 },
  { 1193, 9, 10, 11, 1, -10 },
  { 1205, 8, 10, 8, 1, -10 },
  { 1215, 12, 10, 12, 1, -10 },
  { 1230, 10, 10, 9, -1, -10 },
  { 1243, 11, 15, 8, -2, -10 },
  { 1264, 8, 10, 8, 0, -10 },
  { 1274, 6, 17, 6, 1, -14 },
  { 1287, 1, 19, 10, 5, -14 },
  { 1290, 7, 17, 6, -1, -14 },
  { 1305, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_THINITALIC19PT7B_H_
