#ifndef _NOTOSANS_THINITALIC66PT7B_H_
#define _NOTOSANS_THINITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x04,
  0x00, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC6, 0x01,
  0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80, 0x43, 0x01, 0x86,
  0x03, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x01, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xC4, 0x7E, 0x00, 0x38, 0x18, 0x0E, 0x00, 0xE0,
  0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x38, 0x08, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0x1E, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x20, 0x70, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00, 0x60, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x06, 0x00, 0x60,
  0x70, 0x0F, 0xC0, 0x87, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x18, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x02,
  0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x10, 0x00, 0x30, 0x30, 0x1E, 0x08,
  0x00, 0x30, 0x30, 0x3F, 0xC4, 0x00, 0x18, 0x30, 0x70, 0x33, 0x00, 0x08,
  0x18, 0x70, 0x0D, 0x80, 0x0C, 0x18, 0x30, 0x06, 0xC0, 0x0C, 0x18, 0x30,
  0x01, 0x60, 0x06, 0x0C, 0x30, 0x00, 0xD8, 0x06, 0x0C, 0x18, 0x00, 0x6E,
  0x0E, 0x0C, 0x08, 0x00, 0x33, 0xFE, 0x0C, 0x0C, 0x00, 0x18, 0x78, 0x06,
  0x06, 0x00, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x03, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x70, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x18, 0x38, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x01, 0x80, 0x06,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x60, 0x00, 0x01, 0x80, 0x30, 0xC0, 0x00,
  0x03, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x01, 0x86, 0x00, 0x00, 0x03, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x18, 0x18, 0x00, 0x00, 0x06, 0x60, 0x30, 0x00,
  0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x00, 0x6C, 0x01, 0x80, 0x00, 0x01, 0x8C, 0x03, 0x80,
  0x00, 0x0E, 0x18, 0x03, 0x80, 0x00, 0x38, 0x18, 0x03, 0x80, 0x01, 0xC0,
  0x18, 0x03, 0xC0, 0x1E, 0x00, 0x18, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x08, 0xC6,
  0x21, 0x08, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x07, 0x00, 0x10, 0x00, 0x78, 0x02, 0x00, 0x03, 0x80,
  0x40, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x06, 0x40, 0x1E,
  0x00, 0x3B, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x2F, 0xEE, 0x40, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x3A, 0x00, 0x76, 0x01, 0xC6, 0x03, 0x86,
  0x0E, 0x04, 0x1C, 0x0C, 0x70, 0x0C, 0xE0, 0x0C, 0x80, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x78, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x01,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x07, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x01, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x07, 0xF8, 0x00, 0x18, 0x3F, 0xFE, 0x00, 0x10,
  0xF0, 0x07, 0x80, 0x31, 0xC0, 0x01, 0xC0, 0x33, 0x00, 0x00, 0xE0, 0x26,
  0x00, 0x00, 0x60, 0x2C, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x34, 0x06, 0x00,
  0x00, 0x6C, 0x03, 0x00, 0x00, 0xCC, 0x03, 0x80, 0x03, 0x8C, 0x01, 0xE0,
  0x0E, 0x18, 0x00, 0x7F, 0xFC, 0x18, 0x00, 0x0F, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x38, 0x0E, 0x01, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x7C,
  0x03, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x30, 0x00, 0x07, 0xFF, 0x80, 0x06, 0x10, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x01, 0x88, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x66, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1B, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x0D, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x07, 0x80,
  0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x20, 0x00, 0x58,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x6C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x36,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x1A, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x19,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x0C,
  0x60, 0x06, 0x00, 0x07, 0x80, 0x06, 0x30, 0x03, 0x00, 0x02, 0xC0, 0x06,
  0x18, 0x00, 0xC0, 0x03, 0x20, 0x06, 0x0C, 0x00, 0x60, 0x07, 0x18, 0x06,
  0x06, 0x00, 0x1C, 0x07, 0x0C, 0x0E, 0x01, 0x00, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x10, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x20, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x08,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xFF, 0x88, 0x00, 0x00, 0xFF, 0xFE, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0x30, 0xF0, 0x00,
  0x00, 0x00, 0x43, 0xB0, 0x00, 0x00, 0x01, 0x8C, 0x60, 0x00, 0x00, 0x03,
  0x30, 0x60, 0x00, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x02, 0x80, 0x00, 0x00, 0x00,
  0x28, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x06, 0xC0, 0x00, 0x00,
  0x01, 0x90, 0x01, 0x30, 0x00, 0x00, 0x00, 0x44, 0x00, 0xC4, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x31, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x0C, 0x60, 0x00,
  0x00, 0x06, 0x30, 0x03, 0x18, 0x00, 0x00, 0x03, 0x08, 0x00, 0x86, 0x00,
  0x00, 0x00, 0x86, 0x00, 0x60, 0x80, 0x00, 0x00, 0x61, 0x80, 0x18, 0x20,
  0x00, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x01, 0x83,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x02, 0x00,
  0x60, 0x18, 0x00, 0x02, 0x01, 0x80, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x00, 0x30, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x08, 0x00, 0x60, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0xC0, 0x01, 0x00, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x08,
  0x10, 0x00, 0x30, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x00, 0x20, 0x00, 0x31, 0x80, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x20, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x58, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x06, 0xC0, 0x00,
  0x00, 0x30, 0x03, 0x60, 0x00, 0x00, 0x18, 0x01, 0x90, 0x00, 0x00, 0x0C,
  0x00, 0x8C, 0x00, 0x00, 0x06, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x30, 0x00,
  0x00, 0xC0, 0x08, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x04, 0x00, 0x00, 0x20,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x03, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x00, 0x80, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80,
  0x10, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x80, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x06, 0x00, 0x00, 0x10, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x18, 0x01, 0x00, 0x00, 0x06, 0x08, 0x01, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x20, 0x00, 0x00, 0x19, 0x80, 0x30, 0x00, 0x00, 0x04, 0x80, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x08, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x80, 0x18, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x16, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x60, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x0C, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01, 0x82, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x40, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x80,
  0x30, 0x00, 0x40, 0x18, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x02,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x00,
  0x08, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x20, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x18, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00, 0x80, 0x1C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x04, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1,
  0x83, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x78, 0x3C, 0x10, 0x03, 0x80, 0x0C,
  0x20, 0x0E, 0x00, 0x0C, 0x40, 0x30, 0x00, 0x19, 0x80, 0xC0, 0x00, 0x1B,
  0x03, 0x00, 0x00, 0x34, 0x06, 0x00, 0x00, 0x28, 0x18, 0x00, 0x00, 0x70,
  0x20, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x14, 0x06, 0x00, 0x00,
  0x78, 0x0C, 0x00, 0x01, 0xB0, 0x18, 0x00, 0x06, 0x60, 0x18, 0x00, 0x18,
  0x80, 0x30, 0x00, 0x61, 0x00, 0x30, 0x03, 0x86, 0x00, 0x38, 0x1E, 0x0C,
  0x00, 0x3F, 0xF0, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x01, 0x80, 0xFF,
  0xC0, 0x01, 0x83, 0xC0, 0xF0, 0x01, 0x87, 0x00, 0x38, 0x01, 0x0C, 0x00,
  0x1C, 0x01, 0x18, 0x00, 0x0C, 0x03, 0x30, 0x00, 0x06, 0x03, 0x60, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0x02, 0x02, 0x80, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x28, 0x00, 0x00,
  0x30, 0x68, 0x00, 0x00, 0x60, 0x6C, 0x00, 0x00, 0xC0, 0x64, 0x00, 0x01,
  0x80, 0x46, 0x00, 0x03, 0x00, 0x43, 0x00, 0x0E, 0x00, 0xC1, 0xE0, 0x3C,
  0x00, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x01, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x78, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x1E, 0x07, 0x83,
  0x00, 0x0E, 0x00, 0x38, 0x60, 0x03, 0x80, 0x01, 0x88, 0x00, 0xC0, 0x00,
  0x13, 0x00, 0x30, 0x00, 0x03, 0x60, 0x0C, 0x00, 0x00, 0x2C, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x00,
  0x28, 0x01, 0x80, 0x00, 0x0D, 0x00, 0x30, 0x00, 0x03, 0x60, 0x06, 0x00,
  0x00, 0xCC, 0x00, 0x60, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0xC0, 0x07, 0x04, 0x00, 0x0E, 0x03, 0x81, 0x80, 0x00, 0xFF, 0xE0, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xF1, 0x80, 0x00, 0xF0, 0x60, 0x01,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x02, 0x00, 0x78, 0x07, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0xC0, 0x03, 0xC0, 0xF0, 0x60, 0x07, 0x00, 0x1C, 0x30, 0x07, 0x00, 0x03,
  0x10, 0x06, 0x00, 0x00, 0x88, 0x06, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00,
  0x16, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x00, 0x14, 0x03,
  0x00, 0x00, 0x1A, 0x01, 0x80, 0x00, 0x1B, 0x00, 0xC0, 0x00, 0x19, 0x80,
  0x30, 0x00, 0x18, 0xC0, 0x18, 0x00, 0x18, 0x40, 0x06, 0x00, 0x38, 0x60,
  0x01, 0xC0, 0x70, 0x30, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x70, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x01,
  0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x01, 0x81, 0xE0, 0xF0, 0x03, 0x0E, 0x00,
  0x70, 0x04, 0x30, 0x00, 0x70, 0x08, 0xC0, 0x00, 0x60, 0x33, 0x00, 0x00,
  0xC0, 0x6C, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x01, 0x81, 0x40, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x10, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x40, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x87, 0x80, 0x00, 0x08, 0x64, 0x00, 0x00, 0x46, 0x30, 0x00,
  0x06, 0x60, 0x80, 0x00, 0x36, 0x06, 0x00, 0x01, 0x60, 0x10, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x40, 0x02, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x60, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x18, 0x38, 0x3C, 0x01, 0xE1, 0xE0, 0x04, 0x38, 0x03,
  0x81, 0xC0, 0x0C, 0x01, 0x1C, 0x00, 0x60, 0xE0, 0x01, 0x80, 0x4C, 0x00,
  0x0C, 0x70, 0x00, 0x60, 0x32, 0x00, 0x03, 0x18, 0x00, 0x08, 0x0D, 0x80,
  0x00, 0xCC, 0x00, 0x03, 0x02, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xC0, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x03, 0x01, 0xFF, 0xC0, 0x06, 0x07, 0x83, 0xC0, 0x0C,
  0x38, 0x01, 0xC0, 0x10, 0xC0, 0x01, 0xC0, 0x23, 0x00, 0x01, 0x80, 0xCC,
  0x00, 0x03, 0x01, 0xB0, 0x00, 0x02, 0x02, 0xC0, 0x00, 0x06, 0x05, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x10, 0x38, 0x00, 0x00, 0x20, 0x70, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x06, 0x03, 0xFF, 0x00, 0x00,
  0xC1, 0xF0, 0x78, 0x00, 0x18, 0x70, 0x03, 0x80, 0x02, 0x18, 0x00, 0x38,
  0x00, 0x46, 0x00, 0x03, 0x00, 0x19, 0x80, 0x00, 0x30, 0x03, 0x60, 0x00,
  0x06, 0x00, 0x58, 0x00, 0x00, 0x40, 0x0A, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x50, 0x00, 0x00, 0x60, 0x1A, 0x00, 0x00,
  0x18, 0x03, 0x60, 0x00, 0x06, 0x00, 0x64, 0x00, 0x01, 0x80, 0x0C, 0xC0,
  0x00, 0x60, 0x01, 0x0C, 0x00, 0x38, 0x00, 0x60, 0xF0, 0x1E, 0x00, 0x0C,
  0x0F, 0xFF, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x00, 0x1E, 0x07, 0x83, 0x00, 0x70,
  0x01, 0xC3, 0x00, 0xE0, 0x00, 0x62, 0x01, 0x80, 0x00, 0x22, 0x03, 0x00,
  0x00, 0x36, 0x07, 0x00, 0x00, 0x16, 0x06, 0x00, 0x00, 0x1E, 0x0C, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x40, 0x00,
  0x01, 0x40, 0x60, 0x00, 0x03, 0x40, 0x60, 0x00, 0x06, 0xC0, 0x60, 0x00,
  0x0C, 0xC0, 0x30, 0x00, 0x18, 0xC0, 0x30, 0x00, 0x30, 0x80, 0x18, 0x00,
  0xE1, 0x80, 0x0E, 0x03, 0x81, 0x80, 0x07, 0xFF, 0x01, 0x80, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0xFF, 0x01, 0x83, 0xE1, 0x01, 0x87, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x3E, 0x07, 0xE0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x3F, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x40, 0x1F, 0xF8, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x82,
  0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x70, 0x20, 0x00, 0x03, 0x40, 0x80,
  0x00, 0x19, 0x03, 0x00, 0x00, 0xCC, 0x0C, 0x00, 0x07, 0x30, 0x38, 0x00,
  0x38, 0x80, 0x70, 0x01, 0x82, 0x00, 0xE0, 0x3C, 0x18, 0x01, 0xFF, 0xC0,
  0x60, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x18, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x05, 0x00, 0x00,
  0x4C, 0x00, 0x06, 0x80, 0x00, 0x66, 0x00, 0x03, 0x40, 0x00, 0x23, 0x00,
  0x03, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x10, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x40, 0x06, 0x06, 0x00,
  0x20, 0x20, 0x03, 0x03, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80, 0x10, 0x08,
  0x01, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x10, 0x0C, 0x01, 0x80, 0xC0, 0x08, 0x04, 0x00, 0xC0, 0x60, 0x04, 0x06,
  0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x08,
  0x10, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x61, 0x80, 0x02, 0x08, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x04, 0xF8, 0xF8, 0x00, 0x16, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x78, 0x0E, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00,
};

const GFXglyph NotoSans_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 12, 48, 14, 2, -47 },
  { 73, 15, 17, 20, 7, -47 },
  { 105, 39, 47, 41, 2, -47 },
  { 335, 31, 54, 36, 3, -50 },
  { 545, 41, 49, 50, 6, -48 },
  { 797, 39, 49, 45, 3, -48 },
  { 1036, 5, 17, 11, 7, -47 },
  { 1047, 19, 57, 16, 2, -47 },
  { 1183, 18, 57, 16, -4, -47 },
  { 1312, 27, 28, 35, 8, -50 },
  { 1407, 30, 30, 38, 5, -38 },
  { 1520, 9, 17, 12, -3, -8 },
  { 1540, 15, 2, 21, 3, -19 },
  { 1544, 4, 5, 14, 2, -4 },
  { 1547, 29, 47, 20, -3, -47 },
  { 1718, 31, 49, 36, 4, -48 },
  { 1908, 16, 47, 36, 11, -47 },
  { 2002, 32, 48, 36, 1, -48 },
  { 2194, 34, 49, 36, 1, -48 },
  { 2403, 34, 47, 36, 1, -47 },
  { 2603, 32, 48, 36, 3, -47 },
  { 2795, 32, 49, 36, 4, -48 },
  { 2991, 29, 47, 36, 8, -47 },
  { 3162, 32, 49, 36, 3, -48 },
  { 3358, 32, 49, 36, 3, -48 },
  { 3554, 10, 36, 14, 2, -35 },
  { 3599, 15, 44, 14, -3, -35 },
  { 3682, 30, 30, 38, 5, -39 },
  { 3795, 30, 15, 38, 5, -31 },
  { 3852, 30, 30, 38, 5, -39 },
  { 3965, 23, 49, 27, 5, -48 },
  { 4106, 49, 53, 55, 4, -47 },
  { 4431, 36, 47, 36, -3, -47 },
  { 4643, 35, 47, 39, 3, -47 },
  { 4849, 36, 49, 39, 6, -48 },
  { 5070, 39, 47, 45, 3, -47 },
  { 5300, 34, 47, 35, 3, -47 },
  { 5500, 34, 47, 32, 3, -47 },
  { 5700, 38, 49, 46, 6, -48 },
  { 5933, 42, 47, 45, 3, -47 },
  { 6180, 20, 47, 18, 1, -47 },
  { 6298, 26, 58, 15, -11, -47 },
  { 6487, 39, 47, 36, 3, -47 },
  { 6717, 24, 47, 32, 3, -47 },
  { 6858, 50, 47, 53, 3, -47 },
  { 7152, 41, 47, 44, 3, -47 },
  { 7393, 39, 49, 47, 6, -48 },
  { 7632, 34, 47, 37, 3, -47 },
  { 7832, 39, 59, 47, 6, -48 },
  { 8120, 34, 47, 37, 3, -47 },
  { 8320, 33, 49, 33, 1, -48 },
  { 8523, 32, 47, 32, 6, -47 },
  { 8711, 40, 48, 46, 6, -47 },
  { 8951, 33, 47, 35, 7, -47 },
  { 9145, 51, 47, 55, 8, -47 },
  { 9445, 41, 47, 32, -4, -47 },
  { 9686, 32, 47, 32, 6, -47 },
  { 9874, 39, 47, 36, -1, -47 },
  { 10104, 25, 57, 20, -1, -47 },
  { 10283, 11, 47, 20, 6, -47 },
  { 10348, 25, 57, 20, -5, -47 },
  { 10527, 30, 29, 36, 3, -47 },
  { 10636, 25, 2, 24, -6, 7 },
  { 10643, 7, 11, 15, 10, -51 },
  { 10653, 31, 37, 36, 3, -36 },
  { 10797, 32, 51, 37, 2, -50 },
  { 11001, 26, 37, 30, 4, -36 },
  { 11122, 35, 51, 37, 3, -50 },
  { 11346, 26, 37, 32, 4, -36 },
  { 11467, 36, 66, 17, -9, -50 },
  { 11764, 33, 52, 37, 2, -36 },
  { 11979, 31, 50, 37, 2, -50 },
  { 12173, 12, 48, 14, 2, -48 },
  { 12245, 23, 64, 14, -9, -48 },
  { 12429, 29, 50, 29, 2, -50 },
  { 12611, 12, 50, 14, 2, -50 },
  { 12686, 50, 36, 56, 2, -36 },
  { 12911, 31, 36, 37, 2, -36 },
  { 13051, 30, 37, 37, 4, -36 },
  { 13190, 35, 51, 37, -1, -36 },
  { 13414, 32, 51, 37, 3, -36 },
  { 13618, 24, 35, 24, 2, -35 },
  { 13723, 25, 37, 28, 1, -36 },
  { 13839, 19, 45, 20, 3, -44 },
  { 13946, 30, 36, 37, 4, -35 },
  { 14081, 27, 35, 27, 3, -35 },
  { 14200, 41, 35, 43, 4, -35 },
  { 14380, 33, 35, 30, -2, -35 },
  { 14525, 38, 51, 27, -8, -35 },
  { 14768, 30, 35, 29, -1, -35 },
  { 14900, 23, 57, 22, 2, -47 },
  { 15064, 1, 66, 35, 19, -50 },
  { 15073, 23, 58, 22, -3, -47 },
  { 15240, 30, 6, 38, 5, -26 },
};

const GFXfont NotoSans_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_THINITALIC66PT7B_H_
