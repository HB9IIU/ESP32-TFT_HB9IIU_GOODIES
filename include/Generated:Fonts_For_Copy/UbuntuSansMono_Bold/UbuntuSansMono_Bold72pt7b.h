#ifndef _UBUNTUSANSMONO_BOLD72PT7B_H_
#define _UBUNTUSANSMONO_BOLD72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF9, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F,
  0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFE, 0x07, 0xFF,
  0x00, 0x01, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF1, 0x80, 0x00, 0x0F,
  0xFC, 0x7C, 0x00, 0x03, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xFF,
  0x00, 0x00, 0xFE, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xFF, 0x80, 0x01,
  0xFC, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0x9F, 0xC0, 0x07, 0xF8, 0x7F,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x7F, 0x80, 0x7E, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xFF, 0xC3, 0xF8, 0x00, 0x3F,
  0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0x1F, 0xFF, 0x8F,
  0xE0, 0x00, 0x0F, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0xF8, 0x00,
  0x07, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0xE3,
  0xFD, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xFF,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x03, 0xF0, 0x7E, 0x0F, 0xF0, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x03,
  0xFD, 0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xFC,
  0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x02, 0x00, 0x00,
  0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xF8,
  0x7F, 0xC3, 0xFF, 0xBF, 0xC7, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F,
  0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x7F,
  0x80, 0x0F, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xE0, 0x01, 0xFF,
  0xC0, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF7, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x1F, 0xE0, 0x18, 0x3F, 0x07, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xF9, 0xF8, 0xFF, 0x8F, 0xFE, 0x7D,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF,
  0xF8, 0x1F, 0x07, 0xFD, 0xFF, 0x07, 0xF0, 0xFF, 0xBF, 0xE1, 0xFE, 0x1F,
  0xF7, 0xFC, 0x3F, 0xC3, 0xFE, 0xFF, 0x87, 0xFC, 0x7F, 0xDF, 0xF0, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xEF, 0xF8,
  0x3F, 0x87, 0xFD, 0xFF, 0x03, 0xE0, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0x04, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xF0, 0x38, 0x00,
  0x1F, 0xFC, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xFC, 0x07, 0xC0, 0x0F, 0xFF, 0x03, 0x80, 0x03, 0xFF, 0x81, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x98, 0x00, 0x03, 0xFF, 0xCF, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x20, 0x00, 0x07, 0xFF, 0x3C, 0x00, 0x0F,
  0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xEF, 0xFC,
  0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x00,
  0x7F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xF8, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x1E, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3,
  0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0xCC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xF9, 0xFC, 0x03, 0xFF,
  0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xF7, 0xF8,
  0x1F, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF,
  0xEF, 0xE0, 0xFF, 0xF3, 0xFF, 0x7F, 0x07, 0xFE, 0x0F, 0xFB, 0xF8, 0x3F,
  0xE0, 0x7F, 0xDF, 0xC1, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xE0,
  0x3F, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8,
  0x7F, 0xC0, 0x7F, 0xDF, 0xC1, 0xFE, 0x03, 0xFE, 0xFE, 0x0F, 0xF0, 0x1F,
  0xF7, 0xF0, 0x7F, 0xC0, 0xFF, 0xBF, 0x83, 0xFE, 0x07, 0xFD, 0xFC, 0x1F,
  0xF8, 0x3F, 0xEF, 0xE0, 0xFF, 0xE1, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xFB,
  0xFC, 0x1F, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0x01, 0xFF,
  0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F,
  0x00, 0x7F, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x01, 0x81, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x06, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x0C, 0x00,
  0x07, 0xFF, 0x1E, 0x00, 0x0F, 0xFE, 0x1F, 0x80, 0x3F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0xE0, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0xE3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xCF, 0xFC,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x07,
  0xEF, 0xE3, 0xFF, 0xE0, 0x7E, 0xFE, 0x3F, 0xFF, 0x07, 0xEF, 0xE7, 0xFB,
  0xF0, 0xFE, 0xFE, 0x7F, 0xBF, 0x0F, 0xCF, 0xE7, 0xFB, 0xF8, 0xFC, 0xFE,
  0x7F, 0x9F, 0x9F, 0xCF, 0xE7, 0xF9, 0xF9, 0xF8, 0xFE, 0x7F, 0x9F, 0x9F,
  0x8F, 0xE7, 0xF9, 0xFF, 0xF8, 0xFE, 0x7F, 0x8F, 0xFF, 0x8F, 0xE7, 0xF8,
  0xFF, 0xF0, 0xFE, 0x7F, 0x8F, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0xF0, 0xFE,
  0x7F, 0x87, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xE0, 0xFF, 0x7F, 0x87, 0xFE,
  0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0xFF, 0x7F, 0x83, 0xFC, 0x0F, 0xF7, 0xF8,
  0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xF9,
  0xFE, 0x0F, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF,
  0xE0, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF,
  0xFC, 0x0F, 0xF7, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x3F, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x00,
  0x81, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x10, 0x00, 0x01, 0xFF, 0xC7, 0x00, 0x00, 0x7F,
  0xF3, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFE,
  0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x83, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xC1, 0xFF, 0x7F, 0x83, 0xFE,
  0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0xFF, 0x7F, 0x87, 0xFE, 0x0F, 0xF7, 0xF8,
  0x7F, 0xE0, 0xFE, 0x7F, 0x87, 0xFF, 0x0F, 0xE7, 0xF8, 0xFF, 0xF0, 0xFE,
  0x7F, 0x8F, 0xFF, 0x0F, 0xE7, 0xF8, 0xFF, 0xF8, 0xFE, 0x7F, 0x9F, 0xFF,
  0x8F, 0xE7, 0xF9, 0xFD, 0xF8, 0xFE, 0x7F, 0x9F, 0x9F, 0x8F, 0xE7, 0xF9,
  0xF9, 0xFC, 0xFE, 0x7F, 0xBF, 0x8F, 0xCF, 0xE7, 0xFB, 0xF0, 0xFC, 0xFE,
  0x7F, 0xBF, 0x0F, 0xEF, 0xE3, 0xFF, 0xF0, 0x7E, 0xFE, 0x3F, 0xFE, 0x07,
  0xEF, 0xE3, 0xFF, 0xE0, 0x7E, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0x3F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFD, 0xFF, 0xFE, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x3F, 0xF7, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0x83, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xBF, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x04,
  0x0F, 0xFF, 0xC0, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x08, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0x87, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFB, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x30, 0x00, 0x0F, 0xFE, 0x3F, 0x00, 0x3F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x10, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x10, 0x00, 0x3F,
  0xF3, 0xE0, 0x07, 0xFF, 0x3F, 0xC1, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x10, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xE0, 0x1F, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x7F, 0xFC, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF8, 0x07,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xC3,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xBF, 0xF8, 0x3F, 0xF0, 0x00, 0xF8, 0x7F, 0xE0, 0x00, 0x08,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x40, 0x00, 0x03, 0xFF,
  0x38, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x07, 0xFE, 0x7F, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x02, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x03, 0xFD, 0xFE, 0x07,
  0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xE1, 0xFE, 0x3F, 0x83, 0xFF, 0x87, 0xF8,
  0xFE, 0x1F, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF,
  0xF1, 0xFC, 0x3F, 0xC7, 0xFF, 0xC7, 0xF0, 0xFF, 0x3F, 0xFF, 0x1F, 0xC3,
  0xFC, 0xFC, 0xFE, 0x7F, 0x07, 0xF3, 0xF3, 0xFB, 0xFC, 0x1F, 0xDF, 0xCF,
  0xEF, 0xE0, 0x7F, 0x7F, 0x1F, 0xBF, 0x81, 0xFD, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF,
  0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x01, 0xFF, 0xF0, 0x01, 0xFE,
  0x1F, 0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF,
  0xF1, 0xFE, 0x01, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0x00,
  0x07, 0xFF, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Bold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 14, 51, 40, 13, -50 },
  { 91, 26, 23, 40, 7, -55 },
  { 166, 38, 50, 40, 1, -50 },
  { 404, 35, 64, 40, 3, -56 },
  { 684, 40, 52, 40, 0, -51 },
  { 944, 37, 52, 40, 2, -51 },
  { 1185, 11, 24, 40, 15, -55 },
  { 1218, 26, 71, 40, 8, -57 },
  { 1449, 26, 71, 40, 7, -57 },
  { 1680, 33, 32, 40, 4, -50 },
  { 1812, 34, 36, 40, 3, -39 },
  { 1965, 18, 25, 40, 10, -13 },
  { 2022, 22, 10, 40, 9, -26 },
  { 2050, 14, 14, 40, 13, -13 },
  { 2075, 33, 69, 40, 4, -56 },
  { 2360, 35, 52, 40, 3, -51 },
  { 2588, 33, 50, 40, 4, -50 },
  { 2795, 34, 51, 40, 3, -51 },
  { 3012, 33, 52, 40, 3, -51 },
  { 3227, 36, 50, 40, 2, -50 },
  { 3452, 33, 51, 40, 3, -50 },
  { 3663, 33, 51, 40, 4, -50 },
  { 3874, 33, 50, 40, 4, -50 },
  { 4081, 34, 52, 40, 3, -51 },
  { 4302, 33, 51, 40, 4, -51 },
  { 4513, 14, 38, 40, 13, -37 },
  { 4580, 17, 49, 40, 10, -37 },
  { 4685, 33, 35, 40, 4, -38 },
  { 4830, 34, 24, 40, 3, -33 },
  { 4932, 34, 35, 40, 3, -38 },
  { 5081, 29, 52, 40, 6, -51 },
  { 5270, 37, 62, 40, 1, -51 },
  { 5557, 39, 50, 40, 1, -50 },
  { 5801, 34, 51, 40, 4, -50 },
  { 6018, 36, 52, 40, 2, -51 },
  { 6252, 34, 51, 40, 4, -50 },
  { 6469, 32, 50, 40, 5, -50 },
  { 6669, 31, 50, 40, 5, -50 },
  { 6863, 35, 52, 40, 2, -51 },
  { 7091, 33, 50, 40, 4, -50 },
  { 7298, 32, 50, 40, 4, -50 },
  { 7498, 32, 51, 40, 3, -50 },
  { 7702, 35, 50, 40, 4, -50 },
  { 7921, 31, 50, 40, 6, -50 },
  { 8115, 36, 50, 40, 2, -50 },
  { 8340, 33, 50, 40, 4, -50 },
  { 8547, 36, 52, 40, 2, -51 },
  { 8781, 34, 50, 40, 4, -50 },
  { 8994, 36, 65, 40, 2, -51 },
  { 9287, 35, 50, 40, 4, -50 },
  { 9506, 34, 52, 40, 3, -51 },
  { 9727, 36, 50, 40, 2, -50 },
  { 9952, 34, 51, 40, 3, -50 },
  { 10169, 38, 50, 40, 1, -50 },
  { 10407, 36, 50, 40, 2, -50 },
  { 10632, 38, 50, 40, 1, -50 },
  { 10870, 38, 50, 40, 1, -50 },
  { 11108, 33, 50, 40, 4, -50 },
  { 11315, 22, 69, 40, 9, -56 },
  { 11505, 33, 69, 40, 4, -56 },
  { 11790, 22, 69, 40, 9, -56 },
  { 11980, 39, 29, 40, 1, -50 },
  { 12122, 39, 8, 40, 1, 5 },
  { 12161, 18, 15, 40, 12, -56 },
  { 12195, 32, 40, 40, 4, -39 },
  { 12355, 33, 57, 40, 5, -56 },
  { 12591, 34, 40, 40, 4, -39 },
  { 12761, 33, 57, 40, 2, -56 },
  { 12997, 35, 40, 40, 3, -39 },
  { 13172, 37, 56, 40, 3, -56 },
  { 13431, 32, 53, 40, 3, -39 },
  { 13643, 31, 56, 40, 5, -56 },
  { 13860, 35, 57, 40, 3, -56 },
  { 14110, 28, 70, 40, 4, -56 },
  { 14355, 34, 56, 40, 5, -56 },
  { 14593, 35, 57, 40, 3, -56 },
  { 14843, 36, 38, 40, 2, -38 },
  { 15014, 31, 39, 40, 5, -39 },
  { 15166, 36, 40, 40, 2, -39 },
  { 15346, 33, 52, 40, 5, -39 },
  { 15561, 32, 52, 40, 3, -39 },
  { 15769, 30, 39, 40, 7, -39 },
  { 15916, 32, 40, 40, 4, -39 },
  { 16076, 35, 50, 40, 3, -49 },
  { 16295, 30, 39, 40, 5, -38 },
  { 16442, 38, 38, 40, 1, -38 },
  { 16623, 38, 38, 40, 1, -38 },
  { 16804, 37, 38, 40, 2, -38 },
  { 16980, 36, 52, 40, 2, -38 },
  { 17214, 30, 38, 40, 5, -38 },
  { 17357, 30, 69, 40, 5, -56 },
  { 17616, 10, 69, 40, 15, -56 },
  { 17703, 30, 69, 40, 5, -56 },
  { 17962, 37, 15, 40, 2, -29 },
};

const GFXfont UbuntuSansMono_Bold72pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold72pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold72pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _UBUNTUSANSMONO_BOLD72PT7B_H_
