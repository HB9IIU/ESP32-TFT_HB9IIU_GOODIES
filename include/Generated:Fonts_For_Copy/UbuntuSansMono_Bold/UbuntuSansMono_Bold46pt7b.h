#ifndef _UBUNTUSANSMONO_BOLD46PT7B_H_
#define _UBUNTUSANSMONO_BOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x07, 0xEF, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x03, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC3, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0x1F, 0xC0,
  0x0C, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x20, 0x01, 0xFD,
  0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xF3, 0xFE, 0x00, 0xF9, 0xFF, 0x80, 0x7C, 0x7D, 0xF0,
  0x1E, 0x1E, 0x7C, 0x0F, 0x87, 0x8F, 0x03, 0xC3, 0xE3, 0xC1, 0xE0, 0xF8,
  0xF0, 0xF8, 0x1E, 0x3C, 0x3C, 0x07, 0x8F, 0x1F, 0x01, 0xE7, 0xCF, 0x80,
  0x7F, 0xE3, 0xC0, 0x1F, 0xF9, 0xF0, 0x03, 0xFC, 0xF8, 0x00, 0x7E, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xCF, 0xC0, 0x01,
  0xF7, 0xF8, 0x00, 0xF9, 0xFF, 0x00, 0x3C, 0xFF, 0xE0, 0x1F, 0x3C, 0xF8,
  0x0F, 0x8F, 0x1E, 0x03, 0xC3, 0xC7, 0x81, 0xF0, 0xF1, 0xE0, 0xF8, 0x3C,
  0x78, 0x3C, 0x0F, 0x1E, 0x1F, 0x03, 0xC7, 0x8F, 0x80, 0xFB, 0xE3, 0xC0,
  0x1F, 0xF1, 0xF0, 0x07, 0xFC, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x9F, 0x80,
  0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x40,
  0x07, 0xF0, 0x7E, 0x1F, 0xF8, 0x7E, 0x3F, 0xFC, 0x7C, 0x3F, 0xFE, 0x7C,
  0x7E, 0x7F, 0x7C, 0x7C, 0x3F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xF8,
  0xF8, 0x0F, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xF8,
  0x7F, 0xBF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0x7E, 0x1F, 0xFE, 0x7E,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x79, 0xE7, 0x80, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x04, 0x10,
  0x00, 0x0C, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x20, 0xFC, 0x10, 0xF1, 0xE1, 0xC7, 0xE7, 0x9F, 0x1F, 0xFE, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0,
  0x3E, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xC0, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0x00, 0xFC, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0xBF, 0xC7, 0xF8, 0x7F, 0x07, 0xC0,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F,
  0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0xC0, 0xFE, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF1, 0xC3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3F, 0x3F, 0xFC, 0xFC, 0xFF,
  0xF3, 0xF3, 0xFF, 0xC7, 0x8F, 0xFF, 0x0C, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFD, 0xF8, 0x03, 0xC7, 0xE0, 0x0C, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xE0, 0xFF, 0x0E, 0x01,
  0xFC, 0x10, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xF0, 0x3F, 0xC2, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0xE0, 0x0F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xD8, 0x03, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xCF,
  0xE1, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F,
  0x03, 0xF0, 0xFF, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC7, 0xFC, 0x7E, 0x07, 0xF9,
  0xF8, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFE, 0x7E, 0x01,
  0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFE, 0x3F, 0x02, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xF3,
  0xFF, 0x3F, 0xE1, 0xFE, 0x0F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x7F, 0x8F,
  0xF0, 0xFE, 0x07, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF7, 0x03, 0xFD, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0x3F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x1F, 0xFB, 0xE0, 0xFF, 0xF7, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x7F, 0x3F, 0xF8, 0xFC, 0x3F, 0xF1, 0xF0, 0x7F, 0xE3,
  0xE0, 0xFF, 0xC7, 0xC1, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0x07, 0xFE, 0x3E,
  0x0F, 0xFC, 0x7C, 0x1F, 0xF8, 0xFC, 0x3F, 0xF1, 0xFC, 0x7F, 0xE1, 0xFF,
  0xFB, 0xC3, 0xFF, 0xF7, 0xC3, 0xFF, 0xEF, 0x83, 0xFF, 0xDF, 0x01, 0xFF,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFD,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0, 0x1F,
  0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8,
  0x1F, 0xCF, 0xC3, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0x03, 0xFD, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFC, 0x07, 0x0F, 0xE0, 0x02, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x10,
  0xFF, 0x00, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x2F, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7E, 0x3F, 0xF3,
  0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFC,
  0x07, 0xF7, 0xE0, 0x7F, 0xBF, 0x0F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x0F,
  0x1F, 0xE0, 0x02, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x07,
  0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF1, 0x80, 0x3F, 0x8F, 0x03,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC,
  0x7F, 0xC7, 0xBC, 0x7D, 0xE7, 0xBE, 0x7D, 0xE7, 0xBE, 0x7D, 0xEF, 0xBE,
  0x7D, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFE, 0x3E,
  0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7C, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x7F, 0xF3, 0xE3,
  0xFF, 0x8F, 0x9F, 0xFC, 0x7C, 0xFF, 0xE1, 0xF7, 0xFF, 0x0F, 0xBF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFC, 0xFE,
  0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xF8,
  0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7E, 0x0F, 0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x7F, 0x00,
  0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFC, 0x7E,
  0x03, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0,
  0xFF, 0x8F, 0xC0, 0xFF, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0xCF,
  0xC1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xF0, 0x0E, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF2, 0x00, 0x1F, 0x9E, 0x00, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0B, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x3C, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C,
  0xFE, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7D,
  0xEF, 0x3E, 0x7D, 0xE7, 0xBE, 0x7D, 0xE7, 0xBE, 0x7F, 0xC7, 0xBE, 0x7F,
  0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F,
  0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xF7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC,
  0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x1C, 0x00, 0x38, 0x04, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x10, 0x07, 0x00, 0xF0, 0x3F, 0x0F, 0xF9, 0xFF, 0x8F, 0xF8, 0x3E,
  0x01, 0xC0, 0x10, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF0, 0x3F, 0xBF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x9F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x02, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x28, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xE3, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFC,
  0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFC, 0xFE, 0x07, 0xE7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0x9F,
  0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1C, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x01,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xF3, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0xE0,
  0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0x80,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xD0, 0x07, 0xE7, 0x83, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xE0, 0x00,
  0x06, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xFB,
  0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x20, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x7F, 0xF7, 0xF9, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x8F, 0xFF,
  0x1F, 0x0F, 0xFE, 0x3E, 0x1F, 0xFC, 0x7C, 0x3F, 0xF8, 0xF8, 0x7F, 0xF1,
  0xF0, 0xFF, 0xE3, 0xE1, 0xFF, 0xC7, 0xC3, 0xFF, 0x8F, 0x87, 0xFF, 0x1F,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xE0, 0x7F, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x07,
  0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xFC,
  0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xF1, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x02, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xE3, 0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x00, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x40, 0x03, 0xF7, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x0A, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x30, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3E, 0xF8, 0x7E, 0x3E,
  0x78, 0x7E, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E,
  0x7D, 0xFF, 0x3E, 0x7D, 0xEF, 0xBC, 0x7D, 0xE7, 0xBC, 0x3D, 0xE7, 0xBC,
  0x3F, 0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF0,
  0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0,
  0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xFC,
  0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7E,
  0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFE,
  0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01,
  0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x1C, 0x1F, 0xF8, 0x1F, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0xF8, 0x0F,
  0xF8, 0x18, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 33, 26, 9, -32 },
  { 34, 17, 14, 26, 4, -35 },
  { 64, 24, 32, 26, 1, -32 },
  { 160, 22, 41, 26, 2, -36 },
  { 273, 26, 34, 26, 0, -33 },
  { 384, 24, 33, 26, 1, -33 },
  { 483, 6, 15, 26, 10, -35 },
  { 495, 16, 46, 26, 5, -37 },
  { 587, 17, 46, 26, 4, -37 },
  { 685, 22, 20, 26, 2, -32 },
  { 740, 22, 23, 26, 2, -25 },
  { 804, 12, 17, 26, 6, -9 },
  { 830, 14, 6, 26, 6, -16 },
  { 841, 10, 10, 26, 8, -9 },
  { 854, 21, 45, 26, 2, -36 },
  { 973, 22, 34, 26, 2, -33 },
  { 1067, 22, 32, 26, 2, -32 },
  { 1155, 22, 33, 26, 2, -33 },
  { 1246, 21, 34, 26, 2, -33 },
  { 1336, 23, 32, 26, 1, -32 },
  { 1428, 21, 33, 26, 2, -32 },
  { 1515, 21, 33, 26, 2, -32 },
  { 1602, 20, 32, 26, 3, -32 },
  { 1682, 22, 34, 26, 2, -33 },
  { 1776, 22, 33, 26, 2, -33 },
  { 1867, 10, 26, 26, 8, -25 },
  { 1900, 12, 33, 26, 6, -25 },
  { 1950, 22, 22, 26, 2, -24 },
  { 2011, 22, 15, 26, 2, -21 },
  { 2053, 22, 22, 26, 2, -24 },
  { 2114, 18, 34, 26, 4, -33 },
  { 2191, 23, 40, 26, 1, -33 },
  { 2306, 25, 32, 26, 0, -32 },
  { 2406, 21, 32, 26, 3, -32 },
  { 2490, 23, 34, 26, 1, -33 },
  { 2588, 21, 32, 26, 3, -32 },
  { 2672, 21, 32, 26, 3, -32 },
  { 2756, 20, 32, 26, 3, -32 },
  { 2836, 23, 34, 26, 1, -33 },
  { 2934, 21, 32, 26, 2, -32 },
  { 3018, 20, 32, 26, 3, -32 },
  { 3098, 21, 33, 26, 2, -32 },
  { 3185, 23, 32, 26, 2, -32 },
  { 3277, 20, 32, 26, 4, -32 },
  { 3357, 24, 32, 26, 1, -32 },
  { 3453, 21, 32, 26, 2, -32 },
  { 3537, 23, 34, 26, 1, -33 },
  { 3635, 21, 32, 26, 3, -32 },
  { 3719, 23, 41, 26, 1, -32 },
  { 3837, 22, 32, 26, 3, -32 },
  { 3925, 22, 34, 26, 2, -33 },
  { 4019, 23, 32, 26, 1, -32 },
  { 4111, 22, 33, 26, 2, -32 },
  { 4202, 24, 32, 26, 1, -32 },
  { 4298, 24, 32, 26, 1, -32 },
  { 4394, 24, 32, 26, 1, -32 },
  { 4490, 24, 32, 26, 1, -32 },
  { 4586, 21, 32, 26, 2, -32 },
  { 4670, 14, 45, 26, 6, -36 },
  { 4749, 20, 45, 26, 3, -36 },
  { 4862, 14, 45, 26, 6, -36 },
  { 4941, 24, 19, 26, 1, -32 },
  { 4998, 25, 6, 26, 0, 3 },
  { 5017, 11, 10, 26, 8, -36 },
  { 5031, 21, 26, 26, 2, -25 },
  { 5100, 21, 37, 26, 3, -36 },
  { 5198, 22, 26, 26, 2, -25 },
  { 5270, 21, 37, 26, 1, -36 },
  { 5368, 22, 26, 26, 2, -25 },
  { 5440, 23, 36, 26, 2, -36 },
  { 5544, 21, 34, 26, 2, -25 },
  { 5634, 20, 36, 26, 3, -36 },
  { 5724, 22, 37, 26, 2, -36 },
  { 5826, 18, 45, 26, 3, -36 },
  { 5928, 22, 36, 26, 3, -36 },
  { 6027, 22, 36, 26, 2, -35 },
  { 6126, 23, 24, 26, 1, -24 },
  { 6195, 20, 25, 26, 3, -25 },
  { 6258, 23, 26, 26, 1, -25 },
  { 6333, 21, 34, 26, 3, -25 },
  { 6423, 21, 34, 26, 2, -25 },
  { 6513, 19, 25, 26, 5, -25 },
  { 6573, 20, 26, 26, 3, -25 },
  { 6638, 22, 32, 26, 2, -31 },
  { 6726, 20, 25, 26, 3, -24 },
  { 6789, 24, 24, 26, 1, -24 },
  { 6861, 24, 24, 26, 1, -24 },
  { 6933, 24, 24, 26, 1, -24 },
  { 7005, 23, 33, 26, 1, -24 },
  { 7100, 19, 24, 26, 3, -24 },
  { 7157, 20, 45, 26, 3, -36 },
  { 7270, 6, 45, 26, 10, -36 },
  { 7304, 20, 45, 26, 3, -36 },
  { 7417, 24, 9, 26, 1, -18 },
};

const GFXfont UbuntuSansMono_Bold46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_BOLD46PT7B_H_
