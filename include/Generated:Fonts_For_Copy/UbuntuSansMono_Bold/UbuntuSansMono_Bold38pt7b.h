#ifndef _UBUNTUSANSMONO_BOLD38PT7B_H_
#define _UBUNTUSANSMONO_BOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x00, 0x00, 0x00, 0x87, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x40, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xEF,
  0x8F, 0xBE, 0x1E, 0xF8, 0x79, 0xE1, 0xE7, 0x07, 0x9C, 0x1E, 0x03, 0xC3,
  0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78,
  0x07, 0xC7, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0x01,
  0x8F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xC0, 0x3F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x03, 0xDF, 0xE0, 0x3C, 0xF7, 0x81, 0xC7, 0x3C, 0x1E, 0x79,
  0xE1, 0xE3, 0xC7, 0x0E, 0x1E, 0x78, 0xF0, 0x73, 0xCF, 0x03, 0x9E, 0x70,
  0x1F, 0xE7, 0x80, 0x7F, 0x78, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC6, 0x00, 0x1C, 0xFC, 0x01, 0xEF, 0xF0, 0x1E, 0x7F, 0x80, 0xE7, 0x9E,
  0x0F, 0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x8F, 0x3C, 0x78, 0x79, 0xE7, 0x81,
  0xCF, 0x3C, 0x0F, 0xF3, 0xC0, 0x7F, 0xBC, 0x01, 0xF8, 0x00, 0x01, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x3E,
  0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE2, 0x01, 0xFC, 0x3E, 0x3F,
  0xE3, 0xC7, 0xFF, 0x3C, 0x7D, 0xFB, 0xCF, 0x8F, 0xBC, 0xF8, 0x7F, 0xCF,
  0x03, 0xF8, 0xF0, 0x3F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xBE, 0x0F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xDE, 0xF7, 0x00, 0x00, 0x30, 0x01, 0xE0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0x30, 0x60, 0x03,
  0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0x87, 0x84, 0x79, 0xE7, 0x1F, 0x77,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x7D, 0xF0, 0x3F, 0x3E, 0x0F, 0xCF, 0xC1, 0xE3, 0xC0, 0x10, 0x60, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F,
  0xC7, 0xF1, 0xFC, 0x0E, 0x07, 0x87, 0xCF, 0xE1, 0xF0, 0x78, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x1F, 0x1F,
  0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0x7D, 0xE1, 0x0F, 0xBC,
  0x71, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFB, 0xC7, 0x1F, 0x78,
  0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C,
  0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x71, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1E, 0x0F, 0xC2, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF1, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x81, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFD, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07,
  0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xD8, 0x07, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x7C, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0x7F, 0x9F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF,
  0x03, 0xE7, 0xE1, 0xF1, 0xFE, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0xE1, 0xFB, 0xFC, 0x7C, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0, 0x0F, 0x1F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3, 0xF0, 0x78, 0x38, 0x7D,
  0xFC, 0xFC, 0x78, 0x20, 0x00, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x03, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x60, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xF7, 0xFF, 0xE8, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF0, 0x7C, 0x78,
  0x07, 0x9F, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x3F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xBF, 0xE7, 0xC7, 0xFC, 0xF8, 0xFF, 0x9F,
  0x1F, 0xF3, 0xE3, 0xFE, 0x7C, 0x7F, 0xCF, 0x8F, 0xF9, 0xF1, 0xFF, 0x3F,
  0x3F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFB, 0x87, 0xFF, 0x78, 0x7F, 0xEF, 0x00,
  0xC0, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x04, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFF,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF,
  0x07, 0xCF, 0xC3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xF1, 0xFE, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x01, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x30, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x1F,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x0F,
  0xCF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x0F,
  0xEF, 0xC7, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0x01, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7,
  0xE0, 0x7E, 0xFE, 0x0F, 0xCF, 0xE1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE2, 0x03, 0xF3, 0xC3, 0xF9, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0xF8, 0x0F, 0xDF,
  0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E,
  0x3F, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xC0, 0xF9,
  0xFC, 0x1F, 0x1F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0,
  0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0x73,
  0xF8, 0xEE, 0x7F, 0xBD, 0xCF, 0x77, 0xBD, 0xEE, 0xE7, 0xBD, 0xFC, 0xF7,
  0x9F, 0x9F, 0xF3, 0xE3, 0xFE, 0x7C, 0x7F, 0xCF, 0x8F, 0xF8, 0xF1, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFE, 0xF1, 0xFF, 0x7C, 0xFF, 0x9E,
  0x7F, 0xCF, 0xBF, 0xE3, 0xDF, 0xF1, 0xEF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xC7, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x20, 0x00,
  0x0F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x3F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7C, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x03,
  0xF7, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F, 0xC3, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x0F, 0x80,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0x7F,
  0x3F, 0x07, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0x9F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x3E, 0x3F, 0x07, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x80, 0xFB,
  0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xBE, 0x3F, 0x00, 0x8F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xD0, 0x03, 0xE7, 0x01, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x83, 0xFF, 0xC0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xE7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x08, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x00, 0xF1,
  0xF0, 0x0F, 0x9E, 0x00, 0xF9, 0xE0, 0x0F, 0xBE, 0x00, 0x7B, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x1E, 0x3F, 0xE7, 0xC7, 0xFC, 0xF8, 0xFF, 0x9F, 0x9E, 0xF7, 0xF3, 0xDE,
  0xFE, 0x7B, 0xDD, 0xCF, 0x7B, 0xBD, 0xEF, 0xF3, 0xBD, 0xFC, 0x77, 0x3F,
  0x8F, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0x7C, 0x0F,
  0x83, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F,
  0xC0, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7E,
  0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x00,
  0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xBF, 0x01, 0xF9, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xEF,
  0xE0, 0x7E, 0xFC, 0x03, 0xF7, 0x80, 0x3E, 0x18, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x0F, 0x07, 0xE3, 0xFE, 0x3F, 0xC3, 0xE0, 0x30, 0x00, 0x80, 0x1F,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x08, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB,
  0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C,
  0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xE0, 0x47,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFD, 0xF8, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7E, 0x0F, 0xBF, 0x87, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x81, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFE, 0x0C, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x0F,
  0xDF, 0x83, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1C, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x90, 0x07, 0xE3, 0xC3, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x01,
  0xFF, 0x00, 0x08, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x80, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xD8, 0x1F, 0xBE, 0x7F, 0x7F, 0xFD, 0xFF, 0xFB,
  0xFF, 0xE0, 0xFF, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x83, 0xFB, 0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F,
  0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0x9F, 0x83, 0xE3, 0xE0, 0xF8, 0xFC,
  0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x07, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x80, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x9F, 0x9F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x1E, 0x3F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x87,
  0x8F, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x78, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x1F,
  0x9F, 0x81, 0xF3, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x3E,
  0x7F, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF8,
  0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x0F,
  0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFD, 0xFC,
  0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF0, 0x31, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x7E, 0x80, 0x1F, 0x70, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF,
  0xC3, 0xFF, 0x80, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x20, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC,
  0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xFB, 0xF0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x87, 0x8F, 0x3C, 0x7C, 0x79,
  0xE3, 0xE3, 0xCF, 0x1F, 0x1E, 0x78, 0xFC, 0xF3, 0xC7, 0xE7, 0x8F, 0x7F,
  0x3C, 0x7B, 0xB9, 0xC3, 0xDD, 0xEE, 0x1F, 0xEF, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0x80, 0xFC, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xF9,
  0xF0, 0x1F, 0x7E, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x7E, 0x07, 0xE7,
  0xC0, 0xF8, 0xFC, 0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0xFC, 0x01,
  0xF0, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0x7D, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x11, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0x1F, 0x00, 0xC3, 0xFC, 0x1F, 0x7F, 0xFB, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0x8F, 0xFC, 0xF0, 0x3F, 0x81, 0x00, 0x60,
};

const GFXglyph UbuntuSansMono_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 27, 21, 7, -26 },
  { 25, 14, 12, 21, 4, -29 },
  { 46, 20, 26, 21, 1, -26 },
  { 111, 19, 33, 21, 1, -29 },
  { 190, 21, 28, 21, 0, -27 },
  { 264, 20, 27, 21, 1, -27 },
  { 332, 5, 13, 21, 8, -29 },
  { 341, 14, 37, 21, 4, -30 },
  { 406, 13, 37, 21, 4, -30 },
  { 467, 18, 16, 21, 2, -26 },
  { 503, 18, 19, 21, 2, -21 },
  { 546, 10, 14, 21, 5, -7 },
  { 564, 11, 5, 21, 5, -13 },
  { 571, 7, 7, 21, 7, -7 },
  { 578, 17, 37, 21, 2, -30 },
  { 657, 19, 28, 21, 1, -27 },
  { 724, 18, 26, 21, 2, -26 },
  { 783, 18, 27, 21, 2, -27 },
  { 844, 17, 28, 21, 2, -27 },
  { 904, 19, 26, 21, 1, -26 },
  { 966, 18, 27, 21, 1, -26 },
  { 1027, 17, 28, 21, 2, -27 },
  { 1087, 17, 26, 21, 2, -26 },
  { 1143, 18, 28, 21, 2, -27 },
  { 1206, 17, 27, 21, 2, -27 },
  { 1264, 7, 20, 21, 7, -20 },
  { 1282, 9, 27, 21, 5, -20 },
  { 1313, 18, 18, 21, 2, -20 },
  { 1354, 18, 12, 21, 2, -17 },
  { 1381, 18, 18, 21, 2, -20 },
  { 1422, 15, 28, 21, 3, -27 },
  { 1475, 19, 33, 21, 1, -27 },
  { 1554, 21, 26, 21, 0, -26 },
  { 1623, 18, 27, 21, 2, -27 },
  { 1684, 19, 28, 21, 1, -27 },
  { 1751, 18, 27, 21, 2, -27 },
  { 1812, 17, 26, 21, 3, -26 },
  { 1868, 16, 26, 21, 3, -26 },
  { 1920, 19, 28, 21, 1, -27 },
  { 1987, 17, 26, 21, 2, -26 },
  { 2043, 17, 26, 21, 2, -26 },
  { 2099, 17, 27, 21, 2, -26 },
  { 2157, 19, 26, 21, 2, -26 },
  { 2219, 17, 26, 21, 3, -26 },
  { 2275, 19, 26, 21, 1, -26 },
  { 2337, 17, 26, 21, 2, -26 },
  { 2393, 19, 28, 21, 1, -27 },
  { 2460, 18, 27, 21, 2, -27 },
  { 2521, 19, 34, 21, 1, -27 },
  { 2602, 19, 27, 21, 2, -27 },
  { 2667, 18, 28, 21, 2, -27 },
  { 2730, 19, 26, 21, 1, -26 },
  { 2792, 18, 27, 21, 2, -26 },
  { 2853, 20, 26, 21, 1, -26 },
  { 2918, 19, 26, 21, 1, -26 },
  { 2980, 21, 26, 21, 0, -26 },
  { 3049, 20, 26, 21, 1, -26 },
  { 3114, 17, 26, 21, 2, -26 },
  { 3170, 12, 37, 21, 5, -30 },
  { 3226, 17, 37, 21, 2, -30 },
  { 3305, 11, 37, 21, 5, -30 },
  { 3356, 20, 15, 21, 1, -26 },
  { 3394, 21, 5, 21, 0, 2 },
  { 3408, 10, 7, 21, 6, -29 },
  { 3417, 17, 21, 21, 2, -21 },
  { 3462, 17, 30, 21, 3, -30 },
  { 3526, 18, 21, 21, 2, -21 },
  { 3574, 17, 30, 21, 1, -30 },
  { 3638, 19, 21, 21, 1, -21 },
  { 3688, 19, 29, 21, 2, -29 },
  { 3757, 18, 27, 21, 1, -20 },
  { 3818, 16, 30, 21, 3, -30 },
  { 3878, 18, 29, 21, 2, -29 },
  { 3944, 15, 36, 21, 2, -29 },
  { 4012, 18, 30, 21, 3, -30 },
  { 4080, 18, 29, 21, 2, -29 },
  { 4146, 19, 20, 21, 1, -20 },
  { 4194, 16, 20, 21, 3, -20 },
  { 4234, 19, 22, 21, 1, -21 },
  { 4287, 17, 27, 21, 3, -20 },
  { 4345, 18, 27, 21, 1, -20 },
  { 4406, 16, 20, 21, 4, -20 },
  { 4446, 17, 21, 21, 2, -21 },
  { 4491, 18, 26, 21, 2, -26 },
  { 4550, 16, 20, 21, 3, -20 },
  { 4590, 20, 20, 21, 1, -20 },
  { 4640, 21, 20, 21, 0, -20 },
  { 4693, 19, 20, 21, 1, -20 },
  { 4741, 19, 27, 21, 1, -20 },
  { 4806, 16, 20, 21, 3, -20 },
  { 4846, 16, 37, 21, 3, -30 },
  { 4920, 5, 37, 21, 8, -30 },
  { 4944, 16, 37, 21, 3, -30 },
  { 5018, 20, 8, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_Bold38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_BOLD38PT7B_H_
