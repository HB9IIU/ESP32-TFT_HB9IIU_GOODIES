#ifndef _UBUNTUSANSMONO_BOLD15PT7B_H_
#define _UBUNTUSANSMONO_BOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0x82, 0xF8, 0xED, 0xB4, 0xD3, 0x1B, 0x36, 0xFF, 0xFF,
  0x36, 0x24, 0xFF, 0x6C, 0x6C, 0x6C, 0x30, 0x61, 0xFF, 0xEC, 0x1C, 0x1E,
  0x1E, 0x0F, 0x0F, 0xF3, 0xC3, 0x06, 0x00, 0x60, 0xF3, 0xD2, 0xD4, 0xFC,
  0x68, 0x17, 0x35, 0x2D, 0x65, 0xC7, 0x18, 0x3C, 0x64, 0x6C, 0x7C, 0x33,
  0x7B, 0xCE, 0xC6, 0x6E, 0x7B, 0xFF, 0x40, 0x11, 0xDC, 0xCC, 0x63, 0x18,
  0xC6, 0x30, 0xC7, 0x1C, 0x40, 0x43, 0x83, 0x06, 0x18, 0x30, 0xC3, 0x0C,
  0x31, 0x86, 0x33, 0x84, 0x00, 0x31, 0xAB, 0xF9, 0x87, 0xDD, 0x00, 0x30,
  0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x67, 0x72, 0xE8, 0xFF, 0xC0, 0xDF,
  0x80, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0x83, 0x06,
  0x18, 0x30, 0x00, 0x30, 0xFB, 0x36, 0x3D, 0x76, 0xE5, 0xE3, 0xCD, 0xF9,
  0xE0, 0x39, 0xF3, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0xFF, 0xFC, 0x31, 0xFB,
  0x30, 0x60, 0xC3, 0x0E, 0x38, 0xE1, 0xFF, 0xF8, 0x31, 0xFA, 0x30, 0x61,
  0xC7, 0x07, 0x07, 0x0F, 0xFB, 0xE0, 0x0E, 0x1E, 0x1E, 0x36, 0x66, 0x66,
  0xFF, 0xFF, 0x06, 0x06, 0x7C, 0xC1, 0x03, 0x0F, 0xC1, 0x83, 0x86, 0xFD,
  0xF0, 0x3C, 0xF3, 0x86, 0xCF, 0xD9, 0xF1, 0xE7, 0xFC, 0xF0, 0xFE, 0x18,
  0x30, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC0, 0x30, 0xFB, 0x36, 0x3E, 0xCF,
  0x37, 0x63, 0xC7, 0xFD, 0xF0, 0x30, 0xFB, 0x36, 0x3C, 0x7F, 0xDF, 0x86,
  0x1D, 0xF3, 0x80, 0xDF, 0x81, 0xBF, 0x67, 0x70, 0x06, 0x77, 0x2E, 0x80,
  0x04, 0x3F, 0xE7, 0x0F, 0x07, 0xC3, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x81, 0xE1, 0xF0, 0x73, 0xFF, 0x30, 0x00, 0x33, 0xF8, 0xC3, 0x1C, 0xE3,
  0x00, 0x21, 0xC3, 0x00, 0x1C, 0x3E, 0x63, 0x43, 0xDF, 0xDB, 0xDB, 0xDB,
  0xDB, 0x4F, 0x60, 0x70, 0x1F, 0x1C, 0x1C, 0x3C, 0x36, 0x26, 0x66, 0x7E,
  0x7F, 0x63, 0xC3, 0x21, 0xFB, 0x36, 0x6C, 0xDF, 0x33, 0xE3, 0xC7, 0xFF,
  0xF0, 0x0C, 0x3F, 0x71, 0x60, 0x60, 0xE0, 0xE0, 0x60, 0x60, 0x7F, 0x3F,
  0x21, 0xF3, 0x36, 0x7C, 0x78, 0xF1, 0xE3, 0xCF, 0xFB, 0xE0, 0xFD, 0x83,
  0x06, 0x0F, 0xD8, 0x30, 0x60, 0xFF, 0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0xFC,
  0x30, 0xC3, 0x00, 0x0C, 0x3F, 0x71, 0x60, 0x60, 0xE0, 0xE3, 0x63, 0x63,
  0x7F, 0x3F, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3, 0xC7, 0x8C, 0xFE,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xFF, 0xFC, 0x7C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xE0, 0xCF, 0xBB, 0x67, 0x8F, 0x1F, 0x36, 0x66, 0xCF,
  0x8C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0x66, 0x67,
  0x77, 0x5F, 0x5B, 0x5B, 0x43, 0xC3, 0xC3, 0xC3, 0xC7, 0xCF, 0x9F, 0xBF,
  0x7B, 0xF7, 0xE7, 0xCF, 0x8C, 0x18, 0x3E, 0x66, 0x63, 0x63, 0xE3, 0xE3,
  0x63, 0x67, 0x7E, 0x3C, 0x21, 0xFB, 0x3E, 0x3C, 0x79, 0xFF, 0x60, 0xC1,
  0x83, 0x00, 0x18, 0x3E, 0x66, 0x63, 0x63, 0xE3, 0xE3, 0x63, 0x63, 0x7E,
  0x3C, 0x18, 0x0F, 0x03, 0x21, 0xFB, 0x36, 0x7C, 0xDF, 0xBE, 0x6C, 0xCD,
  0x9F, 0x18, 0x39, 0xFB, 0x16, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0xFB, 0xF0,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFC, 0xF8, 0xE3, 0x63, 0x63, 0x66, 0x66,
  0x36, 0x34, 0x3C, 0x1C, 0x18, 0xC3, 0xC3, 0xC3, 0x5B, 0x5B, 0x5F, 0x57,
  0x77, 0x67, 0x62, 0xE3, 0x76, 0x3C, 0x1C, 0x18, 0x1C, 0x3E, 0x76, 0x67,
  0xE3, 0xE3, 0x66, 0x66, 0x36, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0xFC,
  0x18, 0x70, 0xC3, 0x06, 0x18, 0x70, 0xFF, 0xFC, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xE0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C,
  0x18, 0x38, 0x30, 0x60, 0xE0, 0xC1, 0x83, 0x80, 0xFF, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x1C, 0x3C, 0x36, 0x66, 0xE3, 0x42,
  0xFF, 0xFF, 0x99, 0x80, 0xF9, 0xF0, 0xDF, 0xFF, 0x3E, 0xFF, 0x41, 0x83,
  0x06, 0x0F, 0xDF, 0xB1, 0xE3, 0xC7, 0x8F, 0xF7, 0xC0, 0x3E, 0xFB, 0x06,
  0x0C, 0x18, 0x3F, 0xBF, 0x02, 0x0C, 0x18, 0x33, 0xEF, 0xD9, 0xF3, 0xE6,
  0xCD, 0xF9, 0xF0, 0x79, 0xFB, 0x1F, 0xFF, 0xF8, 0x3F, 0x3E, 0x0C, 0x7D,
  0xCB, 0x0F, 0xFF, 0xD8, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x7F, 0xFC, 0xF3,
  0xCF, 0x3F, 0xC3, 0x0F, 0xFF, 0x00, 0x43, 0x0C, 0x30, 0xFB, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0x20, 0xE1, 0xC0, 0x0F, 0x1E, 0x0C, 0x18, 0x30, 0x60,
  0xF8, 0xF0, 0x08, 0x61, 0x80, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x8F,
  0xE7, 0x00, 0x41, 0x83, 0x06, 0x0C, 0xFB, 0xB6, 0x78, 0xF9, 0xBB, 0x36,
  0x30, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0,
  0xFE, 0xFF, 0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xFB, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0x3C, 0x7E, 0x63, 0x63, 0xE3, 0x63, 0x7E, 0x3C, 0xF9, 0xFB,
  0x3E, 0x3C, 0x78, 0xFF, 0x7E, 0xC1, 0x83, 0x00, 0x7F, 0xFC, 0xF3, 0xCF,
  0x3F, 0xDF, 0x0C, 0x30, 0xC0, 0x7F, 0xFB, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x7F, 0xFC, 0x3C, 0x3C, 0x3F, 0xFF, 0x60, 0xC3, 0xFF, 0xF6, 0x0C, 0x18,
  0x38, 0x3E, 0x7C, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDF, 0xE3, 0x63, 0x66,
  0x66, 0x36, 0x3C, 0x1C, 0x18, 0xC3, 0xC3, 0xDB, 0x5B, 0x5F, 0x77, 0x76,
  0x66, 0xE3, 0x76, 0x3C, 0x1C, 0x1C, 0x3E, 0x66, 0xE3, 0x63, 0x63, 0x66,
  0x36, 0x36, 0x3C, 0x1C, 0x1C, 0x18, 0x78, 0xE0, 0xFF, 0xF1, 0x8E, 0x31,
  0x8F, 0xFF, 0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x30, 0x30, 0xC3, 0x0C, 0x30,
  0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0xC3, 0x04, 0x10, 0x41, 0x83,
  0x18, 0x41, 0x04, 0x33, 0xCE, 0x00, 0x71, 0x7F, 0xCE,
};

const GFXglyph UbuntuSansMono_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 6, 4, 8, 1, -11 },
  { 8, 8, 10, 8, 0, -10 },
  { 18, 7, 14, 8, 1, -12 },
  { 31, 8, 11, 8, 0, -11 },
  { 42, 8, 11, 8, 0, -11 },
  { 53, 2, 5, 8, 3, -11 },
  { 55, 5, 15, 8, 2, -12 },
  { 65, 6, 15, 8, 1, -12 },
  { 77, 7, 6, 8, 1, -10 },
  { 83, 7, 7, 8, 1, -8 },
  { 90, 4, 6, 8, 2, -3 },
  { 93, 5, 2, 8, 2, -5 },
  { 95, 3, 3, 8, 3, -3 },
  { 97, 7, 15, 8, 1, -12 },
  { 111, 7, 11, 8, 1, -11 },
  { 121, 7, 10, 8, 1, -10 },
  { 130, 7, 11, 8, 1, -11 },
  { 140, 7, 11, 8, 1, -11 },
  { 150, 8, 10, 8, 0, -10 },
  { 160, 7, 10, 8, 1, -10 },
  { 169, 7, 10, 8, 1, -10 },
  { 178, 7, 10, 8, 1, -10 },
  { 187, 7, 11, 8, 1, -11 },
  { 197, 7, 11, 8, 1, -11 },
  { 207, 3, 8, 8, 3, -8 },
  { 210, 4, 11, 8, 2, -8 },
  { 216, 7, 7, 8, 1, -8 },
  { 223, 7, 5, 8, 1, -7 },
  { 228, 7, 7, 8, 1, -8 },
  { 235, 6, 11, 8, 1, -11 },
  { 244, 8, 13, 8, 0, -11 },
  { 257, 8, 10, 8, 0, -10 },
  { 267, 7, 11, 8, 1, -11 },
  { 277, 8, 11, 8, 0, -11 },
  { 288, 7, 11, 8, 1, -11 },
  { 298, 7, 10, 8, 1, -10 },
  { 307, 6, 10, 8, 1, -10 },
  { 315, 8, 11, 8, 0, -11 },
  { 326, 7, 10, 8, 1, -10 },
  { 335, 7, 10, 8, 1, -10 },
  { 344, 6, 10, 8, 1, -10 },
  { 352, 7, 10, 8, 1, -10 },
  { 361, 7, 10, 8, 1, -10 },
  { 370, 8, 10, 8, 0, -10 },
  { 380, 7, 10, 8, 1, -10 },
  { 389, 8, 11, 8, 0, -11 },
  { 400, 7, 11, 8, 1, -11 },
  { 410, 8, 14, 8, 0, -11 },
  { 424, 7, 11, 8, 1, -11 },
  { 434, 7, 11, 8, 1, -11 },
  { 444, 8, 10, 8, 0, -10 },
  { 454, 7, 10, 8, 1, -10 },
  { 463, 8, 10, 8, 0, -10 },
  { 473, 8, 10, 8, 0, -10 },
  { 483, 8, 10, 8, 0, -10 },
  { 493, 8, 10, 8, 0, -10 },
  { 503, 7, 10, 8, 1, -10 },
  { 512, 5, 15, 8, 2, -12 },
  { 522, 7, 15, 8, 1, -12 },
  { 536, 5, 15, 8, 2, -12 },
  { 546, 8, 6, 8, 0, -10 },
  { 552, 8, 2, 8, 0, 1 },
  { 554, 3, 3, 8, 3, -12 },
  { 556, 6, 8, 8, 1, -8 },
  { 562, 7, 12, 8, 1, -12 },
  { 573, 7, 8, 8, 1, -8 },
  { 580, 7, 12, 8, 0, -12 },
  { 591, 7, 8, 8, 1, -8 },
  { 598, 7, 12, 8, 1, -12 },
  { 609, 6, 11, 8, 1, -8 },
  { 618, 6, 12, 8, 1, -12 },
  { 627, 7, 12, 8, 1, -12 },
  { 638, 6, 15, 8, 1, -12 },
  { 650, 7, 12, 8, 1, -12 },
  { 661, 7, 12, 8, 1, -12 },
  { 672, 8, 8, 8, 0, -8 },
  { 680, 6, 8, 8, 1, -8 },
  { 686, 8, 8, 8, 0, -8 },
  { 694, 7, 11, 8, 1, -8 },
  { 704, 6, 11, 8, 1, -8 },
  { 713, 7, 8, 8, 1, -8 },
  { 720, 6, 8, 8, 1, -8 },
  { 726, 7, 10, 8, 1, -10 },
  { 735, 6, 8, 8, 1, -8 },
  { 741, 8, 8, 8, 0, -8 },
  { 749, 8, 8, 8, 0, -8 },
  { 757, 8, 8, 8, 0, -8 },
  { 765, 8, 11, 8, 0, -8 },
  { 776, 6, 8, 8, 1, -8 },
  { 782, 6, 15, 8, 1, -12 },
  { 794, 2, 15, 8, 3, -12 },
  { 798, 6, 15, 8, 1, -12 },
  { 810, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_Bold15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_BOLD15PT7B_H_
