#ifndef _UBUNTUSANSMONO_BOLD42PT7B_H_
#define _UBUNTUSANSMONO_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x1C, 0x01, 0xF1, 0xF0,
  0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3C, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x00, 0xC7, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x60, 0x07,
  0xF7, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x3C, 0xFF, 0x00,
  0xF3, 0xFE, 0x01, 0xE7, 0x9E, 0x07, 0x8E, 0x3C, 0x1E, 0x3C, 0x78, 0x3C,
  0x78, 0xF0, 0xF0, 0xF1, 0xE3, 0xC0, 0xE3, 0xC7, 0x81, 0xE7, 0x9E, 0x03,
  0xFE, 0x78, 0x03, 0xFC, 0xF0, 0x07, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0xF0, 0x03, 0xDF, 0xF0, 0x0F,
  0x3F, 0xE0, 0x3E, 0x79, 0xE0, 0x78, 0xE3, 0xC1, 0xE3, 0xC7, 0x87, 0xC7,
  0x8F, 0x0F, 0x0F, 0x1E, 0x3C, 0x0E, 0x3C, 0xF8, 0x1E, 0xF9, 0xE0, 0x3F,
  0xE7, 0x80, 0x3F, 0xDF, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x0F, 0x07, 0xFC, 0x3E, 0x3F, 0xF0, 0xF1, 0xFF, 0xE7, 0xC7,
  0xCF, 0xDF, 0x3F, 0x1F, 0xFC, 0xF8, 0x3F, 0xF3, 0xE0, 0xFF, 0x8F, 0x81,
  0xFE, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0xF8, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x08, 0x30, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x10, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x30, 0xF0, 0xC7,
  0xCF, 0x3C, 0x7E, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xF9, 0xF0, 0x3F, 0x9F,
  0x81, 0xF1, 0xFC, 0x0F, 0x0F, 0x00, 0x20, 0x40, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x03,
  0xC1, 0xE0, 0xFB, 0xFC, 0xFE, 0x3F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x10, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7E, 0x07, 0xE7, 0xC0,
  0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0xE3, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF,
  0x8E, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E,
  0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xC7, 0xF9, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x03, 0x8F, 0xC0,
  0x20, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xE3, 0xFC, 0x38, 0x0F, 0xC3, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x78, 0x7F, 0x88, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x40, 0x0F, 0xEF, 0x87, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7C,
  0x0F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFA, 0x00, 0x7E, 0x7C, 0x3F, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF9, 0x80,
  0x3F, 0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF0, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E,
  0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0x9F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7C, 0x07,
  0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0,
  0xFC, 0x7F, 0x8F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xE7, 0xFC, 0x7E, 0x1F, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xF1, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xF1, 0xFC, 0x7E, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x3E,
  0x7F, 0xDF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x10, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8,
  0x7E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3F,
  0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0x78, 0x1E, 0x1F, 0x3F, 0xCF,
  0xE3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xC1, 0xFC, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x04,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFC, 0x7F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xC0, 0xFF, 0xDE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xE3, 0xFE, 0x3E, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87,
  0xFC, 0x7C, 0x3F, 0xE3, 0xE1, 0xFF, 0x1F, 0x0F, 0xF8, 0xF8, 0x7F, 0xC7,
  0xE3, 0xFE, 0x1F, 0x9F, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0xDE, 0x1F, 0xFE,
  0xF8, 0x3F, 0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x83,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3,
  0xE0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xF8, 0x3F, 0xDF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8,
  0xF8, 0xFE, 0x00, 0x47, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x10, 0xFF, 0xCF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x7F, 0x3E, 0x07, 0xF7,
  0xC0, 0x7E, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBE,
  0x07, 0xF7, 0xC1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x78, 0xFE,
  0x00, 0x87, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x81,
  0xF8, 0xFF, 0x9F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x88, 0x03, 0xF1, 0x80, 0xFE, 0x7E, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xFC, 0x07, 0xF7, 0xE0,
  0x3F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7E,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF8, 0xFE,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFC,
  0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x01,
  0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0x3F,
  0x83, 0xF9, 0xFE, 0x1F, 0xCF, 0xF1, 0xFE, 0x7B, 0x8F, 0xF3, 0xDE, 0x77,
  0x9E, 0xF7, 0xBE, 0xF3, 0xBD, 0xF7, 0x9F, 0xEF, 0xBC, 0xFE, 0x7D, 0xE7,
  0xF3, 0xEF, 0x1F, 0x9F, 0x78, 0xF8, 0xFB, 0xC7, 0xC7, 0xFE, 0x1E, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7,
  0xFE, 0x3E, 0xFF, 0xC7, 0xDF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xE7, 0xF0, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF3,
  0xF0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xCF, 0xC0, 0x7E, 0x3F, 0x07, 0xF1, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xEF, 0xF0, 0xFC,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7,
  0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0x03,
  0xF1, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x38, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0x83, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xF8, 0xFE, 0x0F, 0x87,
  0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xF0, 0x38, 0x7E, 0x00, 0x8F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x60, 0x07, 0xE7, 0xC1, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0x7F,
  0x9F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x0E, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFC,
  0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x1E, 0x3F, 0xF1, 0xF1, 0xF7, 0x8F, 0xCF, 0xBC, 0x7E, 0x7D, 0xE7,
  0xF3, 0xEF, 0x3F, 0x9F, 0x79, 0xFE, 0xFB, 0xCE, 0xF7, 0xDE, 0xF3, 0xBE,
  0xF7, 0x9F, 0xF7, 0xB8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE3,
  0xE0, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF3, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xFB,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xCF, 0x00, 0x3C, 0x08, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x10, 0x0E, 0x03, 0xC1, 0xF8, 0xFF, 0x9F, 0xF1, 0xFC, 0x1E,
  0x00, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x30, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x3E, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x9F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0x00, 0x04,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1,
  0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF9,
  0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xE7, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x1C, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0x9F, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFE, 0xFF, 0x7F, 0x07,
  0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x83, 0xF3, 0xFE, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF,
  0xC0, 0x3E, 0x7E, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x01, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFC, 0x78,
  0x1F, 0x80, 0x20, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x01, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xCE, 0x03,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x04, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xCC, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFD,
  0xFE, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC8, 0x07, 0xE7, 0x87, 0xE7, 0xFF, 0xF3,
  0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7,
  0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x0F,
  0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x10, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x7F, 0xCF, 0xE7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0xDF, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F,
  0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x9F, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x70, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xE7,
  0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0x8F, 0xF7, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9,
  0xF8, 0xFF, 0xBF, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xE1, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFE, 0x7F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x3F,
  0xDF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x04, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x07, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xC0, 0x1B,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0x83, 0xCF, 0xC0, 0x13, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x0C,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xCF,
  0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC3, 0xC3, 0xEF, 0x8F, 0x87, 0x9F, 0x1F, 0x0F, 0x3E, 0x3F,
  0x1E, 0x7C, 0x7E, 0x3C, 0x78, 0xFC, 0x78, 0xF3, 0xF9, 0xF1, 0xE7, 0xFB,
  0xE3, 0xCF, 0xF7, 0xC7, 0xBD, 0xEF, 0x0F, 0x79, 0xDE, 0x1F, 0xF3, 0xFC,
  0x1F, 0xC7, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E,
  0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0,
  0x1F, 0x8F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x43, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x40, 0x7F, 0x81, 0xF3, 0xFF,
  0x07, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0x87, 0xFF,
  0x3E, 0x07, 0xF8, 0x10, 0x07, 0xC0,
};

const GFXglyph UbuntuSansMono_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 30, 24, 8, -29 },
  { 31, 16, 13, 24, 4, -32 },
  { 57, 22, 29, 24, 1, -29 },
  { 137, 20, 38, 24, 2, -33 },
  { 232, 23, 31, 24, 0, -30 },
  { 322, 22, 30, 24, 1, -30 },
  { 405, 6, 14, 24, 9, -32 },
  { 416, 16, 41, 24, 4, -33 },
  { 498, 15, 41, 24, 4, -33 },
  { 575, 20, 18, 24, 2, -29 },
  { 620, 20, 21, 24, 2, -23 },
  { 673, 10, 15, 24, 6, -8 },
  { 692, 13, 6, 24, 5, -15 },
  { 702, 8, 9, 24, 8, -8 },
  { 711, 19, 41, 24, 2, -33 },
  { 809, 20, 31, 24, 2, -30 },
  { 887, 20, 29, 24, 2, -29 },
  { 960, 20, 30, 24, 2, -30 },
  { 1035, 19, 31, 24, 2, -30 },
  { 1109, 21, 29, 24, 1, -29 },
  { 1186, 19, 30, 24, 2, -29 },
  { 1258, 19, 30, 24, 2, -29 },
  { 1330, 19, 29, 24, 2, -29 },
  { 1399, 20, 31, 24, 2, -30 },
  { 1477, 20, 30, 24, 2, -30 },
  { 1552, 8, 23, 24, 8, -22 },
  { 1575, 10, 29, 24, 6, -22 },
  { 1612, 20, 20, 24, 2, -22 },
  { 1662, 20, 14, 24, 2, -19 },
  { 1697, 20, 20, 24, 2, -22 },
  { 1747, 17, 31, 24, 3, -30 },
  { 1813, 21, 36, 24, 1, -30 },
  { 1908, 23, 29, 24, 0, -29 },
  { 1992, 19, 29, 24, 3, -29 },
  { 2061, 21, 31, 24, 1, -30 },
  { 2143, 19, 29, 24, 3, -29 },
  { 2212, 19, 29, 24, 3, -29 },
  { 2281, 18, 29, 24, 3, -29 },
  { 2347, 21, 31, 24, 1, -30 },
  { 2429, 19, 29, 24, 2, -29 },
  { 2498, 18, 29, 24, 3, -29 },
  { 2564, 19, 30, 24, 2, -29 },
  { 2636, 21, 29, 24, 2, -29 },
  { 2713, 19, 29, 24, 3, -29 },
  { 2782, 21, 29, 24, 1, -29 },
  { 2859, 19, 29, 24, 2, -29 },
  { 2928, 21, 31, 24, 1, -30 },
  { 3010, 19, 29, 24, 3, -29 },
  { 3079, 21, 38, 24, 1, -30 },
  { 3179, 20, 29, 24, 3, -29 },
  { 3252, 20, 31, 24, 2, -30 },
  { 3330, 21, 29, 24, 1, -29 },
  { 3407, 20, 30, 24, 2, -29 },
  { 3482, 22, 29, 24, 1, -29 },
  { 3562, 21, 29, 24, 1, -29 },
  { 3639, 23, 29, 24, 0, -29 },
  { 3723, 22, 29, 24, 1, -29 },
  { 3803, 19, 29, 24, 2, -29 },
  { 3872, 13, 41, 24, 5, -33 },
  { 3939, 19, 41, 24, 2, -33 },
  { 4037, 13, 41, 24, 5, -33 },
  { 4104, 22, 17, 24, 1, -29 },
  { 4151, 23, 5, 24, 0, 3 },
  { 4166, 10, 9, 24, 7, -33 },
  { 4178, 19, 24, 24, 2, -23 },
  { 4235, 19, 34, 24, 3, -33 },
  { 4316, 20, 24, 24, 2, -23 },
  { 4376, 19, 34, 24, 1, -33 },
  { 4457, 21, 24, 24, 1, -23 },
  { 4520, 21, 33, 24, 2, -33 },
  { 4607, 19, 31, 24, 2, -23 },
  { 4681, 18, 33, 24, 3, -33 },
  { 4756, 20, 34, 24, 2, -33 },
  { 4841, 17, 41, 24, 2, -33 },
  { 4929, 20, 33, 24, 3, -33 },
  { 5012, 20, 33, 24, 2, -32 },
  { 5095, 21, 22, 24, 1, -22 },
  { 5153, 18, 23, 24, 3, -23 },
  { 5205, 21, 24, 24, 1, -23 },
  { 5268, 19, 31, 24, 3, -23 },
  { 5342, 20, 31, 24, 1, -23 },
  { 5420, 18, 23, 24, 4, -23 },
  { 5472, 18, 24, 24, 3, -23 },
  { 5526, 20, 30, 24, 2, -29 },
  { 5601, 18, 23, 24, 3, -22 },
  { 5653, 22, 22, 24, 1, -22 },
  { 5714, 23, 22, 24, 0, -22 },
  { 5778, 22, 22, 24, 1, -22 },
  { 5839, 21, 30, 24, 1, -22 },
  { 5918, 18, 22, 24, 3, -22 },
  { 5968, 18, 41, 24, 3, -33 },
  { 6061, 6, 41, 24, 9, -33 },
  { 6092, 18, 41, 24, 3, -33 },
  { 6185, 22, 9, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_Bold42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_BOLD42PT7B_H_
