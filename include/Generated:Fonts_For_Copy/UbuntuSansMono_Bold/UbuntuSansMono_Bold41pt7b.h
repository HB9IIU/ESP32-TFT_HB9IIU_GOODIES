#ifndef _UBUNTUSANSMONO_BOLD41PT7B_H_
#define _UBUNTUSANSMONO_BOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xE1, 0x00, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xE0, 0xF9, 0xF8, 0x01, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE8, 0x00, 0xFD, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x02, 0x7F,
  0x00, 0x79, 0xFF, 0x00, 0xF3, 0xFE, 0x03, 0xC7, 0x1E, 0x0F, 0x0E, 0x3C,
  0x1E, 0x3C, 0x78, 0x78, 0x78, 0xF1, 0xE0, 0x71, 0xE3, 0xC0, 0xE3, 0xCF,
  0x01, 0xEF, 0x3C, 0x03, 0xFE, 0x78, 0x03, 0xF9, 0xE0, 0x03, 0xE7, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x20, 0x00, 0xF3, 0xF0, 0x01, 0xEF, 0xF0,
  0x07, 0x9F, 0xF0, 0x1E, 0x79, 0xE0, 0x3C, 0xF1, 0xC0, 0xF1, 0xE3, 0x83,
  0xC3, 0xC7, 0x87, 0x87, 0x8E, 0x1E, 0x0F, 0x1C, 0x7C, 0x1E, 0x78, 0xF0,
  0x1F, 0xF3, 0xC0, 0x3F, 0xCF, 0x80, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xF1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1,
  0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0xC0,
  0x3F, 0x87, 0xC7, 0xFE, 0x3E, 0x3F, 0xF9, 0xF3, 0xFF, 0xEF, 0x9F, 0x3F,
  0x79, 0xF0, 0xFF, 0xCF, 0x83, 0xFE, 0x7C, 0x0F, 0xE3, 0xE0, 0x3F, 0x1F,
  0x01, 0xF8, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xF3,
  0xF0, 0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF,
  0x9E, 0x71, 0xC0, 0x00, 0x08, 0x00, 0x30, 0x01, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x01,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x20,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x10, 0xF8, 0x27, 0x8F,
  0x1C, 0xF9, 0xCF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E,
  0x00, 0x0F, 0xE0, 0x03, 0xDF, 0x00, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xC7,
  0xE0, 0x78, 0xF8, 0x06, 0x0C, 0x00, 0x41, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x07, 0xE3, 0xF8,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x07, 0x81, 0xE1, 0xF3, 0xFC, 0xFE,
  0x3E, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x08, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F,
  0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x71, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0xF8,
  0xE3, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0x1F, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0xF8, 0x06, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xF8, 0x3F, 0x8C, 0x03, 0xF1, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF8, 0x70, 0x3F, 0x08, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFA, 0x00, 0x7E, 0x78, 0x3F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7D, 0xF8, 0x07, 0xEF,
  0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xA0, 0x03, 0xF7, 0xC1, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x7E, 0x7F, 0x1F, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF7,
  0xE0, 0x3F, 0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0x87, 0xC3,
  0xFD, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3E, 0xFF, 0x8F,
  0xC7, 0xFB, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x1F, 0xBF, 0x03, 0xF7,
  0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7E, 0xFE, 0x1F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x03, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xE0, 0x00, 0x08, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x7C, 0x7F, 0x7F,
  0xFF, 0xFF, 0xF7, 0xF1, 0xF0, 0x02, 0x01, 0xF0, 0x7F, 0x1F, 0xF3, 0xFE,
  0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0xFC, 0x1F, 0xC7, 0xF8, 0xFF, 0x9F, 0xF1, 0xFC, 0x1F, 0x80,
  0xF0, 0x3E, 0x0F, 0x9F, 0xE1, 0xF8, 0x3E, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x0E, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0x81, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE3,
  0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x8F, 0xF1, 0xF0,
  0xFF, 0x1F, 0x0F, 0xF1, 0xF0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1F,
  0x0F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xF7, 0x87, 0xFF, 0x78, 0x1F, 0xF7, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xE0, 0x30, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x04, 0x1F, 0xF1, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x16, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF3, 0xFC, 0x06, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7,
  0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0x01, 0xF3, 0xF8, 0x1F,
  0x3F, 0xE3, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x01, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0x01, 0xFD, 0xF1, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0xFC,
  0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0x7B, 0x8E, 0xF3,
  0xDE, 0xF7, 0x9E, 0xF7, 0xBC, 0xF3, 0xB9, 0xE7, 0x9F, 0xCF, 0x3C, 0xFE,
  0x79, 0xE7, 0xE3, 0xCF, 0x1F, 0x1E, 0x78, 0xF8, 0xF7, 0xC7, 0xC7, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0x9F, 0x3F, 0xF1, 0xE7, 0xFE,
  0x3E, 0xFF, 0xC3, 0xDF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83,
  0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0xBF,
  0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC,
  0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x87, 0xF0, 0xF8, 0x0F, 0x8F,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x8F, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x02, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFB, 0x00, 0x3F, 0x7C, 0x1F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF8, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0D, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x3E, 0x3D, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C, 0xFE, 0x79, 0xE7, 0xF3,
  0xCF, 0x3F, 0x9E, 0x7B, 0xDC, 0xF3, 0xDE, 0xF7, 0x9E, 0xF3, 0xBC, 0xF7,
  0x1D, 0xE7, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7F,
  0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7C,
  0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xBE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE,
  0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0x07,
  0xF7, 0xC0, 0x1F, 0x06, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x0E, 0x07,
  0xC1, 0xF8, 0xFF, 0x8F, 0xF0, 0xF8, 0x0E, 0x1F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC3, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x18, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xE0, 0xFE, 0xF8,
  0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0,
  0x7F, 0x7E, 0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0x00, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xDF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x1F, 0x9F, 0xE3,
  0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0,
  0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x23, 0xFF, 0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x38, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x70,
  0x3F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x20, 0x3F, 0x7C, 0x7F, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xE0, 0x1C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xFE,
  0x0F, 0xEF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xE7, 0xE0, 0xFC,
  0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x1F, 0xCF, 0xC1, 0xF9, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0x87, 0x87, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7C, 0x78, 0xFB, 0xE3, 0xE3, 0xFF,
  0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1,
  0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7C, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7C, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C,
  0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F, 0x07, 0xF1, 0xFC,
  0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF9, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x0F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0xE7, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x07, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFC, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0x80, 0x67, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x60, 0x07, 0xDF, 0x07, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x20, 0x7F, 0xBE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFE, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0x9F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F,
  0xF8, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07,
  0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xC7, 0xDF, 0x1F, 0x1F, 0x7C, 0x7C, 0x7D,
  0xF3, 0xF9, 0xE3, 0xCF, 0xE7, 0x8F, 0x3F, 0x9E, 0x3C, 0xEE, 0x78, 0xF7,
  0xBD, 0xE3, 0xDE, 0xF7, 0x8F, 0x73, 0xDE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x80,
  0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x3E,
  0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x43, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x71, 0xFF, 0x03,
  0xCF, 0xFF, 0x3E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7C, 0x7F, 0xFB, 0xE0,
  0xFF, 0x86, 0x01, 0xF0,
};

const GFXglyph UbuntuSansMono_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 29, 23, 8, -28 },
  { 27, 15, 13, 23, 4, -31 },
  { 52, 21, 28, 23, 1, -28 },
  { 126, 19, 36, 23, 2, -32 },
  { 212, 23, 30, 23, 0, -29 },
  { 299, 21, 29, 23, 1, -29 },
  { 376, 6, 14, 23, 9, -31 },
  { 387, 15, 41, 23, 4, -33 },
  { 464, 15, 41, 23, 4, -33 },
  { 541, 19, 18, 23, 2, -28 },
  { 584, 19, 20, 23, 2, -22 },
  { 632, 10, 15, 23, 6, -8 },
  { 651, 13, 6, 23, 5, -15 },
  { 661, 9, 8, 23, 7, -8 },
  { 670, 19, 40, 23, 2, -32 },
  { 765, 19, 30, 23, 2, -29 },
  { 837, 19, 28, 23, 2, -28 },
  { 904, 19, 29, 23, 2, -29 },
  { 973, 19, 30, 23, 2, -29 },
  { 1045, 21, 28, 23, 1, -28 },
  { 1119, 19, 29, 23, 2, -28 },
  { 1188, 19, 30, 23, 2, -29 },
  { 1260, 19, 28, 23, 2, -28 },
  { 1327, 19, 30, 23, 2, -29 },
  { 1399, 19, 29, 23, 2, -29 },
  { 1468, 9, 22, 23, 7, -22 },
  { 1493, 11, 29, 23, 5, -22 },
  { 1533, 19, 20, 23, 2, -22 },
  { 1581, 19, 14, 23, 2, -19 },
  { 1615, 19, 20, 23, 2, -22 },
  { 1663, 17, 30, 23, 3, -29 },
  { 1727, 20, 35, 23, 1, -29 },
  { 1815, 23, 28, 23, 0, -28 },
  { 1896, 20, 29, 23, 2, -29 },
  { 1969, 21, 30, 23, 1, -29 },
  { 2048, 20, 29, 23, 2, -29 },
  { 2121, 18, 28, 23, 3, -28 },
  { 2184, 17, 28, 23, 3, -28 },
  { 2244, 20, 30, 23, 1, -29 },
  { 2319, 19, 28, 23, 2, -28 },
  { 2386, 19, 28, 23, 2, -28 },
  { 2453, 18, 29, 23, 2, -28 },
  { 2519, 20, 28, 23, 2, -28 },
  { 2589, 18, 28, 23, 3, -28 },
  { 2652, 21, 28, 23, 1, -28 },
  { 2726, 19, 28, 23, 2, -28 },
  { 2793, 21, 30, 23, 1, -29 },
  { 2872, 20, 29, 23, 2, -29 },
  { 2945, 21, 37, 23, 1, -29 },
  { 3043, 20, 29, 23, 2, -29 },
  { 3116, 19, 30, 23, 2, -29 },
  { 3188, 21, 28, 23, 1, -28 },
  { 3262, 19, 29, 23, 2, -28 },
  { 3331, 21, 28, 23, 1, -28 },
  { 3405, 21, 28, 23, 1, -28 },
  { 3479, 22, 28, 23, 0, -28 },
  { 3556, 21, 28, 23, 1, -28 },
  { 3630, 19, 28, 23, 2, -28 },
  { 3697, 13, 40, 23, 5, -32 },
  { 3762, 19, 40, 23, 2, -32 },
  { 3857, 13, 40, 23, 5, -32 },
  { 3922, 22, 16, 23, 1, -28 },
  { 3966, 23, 5, 23, 0, 3 },
  { 3981, 10, 8, 23, 7, -32 },
  { 3991, 18, 22, 23, 2, -22 },
  { 4041, 19, 32, 23, 3, -32 },
  { 4117, 19, 22, 23, 2, -22 },
  { 4170, 19, 32, 23, 1, -32 },
  { 4246, 20, 22, 23, 1, -22 },
  { 4301, 21, 32, 23, 2, -32 },
  { 4385, 18, 30, 23, 2, -22 },
  { 4453, 17, 32, 23, 3, -32 },
  { 4521, 19, 32, 23, 2, -32 },
  { 4597, 16, 40, 23, 2, -32 },
  { 4677, 19, 32, 23, 3, -32 },
  { 4753, 19, 32, 23, 2, -32 },
  { 4829, 21, 22, 23, 1, -22 },
  { 4887, 17, 22, 23, 3, -22 },
  { 4934, 21, 23, 23, 1, -22 },
  { 4995, 19, 30, 23, 3, -22 },
  { 5067, 19, 30, 23, 1, -22 },
  { 5139, 17, 22, 23, 4, -22 },
  { 5186, 18, 22, 23, 2, -22 },
  { 5236, 20, 28, 23, 2, -28 },
  { 5306, 17, 22, 23, 3, -22 },
  { 5353, 21, 22, 23, 1, -22 },
  { 5411, 22, 22, 23, 0, -22 },
  { 5472, 21, 22, 23, 1, -22 },
  { 5530, 21, 30, 23, 1, -22 },
  { 5609, 17, 22, 23, 3, -22 },
  { 5656, 17, 40, 23, 3, -32 },
  { 5741, 5, 40, 23, 9, -32 },
  { 5766, 17, 40, 23, 3, -32 },
  { 5851, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuSansMono_Bold41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_BOLD41PT7B_H_
