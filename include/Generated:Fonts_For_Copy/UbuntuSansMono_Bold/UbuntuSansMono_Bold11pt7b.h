#ifndef _UBUNTUSANSMONO_BOLD11PT7B_H_
#define _UBUNTUSANSMONO_BOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCF, 0xFD, 0x90, 0x2C, 0xAF, 0xFF, 0x6B, 0xF5, 0x14, 0x30,
  0xC7, 0xD0, 0x60, 0xE0, 0xD3, 0xF8, 0xC0, 0x46, 0xAA, 0xBC, 0x28, 0xD5,
  0x63, 0x31, 0x65, 0x9C, 0x7F, 0x6C, 0x9F, 0xF4, 0x13, 0x64, 0xCC, 0xCC,
  0x46, 0x30, 0x84, 0x23, 0x31, 0x13, 0x26, 0xC0, 0x65, 0x7E, 0xCD, 0x00,
  0x30, 0xCF, 0xCC, 0x30, 0xC0, 0xF6, 0xFF, 0xF0, 0x18, 0x8C, 0x62, 0x31,
  0x88, 0xC6, 0x20, 0x31, 0xE4, 0xF7, 0xFD, 0x34, 0x9E, 0x23, 0x38, 0x42,
  0x10, 0x9F, 0x67, 0x84, 0x66, 0x62, 0x1F, 0x71, 0xE0, 0x8E, 0x38, 0x38,
  0xBE, 0x08, 0x62, 0x9A, 0x4B, 0xF0, 0x82, 0x79, 0xE6, 0x1C, 0x18, 0x38,
  0xBE, 0x13, 0xB1, 0xE9, 0x4E, 0x5E, 0xFF, 0xCC, 0x46, 0x31, 0x08, 0x39,
  0xE4, 0xDE, 0x79, 0x3C, 0xDE, 0x67, 0xA7, 0x3F, 0x89, 0xD8, 0xF0, 0xF0,
  0x6C, 0x06, 0xCE, 0x13, 0xF1, 0xC3, 0x84, 0xFC, 0x0F, 0xFF, 0x43, 0xC1,
  0xCF, 0xE2, 0x00, 0xEF, 0x13, 0x60, 0x66, 0x39, 0x24, 0xEF, 0xAE, 0xBB,
  0xD2, 0x64, 0x70, 0x30, 0xC3, 0x9A, 0x49, 0xEC, 0xF3, 0xE7, 0xA5, 0xEF,
  0x4E, 0x7E, 0x39, 0xF4, 0x30, 0xC3, 0x06, 0x4F, 0xE7, 0xA7, 0x39, 0xCE,
  0xDC, 0xF7, 0xA1, 0xEF, 0x42, 0x1F, 0xFF, 0x8F, 0xF8, 0x88, 0x39, 0xF4,
  0x30, 0xCF, 0x36, 0xDF, 0x9C, 0xE7, 0xFF, 0xCE, 0x73, 0xFF, 0xD8, 0xC6,
  0x31, 0x9F, 0xFF, 0x11, 0x11, 0x9F, 0x9D, 0xA9, 0xCE, 0x5A, 0x53, 0x84,
  0x21, 0x08, 0x42, 0x1F, 0x49, 0x37, 0x7D, 0xF7, 0x1C, 0x73, 0x9C, 0xF7,
  0xBB, 0xDE, 0x73, 0x31, 0xE4, 0xF3, 0xCF, 0x34, 0x9E, 0xE7, 0xE7, 0x3F,
  0x42, 0x10, 0x31, 0xE4, 0xF3, 0xCF, 0x34, 0x9E, 0x30, 0x70, 0xE7, 0xA7,
  0x2F, 0x5A, 0x53, 0x39, 0xA4, 0x1C, 0x38, 0x34, 0xFE, 0xFF, 0xF3, 0x0C,
  0x30, 0xC3, 0x0C, 0xCF, 0x3C, 0xF3, 0xCF, 0x34, 0xDE, 0xCF, 0x34, 0xD2,
  0x69, 0xE3, 0x0C, 0xCF, 0x3C, 0x7D, 0xF5, 0xD4, 0xD2, 0xCD, 0x27, 0x8C,
  0x31, 0xE4, 0xB3, 0xCD, 0x36, 0x9E, 0x30, 0xC3, 0x0C, 0xF7, 0x8C, 0x46,
  0x62, 0x1F, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x86, 0x30, 0x84, 0x30,
  0x84, 0x30, 0x86, 0xFF, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x30, 0xC7, 0x93,
  0xC8, 0xFC, 0x9D, 0x00, 0xF9, 0x7D, 0x9F, 0x44, 0x21, 0xED, 0xCE, 0x73,
  0xF0, 0x7E, 0x61, 0x0C, 0x3C, 0x08, 0x42, 0xF4, 0xE7, 0x29, 0x78, 0x39,
  0xAC, 0xFF, 0x41, 0xE0, 0x08, 0xF2, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x3B,
  0x73, 0x97, 0x96, 0x2F, 0x48, 0x8F, 0xB9, 0x99, 0x90, 0x20, 0xC0, 0x3C,
  0x30, 0xC3, 0x0C, 0x1C, 0x23, 0x0F, 0x33, 0x33, 0x3B, 0xE0, 0x44, 0x21,
  0x3B, 0x72, 0x96, 0x98, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x07, 0xFB, 0xFF,
  0x7D, 0xC7, 0x10, 0xFB, 0x99, 0x99, 0x39, 0xAC, 0xF3, 0x4D, 0xE0, 0xF4,
  0xA7, 0x39, 0xFA, 0x10, 0x3B, 0x73, 0x94, 0xBC, 0x21, 0xFF, 0xB1, 0x8C,
  0x60, 0x79, 0xC7, 0x9F, 0x23, 0xF2, 0x08, 0x20, 0x93, 0xC0, 0x99, 0x99,
  0x9F, 0xCD, 0x34, 0x9E, 0x30, 0xC0, 0x86, 0x5F, 0x5D, 0x79, 0x20, 0xCD,
  0xE3, 0x0C, 0x7B, 0x30, 0xCD, 0x26, 0x8E, 0x38, 0xC3, 0x38, 0xF3, 0x26,
  0xCF, 0x37, 0x66, 0x6C, 0x46, 0x66, 0x30, 0xFF, 0xFF, 0xFC, 0xCE, 0x22,
  0x23, 0x22, 0x22, 0xE0, 0x7E, 0x60,
};

const GFXglyph UbuntuSansMono_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 6, 8, 6, 0, -8 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 6, 8, 6, 0, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 2, 3, 6, 2, -8 },
  { 32, 4, 11, 6, 1, -9 },
  { 38, 4, 11, 6, 1, -9 },
  { 44, 5, 5, 6, 1, -8 },
  { 48, 6, 6, 6, 0, -6 },
  { 53, 2, 4, 6, 2, -2 },
  { 54, 4, 2, 6, 1, -4 },
  { 55, 2, 2, 6, 2, -2 },
  { 56, 5, 11, 6, 1, -9 },
  { 63, 6, 8, 6, 0, -8 },
  { 69, 5, 8, 6, 1, -8 },
  { 74, 5, 8, 6, 1, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 6, 8, 6, 0, -8 },
  { 91, 6, 8, 6, 0, -8 },
  { 97, 5, 8, 6, 1, -8 },
  { 102, 5, 8, 6, 1, -8 },
  { 107, 6, 8, 6, 0, -8 },
  { 113, 5, 8, 6, 1, -8 },
  { 118, 2, 6, 6, 2, -6 },
  { 120, 3, 8, 6, 1, -6 },
  { 123, 5, 6, 6, 1, -6 },
  { 127, 6, 4, 6, 0, -5 },
  { 130, 6, 6, 6, 0, -6 },
  { 135, 4, 8, 6, 1, -8 },
  { 139, 6, 10, 6, 0, -8 },
  { 147, 6, 8, 6, 0, -8 },
  { 153, 5, 8, 6, 1, -8 },
  { 158, 6, 8, 6, 0, -8 },
  { 164, 5, 8, 6, 1, -8 },
  { 169, 5, 8, 6, 1, -8 },
  { 174, 4, 8, 6, 1, -8 },
  { 178, 6, 8, 6, 0, -8 },
  { 184, 5, 8, 6, 1, -8 },
  { 189, 5, 8, 6, 1, -8 },
  { 194, 4, 8, 6, 1, -8 },
  { 198, 5, 8, 6, 1, -8 },
  { 203, 5, 8, 6, 1, -8 },
  { 208, 6, 8, 6, 0, -8 },
  { 214, 5, 8, 6, 1, -8 },
  { 219, 6, 8, 6, 0, -8 },
  { 225, 5, 8, 6, 1, -8 },
  { 230, 6, 10, 6, 0, -8 },
  { 238, 5, 8, 6, 1, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 8, 6, 0, -8 },
  { 267, 6, 8, 6, 0, -8 },
  { 273, 6, 8, 6, 0, -8 },
  { 279, 6, 8, 6, 0, -8 },
  { 285, 5, 8, 6, 1, -8 },
  { 290, 4, 11, 6, 1, -9 },
  { 296, 5, 11, 6, 1, -9 },
  { 303, 4, 11, 6, 1, -9 },
  { 309, 6, 5, 6, 0, -8 },
  { 313, 6, 1, 6, 0, 1 },
  { 314, 3, 3, 6, 2, -9 },
  { 316, 4, 6, 6, 1, -6 },
  { 319, 5, 9, 6, 1, -9 },
  { 325, 5, 6, 6, 1, -6 },
  { 329, 5, 9, 6, 0, -9 },
  { 335, 6, 6, 6, 0, -6 },
  { 340, 6, 9, 6, 0, -9 },
  { 347, 5, 8, 6, 0, -6 },
  { 352, 4, 9, 6, 1, -9 },
  { 357, 6, 9, 6, 0, -9 },
  { 364, 4, 11, 6, 1, -9 },
  { 370, 5, 9, 6, 1, -9 },
  { 376, 6, 8, 6, 0, -8 },
  { 382, 6, 6, 6, 0, -6 },
  { 387, 4, 6, 6, 1, -6 },
  { 390, 6, 6, 6, 0, -6 },
  { 395, 5, 8, 6, 1, -6 },
  { 400, 5, 8, 6, 0, -6 },
  { 405, 5, 6, 6, 1, -6 },
  { 409, 4, 6, 6, 1, -6 },
  { 412, 6, 7, 6, 0, -7 },
  { 418, 4, 6, 6, 1, -6 },
  { 421, 6, 6, 6, 0, -6 },
  { 426, 6, 6, 6, 0, -6 },
  { 431, 6, 6, 6, 0, -6 },
  { 436, 6, 8, 6, 0, -6 },
  { 442, 4, 6, 6, 1, -6 },
  { 445, 4, 11, 6, 1, -9 },
  { 451, 2, 11, 6, 2, -9 },
  { 454, 4, 11, 6, 1, -9 },
  { 460, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Bold11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_BOLD11PT7B_H_
