#ifndef _UBUNTUSANSMONO_BOLD18PT7B_H_
#define _UBUNTUSANSMONO_BOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x19, 0x86, 0x61, 0xBB, 0xFF, 0xFF, 0xCC, 0xC3, 0x33, 0xFF, 0xFF, 0xD9,
  0x86, 0x61, 0x98, 0x18, 0x18, 0x3F, 0x7F, 0xE1, 0xE0, 0xF0, 0x7E, 0x1F,
  0x07, 0x03, 0xC7, 0xFF, 0x7C, 0x18, 0x18, 0x70, 0x5C, 0x2D, 0x9B, 0x6C,
  0xDA, 0x1D, 0x82, 0xC0, 0x2E, 0x1B, 0xCD, 0xB2, 0x6D, 0x9B, 0xC3, 0x80,
  0x1C, 0x0F, 0x87, 0x71, 0x9C, 0x76, 0x0F, 0x83, 0x99, 0xF6, 0x6F, 0xB9,
  0xE6, 0x31, 0xFE, 0x3D, 0xC0, 0xFF, 0xF0, 0x0C, 0x73, 0x9C, 0x63, 0x8C,
  0x30, 0xC3, 0x0C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0xC3, 0x87, 0x0E, 0x18,
  0x70, 0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0xE3, 0x3C, 0xC0, 0x18, 0x59, 0xFF,
  0xFF, 0x3C, 0x7E, 0x66, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x7F, 0x73, 0xEC, 0xFF, 0xF0, 0xFF, 0x70, 0x07, 0x07, 0x06, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60,
  0xE0, 0x1C, 0x7E, 0xE7, 0xC3, 0xC3, 0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xE7,
  0x7E, 0x3C, 0x1C, 0x7C, 0xFC, 0x5C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x7F, 0x7F, 0x38, 0xFE, 0xEF, 0x47, 0x07, 0x06, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0xFF, 0xFF, 0x38, 0xFE, 0x4E, 0x07, 0x06, 0x3E, 0x3E, 0x1F, 0x07,
  0x03, 0x87, 0xFE, 0xFC, 0x0E, 0x0F, 0x07, 0x86, 0xC6, 0x63, 0x33, 0x19,
  0xFF, 0xFF, 0x83, 0x01, 0x80, 0xC0, 0x7F, 0x7F, 0x60, 0x60, 0x78, 0x7E,
  0x0F, 0x07, 0x07, 0x07, 0xFE, 0xFC, 0x02, 0x1F, 0x3F, 0x70, 0x60, 0xFC,
  0xFF, 0xC7, 0xC3, 0xE3, 0xE7, 0x7E, 0x3E, 0xFF, 0xFF, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x3C, 0x7E, 0xE7, 0xC3, 0xE3,
  0x76, 0x7C, 0x7E, 0xC7, 0xC3, 0xC3, 0xFF, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3,
  0xC3, 0xE3, 0xFF, 0x7F, 0x07, 0x06, 0x1E, 0x7C, 0x70, 0xFF, 0x70, 0x00,
  0xFF, 0x70, 0x7B, 0xCE, 0x00, 0x01, 0xEF, 0x38, 0xBC, 0xC0, 0x01, 0x07,
  0x1F, 0xFC, 0xE0, 0xF0, 0x7E, 0x0F, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xE0, 0xF8, 0x3F, 0x07, 0x0F, 0x7E, 0xF8, 0xC0, 0x3C, 0xFE,
  0x4F, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0E,
  0x1F, 0x8C, 0x6C, 0x36, 0x7A, 0x7F, 0x37, 0xBB, 0xD9, 0xEE, 0xD3, 0xED,
  0xF6, 0x01, 0x80, 0x7E, 0x0F, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x33, 0x0C,
  0xC3, 0x39, 0xFE, 0x7F, 0x98, 0x66, 0x1F, 0x87, 0x78, 0xFE, 0xFF, 0xE7,
  0xE7, 0xFE, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0x1E, 0x3F, 0x73,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE1, 0x7F, 0x3F, 0x70, 0x7F,
  0x3F, 0xDC, 0xEE, 0x37, 0x1B, 0x8F, 0xC7, 0xE3, 0x71, 0xB9, 0xDF, 0xCF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x1E, 0x3F, 0x73, 0xE0, 0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x87,
  0xFE, 0xFC, 0xC7, 0x63, 0x33, 0x9B, 0x8D, 0x87, 0xC3, 0x71, 0x98, 0xCE,
  0x63, 0xB1, 0xD8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0x73, 0x9C, 0xE7, 0x39, 0xEE, 0x7F, 0x9B, 0xE6,
  0xD9, 0xB6, 0x61, 0xD8, 0x76, 0x1F, 0x87, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB,
  0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0xC3, 0x1C, 0x3F, 0x39, 0xD8, 0x6C,
  0x36, 0x1B, 0x0F, 0x87, 0xC3, 0x61, 0xB9, 0xCF, 0xC3, 0xE0, 0x78, 0x7F,
  0x3F, 0xDC, 0x6E, 0x3F, 0x1B, 0x9D, 0xFE, 0xFC, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0x18, 0x3F, 0x3F, 0xDC, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0xC3, 0x61,
  0xB9, 0xCF, 0xC7, 0xE0, 0xC0, 0x7C, 0x0E, 0x78, 0x7F, 0x3F, 0xDC, 0xEE,
  0x37, 0x3B, 0xFD, 0xFC, 0xEE, 0x73, 0x39, 0xDC, 0x6E, 0x38, 0x3C, 0x7F,
  0xE2, 0xC0, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0x03, 0x83, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7,
  0xFF, 0x7E, 0xE1, 0xD8, 0x66, 0x19, 0xC6, 0x73, 0x8C, 0xC3, 0x30, 0xCC,
  0x1F, 0x07, 0x81, 0xE0, 0x30, 0xE1, 0xD8, 0x76, 0x1D, 0x86, 0x6D, 0x9B,
  0x67, 0xF9, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0x86, 0xF1, 0xCC, 0xE3, 0xB0,
  0x78, 0x1E, 0x03, 0x81, 0xE0, 0x7C, 0x33, 0x1C, 0xE7, 0x1B, 0x87, 0xE1,
  0xDC, 0x67, 0x38, 0xCC, 0x3F, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x3F, 0xFC, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18,
  0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x1E, 0x07, 0x83,
  0xF0, 0xEE, 0x73, 0xB8, 0x72, 0x10, 0xFF, 0xFF, 0xF0, 0x4E, 0x71, 0x3C,
  0x7E, 0x4F, 0x07, 0x3F, 0xFF, 0xC3, 0xC3, 0xFF, 0x7F, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFC, 0xFE, 0xF7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0x1E,
  0x7F, 0x79, 0xE0, 0xC0, 0xC0, 0xE0, 0xE0, 0x7F, 0x3F, 0x07, 0x07, 0x07,
  0x07, 0x3F, 0x7F, 0xEF, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x1C,
  0x7E, 0xE7, 0xC3, 0xFF, 0xFF, 0xC0, 0xE0, 0x7F, 0x3F, 0x0F, 0x9F, 0xCE,
  0x26, 0x03, 0x07, 0xFB, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x1C, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0x7F, 0x07, 0x07,
  0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0x30, 0x38, 0x38, 0x00, 0x00, 0xF8, 0xF8, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x1F, 0x1F, 0x0C, 0x1C, 0x38, 0x00, 0x0F, 0xDF,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0xFF, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x3B, 0xB9, 0xF8, 0xF8, 0x7E, 0x3B, 0x1D, 0xCE, 0x77,
  0x1C, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1F, 0x1F, 0x66, 0x7F, 0xBE, 0xDB, 0x6D, 0xBE, 0xDF, 0x0F, 0x87,
  0xC3, 0xE1, 0xC0, 0x3C, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x1C, 0x3F, 0x3D, 0xD8, 0x6C, 0x36, 0x1F, 0x0D, 0xCE, 0x7F, 0x1F,
  0x00, 0x38, 0xFE, 0xEF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0,
  0xE0, 0xE0, 0x1C, 0x7F, 0xF7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F,
  0x07, 0x07, 0x07, 0x3D, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80,
  0x1D, 0x7E, 0xE2, 0xE0, 0x78, 0x3E, 0x0F, 0x87, 0xFF, 0xFE, 0x30, 0x18,
  0x0C, 0x1F, 0xEF, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0F, 0xC3, 0xF0,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7F, 0x7F, 0xE1, 0xD8, 0x67,
  0x38, 0xCC, 0x33, 0x0F, 0xC1, 0xE0, 0x78, 0x0C, 0x00, 0xC0, 0xF3, 0x34,
  0xCD, 0xB2, 0x7F, 0x9F, 0xE7, 0x39, 0xCE, 0x33, 0x80, 0xF3, 0xCC, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0xC3, 0x31, 0xCE, 0xE1, 0xC0, 0x71, 0xDC, 0x63,
  0x38, 0xCC, 0x3B, 0x06, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x07, 0xC3, 0xE0,
  0x7F, 0x7E, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xFF, 0xFF, 0x1F, 0x1F, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x07, 0x0F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xF8, 0xF8,
  0x38, 0xDF, 0xEE, 0xF8, 0x08,
};

const GFXglyph UbuntuSansMono_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 6, 10, 2, -14 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 8, 16, 10, 1, -14 },
  { 43, 10, 13, 10, 0, -13 },
  { 60, 10, 13, 10, 0, -13 },
  { 77, 2, 6, 10, 4, -14 },
  { 79, 6, 17, 10, 2, -14 },
  { 92, 6, 17, 10, 2, -14 },
  { 105, 8, 7, 10, 1, -12 },
  { 112, 8, 9, 10, 1, -10 },
  { 121, 4, 6, 10, 3, -3 },
  { 124, 6, 2, 10, 2, -6 },
  { 126, 4, 3, 10, 3, -3 },
  { 128, 8, 17, 10, 1, -14 },
  { 145, 8, 13, 10, 1, -13 },
  { 158, 8, 12, 10, 1, -12 },
  { 170, 8, 13, 10, 1, -13 },
  { 183, 8, 13, 10, 1, -13 },
  { 196, 9, 12, 10, 1, -12 },
  { 210, 8, 12, 10, 1, -12 },
  { 222, 8, 13, 10, 1, -13 },
  { 235, 8, 12, 10, 1, -12 },
  { 247, 8, 13, 10, 1, -13 },
  { 260, 8, 13, 10, 1, -13 },
  { 273, 4, 9, 10, 3, -9 },
  { 278, 5, 12, 10, 2, -9 },
  { 286, 8, 9, 10, 1, -10 },
  { 295, 8, 6, 10, 1, -8 },
  { 301, 8, 9, 10, 1, -10 },
  { 310, 8, 13, 10, 1, -13 },
  { 323, 9, 16, 10, 0, -13 },
  { 341, 10, 12, 10, 0, -12 },
  { 356, 8, 13, 10, 1, -13 },
  { 369, 8, 13, 10, 1, -13 },
  { 382, 9, 13, 10, 1, -13 },
  { 397, 8, 12, 10, 1, -12 },
  { 409, 8, 12, 10, 1, -12 },
  { 421, 8, 13, 10, 1, -13 },
  { 434, 8, 12, 10, 1, -12 },
  { 446, 8, 12, 10, 1, -12 },
  { 458, 8, 12, 10, 1, -12 },
  { 470, 9, 12, 10, 1, -12 },
  { 484, 8, 12, 10, 1, -12 },
  { 496, 10, 12, 10, 0, -12 },
  { 511, 8, 12, 10, 1, -12 },
  { 523, 9, 13, 10, 1, -13 },
  { 538, 9, 13, 10, 1, -13 },
  { 553, 9, 16, 10, 1, -13 },
  { 571, 9, 13, 10, 1, -13 },
  { 586, 8, 13, 10, 1, -13 },
  { 599, 10, 12, 10, 0, -12 },
  { 614, 8, 12, 10, 1, -12 },
  { 626, 10, 12, 10, 0, -12 },
  { 641, 10, 12, 10, 0, -12 },
  { 656, 10, 12, 10, 0, -12 },
  { 671, 10, 12, 10, 0, -12 },
  { 686, 8, 12, 10, 1, -12 },
  { 698, 6, 17, 10, 2, -14 },
  { 711, 8, 17, 10, 1, -14 },
  { 728, 6, 17, 10, 2, -14 },
  { 741, 10, 7, 10, 0, -12 },
  { 750, 10, 2, 10, 0, 1 },
  { 753, 4, 4, 10, 3, -14 },
  { 755, 8, 10, 10, 1, -10 },
  { 765, 8, 14, 10, 1, -14 },
  { 779, 8, 10, 10, 1, -10 },
  { 789, 8, 14, 10, 1, -14 },
  { 803, 8, 10, 10, 1, -10 },
  { 813, 9, 14, 10, 1, -14 },
  { 829, 8, 13, 10, 1, -10 },
  { 842, 8, 14, 10, 1, -14 },
  { 856, 8, 14, 10, 1, -14 },
  { 870, 7, 17, 10, 1, -14 },
  { 885, 9, 14, 10, 1, -14 },
  { 901, 8, 14, 10, 1, -14 },
  { 915, 9, 10, 10, 1, -10 },
  { 927, 8, 10, 10, 1, -10 },
  { 937, 9, 10, 10, 1, -10 },
  { 949, 8, 13, 10, 1, -10 },
  { 962, 8, 13, 10, 1, -10 },
  { 975, 7, 10, 10, 2, -10 },
  { 984, 8, 10, 10, 1, -10 },
  { 994, 9, 12, 10, 1, -12 },
  { 1008, 8, 9, 10, 1, -9 },
  { 1017, 10, 9, 10, 0, -9 },
  { 1029, 10, 9, 10, 0, -9 },
  { 1041, 10, 9, 10, 0, -9 },
  { 1053, 10, 12, 10, 0, -9 },
  { 1068, 8, 9, 10, 1, -9 },
  { 1077, 8, 17, 10, 1, -14 },
  { 1094, 2, 17, 10, 4, -14 },
  { 1099, 8, 17, 10, 1, -14 },
  { 1116, 10, 4, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_Bold18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_BOLD18PT7B_H_
