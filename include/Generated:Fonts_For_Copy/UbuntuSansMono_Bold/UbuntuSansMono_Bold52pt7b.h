#ifndef _UBUNTUSANSMONO_BOLD52PT7B_H_
#define _UBUNTUSANSMONO_BOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0xC0, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xE7,
  0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFC, 0x07, 0xC7, 0xF8, 0x00, 0x43, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x40, 0x00, 0xFF, 0x3C, 0x00, 0x7F, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xCF, 0xFC, 0x00,
  0x7C, 0x7F, 0xF0, 0x07, 0xC7, 0xFF, 0x80, 0x7E, 0x3E, 0x7C, 0x03, 0xE1,
  0xF1, 0xE0, 0x3E, 0x0F, 0x0F, 0x83, 0xF0, 0x78, 0x7C, 0x1F, 0x03, 0xC3,
  0xE1, 0xF0, 0x1E, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0xF8, 0x07, 0xCF, 0x8F,
  0x80, 0x3F, 0xFC, 0x7C, 0x01, 0xFF, 0xE7, 0xC0, 0x07, 0xFE, 0x7C, 0x00,
  0x1F, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0xF9,
  0xFF, 0x80, 0x0F, 0x9F, 0xFE, 0x00, 0xFC, 0xF9, 0xF0, 0x07, 0xC7, 0x8F,
  0x80, 0x7C, 0x3C, 0x3C, 0x07, 0xE3, 0xE1, 0xE0, 0x3E, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x3F, 0x07, 0xC3, 0xC1, 0xF0, 0x1E, 0x1E, 0x1F, 0x00,
  0xF9, 0xF1, 0xF8, 0x07, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xF8, 0x00, 0xFF,
  0xCF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xC0, 0x1F, 0xF0, 0x3F,
  0x07, 0xFF, 0x07, 0xE1, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0xCF,
  0xF7, 0xE3, 0xF8, 0xFE, 0xFC, 0x7E, 0x1F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3,
  0xF0, 0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0xC3, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0x3F, 0xE0,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0x78, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x38, 0x7C, 0x1C, 0x7C, 0x7C, 0x7C, 0x7F, 0x7C, 0xFC, 0x7F, 0xBF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xE7, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF0, 0x07, 0x83, 0xE0,
  0x03, 0x81, 0x80, 0x01, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x07, 0xF3, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x80, 0xFF,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x20, 0xFF, 0xFC, 0x7C, 0x7F, 0xFE, 0x3E,
  0x1F, 0xFF, 0x3F, 0x8F, 0xFF, 0x9F, 0xC7, 0xFF, 0xCF, 0xE3, 0xFF, 0xE3,
  0xE1, 0xFF, 0xF0, 0xE1, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xEF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7E, 0x7F, 0x80, 0x30, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0x3F, 0xF8, 0x7C, 0x03, 0xFC, 0x1C, 0x01, 0xFE, 0x04,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x87, 0xFC,
  0x1C, 0x03, 0xFE, 0x10, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x30, 0x01, 0xFF,
  0x7F, 0x0F, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x60, 0x01, 0xFE,
  0x7E, 0x0F, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0xEF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xFC, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0xE3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC1, 0xFE, 0x7F, 0xF0, 0xFE, 0x0F, 0xFC, 0xFE, 0x01, 0xFE, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFF, 0x83, 0xFE,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0xC1,
  0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x07,
  0xF1, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1F, 0xC7, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFF, 0x1F,
  0xC0, 0x40, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x9F, 0xFC,
  0xFF, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xC1, 0xFF,
  0x0F, 0xF8, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x83, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0xF8,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF8, 0x7F, 0xE6, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0x7E, 0x07, 0xFF, 0xDF,
  0x07, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x1F, 0xE3, 0xFF, 0x87, 0xF0, 0xFF, 0xE1, 0xF8, 0x3F, 0xF8, 0x7E,
  0x0F, 0xFE, 0x1F, 0x83, 0xFF, 0x87, 0xE0, 0xFF, 0xE1, 0xF8, 0x3F, 0xF8,
  0x7E, 0x0F, 0xFE, 0x1F, 0x83, 0xFF, 0x87, 0xE0, 0xFF, 0xF1, 0xFC, 0x3F,
  0xFC, 0x7F, 0x8F, 0xDF, 0x0F, 0xFF, 0xF7, 0xC3, 0xFF, 0xFD, 0xF0, 0x7F,
  0xFF, 0x7E, 0x0F, 0xFF, 0xDF, 0x81, 0xFF, 0xF3, 0xF0, 0x1F, 0xF0, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x0E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0x00,
  0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xF8, 0xFC,
  0x7F, 0xE0, 0x06, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x0C, 0x3F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xF1, 0xFC,
  0x07, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80,
  0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xE7, 0xF0, 0x7F, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xF8, 0xFC, 0x7F, 0xE0, 0x0E, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF8, 0x03, 0xFB,
  0xFE, 0x01, 0xFC, 0xFF, 0x80, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x10, 0x01, 0xFE, 0x3C, 0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F,
  0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0x80, 0x3F,
  0x9F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0xFE, 0x1F, 0xF0,
  0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xF7, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x3F, 0x78, 0xFF,
  0xE7, 0xEF, 0x1E, 0xFC, 0xFD, 0xF7, 0xDF, 0x9F, 0xBE, 0xFB, 0xF3, 0xF3,
  0xDE, 0x7E, 0x7E, 0x7F, 0xCF, 0xCF, 0xCF, 0xF9, 0xF9, 0xF8, 0xFE, 0x3F,
  0x3F, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0xFC, 0xFC, 0x7F, 0x1F, 0x9F, 0x87,
  0xC3, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xBF, 0x0F, 0xFF, 0x7E, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0x7C, 0x7F, 0xF8,
  0xFC, 0xFF, 0xF0, 0xF9, 0xFF, 0xE1, 0xFB, 0xFF, 0xC1, 0xF7, 0xFF, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF,
  0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xFD, 0xFC, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE,
  0xFE, 0x01, 0xFF, 0x7F, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0xCF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8,
  0x0F, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x0F, 0xF0, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xF0, 0xFF, 0x00, 0x10, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF9, 0x00, 0x03, 0xFC, 0xE0, 0x03, 0xFC, 0x7E, 0x07,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0xDF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x3E, 0x1F, 0x9F, 0x8F, 0xE3, 0xF3, 0xF1,
  0xFC, 0x7E, 0x7E, 0x3F, 0x8F, 0xCF, 0xC7, 0xF9, 0xF9, 0xF9, 0xFF, 0x3F,
  0x3F, 0x3F, 0xE7, 0xE7, 0xE7, 0xFC, 0xFC, 0xFD, 0xF7, 0xDF, 0x9F, 0xBE,
  0xFB, 0xF3, 0xF7, 0x8F, 0x7E, 0x7E, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF9,
  0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F,
  0xE1, 0xE0, 0x00, 0xF8, 0x06, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x01,
  0xE0, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0xFE, 0x01,
  0xE0, 0x02, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x86, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xF7, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE7, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xF7, 0xF0, 0x1F,
  0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFD, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xE8,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xF8, 0x0C, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x02, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x0B, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0xFB, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x30, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xA0, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x70, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x20, 0x01, 0xFE, 0x7E, 0x0F, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xBF, 0x81,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF2,
  0x00, 0x7F, 0x38, 0x0F, 0xF7, 0xF3, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x03, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x0F,
  0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F,
  0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x7F, 0xF9,
  0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0xF0, 0xFC, 0x3F, 0xF8, 0x7E, 0x1F, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xFE, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0x7F,
  0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xE1, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xE0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x30, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xC0, 0x0E, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1E,
  0x3F, 0x80, 0x04, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF4, 0x00, 0x0F, 0xEE, 0x00, 0x3F, 0xDF, 0xE7, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x17, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x01, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8,
  0x1F, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC1, 0xF0, 0x7E, 0xFC, 0x1F, 0x87, 0xEF, 0xC1, 0xF8, 0x7E, 0x7C, 0x3F,
  0x87, 0xE7, 0xC3, 0xF8, 0x7C, 0x7C, 0x3F, 0xC7, 0xC7, 0xC3, 0xFC, 0x7C,
  0x7C, 0x7F, 0xC7, 0xC7, 0xE7, 0xFC, 0x7C, 0x7E, 0x7B, 0xEF, 0xC7, 0xEF,
  0xBE, 0xFC, 0x3E, 0xFB, 0xEF, 0x83, 0xEF, 0xBE, 0xF8, 0x3E, 0xF1, 0xFF,
  0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x07, 0xF0,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1C, 0x7F, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x02, 0x01, 0xFF, 0x00,
  0x78, 0x7F, 0xF0, 0x1F, 0x9F, 0xFF, 0x83, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xF0, 0xFF, 0xFC, 0xFC, 0x07, 0xFF,
  0x8F, 0x80, 0x7F, 0xC0, 0x30, 0x03, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 37, 29, 10, -36 },
  { 43, 19, 17, 29, 5, -40 },
  { 84, 27, 36, 29, 1, -36 },
  { 206, 25, 46, 29, 2, -40 },
  { 350, 29, 38, 29, 0, -37 },
  { 488, 27, 37, 29, 1, -37 },
  { 613, 7, 18, 29, 11, -40 },
  { 629, 19, 51, 29, 5, -41 },
  { 751, 19, 51, 29, 5, -41 },
  { 873, 24, 23, 29, 3, -36 },
  { 942, 25, 26, 29, 2, -28 },
  { 1024, 13, 19, 29, 7, -10 },
  { 1055, 16, 7, 29, 7, -18 },
  { 1069, 11, 11, 29, 9, -10 },
  { 1085, 23, 51, 29, 3, -41 },
  { 1232, 25, 38, 29, 2, -37 },
  { 1351, 24, 36, 29, 3, -36 },
  { 1459, 25, 37, 29, 2, -37 },
  { 1575, 24, 38, 29, 2, -37 },
  { 1689, 26, 36, 29, 2, -36 },
  { 1806, 24, 37, 29, 2, -36 },
  { 1917, 24, 37, 29, 3, -36 },
  { 2028, 23, 36, 29, 3, -36 },
  { 2132, 25, 38, 29, 2, -37 },
  { 2251, 24, 37, 29, 3, -37 },
  { 2362, 11, 29, 29, 9, -28 },
  { 2402, 13, 37, 29, 7, -28 },
  { 2463, 24, 26, 29, 3, -28 },
  { 2541, 25, 17, 29, 2, -24 },
  { 2595, 25, 26, 29, 2, -28 },
  { 2677, 21, 38, 29, 4, -37 },
  { 2777, 26, 45, 29, 1, -37 },
  { 2924, 28, 36, 29, 1, -36 },
  { 3050, 24, 36, 29, 3, -36 },
  { 3158, 25, 38, 29, 2, -37 },
  { 3277, 25, 36, 29, 3, -36 },
  { 3390, 23, 36, 29, 4, -36 },
  { 3494, 22, 36, 29, 4, -36 },
  { 3593, 25, 38, 29, 2, -37 },
  { 3712, 24, 36, 29, 3, -36 },
  { 3820, 23, 36, 29, 3, -36 },
  { 3924, 24, 37, 29, 2, -36 },
  { 4035, 26, 36, 29, 3, -36 },
  { 4152, 23, 36, 29, 4, -36 },
  { 4256, 27, 36, 29, 1, -36 },
  { 4378, 23, 36, 29, 3, -36 },
  { 4482, 26, 38, 29, 2, -37 },
  { 4606, 25, 36, 29, 3, -36 },
  { 4719, 26, 47, 29, 2, -37 },
  { 4872, 26, 36, 29, 3, -36 },
  { 4989, 25, 38, 29, 2, -37 },
  { 5108, 27, 36, 29, 1, -36 },
  { 5230, 25, 37, 29, 2, -36 },
  { 5346, 27, 36, 29, 1, -36 },
  { 5468, 27, 36, 29, 1, -36 },
  { 5590, 28, 36, 29, 1, -36 },
  { 5716, 27, 36, 29, 1, -36 },
  { 5838, 23, 36, 29, 3, -36 },
  { 5942, 16, 51, 29, 7, -41 },
  { 6044, 24, 51, 29, 3, -41 },
  { 6197, 17, 51, 29, 6, -41 },
  { 6306, 28, 21, 29, 1, -36 },
  { 6380, 29, 7, 29, 0, 3 },
  { 6406, 13, 10, 29, 9, -40 },
  { 6423, 23, 29, 29, 3, -28 },
  { 6507, 23, 41, 29, 4, -40 },
  { 6625, 24, 29, 29, 3, -28 },
  { 6712, 23, 41, 29, 2, -40 },
  { 6830, 25, 29, 29, 2, -28 },
  { 6921, 27, 40, 29, 2, -40 },
  { 7056, 24, 38, 29, 2, -28 },
  { 7170, 22, 40, 29, 4, -40 },
  { 7280, 25, 41, 29, 2, -40 },
  { 7409, 20, 50, 29, 3, -40 },
  { 7534, 24, 40, 29, 4, -40 },
  { 7654, 25, 41, 29, 2, -40 },
  { 7783, 25, 28, 29, 2, -28 },
  { 7871, 22, 28, 29, 4, -28 },
  { 7948, 26, 29, 29, 2, -28 },
  { 8043, 23, 38, 29, 4, -28 },
  { 8153, 24, 38, 29, 2, -28 },
  { 8267, 22, 28, 29, 5, -28 },
  { 8344, 23, 29, 29, 3, -28 },
  { 8428, 26, 36, 29, 2, -35 },
  { 8545, 23, 28, 29, 3, -27 },
  { 8626, 27, 27, 29, 1, -27 },
  { 8718, 28, 27, 29, 1, -27 },
  { 8813, 27, 27, 29, 1, -27 },
  { 8905, 27, 37, 29, 1, -27 },
  { 9030, 21, 27, 29, 4, -27 },
  { 9101, 21, 51, 29, 4, -41 },
  { 9235, 7, 51, 29, 11, -41 },
  { 9280, 21, 51, 29, 4, -41 },
  { 9414, 27, 11, 29, 1, -21 },
};

const GFXfont UbuntuSansMono_Bold52pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold52pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold52pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUSANSMONO_BOLD52PT7B_H_
