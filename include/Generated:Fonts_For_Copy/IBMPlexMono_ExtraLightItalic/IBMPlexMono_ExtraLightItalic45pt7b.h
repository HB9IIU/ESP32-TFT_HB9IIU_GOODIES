#ifndef _IBMPLEXMONO_EXTRALIGHTITALIC45PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x30, 0xCC, 0x32, 0x0C,
  0x83, 0x60, 0x98, 0x26, 0x19, 0x86, 0x41, 0x90, 0x6C, 0x13, 0x04, 0x00,
  0x02, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02, 0x02,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x02, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10,
  0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x10, 0x00,
  0x06, 0x06, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x10, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x10, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xC2, 0x38, 0x03, 0x02, 0x0C, 0x06, 0x06, 0x06, 0x0C,
  0x06, 0x03, 0x0C, 0x04, 0x00, 0x18, 0x04, 0x00, 0x18, 0x04, 0x00, 0x18,
  0x04, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x0C,
  0x08, 0x00, 0x06, 0x08, 0x00, 0x03, 0x88, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x10, 0x30, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x20, 0x18, 0x00, 0x20, 0x18, 0x00, 0x20, 0x18, 0x80, 0x20, 0x10, 0xC0,
  0x60, 0x30, 0xE0, 0x60, 0x60, 0x70, 0x40, 0xC0, 0x1C, 0x43, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x30, 0x10, 0x18, 0x01, 0x80, 0x80, 0x20, 0x04, 0x06, 0x00, 0x80, 0x30,
  0x10, 0x02, 0x01, 0x80, 0x40, 0x08, 0x0C, 0x03, 0x00, 0x20, 0x20, 0x0C,
  0x00, 0x81, 0x80, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x10, 0x60, 0x01, 0x00,
  0xC1, 0x00, 0x06, 0x02, 0x0C, 0x00, 0x0C, 0x30, 0x60, 0x00, 0x1F, 0x83,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x03, 0xE0, 0x00, 0x08, 0x30, 0x40, 0x00, 0x41, 0x80, 0x80,
  0x03, 0x0C, 0x03, 0x00, 0x18, 0x20, 0x04, 0x00, 0x40, 0x80, 0x10, 0x02,
  0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x02, 0x01,
  0x00, 0x20, 0x10, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x06, 0x06, 0x00, 0x20,
  0x30, 0x10, 0x00, 0x41, 0x80, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x40,
  0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x10, 0x00,
  0x0F, 0x0C, 0x00, 0x06, 0x36, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x0B, 0x00, 0x07, 0x01, 0xA0, 0x01, 0x20, 0x46, 0x00, 0x26, 0x18, 0xC0,
  0x0C, 0x62, 0x0C, 0x03, 0x04, 0xC0, 0xC0, 0xC0, 0xD0, 0x07, 0xE0, 0x0C,
  0x00, 0x33, 0x32, 0x26, 0x66, 0x64, 0x4C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0xE0, 0x10, 0x0E, 0xF8, 0x61, 0xF0, 0x3E, 0xDF, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x04, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x10, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x00, 0xFF, 0xF0, 0x6F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x03, 0x80, 0x18,
  0x03, 0x00, 0x80, 0x04, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x0E,
  0x03, 0x40, 0x38, 0x0D, 0x00, 0xC0, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x30, 0x60, 0x00,
  0x80, 0x80, 0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x68, 0x00, 0x06, 0x40, 0x00, 0xC6, 0x00, 0x0C,
  0x30, 0x01, 0xC1, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x18, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0x81, 0x80, 0x38, 0x01, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80,
  0x06, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x07, 0x00, 0x18, 0x07, 0x01, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x80,
  0x00, 0x31, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80, 0x06, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x0C, 0x00,
  0x40, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x38, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x63, 0xF8, 0x01, 0x30, 0x38, 0x05, 0x00, 0x30, 0x38,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x20, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80,
  0x0C, 0x03, 0x80, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x8F, 0xE0, 0x33, 0x01, 0x83, 0x40, 0x0C, 0x28,
  0x00, 0x67, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x02,
  0x40, 0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0x83, 0x00, 0x30, 0x1C, 0x0E,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFD, 0x80, 0x00, 0x66, 0x00, 0x01, 0x90,
  0x00, 0x0C, 0x40, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x60, 0x06,
  0x00, 0x20, 0x18, 0x00, 0x60, 0x60, 0x00, 0x60, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x10, 0x60, 0x00, 0x60, 0x60, 0x01, 0x80, 0x60, 0x06, 0x00, 0x60, 0x38,
  0x00, 0x3F, 0x80, 0x03, 0x81, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1,
  0x80, 0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20,
  0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x07, 0x03,
  0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x60, 0x60, 0x02, 0x18,
  0x00, 0x22, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x3A, 0x00, 0x0A, 0x60, 0x02, 0xC3, 0x03, 0x90, 0x3F,
  0x86, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x1E, 0x3C, 0x70, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x10, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0x01, 0x83, 0x00, 0x31, 0x80, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x28,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x1F, 0xC0, 0x07, 0x80,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x20, 0x20, 0x00, 0x82,
  0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x7C,
  0x44, 0x06, 0x12, 0x20, 0x40, 0x73, 0x04, 0x01, 0x98, 0x20, 0x0C, 0x83,
  0x00, 0x64, 0x10, 0x02, 0x20, 0x80, 0x13, 0x04, 0x01, 0x98, 0x60, 0x0C,
  0xC3, 0x00, 0x64, 0x18, 0x03, 0x20, 0x80, 0x11, 0x04, 0x01, 0x88, 0x30,
  0x0C, 0xC1, 0x80, 0xE6, 0x04, 0x07, 0x30, 0x30, 0xD9, 0x80, 0xFC, 0x8C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x7F, 0xFF,
  0x80, 0xC0, 0x01, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x26, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x80, 0x60, 0x03, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x20, 0x00,
  0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x07, 0x07, 0xFF, 0xE0,
  0x30, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x40, 0x01,
  0x83, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x07, 0x00, 0x40, 0x0C,
  0x04, 0x00, 0x60, 0x40, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x42, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x80, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00, 0xC0, 0xC0,
  0x0C, 0x03, 0x81, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x07,
  0x00, 0x40, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20,
  0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x88,
  0x00, 0x06, 0x20, 0x00, 0x19, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x61, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0xC0, 0x03, 0x03, 0x00, 0x30, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0,
  0x01, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x42, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x0F, 0xFD, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01,
  0x90, 0x00, 0x0C, 0x80, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x84, 0x00, 0x1C, 0x30, 0x01, 0x60, 0xC0, 0x1B, 0x03, 0x83, 0x10,
  0x07, 0xE0, 0x00, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x1F, 0xFF, 0xF8, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x07, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x06, 0x04, 0x00,
  0x20, 0x30, 0x06, 0x00, 0xE0, 0x60, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x03,
  0x82, 0x00, 0x03, 0x01, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x20, 0x03, 0x00, 0x10, 0x03, 0x00, 0x08, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x83, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x66, 0x60, 0x00, 0x36,
  0x18, 0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x06, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x83, 0xC0, 0x01, 0x41, 0xA0, 0x01, 0xA0, 0xD0, 0x00, 0xB0,
  0x6C, 0x00, 0x98, 0x26, 0x00, 0xCC, 0x11, 0x00, 0x44, 0x18, 0x80, 0x62,
  0x0C, 0x60, 0x61, 0x06, 0x10, 0x21, 0x83, 0x08, 0x30, 0xC1, 0x06, 0x10,
  0x60, 0x83, 0x18, 0x20, 0xC0, 0x98, 0x10, 0x60, 0x48, 0x08, 0x30, 0x3C,
  0x0C, 0x18, 0x0C, 0x06, 0x08, 0x04, 0x03, 0x04, 0x02, 0x01, 0x06, 0x00,
  0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x07, 0x80, 0x03, 0x05, 0x80, 0x02, 0x04, 0x80, 0x02,
  0x04, 0xC0, 0x02, 0x0C, 0xC0, 0x06, 0x0C, 0x40, 0x06, 0x0C, 0x60, 0x06,
  0x08, 0x60, 0x04, 0x08, 0x20, 0x04, 0x08, 0x30, 0x04, 0x18, 0x30, 0x0C,
  0x18, 0x10, 0x0C, 0x18, 0x18, 0x0C, 0x10, 0x18, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x0C, 0x08, 0x30, 0x0C, 0x18, 0x30, 0x04, 0x18, 0x30, 0x06, 0x18,
  0x20, 0x06, 0x10, 0x20, 0x02, 0x10, 0x20, 0x03, 0x10, 0x60, 0x03, 0x30,
  0x60, 0x01, 0x30, 0x60, 0x01, 0xB0, 0x40, 0x01, 0xA0, 0x40, 0x00, 0xA0,
  0x40, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0x03, 0x80,
  0x18, 0x03, 0x00, 0x80, 0x04, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xC8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x30, 0x60,
  0x00, 0x80, 0x80, 0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x08, 0x00, 0x70, 0x10, 0x00, 0x20, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x03,
  0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC2, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x3F,
  0xFF, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x03,
  0x80, 0x18, 0x03, 0x00, 0x80, 0x04, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xC8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x30,
  0x60, 0x00, 0x80, 0x80, 0x04, 0x03, 0x00, 0x20, 0x03, 0x03, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x10,
  0x60, 0x00, 0x62, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xE0,
  0x08, 0x00, 0x70, 0x10, 0x00, 0x20, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2, 0x00,
  0x03, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x3F, 0xFF, 0x80, 0x60, 0x20,
  0x00, 0xC0, 0x60, 0x01, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x06, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x60, 0x70, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40,
  0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC2,
  0x00, 0x02, 0x08, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x01, 0x80,
  0x18, 0x03, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x84,
  0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x20, 0x03, 0x00, 0x80, 0x08, 0x02, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x20, 0x03, 0x01, 0x80, 0x04,
  0x04, 0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x06, 0x10,
  0x00, 0x18, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x20, 0x00,
  0x06, 0x10, 0x0C, 0x02, 0x08, 0x0E, 0x01, 0x04, 0x07, 0x01, 0x82, 0x02,
  0xC0, 0xC1, 0x03, 0x60, 0x40, 0x81, 0x30, 0x20, 0xC1, 0x98, 0x30, 0x60,
  0x84, 0x18, 0x30, 0xC2, 0x08, 0x18, 0x41, 0x04, 0x0C, 0x60, 0x86, 0x06,
  0x30, 0x43, 0x03, 0x10, 0x31, 0x01, 0x18, 0x19, 0x80, 0x88, 0x0C, 0xC0,
  0x4C, 0x06, 0x40, 0x24, 0x01, 0x20, 0x16, 0x00, 0xB0, 0x0B, 0x00, 0x58,
  0x0D, 0x00, 0x28, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x88, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x40, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x08, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0xC0, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x03, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x30,
  0x00, 0x61, 0x80, 0x06, 0x04, 0x00, 0x60, 0x30, 0x02, 0x00, 0x80, 0x30,
  0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x11,
  0x80, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x18, 0xFF, 0xFF, 0xFC, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x00, 0xFC, 0x00, 0x18, 0x18, 0xC1, 0x80, 0x24,
  0x10, 0x00, 0xA1, 0x80, 0x07, 0x18, 0x00, 0x18, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x84, 0x00, 0x28, 0x30,
  0x03, 0x40, 0xC0, 0x36, 0x03, 0x03, 0x1F, 0x07, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x61, 0xF8,
  0x03, 0x30, 0x30, 0x13, 0x00, 0xC0, 0xB0, 0x03, 0x05, 0x00, 0x08, 0x70,
  0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06,
  0x20, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46,
  0x00, 0x06, 0x38, 0x00, 0x61, 0x40, 0x02, 0x09, 0x00, 0x60, 0xC6, 0x06,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x60, 0x30, 0x06, 0x0C,
  0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0x58, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x03, 0x60, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0xC0,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x03, 0xF0, 0x60, 0x30, 0x31, 0x81, 0x80,
  0x24, 0x08, 0x00, 0x50, 0x60, 0x01, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C,
  0x60, 0x00, 0x31, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00,
  0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC1,
  0x00, 0x0A, 0x06, 0x00, 0x48, 0x0C, 0x03, 0x20, 0x18, 0x19, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x30, 0x18, 0x03, 0x04, 0x00, 0x31,
  0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x58,
  0x00, 0x1B, 0x00, 0x06, 0x60, 0x07, 0x08, 0x0F, 0x81, 0xFE, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x12, 0x00, 0x03, 0x60,
  0x00, 0x44, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x06, 0x30, 0x30, 0x04, 0x81, 0x00,
  0x0A, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x08, 0x00, 0x58, 0x30, 0x01, 0x40,
  0x60, 0x19, 0x00, 0xC0, 0xCC, 0x00, 0xFC, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x08, 0x00, 0x30, 0x30, 0x01, 0x80, 0x70, 0x18, 0x00, 0x7F, 0x80, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x0F, 0xC0,
  0x62, 0x06, 0x0C, 0x80, 0x61, 0xA0, 0x04, 0x28, 0x00, 0x86, 0x00, 0x18,
  0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x22,
  0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x0C, 0x02, 0x01,
  0x80, 0x80, 0x20, 0x60, 0x04, 0x10, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x03, 0x00, 0x20, 0x10, 0x0C, 0x01, 0x01, 0x80, 0x10, 0x30, 0x01, 0x04,
  0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x3F, 0x00, 0x31, 0x83, 0x00, 0x4C, 0x03, 0x00, 0xA0, 0x03,
  0x01, 0x40, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x40, 0x01, 0x00, 0x80, 0x04, 0x03, 0x00, 0x30, 0x06,
  0x01, 0x80, 0x0C, 0x1C, 0x00, 0x10, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x40,
  0x80, 0x01, 0x81, 0x80, 0x1B, 0x01, 0x00, 0x66, 0x03, 0x01, 0x88, 0x02,
  0x06, 0x10, 0x06, 0x18, 0x20, 0x04, 0x60, 0xC0, 0x0D, 0x80, 0x00, 0x0C,
  0x00, 0x7F, 0xE0, 0x20, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x30,
  0x40, 0x10, 0x30, 0x18, 0x0C, 0x08, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x22,
  0x00, 0x0B, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x36, 0x31, 0x0C,
  0x70, 0x24, 0x08, 0xC0, 0x70, 0x11, 0x80, 0xC0, 0x22, 0x01, 0x80, 0x4C,
  0x03, 0x00, 0x98, 0x04, 0x01, 0x30, 0x08, 0x06, 0x40, 0x10, 0x0C, 0x80,
  0x60, 0x19, 0x00, 0xC0, 0x26, 0x01, 0x80, 0x4C, 0x02, 0x00, 0x98, 0x04,
  0x03, 0x20, 0x08, 0x06, 0x40, 0x30, 0x0C, 0x80, 0x60, 0x13, 0x00, 0xC0,
  0x26, 0x01, 0x00, 0x4C, 0x02, 0x01, 0x90, 0x04, 0x03, 0x20, 0x18, 0x06,
  0x40, 0x30, 0x08, 0x00, 0x7E, 0x03, 0x10, 0x30, 0x64, 0x03, 0x0D, 0x00,
  0x21, 0x40, 0x04, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x06,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18,
  0x00, 0xFC, 0x00, 0x60, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x06,
  0x40, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x4C,
  0x00, 0x18, 0xC0, 0x06, 0x08, 0x01, 0x80, 0xC0, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x19, 0x81, 0x80, 0x4C, 0x03, 0x01, 0x60, 0x06, 0x05,
  0x00, 0x08, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x60, 0xA0, 0x01,
  0x02, 0x40, 0x18, 0x18, 0xC0, 0xC0, 0x60, 0xFC, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x18,
  0xC1, 0x80, 0x24, 0x10, 0x00, 0xA1, 0x80, 0x07, 0x18, 0x00, 0x18, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x09,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00,
  0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x84,
  0x00, 0x28, 0x30, 0x01, 0x40, 0xC0, 0x32, 0x03, 0x03, 0x30, 0x07, 0xE1,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0xFF, 0xC7,
  0xFC, 0x02, 0x70, 0x00, 0x0B, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x0E, 0x01, 0x00, 0x0C, 0x10, 0x00,
  0x31, 0x80, 0x01, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x21,
  0xC0, 0x06, 0x03, 0x80, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x04, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x00, 0x81,
  0x80, 0x02, 0x18, 0x00, 0x18, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x66,
  0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x14, 0x60, 0x02, 0x84,
  0x00, 0xB0, 0xC0, 0x26, 0x0C, 0x08, 0xC0, 0x7E, 0x00, 0xFE, 0x00, 0x20,
  0x60, 0x03, 0x04, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00,
  0x20, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80,
  0x18, 0x10, 0x01, 0x01, 0x00, 0x30, 0x10, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x30, 0x03, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0x10, 0x0C, 0x08, 0x40, 0x30,
  0x31, 0x00, 0x80, 0xCC, 0x02, 0x01, 0x30, 0x08, 0x04, 0xC0, 0x60, 0x12,
  0x01, 0x80, 0x48, 0x06, 0x01, 0x20, 0x18, 0x05, 0x80, 0x40, 0x16, 0x01,
  0x00, 0x58, 0x04, 0x01, 0x40, 0x30, 0x05, 0x00, 0xC0, 0x14, 0x03, 0x00,
  0xF0, 0x08, 0x03, 0xC0, 0x20, 0x0B, 0x01, 0x80, 0x2C, 0x06, 0x01, 0xA0,
  0x28, 0x04, 0x80, 0xA0, 0x33, 0x04, 0x81, 0x86, 0x31, 0x0C, 0x0F, 0x03,
  0xC0, 0x00, 0xE0, 0x1E, 0x01, 0x98, 0x31, 0x83, 0x04, 0x30, 0x66, 0x03,
  0x10, 0x14, 0x01, 0x90, 0x08, 0x00, 0x48, 0x04, 0x00, 0x28, 0x02, 0x00,
  0x14, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x14, 0x00, 0x30, 0x0A, 0x00,
  0x10, 0x05, 0x00, 0x08, 0x04, 0xC0, 0x36, 0x06, 0x20, 0x73, 0x02, 0x10,
  0xE0, 0xC6, 0x0C, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0x06, 0x00, 0x08, 0x20,
  0x00, 0x41, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x08,
  0x30, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x0E, 0x0C, 0x00, 0x50, 0x20, 0x05,
  0x81, 0x80, 0x4C, 0x06, 0x04, 0x60, 0x0F, 0xC3, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x40, 0x03, 0x03, 0x00, 0x30, 0x0E, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x0C, 0x1C, 0x0C, 0x20, 0x06, 0x10, 0x40, 0x03, 0x21, 0x80,
  0x01, 0x82, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x20,
  0x0C, 0x00, 0x40, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x09,
  0xE0, 0x06, 0x10, 0x1C, 0x04, 0x60, 0x07, 0x88, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0xFE, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x02, 0x18, 0xC0, 0x04, 0x40, 0x80,
  0x19, 0x80, 0x80, 0x22, 0x01, 0x80, 0x8C, 0x01, 0x83, 0x10, 0x01, 0x8C,
  0x60, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 8, 31, 27, 10, -31 },
  { 32, 10, 12, 27, 11, -33 },
  { 47, 27, 31, 27, 1, -31 },
  { 152, 24, 43, 27, 2, -37 },
  { 281, 30, 33, 27, -1, -32 },
  { 405, 27, 33, 27, 0, -32 },
  { 517, 4, 12, 27, 14, -33 },
  { 523, 15, 40, 27, 10, -34 },
  { 598, 15, 40, 27, 3, -34 },
  { 673, 23, 22, 27, 3, -25 },
  { 737, 22, 21, 27, 3, -24 },
  { 795, 7, 11, 27, 7, -4 },
  { 805, 12, 1, 27, 8, -14 },
  { 807, 4, 4, 27, 10, -4 },
  { 809, 24, 40, 27, 2, -34 },
  { 929, 22, 33, 27, 3, -32 },
  { 1020, 21, 31, 27, 2, -31 },
  { 1102, 22, 32, 27, 2, -32 },
  { 1190, 22, 33, 27, 2, -32 },
  { 1281, 23, 31, 27, 1, -31 },
  { 1371, 22, 32, 27, 3, -31 },
  { 1459, 20, 32, 27, 3, -31 },
  { 1539, 22, 31, 27, 5, -31 },
  { 1625, 23, 33, 27, 2, -32 },
  { 1720, 19, 32, 27, 5, -32 },
  { 1796, 7, 24, 27, 10, -24 },
  { 1817, 10, 31, 27, 7, -24 },
  { 1856, 22, 24, 27, 4, -26 },
  { 1922, 23, 9, 27, 2, -18 },
  { 1948, 22, 24, 27, 2, -26 },
  { 2014, 18, 32, 27, 7, -32 },
  { 2086, 21, 37, 27, 3, -32 },
  { 2184, 23, 31, 27, 0, -31 },
  { 2274, 21, 31, 27, 3, -31 },
  { 2356, 21, 33, 27, 4, -32 },
  { 2443, 22, 31, 27, 3, -31 },
  { 2529, 23, 31, 27, 3, -31 },
  { 2619, 24, 31, 27, 3, -31 },
  { 2712, 21, 33, 27, 4, -32 },
  { 2799, 24, 31, 27, 2, -31 },
  { 2892, 24, 31, 27, 2, -31 },
  { 2985, 21, 32, 27, 3, -31 },
  { 3069, 25, 31, 27, 3, -31 },
  { 3166, 18, 31, 27, 4, -31 },
  { 3236, 25, 31, 27, 2, -31 },
  { 3333, 24, 31, 27, 2, -31 },
  { 3426, 22, 33, 27, 3, -32 },
  { 3517, 23, 31, 27, 3, -31 },
  { 3607, 22, 40, 27, 3, -32 },
  { 3717, 23, 31, 27, 3, -31 },
  { 3807, 24, 33, 27, 2, -32 },
  { 3906, 24, 31, 27, 5, -31 },
  { 3999, 22, 32, 27, 4, -31 },
  { 4087, 22, 31, 27, 6, -31 },
  { 4173, 25, 31, 27, 3, -31 },
  { 4270, 28, 31, 27, 0, -31 },
  { 4379, 25, 31, 27, 4, -31 },
  { 4476, 27, 31, 27, 0, -31 },
  { 4581, 18, 40, 27, 8, -34 },
  { 4671, 10, 40, 27, 9, -34 },
  { 4721, 18, 40, 27, 1, -34 },
  { 4811, 21, 17, 27, 4, -31 },
  { 4856, 22, 1, 27, 0, 5 },
  { 4859, 5, 8, 27, 11, -35 },
  { 4864, 21, 25, 27, 3, -24 },
  { 4930, 21, 34, 27, 3, -33 },
  { 5020, 19, 25, 27, 4, -24 },
  { 5080, 22, 34, 27, 3, -33 },
  { 5174, 19, 25, 27, 4, -24 },
  { 5234, 29, 43, 27, -1, -33 },
  { 5390, 22, 34, 27, 2, -24 },
  { 5484, 19, 33, 27, 4, -33 },
  { 5563, 19, 34, 27, 4, -33 },
  { 5644, 19, 43, 27, 4, -33 },
  { 5747, 23, 34, 27, 3, -33 },
  { 5845, 18, 34, 27, 5, -33 },
  { 5922, 23, 24, 27, 2, -24 },
  { 5991, 19, 24, 27, 4, -24 },
  { 6048, 19, 25, 27, 4, -24 },
  { 6108, 22, 33, 27, 2, -24 },
  { 6199, 21, 33, 27, 3, -24 },
  { 6286, 22, 23, 27, 5, -23 },
  { 6350, 21, 25, 27, 3, -24 },
  { 6416, 22, 32, 27, 3, -31 },
  { 6504, 19, 24, 27, 4, -23 },
  { 6561, 20, 23, 27, 4, -23 },
  { 6619, 22, 24, 27, 3, -23 },
  { 6685, 25, 25, 27, 1, -24 },
  { 6764, 21, 33, 27, 2, -23 },
  { 6851, 23, 25, 27, 2, -24 },
  { 6923, 21, 40, 27, 5, -34 },
  { 7028, 8, 40, 27, 10, -34 },
  { 7068, 20, 40, 27, 2, -34 },
  { 7168, 23, 8, 27, 2, -18 },
};

const GFXfont IBMPlexMono_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_EXTRALIGHTITALIC45PT7B_H_
